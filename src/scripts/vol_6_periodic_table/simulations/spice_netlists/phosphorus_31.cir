* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Phosphorus-31 (Z=15, A=31)
* Auto-generated topological mutual impedance array
* Nodes: 31

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.010322
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.009868
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.009935
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.010081
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.011090
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.011262
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.010740
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.011211
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.011293
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.011027
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.011005
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.010713
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.007112
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.006992
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.006880
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.007020
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.008791
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.008892
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.008573
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.008616
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.006968
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.006867
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.006768
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.006780
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.025782
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.006462
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.006211
K_31 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_32 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_33 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.010816
K_34 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.010322
K_35 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.010386
K_36 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.010552
K_37 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.010896
K_38 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.011090
K_39 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.010578
K_40 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.011026
K_41 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.011544
K_42 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.011293
K_43 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.011253
K_44 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.010942
K_45 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.007231
K_46 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.007112
K_47 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.006990
K_48 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.007138
K_49 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.008677
K_50 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.008791
K_51 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.008475
K_52 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.008516
K_53 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.007066
K_54 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.006968
K_55 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.006861
K_56 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.006873
K_57 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.023717
K_58 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.006643
K_59 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.006173
K_60 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_61 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.010729
K_62 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.010234
K_63 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.010322
K_64 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.010472
K_65 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.011442
K_66 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.011649
K_67 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.011090
K_68 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.011592
K_69 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.011569
K_70 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.011300
K_71 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.011293
K_72 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.010963
K_73 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.007361
K_74 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.007232
K_75 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.007112
K_76 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.007263
K_77 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.009009
K_78 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.009127
K_79 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.008791
K_80 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.008829
K_81 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.007178
K_82 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.007072
K_83 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.006968
K_84 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.006977
K_85 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.023449
K_86 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.006636
K_87 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.006352
K_88 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.010554
K_89 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.010082
K_90 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.010153
K_91 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.010322
K_92 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.010943
K_93 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.011124
K_94 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.010620
K_95 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.011090
K_96 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.011939
K_97 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.011644
K_98 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.011618
K_99 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.011293
K_100 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.007200
K_101 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.007079
K_102 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.006963
K_103 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.007112
K_104 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.008960
K_105 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.009076
K_106 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.008737
K_107 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.008791
K_108 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.007164
K_109 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.007058
K_110 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.006951
K_111 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.006968
K_112 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.025439
K_113 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.006591
K_114 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.006258
K_115 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_116 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_117 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_118 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.007862
K_119 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.008145
K_120 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.007907
K_121 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.008013
K_122 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.009712
K_123 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.009939
K_124 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.009856
K_125 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.009517
K_126 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.011308
K_127 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.011436
K_128 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.010874
K_129 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.011242
K_130 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.006634
K_131 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.006809
K_132 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.006642
K_133 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.006619
K_134 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.008791
K_135 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.008876
K_136 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008621
K_137 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008553
K_138 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.007569
K_139 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.015464
K_140 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.005760
K_141 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_142 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_143 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.007596
K_144 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.007862
K_145 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.007642
K_146 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.007738
K_147 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.009481
K_148 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.009712
K_149 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.009625
K_150 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.009308
K_151 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.011153
K_152 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.011308
K_153 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.010749
K_154 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.011104
K_155 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.006465
K_156 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.006634
K_157 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.006476
K_158 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.006455
K_159 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.008692
K_160 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.008791
K_161 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008535
K_162 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008470
K_163 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.007335
K_164 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.016314
K_165 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.005651
K_166 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_167 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.007807
K_168 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.008090
K_169 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.007862
K_170 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.007961
K_171 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.009555
K_172 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.009781
K_173 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.009712
K_174 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.009378
K_175 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.011762
K_176 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.011925
K_177 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.011308
K_178 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.011705
K_179 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.006619
K_180 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.006797
K_181 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.006634
K_182 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.006608
K_183 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.008954
K_184 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.009053
K_185 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.008791
K_186 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.008712
K_187 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.007354
K_188 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.016515
K_189 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.005801
K_190 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.007708
K_191 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.007981
K_192 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.007756
K_193 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.007862
K_194 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.009898
K_195 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.010150
K_196 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.010062
K_197 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.009712
K_198 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.011342
K_199 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.011488
K_200 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.010919
K_201 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.011308
K_202 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.006642
K_203 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.006821
K_204 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.006653
K_205 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.006634
K_206 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.009032
K_207 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.009133
K_208 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.008856
K_209 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.008791
K_210 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.007469
K_211 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.016473
K_212 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.005756
K_213 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_214 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_215 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_216 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.007163
K_217 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.007046
K_218 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.007181
K_219 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.006974
K_220 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.009351
K_221 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.008983
K_222 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.009024
K_223 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.009070
K_224 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.011308
K_225 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.011327
K_226 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.011201
K_227 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.010816
K_228 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.007112
K_229 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.006959
K_230 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.006986
K_231 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.006880
K_232 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.008852
K_233 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.005854
K_234 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.010615
K_235 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_236 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_237 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.007277
K_238 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.007163
K_239 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.007301
K_240 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.007084
K_241 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.009747
K_242 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.009351
K_243 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.009388
K_244 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.009439
K_245 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.011257
K_246 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.011308
K_247 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.011167
K_248 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.010786
K_249 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.007268
K_250 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.007112
K_251 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.007137
K_252 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.007024
K_253 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.008850
K_254 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.006017
K_255 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.010586
K_256 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_257 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.007136
K_258 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.007025
K_259 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.007163
K_260 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.006954
K_261 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.009696
K_262 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.009297
K_263 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.009351
K_264 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.009392
K_265 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.011385
K_266 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.011421
K_267 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.011308
K_268 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.010898
K_269 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.007237
K_270 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.007080
K_271 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.007112
K_272 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.006997
K_273 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.008578
K_274 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.005928
K_275 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.011009
K_276 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.007359
K_277 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.007236
K_278 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.007383
K_279 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.007163
K_280 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.009640
K_281 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.009248
K_282 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.009292
K_283 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.009351
K_284 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.011836
K_285 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.011876
K_286 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.011731
K_287 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.011308
K_288 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.007361
K_289 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.007195
K_290 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.007225
K_291 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.007112
K_292 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.008907
K_293 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.005971
K_294 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.010982
K_295 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_296 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_297 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_298 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.007163
K_299 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.007104
K_300 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.006992
K_301 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.007223
K_302 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.009712
K_303 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.010027
K_304 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.009590
K_305 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.009861
K_306 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.011293
K_307 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.011116
K_308 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.010730
K_309 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.011075
K_310 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.010451
K_311 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.007894
K_312 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.006237
K_313 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_314 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_315 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.007215
K_316 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.007163
K_317 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.007044
K_318 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.007281
K_319 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.009407
K_320 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.009712
K_321 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.009304
K_322 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.009552
K_323 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.011444
K_324 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.011293
K_325 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.010874
K_326 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.011234
K_327 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.010107
K_328 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.008131
K_329 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.006156
K_330 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_331 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.007339
K_332 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.007279
K_333 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.007163
K_334 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.007408
K_335 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.009818
K_336 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.010155
K_337 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.009712
K_338 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.009984
K_339 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.011916
K_340 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.011727
K_341 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.011293
K_342 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.011680
K_343 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.010069
K_344 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.008110
K_345 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.006329
K_346 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.007096
K_347 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.007042
K_348 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.006933
K_349 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.007163
K_350 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.009550
K_351 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.009859
K_352 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.009443
K_353 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.009712
K_354 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.011489
K_355 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.011319
K_356 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.010912
K_357 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.011293
K_358 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.009977
K_359 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.007913
K_360 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.006181
K_361 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_362 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_363 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_364 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.007862
K_365 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.008106
K_366 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.008030
K_367 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.007855
K_368 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.011090
K_369 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.011126
K_370 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.011159
K_371 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.010667
K_372 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.005721
K_373 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.011271
K_374 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.008906
K_375 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_376 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_377 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.007629
K_378 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.007862
K_379 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.007788
K_380 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.007627
K_381 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.011024
K_382 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.011090
K_383 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.011107
K_384 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.010622
K_385 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.005636
K_386 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.011744
K_387 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.008578
K_388 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_389 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.007693
K_390 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.007927
K_391 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.007862
K_392 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.007692
K_393 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.010992
K_394 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.011042
K_395 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.011090
K_396 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.010593
K_397 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.005573
K_398 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.011201
K_399 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.008837
K_400 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.007858
K_401 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.008107
K_402 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.008032
K_403 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.007862
K_404 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.011533
K_405 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.011590
K_406 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.011628
K_407 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.011090
K_408 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.005671
K_409 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.011590
K_410 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.008865
K_411 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_412 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_413 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_414 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.010322
K_415 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.009846
K_416 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.010010
K_417 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.009981
K_418 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.008317
K_419 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.005716
K_420 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.014143
K_421 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_422 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_423 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.010845
K_424 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.010322
K_425 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.010498
K_426 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.010465
K_427 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.008330
K_428 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.005871
K_429 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.014142
K_430 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_431 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.010637
K_432 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.010130
K_433 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.010322
K_434 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.010278
K_435 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.008055
K_436 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.005772
K_437 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.014902
K_438 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.010672
K_439 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.010160
K_440 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.010341
K_441 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.010322
K_442 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.008164
K_443 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.005755
K_444 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.013973
K_445 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_446 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_447 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_448 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.006101
K_449 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.009929
K_450 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.008621
K_451 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_452 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_453 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.006005
K_454 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.010288
K_455 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.008345
K_456 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_457 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.005935
K_458 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.009940
K_459 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.008598
K_460 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.005972
K_461 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.009828
K_462 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.008390
K_463 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.005350
K_464 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.005637
K_465 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.005350

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
