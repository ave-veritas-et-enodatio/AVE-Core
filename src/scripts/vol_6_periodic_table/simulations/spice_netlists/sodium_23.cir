* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Sodium-23 (Z=11, A=23)
* Auto-generated topological mutual impedance array
* Nodes: 23

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.004080
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.004080
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.004024
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.004024
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.005771
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.005850
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.005768
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.005690
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.005771
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.005798
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.005652
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.005758
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.005771
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.005662
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005652
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.005625
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.011592
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.011583
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.012065
K_23 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_24 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_25 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.004080
K_26 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.004080
K_27 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.004024
K_28 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.004024
K_29 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.005690
K_30 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.005771
K_31 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.005690
K_32 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.005615
K_33 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.005739
K_34 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.005771
K_35 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.005625
K_36 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.005729
K_37 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.005881
K_38 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.005771
K_39 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.005758
K_40 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.005729
K_41 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.011583
K_42 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.011592
K_43 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.012065
K_44 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_45 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.004137
K_46 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.004137
K_47 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.004080
K_48 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.004080
K_49 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.005768
K_50 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.005850
K_51 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.005771
K_52 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.005690
K_53 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.005892
K_54 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.005924
K_55 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.005771
K_56 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.005881
K_57 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.005892
K_58 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.005779
K_59 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.005771
K_60 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.005739
K_61 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.011153
K_62 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.011145
K_63 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.011590
K_64 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.004137
K_65 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.004137
K_66 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.004080
K_67 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.004080
K_68 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.005850
K_69 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.005935
K_70 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.005850
K_71 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.005771
K_72 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.005779
K_73 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.005809
K_74 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.005662
K_75 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.005771
K_76 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.005924
K_77 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.005809
K_78 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.005798
K_79 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.005771
K_80 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.011145
K_81 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.011153
K_82 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.011590
K_83 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_84 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_85 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_86 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.005771
K_87 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.005850
K_88 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.005935
K_89 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.005850
K_90 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.005771
K_91 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.005798
K_92 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.005809
K_93 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.005924
K_94 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.005771
K_95 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.005662
K_96 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.005809
K_97 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.005779
K_98 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.003018
K_99 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.003018
K_100 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.003049
K_101 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_102 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_103 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.005690
K_104 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.005771
K_105 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.005850
K_106 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.005768
K_107 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.005739
K_108 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.005771
K_109 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.005779
K_110 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.005892
K_111 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.005881
K_112 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.005771
K_113 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.005924
K_114 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.005892
K_115 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.003018
K_116 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.003018
K_117 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.003049
K_118 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_119 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.005615
K_120 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.005690
K_121 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.005771
K_122 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.005690
K_123 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.005729
K_124 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.005758
K_125 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.005771
K_126 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.005881
K_127 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.005729
K_128 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.005625
K_129 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.005771
K_130 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.005739
K_131 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.002988
K_132 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.002987
K_133 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.003018
K_134 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.005690
K_135 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.005768
K_136 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.005850
K_137 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.005771
K_138 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.005625
K_139 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.005652
K_140 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.005662
K_141 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.005771
K_142 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.005758
K_143 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.005652
K_144 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.005798
K_145 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.005771
K_146 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.002987
K_147 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.002988
K_148 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.003018
K_149 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_150 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_151 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_152 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.004712
K_153 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.004683
K_154 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.004646
K_155 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.004749
K_156 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.004712
K_157 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.004611
K_158 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.004646
K_159 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.004673
K_160 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.004116
K_161 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.004116
K_162 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.004166
K_163 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_164 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_165 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.004738
K_166 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.004712
K_167 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.004673
K_168 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.004777
K_169 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.004817
K_170 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.004712
K_171 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.004749
K_172 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.004777
K_173 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.004145
K_174 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.004145
K_175 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.004196
K_176 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_177 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.004777
K_178 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.004749
K_179 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.004712
K_180 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.004817
K_181 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.004777
K_182 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.004673
K_183 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.004712
K_184 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.004738
K_185 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.004095
K_186 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.004095
K_187 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.004145
K_188 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.004673
K_189 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.004646
K_190 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.004611
K_191 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.004712
K_192 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.004749
K_193 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.004646
K_194 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.004683
K_195 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.004712
K_196 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.004067
K_197 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.004067
K_198 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.004116
K_199 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_200 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_201 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_202 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.004712
K_203 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.004637
K_204 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.004710
K_205 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.004637
K_206 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.004138
K_207 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.004112
K_208 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.004175
K_209 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_210 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_211 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.004788
K_212 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.004712
K_213 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.004788
K_214 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.004710
K_215 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.004148
K_216 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.004123
K_217 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.004187
K_218 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_219 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.004710
K_220 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.004637
K_221 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.004712
K_222 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.004637
K_223 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.004074
K_224 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.004049
K_225 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.004111
K_226 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.004788
K_227 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.004710
K_228 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.004788
K_229 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.004712
K_230 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.004113
K_231 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.004088
K_232 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.004151
K_233 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_234 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_235 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_236 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.004138
K_237 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.004163
K_238 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.004202
K_239 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_240 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_241 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.004098
K_242 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.004123
K_243 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.004160
K_244 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_245 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.004074
K_246 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.004098
K_247 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.004136
K_248 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.004063
K_249 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.004088
K_250 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.004125
K_251 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.294118
K_252 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.263067
K_253 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.263067

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
