* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Neon-20 (Z=10, A=20)
* Auto-generated topological mutual impedance array
* Nodes: 20

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.004080
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.004080
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.004024
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.004024
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.005771
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.005850
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.005768
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.005690
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.005771
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.005798
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.005652
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.005758
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.005771
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.005662
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005652
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.005625
K_20 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_21 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_22 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.004080
K_23 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.004080
K_24 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.004024
K_25 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.004024
K_26 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.005690
K_27 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.005771
K_28 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.005690
K_29 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.005615
K_30 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.005739
K_31 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.005771
K_32 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.005625
K_33 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.005729
K_34 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.005881
K_35 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.005771
K_36 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.005758
K_37 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.005729
K_38 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_39 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.004137
K_40 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.004137
K_41 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.004080
K_42 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.004080
K_43 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.005768
K_44 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.005850
K_45 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.005771
K_46 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.005690
K_47 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.005892
K_48 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.005924
K_49 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.005771
K_50 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.005881
K_51 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.005892
K_52 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.005779
K_53 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.005771
K_54 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.005739
K_55 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.004137
K_56 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.004137
K_57 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.004080
K_58 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.004080
K_59 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.005850
K_60 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.005935
K_61 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.005850
K_62 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.005771
K_63 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.005779
K_64 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.005809
K_65 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.005662
K_66 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.005771
K_67 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.005924
K_68 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.005809
K_69 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.005798
K_70 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.005771
K_71 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_72 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_73 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_74 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.005771
K_75 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.005850
K_76 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.005935
K_77 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.005850
K_78 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.005771
K_79 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.005798
K_80 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.005809
K_81 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.005924
K_82 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.005771
K_83 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.005662
K_84 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.005809
K_85 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.005779
K_86 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_87 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_88 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.005690
K_89 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.005771
K_90 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.005850
K_91 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.005768
K_92 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.005739
K_93 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.005771
K_94 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.005779
K_95 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.005892
K_96 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.005881
K_97 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.005771
K_98 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.005924
K_99 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.005892
K_100 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_101 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.005615
K_102 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.005690
K_103 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.005771
K_104 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.005690
K_105 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.005729
K_106 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.005758
K_107 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.005771
K_108 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.005881
K_109 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.005729
K_110 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.005625
K_111 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.005771
K_112 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.005739
K_113 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.005690
K_114 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.005768
K_115 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.005850
K_116 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.005771
K_117 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.005625
K_118 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.005652
K_119 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.005662
K_120 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.005771
K_121 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.005758
K_122 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.005652
K_123 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.005798
K_124 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.005771
K_125 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_126 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_127 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_128 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.004712
K_129 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.004683
K_130 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.004646
K_131 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.004749
K_132 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.004712
K_133 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.004611
K_134 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.004646
K_135 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.004673
K_136 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_137 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_138 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.004738
K_139 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.004712
K_140 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.004673
K_141 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.004777
K_142 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.004817
K_143 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.004712
K_144 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.004749
K_145 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.004777
K_146 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_147 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.004777
K_148 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.004749
K_149 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.004712
K_150 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.004817
K_151 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.004777
K_152 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.004673
K_153 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.004712
K_154 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.004738
K_155 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.004673
K_156 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.004646
K_157 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.004611
K_158 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.004712
K_159 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.004749
K_160 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.004646
K_161 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.004683
K_162 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.004712
K_163 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_164 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_165 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_166 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.004712
K_167 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.004637
K_168 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.004710
K_169 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.004637
K_170 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_171 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_172 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.004788
K_173 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.004712
K_174 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.004788
K_175 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.004710
K_176 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_177 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.004710
K_178 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.004637
K_179 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.004712
K_180 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.004637
K_181 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.004788
K_182 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.004710
K_183 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.004788
K_184 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.004712
K_185 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_186 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_187 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_188 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_189 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_190 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
