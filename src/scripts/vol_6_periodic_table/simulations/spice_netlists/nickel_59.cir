* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Nickel-59 (Z=28, A=59)
* Auto-generated topological mutual impedance array
* Nodes: 59

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.008829
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.008489
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.008559
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.008667
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.009519
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.009676
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.009308
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.009683
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.010038
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.009813
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.009915
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.009594
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.005826
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.005734
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005678
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.005791
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.008320
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.008554
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.008252
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.008269
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.005769
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.005645
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.005653
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.005629
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.005264
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.005265
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.005156
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.005255
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.006319
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.006338
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.006255
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.006168
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.004555
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.004493
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.004459
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.004491
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.005080
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.005121
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.005003
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.005044
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.004761
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.004722
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.004686
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.004661
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.004216
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.004197
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.004137
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.004173
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.004454
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.004455
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.004387
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.004390
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.014798
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.004528
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.004092
K_59 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_60 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_61 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.009194
K_62 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.008829
K_63 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.008899
K_64 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.009020
K_65 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.009351
K_66 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.009519
K_67 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.009159
K_68 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.009516
K_69 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.010254
K_70 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.010038
K_71 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.010135
K_72 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.009793
K_73 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.005917
K_74 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.005826
K_75 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.005765
K_76 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.005883
K_77 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.008092
K_78 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.008320
K_79 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.008035
K_80 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.008051
K_81 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.005897
K_82 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.005769
K_83 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.005775
K_84 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.005749
K_85 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.005259
K_86 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.005264
K_87 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.005153
K_88 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.005252
K_89 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.006294
K_90 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.006319
K_91 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.006234
K_92 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.006148
K_93 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.004617
K_94 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.004555
K_95 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.004518
K_96 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.004552
K_97 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.005037
K_98 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.005080
K_99 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.004963
K_100 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.005004
K_101 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.004799
K_102 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.004761
K_103 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.004723
K_104 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.004698
K_105 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.004234
K_106 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.004216
K_107 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.004154
K_108 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.004190
K_109 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.004450
K_110 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.004454
K_111 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.004384
K_112 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.004387
K_113 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.014101
K_114 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.004611
K_115 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.004074
K_116 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_117 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.009108
K_118 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.008744
K_119 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.008829
K_120 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.008938
K_121 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.009725
K_122 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.009903
K_123 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.009519
K_124 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.009910
K_125 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.010141
K_126 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.009921
K_127 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.010038
K_128 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.009694
K_129 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.005981
K_130 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.005884
K_131 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.005826
K_132 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.005945
K_133 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.008375
K_134 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.008622
K_135 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.008320
K_136 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.008330
K_137 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.005888
K_138 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.005758
K_139 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.005769
K_140 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.005741
K_141 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.005375
K_142 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.005379
K_143 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.005264
K_144 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.005368
K_145 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.006378
K_146 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.006401
K_147 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.006319
K_148 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.006226
K_149 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.004655
K_150 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.004590
K_151 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.004555
K_152 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.004588
K_153 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.005157
K_154 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.005202
K_155 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.005080
K_156 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.005121
K_157 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.004838
K_158 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.004798
K_159 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.004761
K_160 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.004734
K_161 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.004298
K_162 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.004279
K_163 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.004216
K_164 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.004253
K_165 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.004522
K_166 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.004525
K_167 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.004454
K_168 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.004456
K_169 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.014209
K_170 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.004615
K_171 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.004151
K_172 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.008983
K_173 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.008634
K_174 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.008707
K_175 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.008829
K_176 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.009345
K_177 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.009503
K_178 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.009154
K_179 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.009519
K_180 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.010523
K_181 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.010277
K_182 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.010394
K_183 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.010038
K_184 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.005857
K_185 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.005766
K_186 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.005709
K_187 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.005826
K_188 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.008358
K_189 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.008603
K_190 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.008296
K_191 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.008320
K_192 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.005916
K_193 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.005785
K_194 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.005793
K_195 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.005769
K_196 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.005269
K_197 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.005272
K_198 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.005162
K_199 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.005264
K_200 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.006474
K_201 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006498
K_202 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.006409
K_203 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.006319
K_204 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.004619
K_205 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.004556
K_206 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.004520
K_207 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.004555
K_208 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.005114
K_209 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.005157
K_210 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.005037
K_211 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.005080
K_212 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.004865
K_213 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.004825
K_214 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.004786
K_215 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.004761
K_216 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.004259
K_217 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.004240
K_218 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.004178
K_219 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.004216
K_220 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.004519
K_221 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.004521
K_222 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.004450
K_223 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.004454
K_224 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.014923
K_225 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.004597
K_226 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.004115
K_227 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_228 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_229 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_230 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.006371
K_231 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.006557
K_232 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.006409
K_233 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.006481
K_234 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.007821
K_235 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.007959
K_236 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.007956
K_237 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.007709
K_238 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.009653
K_239 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.009686
K_240 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.009330
K_241 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.009699
K_242 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.004901
K_243 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.005011
K_244 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.004935
K_245 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.004918
K_246 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.008998
K_247 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.008888
K_248 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008839
K_249 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008636
K_250 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.005308
K_251 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.005388
K_252 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.005254
K_253 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.005334
K_254 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.004867
K_255 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.004936
K_256 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.004883
K_257 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.004823
K_258 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006815
K_259 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.006767
K_260 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.006619
K_261 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.006675
K_262 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.004261
K_263 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.004325
K_264 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.004245
K_265 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.004257
K_266 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.005126
K_267 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.005145
K_268 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.005084
K_269 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.005031
K_270 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.004775
K_271 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.004803
K_272 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.004702
K_273 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.004737
K_274 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.004216
K_275 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.004256
K_276 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.004188
K_277 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.004178
K_278 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.005771
K_279 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.008010
K_280 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.003807
K_281 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_282 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_283 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.006195
K_284 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.006371
K_285 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.006232
K_286 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.006299
K_287 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.007679
K_288 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.007821
K_289 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.007812
K_290 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.007578
K_291 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.009599
K_292 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.009653
K_293 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.009291
K_294 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.009655
K_295 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.004796
K_296 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.004901
K_297 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.004828
K_298 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.004813
K_299 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.009096
K_300 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.008998
K_301 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008940
K_302 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008730
K_303 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.005229
K_304 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.005308
K_305 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.005179
K_306 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.005255
K_307 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.004798
K_308 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.004867
K_309 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.004815
K_310 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.004757
K_311 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006857
K_312 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006815
K_313 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.006660
K_314 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.006718
K_315 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.004197
K_316 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.004261
K_317 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.004183
K_318 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.004194
K_319 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.005104
K_320 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.005126
K_321 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.005064
K_322 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.005012
K_323 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.004745
K_324 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.004775
K_325 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.004675
K_326 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.004709
K_327 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.004175
K_328 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.004216
K_329 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.004149
K_330 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.004139
K_331 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.005633
K_332 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.008207
K_333 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.003765
K_334 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_335 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.006328
K_336 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.006514
K_337 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.006371
K_338 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.006439
K_339 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.007682
K_340 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.007819
K_341 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.007821
K_342 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.007581
K_343 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.009989
K_344 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.010037
K_345 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.009653
K_346 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.010051
K_347 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.004866
K_348 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.004975
K_349 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.004901
K_350 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.004884
K_351 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.009148
K_352 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.009041
K_353 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.008998
K_354 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.008776
K_355 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.005360
K_356 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.005444
K_357 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.005308
K_358 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.005389
K_359 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.004848
K_360 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.004918
K_361 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.004867
K_362 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.004806
K_363 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.007022
K_364 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006973
K_365 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006815
K_366 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006873
K_367 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.004274
K_368 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.004341
K_369 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.004261
K_370 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.004272
K_371 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.005166
K_372 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.005187
K_373 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.005126
K_374 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.005070
K_375 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.004850
K_376 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.004880
K_377 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.004775
K_378 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.004811
K_379 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.004243
K_380 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.004285
K_381 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.004216
K_382 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.004205
K_383 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.005660
K_384 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.008289
K_385 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.003832
K_386 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.006261
K_387 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.006440
K_388 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.006300
K_389 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.006371
K_390 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.007927
K_391 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.008077
K_392 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.008073
K_393 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.007821
K_394 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.009587
K_395 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.009629
K_396 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.009279
K_397 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.009653
K_398 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.004882
K_399 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.004992
K_400 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.004916
K_401 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.004901
K_402 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.009391
K_403 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.009275
K_404 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.009220
K_405 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.008998
K_406 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.005279
K_407 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.005360
K_408 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.005228
K_409 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.005308
K_410 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.004910
K_411 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.004982
K_412 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.004928
K_413 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.004867
K_414 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006956
K_415 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006909
K_416 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.006752
K_417 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006815
K_418 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.004262
K_419 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.004328
K_420 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.004248
K_421 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.004261
K_422 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.005224
K_423 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.005246
K_424 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.005181
K_425 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.005126
K_426 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.004812
K_427 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.004842
K_428 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.004739
K_429 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.004775
K_430 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.004253
K_431 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.004295
K_432 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.004225
K_433 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.004216
K_434 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.005734
K_435 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.008280
K_436 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.003813
K_437 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_438 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_439 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_440 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.005418
K_441 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.005352
K_442 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.005437
K_443 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.005315
K_444 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.006958
K_445 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.006745
K_446 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.006785
K_447 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.006835
K_448 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.009176
K_449 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.009336
K_450 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.009273
K_451 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.008963
K_452 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.004482
K_453 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.004407
K_454 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.004448
K_455 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.004398
K_456 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.009242
K_457 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.009105
K_458 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008856
K_459 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.009047
K_460 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.005072
K_461 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.005058
K_462 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.005071
K_463 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.004969
K_464 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.004688
K_465 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.004603
K_466 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.004607
K_467 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.004600
K_468 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.007006
K_469 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.007047
K_470 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006886
K_471 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006849
K_472 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.004186
K_473 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.004146
K_474 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.004152
K_475 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.004104
K_476 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.005126
K_477 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.005067
K_478 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.005016
K_479 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.005024
K_480 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.004761
K_481 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.004743
K_482 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.004704
K_483 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.004663
K_484 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.007090
K_485 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.004100
K_486 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.005518
K_487 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_488 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_489 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.005482
K_490 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.005418
K_491 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.005503
K_492 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.005377
K_493 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.007184
K_494 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.006958
K_495 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.006998
K_496 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.007053
K_497 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.009008
K_498 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.009176
K_499 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.009108
K_500 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.008814
K_501 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.004558
K_502 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.004482
K_503 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.004524
K_504 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.004471
K_505 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.009366
K_506 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.009242
K_507 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.008974
K_508 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.009173
K_509 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.005084
K_510 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.005072
K_511 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.005084
K_512 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.004982
K_513 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.004776
K_514 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.004688
K_515 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.004692
K_516 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.004684
K_517 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006957
K_518 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.007006
K_519 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006843
K_520 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.006807
K_521 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.004226
K_522 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.004186
K_523 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.004192
K_524 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.004143
K_525 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.005184
K_526 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.005126
K_527 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.005071
K_528 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.005079
K_529 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.004777
K_530 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.004761
K_531 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.004721
K_532 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.004679
K_533 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.007075
K_534 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.004175
K_535 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.005506
K_536 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_537 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.005395
K_538 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.005332
K_539 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.005418
K_540 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.005295
K_541 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.007137
K_542 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.006911
K_543 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.006958
K_544 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.007008
K_545 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.009065
K_546 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.009228
K_547 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.009176
K_548 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.008868
K_549 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.004514
K_550 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.004438
K_551 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.004482
K_552 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.004430
K_553 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009662
K_554 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.009516
K_555 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.009242
K_556 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.009450
K_557 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.005071
K_558 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.005058
K_559 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.005072
K_560 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.004970
K_561 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.004771
K_562 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.004682
K_563 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.004688
K_564 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.004679
K_565 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.007124
K_566 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.007172
K_567 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.007006
K_568 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006963
K_569 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.004220
K_570 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.004179
K_571 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.004186
K_572 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.004136
K_573 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.005241
K_574 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.005179
K_575 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.005126
K_576 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.005133
K_577 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.004817
K_578 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.004800
K_579 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.004761
K_580 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.004717
K_581 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.006940
K_582 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.004147
K_583 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.005622
K_584 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.005523
K_585 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.005455
K_586 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.005545
K_587 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.005418
K_588 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.007080
K_589 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.006859
K_590 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.006902
K_591 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.006958
K_592 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.009386
K_593 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.009567
K_594 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.009500
K_595 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.009176
K_596 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.004568
K_597 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.004490
K_598 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.004533
K_599 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.004482
K_600 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.009430
K_601 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.009294
K_602 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.009030
K_603 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.009242
K_604 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.005179
K_605 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.005165
K_606 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.005179
K_607 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.005072
K_608 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.004779
K_609 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.004690
K_610 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.004695
K_611 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.004688
K_612 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.007165
K_613 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.007214
K_614 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.007041
K_615 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.007006
K_616 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.004272
K_617 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.004230
K_618 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.004236
K_619 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.004186
K_620 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.005232
K_621 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.005171
K_622 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.005116
K_623 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.005126
K_624 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.004863
K_625 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.004845
K_626 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.004804
K_627 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.004761
K_628 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.007175
K_629 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.004165
K_630 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.005611
K_631 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_632 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_633 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_634 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.004916
K_635 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.004886
K_636 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.004839
K_637 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.004950
K_638 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.006469
K_639 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.006640
K_640 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.006467
K_641 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.006571
K_642 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.008839
K_643 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.008545
K_644 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.008506
K_645 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.008638
K_646 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.004262
K_647 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.004280
K_648 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.004213
K_649 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.004294
K_650 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.009334
K_651 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.009582
K_652 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.009218
K_653 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.009206
K_654 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.004968
K_655 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.004914
K_656 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.004857
K_657 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.004940
K_658 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.004634
K_659 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.004688
K_660 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.004587
K_661 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.004653
K_662 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.007006
K_663 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006954
K_664 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006807
K_665 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006840
K_666 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.004261
K_667 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.004258
K_668 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.004187
K_669 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.004251
K_670 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.005080
K_671 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.005111
K_672 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.004995
K_673 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.005043
K_674 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.009818
K_675 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.005299
K_676 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.003858
K_677 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_678 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_679 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.004944
K_680 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.004916
K_681 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.004867
K_682 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.004980
K_683 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.006305
K_684 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.006469
K_685 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.006306
K_686 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.006402
K_687 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.009147
K_688 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.008839
K_689 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.008788
K_690 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.008933
K_691 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.004243
K_692 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.004262
K_693 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.004195
K_694 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.004275
K_695 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.009086
K_696 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.009334
K_697 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008988
K_698 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.008977
K_699 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.005021
K_700 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.004968
K_701 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.004908
K_702 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.004994
K_703 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.004581
K_704 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.004634
K_705 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.004536
K_706 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.004599
K_707 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.007050
K_708 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.007006
K_709 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006852
K_710 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006885
K_711 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.004262
K_712 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.004261
K_713 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.004189
K_714 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.004253
K_715 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.005046
K_716 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.005080
K_717 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.004964
K_718 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.005012
K_719 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.009418
K_720 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.005400
K_721 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.003831
K_722 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_723 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.004994
K_724 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.004964
K_725 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.004916
K_726 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.005031
K_727 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.006465
K_728 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.006639
K_729 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.006469
K_730 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.006570
K_731 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.009196
K_732 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.008874
K_733 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.008839
K_734 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.008978
K_735 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.004312
K_736 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.004331
K_737 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.004262
K_738 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.004345
K_739 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.009434
K_740 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.009701
K_741 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.009334
K_742 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.009312
K_743 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.005084
K_744 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.005028
K_745 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.004968
K_746 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.005056
K_747 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.004681
K_748 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.004738
K_749 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.004634
K_750 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.004701
K_751 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.007214
K_752 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.007162
K_753 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.007006
K_754 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.007038
K_755 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.004336
K_756 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.004334
K_757 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.004261
K_758 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.004327
K_759 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.005166
K_760 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.005201
K_761 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.005080
K_762 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.005129
K_763 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.009541
K_764 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.005422
K_765 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.003901
K_766 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.004881
K_767 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.004853
K_768 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.004807
K_769 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.004916
K_770 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.006366
K_771 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.006532
K_772 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.006367
K_773 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.006469
K_774 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.009037
K_775 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.008731
K_776 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.008690
K_777 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.008839
K_778 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.004230
K_779 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.004248
K_780 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.004183
K_781 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.004262
K_782 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.009447
K_783 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.009715
K_784 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.009337
K_785 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.009334
K_786 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.004993
K_787 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.004940
K_788 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.004882
K_789 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.004968
K_790 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.004614
K_791 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.004668
K_792 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.004568
K_793 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.004634
K_794 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.007175
K_795 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.007124
K_796 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006966
K_797 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.007006
K_798 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.004269
K_799 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.004267
K_800 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.004196
K_801 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.004261
K_802 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.005114
K_803 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.005148
K_804 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.005029
K_805 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.005080
K_806 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.009443
K_807 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.005340
K_808 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.003852
K_809 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_810 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_811 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_812 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.004634
K_813 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.004721
K_814 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.004699
K_815 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.004641
K_816 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.006195
K_817 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.006147
K_818 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.006229
K_819 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.006059
K_820 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.008644
K_821 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.008968
K_822 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.008645
K_823 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.008716
K_824 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.004166
K_825 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.004205
K_826 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.004203
K_827 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.004134
K_828 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.009357
K_829 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.009196
K_830 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.009135
K_831 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.008960
K_832 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.004968
K_833 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.005066
K_834 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.004988
K_835 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.004955
K_836 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.004688
K_837 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.004698
K_838 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.004693
K_839 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.004609
K_840 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006815
K_841 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006882
K_842 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.006715
K_843 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.006686
K_844 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.004555
K_845 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.004601
K_846 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.004553
K_847 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.004501
K_848 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.004344
K_849 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.007604
K_850 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.004780
K_851 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_852 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_853 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.004549
K_854 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.004634
K_855 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.004612
K_856 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.004557
K_857 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.006238
K_858 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.006195
K_859 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.006276
K_860 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.006102
K_861 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.008340
K_862 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.008644
K_863 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.008348
K_864 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.008411
K_865 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.004126
K_866 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.004166
K_867 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.004163
K_868 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.004095
K_869 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.009507
K_870 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.009357
K_871 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.009283
K_872 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.009100
K_873 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.004873
K_874 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.004968
K_875 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.004894
K_876 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.004862
K_877 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.004676
K_878 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.004688
K_879 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.004682
K_880 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.004599
K_881 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.006744
K_882 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006815
K_883 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.006650
K_884 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.006622
K_885 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.004508
K_886 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.004555
K_887 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.004508
K_888 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.004457
K_889 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.004288
K_890 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.007794
K_891 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.004703
K_892 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_893 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.004569
K_894 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.004653
K_895 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.004634
K_896 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.004577
K_897 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.006156
K_898 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.006112
K_899 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.006195
K_900 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.006025
K_901 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.008629
K_902 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.008959
K_903 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.008644
K_904 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.008707
K_905 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.004128
K_906 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.004167
K_907 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.004166
K_908 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.004097
K_909 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.009577
K_910 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.009414
K_911 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.009357
K_912 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.009161
K_913 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.004945
K_914 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.005043
K_915 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.004968
K_916 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.004934
K_917 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.004681
K_918 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.004691
K_919 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.004688
K_920 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.004603
K_921 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006912
K_922 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006985
K_923 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006815
K_924 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.006781
K_925 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.004554
K_926 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.004601
K_927 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.004555
K_928 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.004502
K_929 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.004268
K_930 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.007670
K_931 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.004789
K_932 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.004624
K_933 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.004712
K_934 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.004690
K_935 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.004634
K_936 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.006335
K_937 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.006287
K_938 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.006374
K_939 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.006195
K_940 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.008560
K_941 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.008882
K_942 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.008568
K_943 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.008644
K_944 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.004197
K_945 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.004238
K_946 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.004236
K_947 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.004166
K_948 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.009791
K_949 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.009618
K_950 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.009547
K_951 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.009357
K_952 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.004979
K_953 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.005078
K_954 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.005000
K_955 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.004968
K_956 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.004769
K_957 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.004781
K_958 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.004776
K_959 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.004688
K_960 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006945
K_961 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.007019
K_962 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006843
K_963 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006815
K_964 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.004608
K_965 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.004657
K_966 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.004607
K_967 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.004555
K_968 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.004334
K_969 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.007863
K_970 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.004800
K_971 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_972 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_973 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_974 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.004486
K_975 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.004393
K_976 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.004440
K_977 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.004426
K_978 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.006070
K_979 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.005985
K_980 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.005929
K_981 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.006074
K_982 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.008581
K_983 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.008382
K_984 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.008488
K_985 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.008259
K_986 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.004166
K_987 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.004091
K_988 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.004099
K_989 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.004123
K_990 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.009334
K_991 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.009259
K_992 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.008957
K_993 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.009177
K_994 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.005072
K_995 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.004975
K_996 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.004995
K_997 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.004962
K_998 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.004867
K_999 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.004793
K_1000 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.004758
K_1001 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.004809
K_1002 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.006319
K_1003 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.006224
K_1004 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.006156
K_1005 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.006158
K_1006 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.010132
K_1007 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.003675
K_1008 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.006074
K_1009 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_1010 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_1011 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.004583
K_1012 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.004486
K_1013 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.004536
K_1014 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.004520
K_1015 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.006154
K_1016 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.006070
K_1017 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.006009
K_1018 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.006161
K_1019 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.008779
K_1020 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.008581
K_1021 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.008688
K_1022 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.008442
K_1023 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.004243
K_1024 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.004166
K_1025 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.004174
K_1026 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.004198
K_1027 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.009391
K_1028 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.009334
K_1029 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.009016
K_1030 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.009240
K_1031 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.005173
K_1032 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.005072
K_1033 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.005092
K_1034 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.005057
K_1035 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.004942
K_1036 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.004867
K_1037 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.004829
K_1038 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.004883
K_1039 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.006412
K_1040 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.006319
K_1041 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.006245
K_1042 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.006246
K_1043 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.010314
K_1044 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.003740
K_1045 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.006105
K_1046 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_1047 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.004531
K_1048 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.004436
K_1049 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.004486
K_1050 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.004470
K_1051 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.006217
K_1052 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.006128
K_1053 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.006070
K_1054 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.006224
K_1055 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.008662
K_1056 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.008465
K_1057 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.008581
K_1058 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.008338
K_1059 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.004234
K_1060 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.004156
K_1061 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.004166
K_1062 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.004189
K_1063 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.009741
K_1064 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.009667
K_1065 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.009334
K_1066 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.009573
K_1067 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.005151
K_1068 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.005050
K_1069 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.005072
K_1070 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.005036
K_1071 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.004981
K_1072 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.004903
K_1073 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.004867
K_1074 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.004921
K_1075 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.006488
K_1076 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.006389
K_1077 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.006319
K_1078 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.006317
K_1079 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.009833
K_1080 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.003715
K_1081 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.006245
K_1082 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.004547
K_1083 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.004450
K_1084 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.004500
K_1085 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.004486
K_1086 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.006061
K_1087 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.005978
K_1088 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.005922
K_1089 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.006070
K_1090 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.008928
K_1091 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.008712
K_1092 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.008832
K_1093 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.008581
K_1094 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.004209
K_1095 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.004132
K_1096 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.004141
K_1097 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.004166
K_1098 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.009479
K_1099 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.009411
K_1100 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.009094
K_1101 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.009334
K_1102 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.005188
K_1103 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.005085
K_1104 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.005107
K_1105 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.005072
K_1106 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.004924
K_1107 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.004849
K_1108 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.004812
K_1109 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.004867
K_1110 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.006487
K_1111 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.006387
K_1112 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.006314
K_1113 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.006319
K_1114 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.010091
K_1115 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.003707
K_1116 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.006134
K_1117 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_1118 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_1119 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_1120 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.004440
K_1121 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.004499
K_1122 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.004426
K_1123 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.004501
K_1124 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.006070
K_1125 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.006240
K_1126 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.006151
K_1127 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.006099
K_1128 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.008644
K_1129 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.008638
K_1130 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.008376
K_1131 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.008684
K_1132 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.004262
K_1133 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.004339
K_1134 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.004263
K_1135 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.004299
K_1136 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.009242
K_1137 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.009475
K_1138 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.009160
K_1139 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.009081
K_1140 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.005308
K_1141 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.005369
K_1142 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.005238
K_1143 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.005332
K_1144 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.005264
K_1145 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.005365
K_1146 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.005240
K_1147 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.005265
K_1148 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.004901
K_1149 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.011959
K_1150 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.003908
K_1151 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_1152 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_1153 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.004381
K_1154 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.004440
K_1155 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.004369
K_1156 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.004441
K_1157 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.005909
K_1158 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.006070
K_1159 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.005985
K_1160 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.005938
K_1161 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.008636
K_1162 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.008644
K_1163 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.008375
K_1164 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.008684
K_1165 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.004188
K_1166 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.004262
K_1167 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.004190
K_1168 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.004224
K_1169 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.009008
K_1170 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.009242
K_1171 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.008941
K_1172 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.008867
K_1173 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.005246
K_1174 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.005308
K_1175 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.005180
K_1176 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.005271
K_1177 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.005165
K_1178 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.005264
K_1179 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.005144
K_1180 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.005168
K_1181 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.004800
K_1182 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.012364
K_1183 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.003854
K_1184 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_1185 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.004451
K_1186 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.004512
K_1187 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.004440
K_1188 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.004514
K_1189 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.005987
K_1190 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.006153
K_1191 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.006070
K_1192 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.006018
K_1193 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.008924
K_1194 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.008925
K_1195 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.008644
K_1196 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.008976
K_1197 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.004260
K_1198 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.004337
K_1199 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.004262
K_1200 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.004298
K_1201 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.009307
K_1202 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.009555
K_1203 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.009242
K_1204 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.009151
K_1205 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.005377
K_1206 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.005442
K_1207 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.005308
K_1208 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.005404
K_1209 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.005285
K_1210 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.005389
K_1211 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.005264
K_1212 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.005287
K_1213 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.004809
K_1214 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.012512
K_1215 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.003922
K_1216 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.004379
K_1217 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.004437
K_1218 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.004367
K_1219 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.004440
K_1220 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.006036
K_1221 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.006206
K_1222 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.006119
K_1223 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.006070
K_1224 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.008590
K_1225 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.008591
K_1226 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.008333
K_1227 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.008644
K_1228 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.004225
K_1229 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.004300
K_1230 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.004226
K_1231 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.004262
K_1232 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.009393
K_1233 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.009648
K_1234 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.009316
K_1235 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.009242
K_1236 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.005281
K_1237 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.005343
K_1238 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.005214
K_1239 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.005308
K_1240 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.005259
K_1241 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.005362
K_1242 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.005237
K_1243 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.005264
K_1244 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.004820
K_1245 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.011927
K_1246 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.003884
K_1247 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_1248 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_1249 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_1250 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.004486
K_1251 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.004491
K_1252 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.004531
K_1253 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.004435
K_1254 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.006195
K_1255 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.006038
K_1256 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.006126
K_1257 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.006048
K_1258 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.008839
K_1259 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.009043
K_1260 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.008945
K_1261 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.008685
K_1262 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.004482
K_1263 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.004447
K_1264 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.004485
K_1265 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.004402
K_1266 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.008998
K_1267 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.008802
K_1268 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.008763
K_1269 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.008628
K_1270 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.005769
K_1271 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.005768
K_1272 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.005764
K_1273 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.005640
K_1274 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.004419
K_1275 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.004571
K_1276 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.008802
K_1277 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_1278 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_1279 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.004479
K_1280 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.004486
K_1281 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.004525
K_1282 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.004430
K_1283 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.006359
K_1284 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.006195
K_1285 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.006288
K_1286 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.006204
K_1287 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.008632
K_1288 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.008839
K_1289 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.008739
K_1290 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.008496
K_1291 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.004515
K_1292 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.004482
K_1293 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.004520
K_1294 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.004435
K_1295 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.009191
K_1296 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.008998
K_1297 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.008949
K_1298 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.008805
K_1299 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.005765
K_1300 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.005769
K_1301 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.005763
K_1302 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.005639
K_1303 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.004401
K_1304 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.004660
K_1305 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.008642
K_1306 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_1307 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.004440
K_1308 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.004445
K_1309 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.004486
K_1310 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.004392
K_1311 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.006261
K_1312 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.006101
K_1313 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.006195
K_1314 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.006112
K_1315 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.008720
K_1316 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.008925
K_1317 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.008839
K_1318 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.008579
K_1319 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.004476
K_1320 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.004442
K_1321 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.004482
K_1322 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.004398
K_1323 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.009235
K_1324 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.009032
K_1325 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.008998
K_1326 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.008844
K_1327 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.005770
K_1328 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.005771
K_1329 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.005769
K_1330 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.005643
K_1331 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.004340
K_1332 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.004587
K_1333 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.008865
K_1334 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.004536
K_1335 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.004542
K_1336 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.004584
K_1337 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.004486
K_1338 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.006347
K_1339 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.006181
K_1340 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.006276
K_1341 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.006195
K_1342 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.008984
K_1343 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.009209
K_1344 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.009105
K_1345 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.008839
K_1346 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.004564
K_1347 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.004528
K_1348 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.004568
K_1349 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.004482
K_1350 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.009401
K_1351 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.009187
K_1352 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.009143
K_1353 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.008998
K_1354 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.005902
K_1355 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.005904
K_1356 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.005899
K_1357 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.005769
K_1358 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.004418
K_1359 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.004638
K_1360 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.009011
K_1361 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_1362 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_1363 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_1364 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.004634
K_1365 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.004561
K_1366 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.004556
K_1367 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.004626
K_1368 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.006469
K_1369 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.006530
K_1370 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.006375
K_1371 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.006561
K_1372 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.009176
K_1373 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.008842
K_1374 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.008833
K_1375 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.008917
K_1376 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.004901
K_1377 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.004861
K_1378 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.004805
K_1379 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.004904
K_1380 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.008320
K_1381 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.008280
K_1382 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.008029
K_1383 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.008243
K_1384 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.007635
K_1385 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.004270
K_1386 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.005046
K_1387 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_1388 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_1389 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.004708
K_1390 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.004634
K_1391 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.004628
K_1392 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.004701
K_1393 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.006404
K_1394 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.006469
K_1395 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.006316
K_1396 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.006496
K_1397 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.009531
K_1398 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.009176
K_1399 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.009157
K_1400 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.009251
K_1401 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.004940
K_1402 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.004901
K_1403 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.004842
K_1404 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.004943
K_1405 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.008346
K_1406 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.008320
K_1407 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.008059
K_1408 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.008276
K_1409 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.007571
K_1410 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.004347
K_1411 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.005023
K_1412 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_1413 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.004713
K_1414 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.004638
K_1415 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.004634
K_1416 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.004706
K_1417 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.006561
K_1418 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.006628
K_1419 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.006469
K_1420 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.006660
K_1421 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.009543
K_1422 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.009178
K_1423 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.009176
K_1424 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.009261
K_1425 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.005001
K_1426 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.004960
K_1427 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.004901
K_1428 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.005005
K_1429 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.008630
K_1430 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.008593
K_1431 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.008320
K_1432 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.008552
K_1433 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.007447
K_1434 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.004323
K_1435 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.005124
K_1436 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.004639
K_1437 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.004567
K_1438 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.004562
K_1439 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.004634
K_1440 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.006376
K_1441 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.006437
K_1442 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.006288
K_1443 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.006469
K_1444 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.009440
K_1445 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.009086
K_1446 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.009076
K_1447 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.009176
K_1448 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.004896
K_1449 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.004858
K_1450 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.004802
K_1451 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.004901
K_1452 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.008385
K_1453 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.008351
K_1454 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.008093
K_1455 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.008320
K_1456 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.007394
K_1457 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.004279
K_1458 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.005012
K_1459 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_1460 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_1461 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_1462 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.004916
K_1463 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.005035
K_1464 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.004969
K_1465 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.004964
K_1466 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.006958
K_1467 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.007056
K_1468 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.007069
K_1469 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.006865
K_1470 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.009653
K_1471 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.010031
K_1472 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.009605
K_1473 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.009731
K_1474 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.005826
K_1475 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.005963
K_1476 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.005877
K_1477 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.005813
K_1478 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.003824
K_1479 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.013473
K_1480 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.005011
K_1481 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_1482 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_1483 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.004803
K_1484 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.004916
K_1485 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.004854
K_1486 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.004849
K_1487 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.006857
K_1488 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.006958
K_1489 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.006967
K_1490 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.006771
K_1491 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.009296
K_1492 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.009653
K_1493 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.009263
K_1494 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.009375
K_1495 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.005693
K_1496 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.005826
K_1497 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.005744
K_1498 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.005683
K_1499 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.003776
K_1500 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.014063
K_1501 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.004900
K_1502 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_1503 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.004863
K_1504 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.004979
K_1505 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.004916
K_1506 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.004911
K_1507 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.006845
K_1508 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.006942
K_1509 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.006958
K_1510 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.006760
K_1511 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.009679
K_1512 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.010073
K_1513 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.009653
K_1514 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.009769
K_1515 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.005771
K_1516 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.005907
K_1517 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.005826
K_1518 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.005761
K_1519 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.003757
K_1520 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.013185
K_1521 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.004987
K_1522 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.004867
K_1523 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.004983
K_1524 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.004919
K_1525 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.004916
K_1526 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.007047
K_1527 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.007153
K_1528 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.007166
K_1529 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.006958
K_1530 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.009556
K_1531 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.009934
K_1532 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.009520
K_1533 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.009653
K_1534 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.005835
K_1535 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.005975
K_1536 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.005889
K_1537 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.005826
K_1538 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.003789
K_1539 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.013608
K_1540 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.004970
K_1541 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_1542 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_1543 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_1544 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.005418
K_1545 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.005311
K_1546 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.005398
K_1547 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.005311
K_1548 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.007821
K_1549 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.007559
K_1550 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.007592
K_1551 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.007671
K_1552 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.010038
K_1553 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.009745
K_1554 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.009852
K_1555 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.009588
K_1556 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.005048
K_1557 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.003841
K_1558 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.017286
K_1559 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_1560 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_1561 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.005527
K_1562 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.005418
K_1563 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.005508
K_1564 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.005415
K_1565 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.008100
K_1566 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.007821
K_1567 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.007853
K_1568 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.007939
K_1569 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.010333
K_1570 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.010038
K_1571 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.010142
K_1572 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.009855
K_1573 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.005060
K_1574 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.003911
K_1575 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.017589
K_1576 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_1577 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.005434
K_1578 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.005328
K_1579 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.005418
K_1580 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.005328
K_1581 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.008059
K_1582 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.007779
K_1583 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.007821
K_1584 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.007901
K_1585 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.010210
K_1586 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.009914
K_1587 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.010038
K_1588 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.009748
K_1589 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.004951
K_1590 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.003859
K_1591 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.018776
K_1592 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.005527
K_1593 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.005416
K_1594 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.005508
K_1595 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.005418
K_1596 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.007969
K_1597 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.007697
K_1598 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.007733
K_1599 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.007821
K_1600 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.010531
K_1601 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.010206
K_1602 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.010329
K_1603 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.010038
K_1604 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.005019
K_1605 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.003868
K_1606 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.017703
K_1607 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_1608 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_1609 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_1610 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.006371
K_1611 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.006398
K_1612 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.006274
K_1613 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.006466
K_1614 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.009519
K_1615 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.009861
K_1616 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.009456
K_1617 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.009700
K_1618 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.004676
K_1619 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.006214
K_1620 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.004963
K_1621 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_1622 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_1623 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.006339
K_1624 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.006371
K_1625 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.006246
K_1626 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.006435
K_1627 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.009193
K_1628 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.009519
K_1629 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.009144
K_1630 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.009365
K_1631 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.004617
K_1632 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.006343
K_1633 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.004889
K_1634 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_1635 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.006467
K_1636 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.006498
K_1637 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.006371
K_1638 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.006569
K_1639 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.009564
K_1640 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.009922
K_1641 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.009519
K_1642 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.009758
K_1643 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.004587
K_1644 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.006265
K_1645 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.004980
K_1646 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.006275
K_1647 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.006303
K_1648 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.006185
K_1649 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.006371
K_1650 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.009329
K_1651 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.009661
K_1652 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.009279
K_1653 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.009519
K_1654 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.004586
K_1655 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.006162
K_1656 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.004891
K_1657 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_1658 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_1659 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_1660 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.008829
K_1661 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.009015
K_1662 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.009041
K_1663 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.008717
K_1664 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.003776
K_1665 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.005674
K_1666 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.009656
K_1667 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_1668 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_1669 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.008638
K_1670 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.008829
K_1671 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.008845
K_1672 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.008541
K_1673 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.003751
K_1674 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.005794
K_1675 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.009229
K_1676 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_1677 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.008615
K_1678 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.008796
K_1679 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.008829
K_1680 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.008519
K_1681 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.003710
K_1682 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.005645
K_1683 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.009453
K_1684 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.008928
K_1685 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.009129
K_1686 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.009157
K_1687 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.008829
K_1688 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.003748
K_1689 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.005702
K_1690 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.009452
K_1691 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_1692 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_1693 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_1694 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.004502
K_1695 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.004482
K_1696 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.009294
K_1697 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_1698 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_1699 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.004483
K_1700 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.004566
K_1701 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.009112
K_1702 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_1703 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.004417
K_1704 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.004495
K_1705 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.009357
K_1706 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.004440
K_1707 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.004482
K_1708 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.008998
K_1709 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.003752
K_1710 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.003953
K_1711 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.003752

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
