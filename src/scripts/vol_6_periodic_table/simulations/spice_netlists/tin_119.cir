* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Tin-119 (Z=50, A=119)
* Auto-generated topological mutual impedance array
* Nodes: 119

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON
X_NUC_65 NODE_65 0 NUCLEON
X_NUC_66 NODE_66 0 NUCLEON
X_NUC_67 NODE_67 0 NUCLEON
X_NUC_68 NODE_68 0 NUCLEON
X_NUC_69 NODE_69 0 NUCLEON
X_NUC_70 NODE_70 0 NUCLEON
X_NUC_71 NODE_71 0 NUCLEON
X_NUC_72 NODE_72 0 NUCLEON
X_NUC_73 NODE_73 0 NUCLEON
X_NUC_74 NODE_74 0 NUCLEON
X_NUC_75 NODE_75 0 NUCLEON
X_NUC_76 NODE_76 0 NUCLEON
X_NUC_77 NODE_77 0 NUCLEON
X_NUC_78 NODE_78 0 NUCLEON
X_NUC_79 NODE_79 0 NUCLEON
X_NUC_80 NODE_80 0 NUCLEON
X_NUC_81 NODE_81 0 NUCLEON
X_NUC_82 NODE_82 0 NUCLEON
X_NUC_83 NODE_83 0 NUCLEON
X_NUC_84 NODE_84 0 NUCLEON
X_NUC_85 NODE_85 0 NUCLEON
X_NUC_86 NODE_86 0 NUCLEON
X_NUC_87 NODE_87 0 NUCLEON
X_NUC_88 NODE_88 0 NUCLEON
X_NUC_89 NODE_89 0 NUCLEON
X_NUC_90 NODE_90 0 NUCLEON
X_NUC_91 NODE_91 0 NUCLEON
X_NUC_92 NODE_92 0 NUCLEON
X_NUC_93 NODE_93 0 NUCLEON
X_NUC_94 NODE_94 0 NUCLEON
X_NUC_95 NODE_95 0 NUCLEON
X_NUC_96 NODE_96 0 NUCLEON
X_NUC_97 NODE_97 0 NUCLEON
X_NUC_98 NODE_98 0 NUCLEON
X_NUC_99 NODE_99 0 NUCLEON
X_NUC_100 NODE_100 0 NUCLEON
X_NUC_101 NODE_101 0 NUCLEON
X_NUC_102 NODE_102 0 NUCLEON
X_NUC_103 NODE_103 0 NUCLEON
X_NUC_104 NODE_104 0 NUCLEON
X_NUC_105 NODE_105 0 NUCLEON
X_NUC_106 NODE_106 0 NUCLEON
X_NUC_107 NODE_107 0 NUCLEON
X_NUC_108 NODE_108 0 NUCLEON
X_NUC_109 NODE_109 0 NUCLEON
X_NUC_110 NODE_110 0 NUCLEON
X_NUC_111 NODE_111 0 NUCLEON
X_NUC_112 NODE_112 0 NUCLEON
X_NUC_113 NODE_113 0 NUCLEON
X_NUC_114 NODE_114 0 NUCLEON
X_NUC_115 NODE_115 0 NUCLEON
X_NUC_116 NODE_116 0 NUCLEON
X_NUC_117 NODE_117 0 NUCLEON
X_NUC_118 NODE_118 0 NUCLEON
X_NUC_119 NODE_119 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.006455
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.006270
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.006315
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.006373
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.006968
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.007059
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.006869
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.007076
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.007441
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.007315
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.007407
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.007207
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.004202
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.004153
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.004129
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.004191
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.006290
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.006453
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.006291
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.006296
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.004183
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.004111
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.004130
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.004112
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.003791
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.003795
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.003740
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.003800
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.004877
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.004900
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.004873
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.004795
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.003215
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.003177
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.003169
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.003188
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.003804
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.003846
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.003777
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.003807
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.003545
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.003514
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.003516
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.003486
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.002914
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.002902
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.002876
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.002906
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.003622
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.003654
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.003610
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.003593
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.002835
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.002808
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.002802
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.002803
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.002888
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.002897
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.002859
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.002883
K_64 X_NUC_1.L_CORE X_NUC_65.L_CORE 0.003091
K_65 X_NUC_1.L_CORE X_NUC_66.L_CORE 0.003087
K_66 X_NUC_1.L_CORE X_NUC_67.L_CORE 0.003073
K_67 X_NUC_1.L_CORE X_NUC_68.L_CORE 0.003050
K_68 X_NUC_1.L_CORE X_NUC_69.L_CORE 0.002536
K_69 X_NUC_1.L_CORE X_NUC_70.L_CORE 0.002521
K_70 X_NUC_1.L_CORE X_NUC_71.L_CORE 0.002506
K_71 X_NUC_1.L_CORE X_NUC_72.L_CORE 0.002519
K_72 X_NUC_1.L_CORE X_NUC_73.L_CORE 0.002864
K_73 X_NUC_1.L_CORE X_NUC_74.L_CORE 0.002880
K_74 X_NUC_1.L_CORE X_NUC_75.L_CORE 0.002844
K_75 X_NUC_1.L_CORE X_NUC_76.L_CORE 0.002849
K_76 X_NUC_1.L_CORE X_NUC_77.L_CORE 0.002611
K_77 X_NUC_1.L_CORE X_NUC_78.L_CORE 0.002595
K_78 X_NUC_1.L_CORE X_NUC_79.L_CORE 0.002586
K_79 X_NUC_1.L_CORE X_NUC_80.L_CORE 0.002580
K_80 X_NUC_1.L_CORE X_NUC_81.L_CORE 0.002454
K_81 X_NUC_1.L_CORE X_NUC_82.L_CORE 0.002452
K_82 X_NUC_1.L_CORE X_NUC_83.L_CORE 0.002428
K_83 X_NUC_1.L_CORE X_NUC_84.L_CORE 0.002443
K_84 X_NUC_1.L_CORE X_NUC_85.L_CORE 0.002653
K_85 X_NUC_1.L_CORE X_NUC_86.L_CORE 0.002658
K_86 X_NUC_1.L_CORE X_NUC_87.L_CORE 0.002636
K_87 X_NUC_1.L_CORE X_NUC_88.L_CORE 0.002629
K_88 X_NUC_1.L_CORE X_NUC_89.L_CORE 0.002353
K_89 X_NUC_1.L_CORE X_NUC_90.L_CORE 0.002342
K_90 X_NUC_1.L_CORE X_NUC_91.L_CORE 0.002329
K_91 X_NUC_1.L_CORE X_NUC_92.L_CORE 0.002333
K_92 X_NUC_1.L_CORE X_NUC_93.L_CORE 0.002411
K_93 X_NUC_1.L_CORE X_NUC_94.L_CORE 0.002414
K_94 X_NUC_1.L_CORE X_NUC_95.L_CORE 0.002390
K_95 X_NUC_1.L_CORE X_NUC_96.L_CORE 0.002396
K_96 X_NUC_1.L_CORE X_NUC_97.L_CORE 0.002367
K_97 X_NUC_1.L_CORE X_NUC_98.L_CORE 0.002364
K_98 X_NUC_1.L_CORE X_NUC_99.L_CORE 0.002347
K_99 X_NUC_1.L_CORE X_NUC_100.L_CORE 0.002346
K_100 X_NUC_1.L_CORE X_NUC_101.L_CORE 0.033548
K_101 X_NUC_1.L_CORE X_NUC_102.L_CORE 0.005381
K_102 X_NUC_1.L_CORE X_NUC_103.L_CORE 0.005729
K_103 X_NUC_1.L_CORE X_NUC_104.L_CORE 0.005800
K_104 X_NUC_1.L_CORE X_NUC_105.L_CORE 0.003518
K_105 X_NUC_1.L_CORE X_NUC_106.L_CORE 0.004898
K_106 X_NUC_1.L_CORE X_NUC_107.L_CORE 0.003423
K_107 X_NUC_1.L_CORE X_NUC_108.L_CORE 0.003143
K_108 X_NUC_1.L_CORE X_NUC_109.L_CORE 0.003775
K_109 X_NUC_1.L_CORE X_NUC_110.L_CORE 0.002682
K_110 X_NUC_1.L_CORE X_NUC_111.L_CORE 0.003056
K_111 X_NUC_1.L_CORE X_NUC_112.L_CORE 0.002844
K_112 X_NUC_1.L_CORE X_NUC_113.L_CORE 0.002439
K_113 X_NUC_1.L_CORE X_NUC_114.L_CORE 0.002814
K_114 X_NUC_1.L_CORE X_NUC_115.L_CORE 0.002352
K_115 X_NUC_1.L_CORE X_NUC_116.L_CORE 0.002367
K_116 X_NUC_1.L_CORE X_NUC_117.L_CORE 0.002416
K_117 X_NUC_1.L_CORE X_NUC_118.L_CORE 0.002157
K_118 X_NUC_1.L_CORE X_NUC_119.L_CORE 0.002226
K_119 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_120 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_121 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.006649
K_122 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.006455
K_123 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.006500
K_124 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.006564
K_125 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.006873
K_126 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.006968
K_127 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.006782
K_128 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.006981
K_129 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.007564
K_130 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.007441
K_131 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.007533
K_132 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.007322
K_133 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.004252
K_134 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.004202
K_135 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.004177
K_136 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.004242
K_137 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.006134
K_138 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.006290
K_139 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.006138
K_140 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.006142
K_141 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.004258
K_142 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.004183
K_143 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.004202
K_144 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.004184
K_145 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.003786
K_146 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.003791
K_147 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.003736
K_148 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.003796
K_149 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.004851
K_150 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.004877
K_151 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.004849
K_152 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.004772
K_153 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.003253
K_154 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.003215
K_155 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.003206
K_156 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.003226
K_157 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.003762
K_158 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.003804
K_159 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.003736
K_160 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.003766
K_161 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.003576
K_162 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.003545
K_163 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.003547
K_164 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.003515
K_165 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.002926
K_166 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.002914
K_167 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.002888
K_168 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.002918
K_169 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.003590
K_170 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.003622
K_171 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.003578
K_172 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.003562
K_173 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.002863
K_174 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.002835
K_175 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.002830
K_176 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.002830
K_177 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.002878
K_178 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.002888
K_179 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.002850
K_180 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.002873
K_181 X_NUC_2.L_CORE X_NUC_65.L_CORE 0.003094
K_182 X_NUC_2.L_CORE X_NUC_66.L_CORE 0.003091
K_183 X_NUC_2.L_CORE X_NUC_67.L_CORE 0.003076
K_184 X_NUC_2.L_CORE X_NUC_68.L_CORE 0.003054
K_185 X_NUC_2.L_CORE X_NUC_69.L_CORE 0.002551
K_186 X_NUC_2.L_CORE X_NUC_70.L_CORE 0.002536
K_187 X_NUC_2.L_CORE X_NUC_71.L_CORE 0.002520
K_188 X_NUC_2.L_CORE X_NUC_72.L_CORE 0.002534
K_189 X_NUC_2.L_CORE X_NUC_73.L_CORE 0.002847
K_190 X_NUC_2.L_CORE X_NUC_74.L_CORE 0.002864
K_191 X_NUC_2.L_CORE X_NUC_75.L_CORE 0.002828
K_192 X_NUC_2.L_CORE X_NUC_76.L_CORE 0.002833
K_193 X_NUC_2.L_CORE X_NUC_77.L_CORE 0.002626
K_194 X_NUC_2.L_CORE X_NUC_78.L_CORE 0.002611
K_195 X_NUC_2.L_CORE X_NUC_79.L_CORE 0.002601
K_196 X_NUC_2.L_CORE X_NUC_80.L_CORE 0.002595
K_197 X_NUC_2.L_CORE X_NUC_81.L_CORE 0.002456
K_198 X_NUC_2.L_CORE X_NUC_82.L_CORE 0.002454
K_199 X_NUC_2.L_CORE X_NUC_83.L_CORE 0.002430
K_200 X_NUC_2.L_CORE X_NUC_84.L_CORE 0.002445
K_201 X_NUC_2.L_CORE X_NUC_85.L_CORE 0.002649
K_202 X_NUC_2.L_CORE X_NUC_86.L_CORE 0.002653
K_203 X_NUC_2.L_CORE X_NUC_87.L_CORE 0.002632
K_204 X_NUC_2.L_CORE X_NUC_88.L_CORE 0.002625
K_205 X_NUC_2.L_CORE X_NUC_89.L_CORE 0.002364
K_206 X_NUC_2.L_CORE X_NUC_90.L_CORE 0.002353
K_207 X_NUC_2.L_CORE X_NUC_91.L_CORE 0.002339
K_208 X_NUC_2.L_CORE X_NUC_92.L_CORE 0.002343
K_209 X_NUC_2.L_CORE X_NUC_93.L_CORE 0.002408
K_210 X_NUC_2.L_CORE X_NUC_94.L_CORE 0.002411
K_211 X_NUC_2.L_CORE X_NUC_95.L_CORE 0.002387
K_212 X_NUC_2.L_CORE X_NUC_96.L_CORE 0.002393
K_213 X_NUC_2.L_CORE X_NUC_97.L_CORE 0.002371
K_214 X_NUC_2.L_CORE X_NUC_98.L_CORE 0.002367
K_215 X_NUC_2.L_CORE X_NUC_99.L_CORE 0.002351
K_216 X_NUC_2.L_CORE X_NUC_100.L_CORE 0.002350
K_217 X_NUC_2.L_CORE X_NUC_101.L_CORE 0.031395
K_218 X_NUC_2.L_CORE X_NUC_102.L_CORE 0.005518
K_219 X_NUC_2.L_CORE X_NUC_103.L_CORE 0.005653
K_220 X_NUC_2.L_CORE X_NUC_104.L_CORE 0.005865
K_221 X_NUC_2.L_CORE X_NUC_105.L_CORE 0.003552
K_222 X_NUC_2.L_CORE X_NUC_106.L_CORE 0.004801
K_223 X_NUC_2.L_CORE X_NUC_107.L_CORE 0.003471
K_224 X_NUC_2.L_CORE X_NUC_108.L_CORE 0.003139
K_225 X_NUC_2.L_CORE X_NUC_109.L_CORE 0.003759
K_226 X_NUC_2.L_CORE X_NUC_110.L_CORE 0.002707
K_227 X_NUC_2.L_CORE X_NUC_111.L_CORE 0.003030
K_228 X_NUC_2.L_CORE X_NUC_112.L_CORE 0.002861
K_229 X_NUC_2.L_CORE X_NUC_113.L_CORE 0.002446
K_230 X_NUC_2.L_CORE X_NUC_114.L_CORE 0.002798
K_231 X_NUC_2.L_CORE X_NUC_115.L_CORE 0.002368
K_232 X_NUC_2.L_CORE X_NUC_116.L_CORE 0.002362
K_233 X_NUC_2.L_CORE X_NUC_117.L_CORE 0.002418
K_234 X_NUC_2.L_CORE X_NUC_118.L_CORE 0.002164
K_235 X_NUC_2.L_CORE X_NUC_119.L_CORE 0.002224
K_236 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_237 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.006597
K_238 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.006404
K_239 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.006455
K_240 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.006514
K_241 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.007063
K_242 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.007162
K_243 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.006968
K_244 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.007180
K_245 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.007466
K_246 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.007343
K_247 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.007441
K_248 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.007234
K_249 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.004278
K_250 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.004227
K_251 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.004202
K_252 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.004267
K_253 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.006284
K_254 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.006449
K_255 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.006290
K_256 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.006292
K_257 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.004237
K_258 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.004163
K_259 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.004183
K_260 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.004164
K_261 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.003842
K_262 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.003847
K_263 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.003791
K_264 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.003853
K_265 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.004878
K_266 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.004903
K_267 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.004877
K_268 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.004797
K_269 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.003262
K_270 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.003223
K_271 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.003215
K_272 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.003235
K_273 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.003830
K_274 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.003874
K_275 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.003804
K_276 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.003834
K_277 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.003573
K_278 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.003542
K_279 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.003545
K_280 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.003513
K_281 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.002953
K_282 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.002941
K_283 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.002914
K_284 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.002945
K_285 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.003634
K_286 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.003667
K_287 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.003622
K_288 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.003605
K_289 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.002869
K_290 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.002840
K_291 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.002835
K_292 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.002836
K_293 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.002916
K_294 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.002927
K_295 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.002888
K_296 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.002912
K_297 X_NUC_3.L_CORE X_NUC_65.L_CORE 0.003109
K_298 X_NUC_3.L_CORE X_NUC_66.L_CORE 0.003105
K_299 X_NUC_3.L_CORE X_NUC_67.L_CORE 0.003091
K_300 X_NUC_3.L_CORE X_NUC_68.L_CORE 0.003068
K_301 X_NUC_3.L_CORE X_NUC_69.L_CORE 0.002567
K_302 X_NUC_3.L_CORE X_NUC_70.L_CORE 0.002552
K_303 X_NUC_3.L_CORE X_NUC_71.L_CORE 0.002536
K_304 X_NUC_3.L_CORE X_NUC_72.L_CORE 0.002550
K_305 X_NUC_3.L_CORE X_NUC_73.L_CORE 0.002883
K_306 X_NUC_3.L_CORE X_NUC_74.L_CORE 0.002900
K_307 X_NUC_3.L_CORE X_NUC_75.L_CORE 0.002864
K_308 X_NUC_3.L_CORE X_NUC_76.L_CORE 0.002868
K_309 X_NUC_3.L_CORE X_NUC_77.L_CORE 0.002635
K_310 X_NUC_3.L_CORE X_NUC_78.L_CORE 0.002619
K_311 X_NUC_3.L_CORE X_NUC_79.L_CORE 0.002611
K_312 X_NUC_3.L_CORE X_NUC_80.L_CORE 0.002604
K_313 X_NUC_3.L_CORE X_NUC_81.L_CORE 0.002480
K_314 X_NUC_3.L_CORE X_NUC_82.L_CORE 0.002478
K_315 X_NUC_3.L_CORE X_NUC_83.L_CORE 0.002454
K_316 X_NUC_3.L_CORE X_NUC_84.L_CORE 0.002469
K_317 X_NUC_3.L_CORE X_NUC_85.L_CORE 0.002671
K_318 X_NUC_3.L_CORE X_NUC_86.L_CORE 0.002675
K_319 X_NUC_3.L_CORE X_NUC_87.L_CORE 0.002653
K_320 X_NUC_3.L_CORE X_NUC_88.L_CORE 0.002646
K_321 X_NUC_3.L_CORE X_NUC_89.L_CORE 0.002378
K_322 X_NUC_3.L_CORE X_NUC_90.L_CORE 0.002367
K_323 X_NUC_3.L_CORE X_NUC_91.L_CORE 0.002353
K_324 X_NUC_3.L_CORE X_NUC_92.L_CORE 0.002357
K_325 X_NUC_3.L_CORE X_NUC_93.L_CORE 0.002432
K_326 X_NUC_3.L_CORE X_NUC_94.L_CORE 0.002435
K_327 X_NUC_3.L_CORE X_NUC_95.L_CORE 0.002411
K_328 X_NUC_3.L_CORE X_NUC_96.L_CORE 0.002417
K_329 X_NUC_3.L_CORE X_NUC_97.L_CORE 0.002388
K_330 X_NUC_3.L_CORE X_NUC_98.L_CORE 0.002384
K_331 X_NUC_3.L_CORE X_NUC_99.L_CORE 0.002367
K_332 X_NUC_3.L_CORE X_NUC_100.L_CORE 0.002366
K_333 X_NUC_3.L_CORE X_NUC_101.L_CORE 0.028952
K_334 X_NUC_3.L_CORE X_NUC_102.L_CORE 0.005467
K_335 X_NUC_3.L_CORE X_NUC_103.L_CORE 0.005776
K_336 X_NUC_3.L_CORE X_NUC_104.L_CORE 0.005797
K_337 X_NUC_3.L_CORE X_NUC_105.L_CORE 0.003570
K_338 X_NUC_3.L_CORE X_NUC_106.L_CORE 0.004888
K_339 X_NUC_3.L_CORE X_NUC_107.L_CORE 0.003458
K_340 X_NUC_3.L_CORE X_NUC_108.L_CORE 0.003179
K_341 X_NUC_3.L_CORE X_NUC_109.L_CORE 0.003777
K_342 X_NUC_3.L_CORE X_NUC_110.L_CORE 0.002715
K_343 X_NUC_3.L_CORE X_NUC_111.L_CORE 0.003074
K_344 X_NUC_3.L_CORE X_NUC_112.L_CORE 0.002863
K_345 X_NUC_3.L_CORE X_NUC_113.L_CORE 0.002466
K_346 X_NUC_3.L_CORE X_NUC_114.L_CORE 0.002826
K_347 X_NUC_3.L_CORE X_NUC_115.L_CORE 0.002375
K_348 X_NUC_3.L_CORE X_NUC_116.L_CORE 0.002388
K_349 X_NUC_3.L_CORE X_NUC_117.L_CORE 0.002432
K_350 X_NUC_3.L_CORE X_NUC_118.L_CORE 0.002179
K_351 X_NUC_3.L_CORE X_NUC_119.L_CORE 0.002243
K_352 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.006533
K_353 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.006345
K_354 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.006391
K_355 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.006455
K_356 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.006857
K_357 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.006947
K_358 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.006767
K_359 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.006968
K_360 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.007689
K_361 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.007555
K_362 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.007656
K_363 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.007441
K_364 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.004212
K_365 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.004163
K_366 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.004139
K_367 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.004202
K_368 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.006279
K_369 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.006444
K_370 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.006283
K_371 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.006290
K_372 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.004256
K_373 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.004181
K_374 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.004201
K_375 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.004183
K_376 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.003780
K_377 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.003784
K_378 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.003730
K_379 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.003791
K_380 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.004961
K_381 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.004987
K_382 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.004958
K_383 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.004877
K_384 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.003242
K_385 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.003203
K_386 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.003195
K_387 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.003215
K_388 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.003799
K_389 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.003842
K_390 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.003773
K_391 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.003804
K_392 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.003606
K_393 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.003574
K_394 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.003577
K_395 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.003545
K_396 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.002923
K_397 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.002911
K_398 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.002884
K_399 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.002914
K_400 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.003651
K_401 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.003684
K_402 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.003639
K_403 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.003622
K_404 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.002868
K_405 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.002840
K_406 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.002834
K_407 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.002835
K_408 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.002892
K_409 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.002902
K_410 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.002863
K_411 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.002888
K_412 X_NUC_4.L_CORE X_NUC_65.L_CORE 0.003133
K_413 X_NUC_4.L_CORE X_NUC_66.L_CORE 0.003129
K_414 X_NUC_4.L_CORE X_NUC_67.L_CORE 0.003114
K_415 X_NUC_4.L_CORE X_NUC_68.L_CORE 0.003091
K_416 X_NUC_4.L_CORE X_NUC_69.L_CORE 0.002553
K_417 X_NUC_4.L_CORE X_NUC_70.L_CORE 0.002538
K_418 X_NUC_4.L_CORE X_NUC_71.L_CORE 0.002522
K_419 X_NUC_4.L_CORE X_NUC_72.L_CORE 0.002536
K_420 X_NUC_4.L_CORE X_NUC_73.L_CORE 0.002878
K_421 X_NUC_4.L_CORE X_NUC_74.L_CORE 0.002895
K_422 X_NUC_4.L_CORE X_NUC_75.L_CORE 0.002859
K_423 X_NUC_4.L_CORE X_NUC_76.L_CORE 0.002864
K_424 X_NUC_4.L_CORE X_NUC_77.L_CORE 0.002642
K_425 X_NUC_4.L_CORE X_NUC_78.L_CORE 0.002626
K_426 X_NUC_4.L_CORE X_NUC_79.L_CORE 0.002617
K_427 X_NUC_4.L_CORE X_NUC_80.L_CORE 0.002611
K_428 X_NUC_4.L_CORE X_NUC_81.L_CORE 0.002465
K_429 X_NUC_4.L_CORE X_NUC_82.L_CORE 0.002463
K_430 X_NUC_4.L_CORE X_NUC_83.L_CORE 0.002439
K_431 X_NUC_4.L_CORE X_NUC_84.L_CORE 0.002454
K_432 X_NUC_4.L_CORE X_NUC_85.L_CORE 0.002678
K_433 X_NUC_4.L_CORE X_NUC_86.L_CORE 0.002683
K_434 X_NUC_4.L_CORE X_NUC_87.L_CORE 0.002660
K_435 X_NUC_4.L_CORE X_NUC_88.L_CORE 0.002653
K_436 X_NUC_4.L_CORE X_NUC_89.L_CORE 0.002373
K_437 X_NUC_4.L_CORE X_NUC_90.L_CORE 0.002362
K_438 X_NUC_4.L_CORE X_NUC_91.L_CORE 0.002349
K_439 X_NUC_4.L_CORE X_NUC_92.L_CORE 0.002353
K_440 X_NUC_4.L_CORE X_NUC_93.L_CORE 0.002425
K_441 X_NUC_4.L_CORE X_NUC_94.L_CORE 0.002428
K_442 X_NUC_4.L_CORE X_NUC_95.L_CORE 0.002404
K_443 X_NUC_4.L_CORE X_NUC_96.L_CORE 0.002411
K_444 X_NUC_4.L_CORE X_NUC_97.L_CORE 0.002389
K_445 X_NUC_4.L_CORE X_NUC_98.L_CORE 0.002385
K_446 X_NUC_4.L_CORE X_NUC_99.L_CORE 0.002368
K_447 X_NUC_4.L_CORE X_NUC_100.L_CORE 0.002367
K_448 X_NUC_4.L_CORE X_NUC_101.L_CORE 0.030614
K_449 X_NUC_4.L_CORE X_NUC_102.L_CORE 0.005429
K_450 X_NUC_4.L_CORE X_NUC_103.L_CORE 0.005641
K_451 X_NUC_4.L_CORE X_NUC_104.L_CORE 0.005941
K_452 X_NUC_4.L_CORE X_NUC_105.L_CORE 0.003524
K_453 X_NUC_4.L_CORE X_NUC_106.L_CORE 0.004891
K_454 X_NUC_4.L_CORE X_NUC_107.L_CORE 0.003473
K_455 X_NUC_4.L_CORE X_NUC_108.L_CORE 0.003137
K_456 X_NUC_4.L_CORE X_NUC_109.L_CORE 0.003825
K_457 X_NUC_4.L_CORE X_NUC_110.L_CORE 0.002702
K_458 X_NUC_4.L_CORE X_NUC_111.L_CORE 0.003057
K_459 X_NUC_4.L_CORE X_NUC_112.L_CORE 0.002883
K_460 X_NUC_4.L_CORE X_NUC_113.L_CORE 0.002447
K_461 X_NUC_4.L_CORE X_NUC_114.L_CORE 0.002834
K_462 X_NUC_4.L_CORE X_NUC_115.L_CORE 0.002375
K_463 X_NUC_4.L_CORE X_NUC_116.L_CORE 0.002375
K_464 X_NUC_4.L_CORE X_NUC_117.L_CORE 0.002440
K_465 X_NUC_4.L_CORE X_NUC_118.L_CORE 0.002172
K_466 X_NUC_4.L_CORE X_NUC_119.L_CORE 0.002241
K_467 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_468 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_469 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_470 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.004566
K_471 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.004661
K_472 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.004588
K_473 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.004625
K_474 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.005591
K_475 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.005660
K_476 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.005670
K_477 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.005539
K_478 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.007010
K_479 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.007018
K_480 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.006847
K_481 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.007061
K_482 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.003434
K_483 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.003489
K_484 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.003456
K_485 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.003447
K_486 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.006832
K_487 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.006736
K_488 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.006764
K_489 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.006620
K_490 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.003724
K_491 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.003764
K_492 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.003702
K_493 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.003748
K_494 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.003376
K_495 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.003411
K_496 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.003395
K_497 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.003360
K_498 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.005447
K_499 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.005375
K_500 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.005308
K_501 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.005364
K_502 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.002857
K_503 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.002892
K_504 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.002858
K_505 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.002865
K_506 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.003805
K_507 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.003805
K_508 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.003798
K_509 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.003747
K_510 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.003507
K_511 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.003516
K_512 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.003463
K_513 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.003505
K_514 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.002670
K_515 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.002696
K_516 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.002675
K_517 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.002664
K_518 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.003931
K_519 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.003899
K_520 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.003875
K_521 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.003863
K_522 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.002673
K_523 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.002695
K_524 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.002661
K_525 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.002675
K_526 X_NUC_5.L_CORE X_NUC_65.L_CORE 0.002807
K_527 X_NUC_5.L_CORE X_NUC_66.L_CORE 0.002819
K_528 X_NUC_5.L_CORE X_NUC_67.L_CORE 0.002804
K_529 X_NUC_5.L_CORE X_NUC_68.L_CORE 0.002782
K_530 X_NUC_5.L_CORE X_NUC_69.L_CORE 0.003218
K_531 X_NUC_5.L_CORE X_NUC_70.L_CORE 0.003210
K_532 X_NUC_5.L_CORE X_NUC_71.L_CORE 0.003173
K_533 X_NUC_5.L_CORE X_NUC_72.L_CORE 0.003193
K_534 X_NUC_5.L_CORE X_NUC_73.L_CORE 0.002396
K_535 X_NUC_5.L_CORE X_NUC_74.L_CORE 0.002415
K_536 X_NUC_5.L_CORE X_NUC_75.L_CORE 0.002391
K_537 X_NUC_5.L_CORE X_NUC_76.L_CORE 0.002391
K_538 X_NUC_5.L_CORE X_NUC_77.L_CORE 0.002948
K_539 X_NUC_5.L_CORE X_NUC_78.L_CORE 0.002944
K_540 X_NUC_5.L_CORE X_NUC_79.L_CORE 0.002927
K_541 X_NUC_5.L_CORE X_NUC_80.L_CORE 0.002912
K_542 X_NUC_5.L_CORE X_NUC_81.L_CORE 0.002584
K_543 X_NUC_5.L_CORE X_NUC_82.L_CORE 0.002594
K_544 X_NUC_5.L_CORE X_NUC_83.L_CORE 0.002563
K_545 X_NUC_5.L_CORE X_NUC_84.L_CORE 0.002576
K_546 X_NUC_5.L_CORE X_NUC_85.L_CORE 0.002392
K_547 X_NUC_5.L_CORE X_NUC_86.L_CORE 0.002404
K_548 X_NUC_5.L_CORE X_NUC_87.L_CORE 0.002386
K_549 X_NUC_5.L_CORE X_NUC_88.L_CORE 0.002378
K_550 X_NUC_5.L_CORE X_NUC_89.L_CORE 0.002724
K_551 X_NUC_5.L_CORE X_NUC_90.L_CORE 0.002722
K_552 X_NUC_5.L_CORE X_NUC_91.L_CORE 0.002697
K_553 X_NUC_5.L_CORE X_NUC_92.L_CORE 0.002699
K_554 X_NUC_5.L_CORE X_NUC_93.L_CORE 0.002320
K_555 X_NUC_5.L_CORE X_NUC_94.L_CORE 0.002332
K_556 X_NUC_5.L_CORE X_NUC_95.L_CORE 0.002308
K_557 X_NUC_5.L_CORE X_NUC_96.L_CORE 0.002311
K_558 X_NUC_5.L_CORE X_NUC_97.L_CORE 0.002411
K_559 X_NUC_5.L_CORE X_NUC_98.L_CORE 0.002416
K_560 X_NUC_5.L_CORE X_NUC_99.L_CORE 0.002397
K_561 X_NUC_5.L_CORE X_NUC_100.L_CORE 0.002392
K_562 X_NUC_5.L_CORE X_NUC_101.L_CORE 0.005761
K_563 X_NUC_5.L_CORE X_NUC_102.L_CORE 0.027386
K_564 X_NUC_5.L_CORE X_NUC_103.L_CORE 0.003970
K_565 X_NUC_5.L_CORE X_NUC_104.L_CORE 0.004702
K_566 X_NUC_5.L_CORE X_NUC_105.L_CORE 0.005530
K_567 X_NUC_5.L_CORE X_NUC_106.L_CORE 0.002967
K_568 X_NUC_5.L_CORE X_NUC_107.L_CORE 0.005079
K_569 X_NUC_5.L_CORE X_NUC_108.L_CORE 0.003136
K_570 X_NUC_5.L_CORE X_NUC_109.L_CORE 0.002862
K_571 X_NUC_5.L_CORE X_NUC_110.L_CORE 0.004014
K_572 X_NUC_5.L_CORE X_NUC_111.L_CORE 0.002459
K_573 X_NUC_5.L_CORE X_NUC_112.L_CORE 0.003034
K_574 X_NUC_5.L_CORE X_NUC_113.L_CORE 0.002826
K_575 X_NUC_5.L_CORE X_NUC_114.L_CORE 0.002300
K_576 X_NUC_5.L_CORE X_NUC_115.L_CORE 0.002910
K_577 X_NUC_5.L_CORE X_NUC_116.L_CORE 0.002281
K_578 X_NUC_5.L_CORE X_NUC_117.L_CORE 0.002329
K_579 X_NUC_5.L_CORE X_NUC_118.L_CORE 0.002430
K_580 X_NUC_5.L_CORE X_NUC_119.L_CORE 0.002151
K_581 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_582 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_583 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.004474
K_584 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.004566
K_585 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.004496
K_586 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.004531
K_587 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.005520
K_588 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.005591
K_589 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.005598
K_590 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.005472
K_591 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.006993
K_592 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.007010
K_593 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.006835
K_594 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.007048
K_595 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.003381
K_596 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.003434
K_597 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.003402
K_598 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.003393
K_599 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.006926
K_600 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.006832
K_601 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.006859
K_602 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.006709
K_603 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.003683
K_604 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.003724
K_605 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.003663
K_606 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.003708
K_607 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.003341
K_608 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.003376
K_609 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.003360
K_610 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.003325
K_611 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.005517
K_612 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.005447
K_613 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.005376
K_614 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.005434
K_615 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.002823
K_616 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.002857
K_617 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.002824
K_618 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.002831
K_619 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.003803
K_620 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.003805
K_621 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.003797
K_622 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.003746
K_623 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.003497
K_624 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.003507
K_625 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.003454
K_626 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.003495
K_627 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.002644
K_628 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.002670
K_629 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.002649
K_630 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.002638
K_631 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.003962
K_632 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.003931
K_633 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.003905
K_634 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.003894
K_635 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.002652
K_636 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.002673
K_637 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.002640
K_638 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.002654
K_639 X_NUC_6.L_CORE X_NUC_65.L_CORE 0.002794
K_640 X_NUC_6.L_CORE X_NUC_66.L_CORE 0.002807
K_641 X_NUC_6.L_CORE X_NUC_67.L_CORE 0.002792
K_642 X_NUC_6.L_CORE X_NUC_68.L_CORE 0.002770
K_643 X_NUC_6.L_CORE X_NUC_69.L_CORE 0.003224
K_644 X_NUC_6.L_CORE X_NUC_70.L_CORE 0.003218
K_645 X_NUC_6.L_CORE X_NUC_71.L_CORE 0.003179
K_646 X_NUC_6.L_CORE X_NUC_72.L_CORE 0.003200
K_647 X_NUC_6.L_CORE X_NUC_73.L_CORE 0.002376
K_648 X_NUC_6.L_CORE X_NUC_74.L_CORE 0.002396
K_649 X_NUC_6.L_CORE X_NUC_75.L_CORE 0.002372
K_650 X_NUC_6.L_CORE X_NUC_76.L_CORE 0.002372
K_651 X_NUC_6.L_CORE X_NUC_77.L_CORE 0.002952
K_652 X_NUC_6.L_CORE X_NUC_78.L_CORE 0.002948
K_653 X_NUC_6.L_CORE X_NUC_79.L_CORE 0.002930
K_654 X_NUC_6.L_CORE X_NUC_80.L_CORE 0.002915
K_655 X_NUC_6.L_CORE X_NUC_81.L_CORE 0.002574
K_656 X_NUC_6.L_CORE X_NUC_82.L_CORE 0.002584
K_657 X_NUC_6.L_CORE X_NUC_83.L_CORE 0.002553
K_658 X_NUC_6.L_CORE X_NUC_84.L_CORE 0.002567
K_659 X_NUC_6.L_CORE X_NUC_85.L_CORE 0.002379
K_660 X_NUC_6.L_CORE X_NUC_86.L_CORE 0.002392
K_661 X_NUC_6.L_CORE X_NUC_87.L_CORE 0.002373
K_662 X_NUC_6.L_CORE X_NUC_88.L_CORE 0.002365
K_663 X_NUC_6.L_CORE X_NUC_89.L_CORE 0.002727
K_664 X_NUC_6.L_CORE X_NUC_90.L_CORE 0.002724
K_665 X_NUC_6.L_CORE X_NUC_91.L_CORE 0.002700
K_666 X_NUC_6.L_CORE X_NUC_92.L_CORE 0.002701
K_667 X_NUC_6.L_CORE X_NUC_93.L_CORE 0.002309
K_668 X_NUC_6.L_CORE X_NUC_94.L_CORE 0.002320
K_669 X_NUC_6.L_CORE X_NUC_95.L_CORE 0.002297
K_670 X_NUC_6.L_CORE X_NUC_96.L_CORE 0.002300
K_671 X_NUC_6.L_CORE X_NUC_97.L_CORE 0.002405
K_672 X_NUC_6.L_CORE X_NUC_98.L_CORE 0.002411
K_673 X_NUC_6.L_CORE X_NUC_99.L_CORE 0.002391
K_674 X_NUC_6.L_CORE X_NUC_100.L_CORE 0.002387
K_675 X_NUC_6.L_CORE X_NUC_101.L_CORE 0.005620
K_676 X_NUC_6.L_CORE X_NUC_102.L_CORE 0.031005
K_677 X_NUC_6.L_CORE X_NUC_103.L_CORE 0.003902
K_678 X_NUC_6.L_CORE X_NUC_104.L_CORE 0.004664
K_679 X_NUC_6.L_CORE X_NUC_105.L_CORE 0.005544
K_680 X_NUC_6.L_CORE X_NUC_106.L_CORE 0.002927
K_681 X_NUC_6.L_CORE X_NUC_107.L_CORE 0.005144
K_682 X_NUC_6.L_CORE X_NUC_108.L_CORE 0.003110
K_683 X_NUC_6.L_CORE X_NUC_109.L_CORE 0.002838
K_684 X_NUC_6.L_CORE X_NUC_110.L_CORE 0.004054
K_685 X_NUC_6.L_CORE X_NUC_111.L_CORE 0.002435
K_686 X_NUC_6.L_CORE X_NUC_112.L_CORE 0.003035
K_687 X_NUC_6.L_CORE X_NUC_113.L_CORE 0.002821
K_688 X_NUC_6.L_CORE X_NUC_114.L_CORE 0.002283
K_689 X_NUC_6.L_CORE X_NUC_115.L_CORE 0.002923
K_690 X_NUC_6.L_CORE X_NUC_116.L_CORE 0.002269
K_691 X_NUC_6.L_CORE X_NUC_117.L_CORE 0.002322
K_692 X_NUC_6.L_CORE X_NUC_118.L_CORE 0.002430
K_693 X_NUC_6.L_CORE X_NUC_119.L_CORE 0.002142
K_694 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_695 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.004542
K_696 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.004637
K_697 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.004566
K_698 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.004602
K_699 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.005511
K_700 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.005580
K_701 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.005591
K_702 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.005464
K_703 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.007176
K_704 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.007189
K_705 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.007010
K_706 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.007236
K_707 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.003412
K_708 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.003467
K_709 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.003434
K_710 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.003425
K_711 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.006895
K_712 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.006799
K_713 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.006832
K_714 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.006681
K_715 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.003744
K_716 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.003786
K_717 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.003724
K_718 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.003770
K_719 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.003356
K_720 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.003391
K_721 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.003376
K_722 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.003341
K_723 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.005592
K_724 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.005517
K_725 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.005447
K_726 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.005505
K_727 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.002856
K_728 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.002891
K_729 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.002857
K_730 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.002865
K_731 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.003810
K_732 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.003811
K_733 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.003805
K_734 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.003753
K_735 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.003552
K_736 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.003562
K_737 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.003507
K_738 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.003550
K_739 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.002665
K_740 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.002691
K_741 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.002670
K_742 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.002659
K_743 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.003988
K_744 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.003955
K_745 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.003931
K_746 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.003918
K_747 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.002686
K_748 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.002708
K_749 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.002673
K_750 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.002688
K_751 X_NUC_7.L_CORE X_NUC_65.L_CORE 0.002809
K_752 X_NUC_7.L_CORE X_NUC_66.L_CORE 0.002821
K_753 X_NUC_7.L_CORE X_NUC_67.L_CORE 0.002807
K_754 X_NUC_7.L_CORE X_NUC_68.L_CORE 0.002784
K_755 X_NUC_7.L_CORE X_NUC_69.L_CORE 0.003264
K_756 X_NUC_7.L_CORE X_NUC_70.L_CORE 0.003257
K_757 X_NUC_7.L_CORE X_NUC_71.L_CORE 0.003218
K_758 X_NUC_7.L_CORE X_NUC_72.L_CORE 0.003238
K_759 X_NUC_7.L_CORE X_NUC_73.L_CORE 0.002399
K_760 X_NUC_7.L_CORE X_NUC_74.L_CORE 0.002419
K_761 X_NUC_7.L_CORE X_NUC_75.L_CORE 0.002396
K_762 X_NUC_7.L_CORE X_NUC_76.L_CORE 0.002395
K_763 X_NUC_7.L_CORE X_NUC_77.L_CORE 0.002970
K_764 X_NUC_7.L_CORE X_NUC_78.L_CORE 0.002966
K_765 X_NUC_7.L_CORE X_NUC_79.L_CORE 0.002948
K_766 X_NUC_7.L_CORE X_NUC_80.L_CORE 0.002933
K_767 X_NUC_7.L_CORE X_NUC_81.L_CORE 0.002605
K_768 X_NUC_7.L_CORE X_NUC_82.L_CORE 0.002616
K_769 X_NUC_7.L_CORE X_NUC_83.L_CORE 0.002584
K_770 X_NUC_7.L_CORE X_NUC_84.L_CORE 0.002598
K_771 X_NUC_7.L_CORE X_NUC_85.L_CORE 0.002397
K_772 X_NUC_7.L_CORE X_NUC_86.L_CORE 0.002410
K_773 X_NUC_7.L_CORE X_NUC_87.L_CORE 0.002392
K_774 X_NUC_7.L_CORE X_NUC_88.L_CORE 0.002383
K_775 X_NUC_7.L_CORE X_NUC_89.L_CORE 0.002752
K_776 X_NUC_7.L_CORE X_NUC_90.L_CORE 0.002749
K_777 X_NUC_7.L_CORE X_NUC_91.L_CORE 0.002724
K_778 X_NUC_7.L_CORE X_NUC_92.L_CORE 0.002726
K_779 X_NUC_7.L_CORE X_NUC_93.L_CORE 0.002332
K_780 X_NUC_7.L_CORE X_NUC_94.L_CORE 0.002344
K_781 X_NUC_7.L_CORE X_NUC_95.L_CORE 0.002320
K_782 X_NUC_7.L_CORE X_NUC_96.L_CORE 0.002323
K_783 X_NUC_7.L_CORE X_NUC_97.L_CORE 0.002425
K_784 X_NUC_7.L_CORE X_NUC_98.L_CORE 0.002431
K_785 X_NUC_7.L_CORE X_NUC_99.L_CORE 0.002411
K_786 X_NUC_7.L_CORE X_NUC_100.L_CORE 0.002406
K_787 X_NUC_7.L_CORE X_NUC_101.L_CORE 0.005636
K_788 X_NUC_7.L_CORE X_NUC_102.L_CORE 0.027740
K_789 X_NUC_7.L_CORE X_NUC_103.L_CORE 0.003952
K_790 X_NUC_7.L_CORE X_NUC_104.L_CORE 0.004647
K_791 X_NUC_7.L_CORE X_NUC_105.L_CORE 0.005644
K_792 X_NUC_7.L_CORE X_NUC_106.L_CORE 0.002951
K_793 X_NUC_7.L_CORE X_NUC_107.L_CORE 0.005123
K_794 X_NUC_7.L_CORE X_NUC_108.L_CORE 0.003155
K_795 X_NUC_7.L_CORE X_NUC_109.L_CORE 0.002850
K_796 X_NUC_7.L_CORE X_NUC_110.L_CORE 0.004092
K_797 X_NUC_7.L_CORE X_NUC_111.L_CORE 0.002461
K_798 X_NUC_7.L_CORE X_NUC_112.L_CORE 0.003043
K_799 X_NUC_7.L_CORE X_NUC_113.L_CORE 0.002857
K_800 X_NUC_7.L_CORE X_NUC_114.L_CORE 0.002300
K_801 X_NUC_7.L_CORE X_NUC_115.L_CORE 0.002942
K_802 X_NUC_7.L_CORE X_NUC_116.L_CORE 0.002293
K_803 X_NUC_7.L_CORE X_NUC_117.L_CORE 0.002337
K_804 X_NUC_7.L_CORE X_NUC_118.L_CORE 0.002453
K_805 X_NUC_7.L_CORE X_NUC_119.L_CORE 0.002161
K_806 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.004507
K_807 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.004599
K_808 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.004529
K_809 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.004566
K_810 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.005640
K_811 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.005713
K_812 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.005723
K_813 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.005591
K_814 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.006952
K_815 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.006964
K_816 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.006796
K_817 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.007010
K_818 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.003420
K_819 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.003475
K_820 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.003442
K_821 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.003434
K_822 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.007058
K_823 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.006955
K_824 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.006987
K_825 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.006832
K_826 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.003698
K_827 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.003739
K_828 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.003678
K_829 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.003724
K_830 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.003392
K_831 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.003428
K_832 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.003411
K_833 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.003376
K_834 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.005529
K_835 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.005456
K_836 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.005386
K_837 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.005447
K_838 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.002848
K_839 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.002883
K_840 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.002849
K_841 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.002857
K_842 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.003864
K_843 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.003864
K_844 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.003857
K_845 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.003805
K_846 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.003508
K_847 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.003518
K_848 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.003465
K_849 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.003507
K_850 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.002676
K_851 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.002703
K_852 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.002681
K_853 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.002670
K_854 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.004001
K_855 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.003968
K_856 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.003942
K_857 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.003931
K_858 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.002671
K_859 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.002692
K_860 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.002658
K_861 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.002673
K_862 X_NUC_8.L_CORE X_NUC_65.L_CORE 0.002831
K_863 X_NUC_8.L_CORE X_NUC_66.L_CORE 0.002844
K_864 X_NUC_8.L_CORE X_NUC_67.L_CORE 0.002829
K_865 X_NUC_8.L_CORE X_NUC_68.L_CORE 0.002807
K_866 X_NUC_8.L_CORE X_NUC_69.L_CORE 0.003242
K_867 X_NUC_8.L_CORE X_NUC_70.L_CORE 0.003235
K_868 X_NUC_8.L_CORE X_NUC_71.L_CORE 0.003197
K_869 X_NUC_8.L_CORE X_NUC_72.L_CORE 0.003218
K_870 X_NUC_8.L_CORE X_NUC_73.L_CORE 0.002400
K_871 X_NUC_8.L_CORE X_NUC_74.L_CORE 0.002419
K_872 X_NUC_8.L_CORE X_NUC_75.L_CORE 0.002396
K_873 X_NUC_8.L_CORE X_NUC_76.L_CORE 0.002396
K_874 X_NUC_8.L_CORE X_NUC_77.L_CORE 0.002986
K_875 X_NUC_8.L_CORE X_NUC_78.L_CORE 0.002982
K_876 X_NUC_8.L_CORE X_NUC_79.L_CORE 0.002964
K_877 X_NUC_8.L_CORE X_NUC_80.L_CORE 0.002948
K_878 X_NUC_8.L_CORE X_NUC_81.L_CORE 0.002592
K_879 X_NUC_8.L_CORE X_NUC_82.L_CORE 0.002602
K_880 X_NUC_8.L_CORE X_NUC_83.L_CORE 0.002571
K_881 X_NUC_8.L_CORE X_NUC_84.L_CORE 0.002584
K_882 X_NUC_8.L_CORE X_NUC_85.L_CORE 0.002405
K_883 X_NUC_8.L_CORE X_NUC_86.L_CORE 0.002419
K_884 X_NUC_8.L_CORE X_NUC_87.L_CORE 0.002400
K_885 X_NUC_8.L_CORE X_NUC_88.L_CORE 0.002392
K_886 X_NUC_8.L_CORE X_NUC_89.L_CORE 0.002750
K_887 X_NUC_8.L_CORE X_NUC_90.L_CORE 0.002747
K_888 X_NUC_8.L_CORE X_NUC_91.L_CORE 0.002722
K_889 X_NUC_8.L_CORE X_NUC_92.L_CORE 0.002724
K_890 X_NUC_8.L_CORE X_NUC_93.L_CORE 0.002329
K_891 X_NUC_8.L_CORE X_NUC_94.L_CORE 0.002341
K_892 X_NUC_8.L_CORE X_NUC_95.L_CORE 0.002317
K_893 X_NUC_8.L_CORE X_NUC_96.L_CORE 0.002320
K_894 X_NUC_8.L_CORE X_NUC_97.L_CORE 0.002429
K_895 X_NUC_8.L_CORE X_NUC_98.L_CORE 0.002435
K_896 X_NUC_8.L_CORE X_NUC_99.L_CORE 0.002415
K_897 X_NUC_8.L_CORE X_NUC_100.L_CORE 0.002411
K_898 X_NUC_8.L_CORE X_NUC_101.L_CORE 0.005689
K_899 X_NUC_8.L_CORE X_NUC_102.L_CORE 0.027604
K_900 X_NUC_8.L_CORE X_NUC_103.L_CORE 0.003922
K_901 X_NUC_8.L_CORE X_NUC_104.L_CORE 0.004744
K_902 X_NUC_8.L_CORE X_NUC_105.L_CORE 0.005503
K_903 X_NUC_8.L_CORE X_NUC_106.L_CORE 0.002958
K_904 X_NUC_8.L_CORE X_NUC_107.L_CORE 0.005204
K_905 X_NUC_8.L_CORE X_NUC_108.L_CORE 0.003121
K_906 X_NUC_8.L_CORE X_NUC_109.L_CORE 0.002876
K_907 X_NUC_8.L_CORE X_NUC_110.L_CORE 0.004062
K_908 X_NUC_8.L_CORE X_NUC_111.L_CORE 0.002455
K_909 X_NUC_8.L_CORE X_NUC_112.L_CORE 0.003073
K_910 X_NUC_8.L_CORE X_NUC_113.L_CORE 0.002832
K_911 X_NUC_8.L_CORE X_NUC_114.L_CORE 0.002308
K_912 X_NUC_8.L_CORE X_NUC_115.L_CORE 0.002947
K_913 X_NUC_8.L_CORE X_NUC_116.L_CORE 0.002285
K_914 X_NUC_8.L_CORE X_NUC_117.L_CORE 0.002347
K_915 X_NUC_8.L_CORE X_NUC_118.L_CORE 0.002447
K_916 X_NUC_8.L_CORE X_NUC_119.L_CORE 0.002161
K_917 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_918 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_919 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_920 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.003799
K_921 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.003767
K_922 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.003810
K_923 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.003750
K_924 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.004855
K_925 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.004749
K_926 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.004773
K_927 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.004801
K_928 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.006502
K_929 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.006602
K_930 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.006584
K_931 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.006421
K_932 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.003050
K_933 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.003014
K_934 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.003037
K_935 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.003013
K_936 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.006989
K_937 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.006921
K_938 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.006774
K_939 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.006939
K_940 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.003440
K_941 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.003437
K_942 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.003451
K_943 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.003398
K_944 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.003131
K_945 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.003088
K_946 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.003097
K_947 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.003096
K_948 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.005782
K_949 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.005876
K_950 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.005741
K_951 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.005731
K_952 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.002662
K_953 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.002644
K_954 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.002655
K_955 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.002631
K_956 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.003762
K_957 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.003722
K_958 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.003695
K_959 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.003726
K_960 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.003453
K_961 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.003469
K_962 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.003454
K_963 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.003415
K_964 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.002536
K_965 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.002512
K_966 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.002517
K_967 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.002508
K_968 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.004115
K_969 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.004124
K_970 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.004053
K_971 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.004080
K_972 X_NUC_9.L_CORE X_NUC_65.L_CORE 0.002582
K_973 X_NUC_9.L_CORE X_NUC_66.L_CORE 0.002575
K_974 X_NUC_9.L_CORE X_NUC_67.L_CORE 0.002576
K_975 X_NUC_9.L_CORE X_NUC_68.L_CORE 0.002552
K_976 X_NUC_9.L_CORE X_NUC_69.L_CORE 0.002755
K_977 X_NUC_9.L_CORE X_NUC_70.L_CORE 0.002730
K_978 X_NUC_9.L_CORE X_NUC_71.L_CORE 0.002721
K_979 X_NUC_9.L_CORE X_NUC_72.L_CORE 0.002726
K_980 X_NUC_9.L_CORE X_NUC_73.L_CORE 0.003279
K_981 X_NUC_9.L_CORE X_NUC_74.L_CORE 0.003294
K_982 X_NUC_9.L_CORE X_NUC_75.L_CORE 0.003260
K_983 X_NUC_9.L_CORE X_NUC_76.L_CORE 0.003246
K_984 X_NUC_9.L_CORE X_NUC_77.L_CORE 0.002329
K_985 X_NUC_9.L_CORE X_NUC_78.L_CORE 0.002315
K_986 X_NUC_9.L_CORE X_NUC_79.L_CORE 0.002316
K_987 X_NUC_9.L_CORE X_NUC_80.L_CORE 0.002304
K_988 X_NUC_9.L_CORE X_NUC_81.L_CORE 0.002984
K_989 X_NUC_9.L_CORE X_NUC_82.L_CORE 0.002973
K_990 X_NUC_9.L_CORE X_NUC_83.L_CORE 0.002945
K_991 X_NUC_9.L_CORE X_NUC_84.L_CORE 0.002955
K_992 X_NUC_9.L_CORE X_NUC_85.L_CORE 0.002572
K_993 X_NUC_9.L_CORE X_NUC_86.L_CORE 0.002571
K_994 X_NUC_9.L_CORE X_NUC_87.L_CORE 0.002561
K_995 X_NUC_9.L_CORE X_NUC_88.L_CORE 0.002544
K_996 X_NUC_9.L_CORE X_NUC_89.L_CORE 0.002375
K_997 X_NUC_9.L_CORE X_NUC_90.L_CORE 0.002360
K_998 X_NUC_9.L_CORE X_NUC_91.L_CORE 0.002354
K_999 X_NUC_9.L_CORE X_NUC_92.L_CORE 0.002350
K_1000 X_NUC_9.L_CORE X_NUC_93.L_CORE 0.002724
K_1001 X_NUC_9.L_CORE X_NUC_94.L_CORE 0.002723
K_1002 X_NUC_9.L_CORE X_NUC_95.L_CORE 0.002700
K_1003 X_NUC_9.L_CORE X_NUC_96.L_CORE 0.002697
K_1004 X_NUC_9.L_CORE X_NUC_97.L_CORE 0.002353
K_1005 X_NUC_9.L_CORE X_NUC_98.L_CORE 0.002346
K_1006 X_NUC_9.L_CORE X_NUC_99.L_CORE 0.002337
K_1007 X_NUC_9.L_CORE X_NUC_100.L_CORE 0.002328
K_1008 X_NUC_9.L_CORE X_NUC_101.L_CORE 0.006286
K_1009 X_NUC_9.L_CORE X_NUC_102.L_CORE 0.003984
K_1010 X_NUC_9.L_CORE X_NUC_103.L_CORE 0.027669
K_1011 X_NUC_9.L_CORE X_NUC_104.L_CORE 0.003294
K_1012 X_NUC_9.L_CORE X_NUC_105.L_CORE 0.004085
K_1013 X_NUC_9.L_CORE X_NUC_106.L_CORE 0.005234
K_1014 X_NUC_9.L_CORE X_NUC_107.L_CORE 0.002634
K_1015 X_NUC_9.L_CORE X_NUC_108.L_CORE 0.005138
K_1016 X_NUC_9.L_CORE X_NUC_109.L_CORE 0.002921
K_1017 X_NUC_9.L_CORE X_NUC_110.L_CORE 0.002662
K_1018 X_NUC_9.L_CORE X_NUC_111.L_CORE 0.004166
K_1019 X_NUC_9.L_CORE X_NUC_112.L_CORE 0.002309
K_1020 X_NUC_9.L_CORE X_NUC_113.L_CORE 0.002989
K_1021 X_NUC_9.L_CORE X_NUC_114.L_CORE 0.002791
K_1022 X_NUC_9.L_CORE X_NUC_115.L_CORE 0.002210
K_1023 X_NUC_9.L_CORE X_NUC_116.L_CORE 0.002941
K_1024 X_NUC_9.L_CORE X_NUC_117.L_CORE 0.002238
K_1025 X_NUC_9.L_CORE X_NUC_118.L_CORE 0.002303
K_1026 X_NUC_9.L_CORE X_NUC_119.L_CORE 0.002380
K_1027 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_1028 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_1029 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.003831
K_1030 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.003799
K_1031 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.003843
K_1032 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.003780
K_1033 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.004965
K_1034 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.004855
K_1035 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.004879
K_1036 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.004909
K_1037 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.006401
K_1038 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.006502
K_1039 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.006482
K_1040 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.006326
K_1041 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.003086
K_1042 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.003050
K_1043 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.003073
K_1044 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.003049
K_1045 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.007051
K_1046 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.006989
K_1047 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.006835
K_1048 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.007004
K_1049 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.003442
K_1050 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.003440
K_1051 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.003453
K_1052 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.003401
K_1053 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.003175
K_1054 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.003131
K_1055 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.003140
K_1056 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.003139
K_1057 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.005687
K_1058 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.005782
K_1059 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.005650
K_1060 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.005641
K_1061 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.002680
K_1062 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.002662
K_1063 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.002674
K_1064 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.002649
K_1065 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.003802
K_1066 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.003762
K_1067 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.003734
K_1068 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.003766
K_1069 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.003436
K_1070 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.003453
K_1071 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.003437
K_1072 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.003399
K_1073 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.002561
K_1074 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.002536
K_1075 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.002541
K_1076 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.002532
K_1077 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.004105
K_1078 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.004115
K_1079 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.004044
K_1080 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.004070
K_1081 X_NUC_10.L_CORE X_NUC_65.L_CORE 0.002588
K_1082 X_NUC_10.L_CORE X_NUC_66.L_CORE 0.002582
K_1083 X_NUC_10.L_CORE X_NUC_67.L_CORE 0.002583
K_1084 X_NUC_10.L_CORE X_NUC_68.L_CORE 0.002559
K_1085 X_NUC_10.L_CORE X_NUC_69.L_CORE 0.002779
K_1086 X_NUC_10.L_CORE X_NUC_70.L_CORE 0.002755
K_1087 X_NUC_10.L_CORE X_NUC_71.L_CORE 0.002746
K_1088 X_NUC_10.L_CORE X_NUC_72.L_CORE 0.002751
K_1089 X_NUC_10.L_CORE X_NUC_73.L_CORE 0.003263
K_1090 X_NUC_10.L_CORE X_NUC_74.L_CORE 0.003279
K_1091 X_NUC_10.L_CORE X_NUC_75.L_CORE 0.003245
K_1092 X_NUC_10.L_CORE X_NUC_76.L_CORE 0.003231
K_1093 X_NUC_10.L_CORE X_NUC_77.L_CORE 0.002344
K_1094 X_NUC_10.L_CORE X_NUC_78.L_CORE 0.002329
K_1095 X_NUC_10.L_CORE X_NUC_79.L_CORE 0.002330
K_1096 X_NUC_10.L_CORE X_NUC_80.L_CORE 0.002317
K_1097 X_NUC_10.L_CORE X_NUC_81.L_CORE 0.002994
K_1098 X_NUC_10.L_CORE X_NUC_82.L_CORE 0.002984
K_1099 X_NUC_10.L_CORE X_NUC_83.L_CORE 0.002956
K_1100 X_NUC_10.L_CORE X_NUC_84.L_CORE 0.002966
K_1101 X_NUC_10.L_CORE X_NUC_85.L_CORE 0.002572
K_1102 X_NUC_10.L_CORE X_NUC_86.L_CORE 0.002572
K_1103 X_NUC_10.L_CORE X_NUC_87.L_CORE 0.002561
K_1104 X_NUC_10.L_CORE X_NUC_88.L_CORE 0.002545
K_1105 X_NUC_10.L_CORE X_NUC_89.L_CORE 0.002390
K_1106 X_NUC_10.L_CORE X_NUC_90.L_CORE 0.002375
K_1107 X_NUC_10.L_CORE X_NUC_91.L_CORE 0.002368
K_1108 X_NUC_10.L_CORE X_NUC_92.L_CORE 0.002364
K_1109 X_NUC_10.L_CORE X_NUC_93.L_CORE 0.002725
K_1110 X_NUC_10.L_CORE X_NUC_94.L_CORE 0.002724
K_1111 X_NUC_10.L_CORE X_NUC_95.L_CORE 0.002701
K_1112 X_NUC_10.L_CORE X_NUC_96.L_CORE 0.002699
K_1113 X_NUC_10.L_CORE X_NUC_97.L_CORE 0.002360
K_1114 X_NUC_10.L_CORE X_NUC_98.L_CORE 0.002353
K_1115 X_NUC_10.L_CORE X_NUC_99.L_CORE 0.002344
K_1116 X_NUC_10.L_CORE X_NUC_100.L_CORE 0.002335
K_1117 X_NUC_10.L_CORE X_NUC_101.L_CORE 0.006340
K_1118 X_NUC_10.L_CORE X_NUC_102.L_CORE 0.004057
K_1119 X_NUC_10.L_CORE X_NUC_103.L_CORE 0.025153
K_1120 X_NUC_10.L_CORE X_NUC_104.L_CORE 0.003316
K_1121 X_NUC_10.L_CORE X_NUC_105.L_CORE 0.004160
K_1122 X_NUC_10.L_CORE X_NUC_106.L_CORE 0.005154
K_1123 X_NUC_10.L_CORE X_NUC_107.L_CORE 0.002661
K_1124 X_NUC_10.L_CORE X_NUC_108.L_CORE 0.005156
K_1125 X_NUC_10.L_CORE X_NUC_109.L_CORE 0.002921
K_1126 X_NUC_10.L_CORE X_NUC_110.L_CORE 0.002692
K_1127 X_NUC_10.L_CORE X_NUC_111.L_CORE 0.004121
K_1128 X_NUC_10.L_CORE X_NUC_112.L_CORE 0.002321
K_1129 X_NUC_10.L_CORE X_NUC_113.L_CORE 0.003010
K_1130 X_NUC_10.L_CORE X_NUC_114.L_CORE 0.002782
K_1131 X_NUC_10.L_CORE X_NUC_115.L_CORE 0.002226
K_1132 X_NUC_10.L_CORE X_NUC_116.L_CORE 0.002939
K_1133 X_NUC_10.L_CORE X_NUC_117.L_CORE 0.002243
K_1134 X_NUC_10.L_CORE X_NUC_118.L_CORE 0.002314
K_1135 X_NUC_10.L_CORE X_NUC_119.L_CORE 0.002381
K_1136 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_1137 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.003787
K_1138 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.003756
K_1139 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.003799
K_1140 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.003738
K_1141 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.004938
K_1142 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.004828
K_1143 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.004855
K_1144 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.004883
K_1145 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.006418
K_1146 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.006517
K_1147 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.006502
K_1148 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.006343
K_1149 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.003062
K_1150 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.003026
K_1151 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.003050
K_1152 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.003025
K_1153 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.007217
K_1154 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.007146
K_1155 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.006989
K_1156 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.007166
K_1157 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.003429
K_1158 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.003426
K_1159 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.003440
K_1160 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.003388
K_1161 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.003165
K_1162 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.003121
K_1163 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.003131
K_1164 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.003130
K_1165 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.005819
K_1166 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.005918
K_1167 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.005782
K_1168 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.005769
K_1169 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.002669
K_1170 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.002650
K_1171 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.002662
K_1172 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.002637
K_1173 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.003831
K_1174 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.003789
K_1175 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.003762
K_1176 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.003794
K_1177 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.003451
K_1178 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.003468
K_1179 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.003453
K_1180 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.003413
K_1181 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.002555
K_1182 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.002531
K_1183 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.002536
K_1184 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.002527
K_1185 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.004178
K_1186 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.004189
K_1187 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.004115
K_1188 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.004142
K_1189 X_NUC_11.L_CORE X_NUC_65.L_CORE 0.002587
K_1190 X_NUC_11.L_CORE X_NUC_66.L_CORE 0.002580
K_1191 X_NUC_11.L_CORE X_NUC_67.L_CORE 0.002582
K_1192 X_NUC_11.L_CORE X_NUC_68.L_CORE 0.002558
K_1193 X_NUC_11.L_CORE X_NUC_69.L_CORE 0.002788
K_1194 X_NUC_11.L_CORE X_NUC_70.L_CORE 0.002763
K_1195 X_NUC_11.L_CORE X_NUC_71.L_CORE 0.002755
K_1196 X_NUC_11.L_CORE X_NUC_72.L_CORE 0.002759
K_1197 X_NUC_11.L_CORE X_NUC_73.L_CORE 0.003297
K_1198 X_NUC_11.L_CORE X_NUC_74.L_CORE 0.003313
K_1199 X_NUC_11.L_CORE X_NUC_75.L_CORE 0.003279
K_1200 X_NUC_11.L_CORE X_NUC_76.L_CORE 0.003264
K_1201 X_NUC_11.L_CORE X_NUC_77.L_CORE 0.002343
K_1202 X_NUC_11.L_CORE X_NUC_78.L_CORE 0.002329
K_1203 X_NUC_11.L_CORE X_NUC_79.L_CORE 0.002329
K_1204 X_NUC_11.L_CORE X_NUC_80.L_CORE 0.002317
K_1205 X_NUC_11.L_CORE X_NUC_81.L_CORE 0.003023
K_1206 X_NUC_11.L_CORE X_NUC_82.L_CORE 0.003012
K_1207 X_NUC_11.L_CORE X_NUC_83.L_CORE 0.002984
K_1208 X_NUC_11.L_CORE X_NUC_84.L_CORE 0.002994
K_1209 X_NUC_11.L_CORE X_NUC_85.L_CORE 0.002583
K_1210 X_NUC_11.L_CORE X_NUC_86.L_CORE 0.002582
K_1211 X_NUC_11.L_CORE X_NUC_87.L_CORE 0.002572
K_1212 X_NUC_11.L_CORE X_NUC_88.L_CORE 0.002555
K_1213 X_NUC_11.L_CORE X_NUC_89.L_CORE 0.002396
K_1214 X_NUC_11.L_CORE X_NUC_90.L_CORE 0.002381
K_1215 X_NUC_11.L_CORE X_NUC_91.L_CORE 0.002375
K_1216 X_NUC_11.L_CORE X_NUC_92.L_CORE 0.002371
K_1217 X_NUC_11.L_CORE X_NUC_93.L_CORE 0.002749
K_1218 X_NUC_11.L_CORE X_NUC_94.L_CORE 0.002748
K_1219 X_NUC_11.L_CORE X_NUC_95.L_CORE 0.002724
K_1220 X_NUC_11.L_CORE X_NUC_96.L_CORE 0.002721
K_1221 X_NUC_11.L_CORE X_NUC_97.L_CORE 0.002369
K_1222 X_NUC_11.L_CORE X_NUC_98.L_CORE 0.002362
K_1223 X_NUC_11.L_CORE X_NUC_99.L_CORE 0.002353
K_1224 X_NUC_11.L_CORE X_NUC_100.L_CORE 0.002344
K_1225 X_NUC_11.L_CORE X_NUC_101.L_CORE 0.006180
K_1226 X_NUC_11.L_CORE X_NUC_102.L_CORE 0.004000
K_1227 X_NUC_11.L_CORE X_NUC_103.L_CORE 0.026840
K_1228 X_NUC_11.L_CORE X_NUC_104.L_CORE 0.003283
K_1229 X_NUC_11.L_CORE X_NUC_105.L_CORE 0.004148
K_1230 X_NUC_11.L_CORE X_NUC_106.L_CORE 0.005182
K_1231 X_NUC_11.L_CORE X_NUC_107.L_CORE 0.002645
K_1232 X_NUC_11.L_CORE X_NUC_108.L_CORE 0.005255
K_1233 X_NUC_11.L_CORE X_NUC_109.L_CORE 0.002915
K_1234 X_NUC_11.L_CORE X_NUC_110.L_CORE 0.002689
K_1235 X_NUC_11.L_CORE X_NUC_111.L_CORE 0.004193
K_1236 X_NUC_11.L_CORE X_NUC_112.L_CORE 0.002315
K_1237 X_NUC_11.L_CORE X_NUC_113.L_CORE 0.003033
K_1238 X_NUC_11.L_CORE X_NUC_114.L_CORE 0.002796
K_1239 X_NUC_11.L_CORE X_NUC_115.L_CORE 0.002226
K_1240 X_NUC_11.L_CORE X_NUC_116.L_CORE 0.002974
K_1241 X_NUC_11.L_CORE X_NUC_117.L_CORE 0.002247
K_1242 X_NUC_11.L_CORE X_NUC_118.L_CORE 0.002325
K_1243 X_NUC_11.L_CORE X_NUC_119.L_CORE 0.002397
K_1244 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.003849
K_1245 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.003817
K_1246 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.003862
K_1247 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.003799
K_1248 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.004907
K_1249 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.004799
K_1250 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.004824
K_1251 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.004855
K_1252 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.006581
K_1253 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.006687
K_1254 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.006668
K_1255 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.006502
K_1256 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.003087
K_1257 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.003050
K_1258 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.003074
K_1259 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.003050
K_1260 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.007032
K_1261 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.006966
K_1262 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.006817
K_1263 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.006989
K_1264 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.003483
K_1265 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.003480
K_1266 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.003494
K_1267 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.003440
K_1268 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.003166
K_1269 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.003122
K_1270 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.003131
K_1271 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.003131
K_1272 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.005829
K_1273 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.005929
K_1274 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.005789
K_1275 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.005782
K_1276 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.002694
K_1277 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.002676
K_1278 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.002687
K_1279 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.002662
K_1280 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.003797
K_1281 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.003756
K_1282 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.003729
K_1283 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.003762
K_1284 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.003492
K_1285 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.003509
K_1286 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.003493
K_1287 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.003453
K_1288 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.002565
K_1289 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.002540
K_1290 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.002546
K_1291 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.002536
K_1292 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.004149
K_1293 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.004159
K_1294 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.004087
K_1295 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.004115
K_1296 X_NUC_12.L_CORE X_NUC_65.L_CORE 0.002612
K_1297 X_NUC_12.L_CORE X_NUC_66.L_CORE 0.002605
K_1298 X_NUC_12.L_CORE X_NUC_67.L_CORE 0.002606
K_1299 X_NUC_12.L_CORE X_NUC_68.L_CORE 0.002582
K_1300 X_NUC_12.L_CORE X_NUC_69.L_CORE 0.002783
K_1301 X_NUC_12.L_CORE X_NUC_70.L_CORE 0.002758
K_1302 X_NUC_12.L_CORE X_NUC_71.L_CORE 0.002749
K_1303 X_NUC_12.L_CORE X_NUC_72.L_CORE 0.002755
K_1304 X_NUC_12.L_CORE X_NUC_73.L_CORE 0.003312
K_1305 X_NUC_12.L_CORE X_NUC_74.L_CORE 0.003328
K_1306 X_NUC_12.L_CORE X_NUC_75.L_CORE 0.003293
K_1307 X_NUC_12.L_CORE X_NUC_76.L_CORE 0.003279
K_1308 X_NUC_12.L_CORE X_NUC_77.L_CORE 0.002356
K_1309 X_NUC_12.L_CORE X_NUC_78.L_CORE 0.002341
K_1310 X_NUC_12.L_CORE X_NUC_79.L_CORE 0.002342
K_1311 X_NUC_12.L_CORE X_NUC_80.L_CORE 0.002329
K_1312 X_NUC_12.L_CORE X_NUC_81.L_CORE 0.003012
K_1313 X_NUC_12.L_CORE X_NUC_82.L_CORE 0.003001
K_1314 X_NUC_12.L_CORE X_NUC_83.L_CORE 0.002973
K_1315 X_NUC_12.L_CORE X_NUC_84.L_CORE 0.002984
K_1316 X_NUC_12.L_CORE X_NUC_85.L_CORE 0.002600
K_1317 X_NUC_12.L_CORE X_NUC_86.L_CORE 0.002599
K_1318 X_NUC_12.L_CORE X_NUC_87.L_CORE 0.002588
K_1319 X_NUC_12.L_CORE X_NUC_88.L_CORE 0.002572
K_1320 X_NUC_12.L_CORE X_NUC_89.L_CORE 0.002400
K_1321 X_NUC_12.L_CORE X_NUC_90.L_CORE 0.002385
K_1322 X_NUC_12.L_CORE X_NUC_91.L_CORE 0.002379
K_1323 X_NUC_12.L_CORE X_NUC_92.L_CORE 0.002375
K_1324 X_NUC_12.L_CORE X_NUC_93.L_CORE 0.002752
K_1325 X_NUC_12.L_CORE X_NUC_94.L_CORE 0.002750
K_1326 X_NUC_12.L_CORE X_NUC_95.L_CORE 0.002727
K_1327 X_NUC_12.L_CORE X_NUC_96.L_CORE 0.002724
K_1328 X_NUC_12.L_CORE X_NUC_97.L_CORE 0.002378
K_1329 X_NUC_12.L_CORE X_NUC_98.L_CORE 0.002371
K_1330 X_NUC_12.L_CORE X_NUC_99.L_CORE 0.002362
K_1331 X_NUC_12.L_CORE X_NUC_100.L_CORE 0.002353
K_1332 X_NUC_12.L_CORE X_NUC_101.L_CORE 0.006346
K_1333 X_NUC_12.L_CORE X_NUC_102.L_CORE 0.004024
K_1334 X_NUC_12.L_CORE X_NUC_103.L_CORE 0.024858
K_1335 X_NUC_12.L_CORE X_NUC_104.L_CORE 0.003331
K_1336 X_NUC_12.L_CORE X_NUC_105.L_CORE 0.004117
K_1337 X_NUC_12.L_CORE X_NUC_106.L_CORE 0.005273
K_1338 X_NUC_12.L_CORE X_NUC_107.L_CORE 0.002663
K_1339 X_NUC_12.L_CORE X_NUC_108.L_CORE 0.005155
K_1340 X_NUC_12.L_CORE X_NUC_109.L_CORE 0.002953
K_1341 X_NUC_12.L_CORE X_NUC_110.L_CORE 0.002688
K_1342 X_NUC_12.L_CORE X_NUC_111.L_CORE 0.004193
K_1343 X_NUC_12.L_CORE X_NUC_112.L_CORE 0.002334
K_1344 X_NUC_12.L_CORE X_NUC_113.L_CORE 0.003014
K_1345 X_NUC_12.L_CORE X_NUC_114.L_CORE 0.002818
K_1346 X_NUC_12.L_CORE X_NUC_115.L_CORE 0.002232
K_1347 X_NUC_12.L_CORE X_NUC_116.L_CORE 0.002965
K_1348 X_NUC_12.L_CORE X_NUC_117.L_CORE 0.002261
K_1349 X_NUC_12.L_CORE X_NUC_118.L_CORE 0.002324
K_1350 X_NUC_12.L_CORE X_NUC_119.L_CORE 0.002402
K_1351 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_1352 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_1353 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_1354 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.003364
K_1355 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.003350
K_1356 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.003329
K_1357 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.003381
K_1358 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.004394
K_1359 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.004475
K_1360 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.004400
K_1361 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.004446
K_1362 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.006096
K_1363 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.005940
K_1364 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.005949
K_1365 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.006005
K_1366 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.002808
K_1367 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.002816
K_1368 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.002789
K_1369 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.002825
K_1370 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.007008
K_1371 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.007187
K_1372 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.007021
K_1373 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.006960
K_1374 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.003245
K_1375 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.003216
K_1376 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.003200
K_1377 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.003237
K_1378 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.002965
K_1379 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.002992
K_1380 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.002954
K_1381 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.002982
K_1382 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006005
K_1383 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.005920
K_1384 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.005884
K_1385 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.005842
K_1386 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.002535
K_1387 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.002532
K_1388 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.002511
K_1389 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.002539
K_1390 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.003715
K_1391 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.003766
K_1392 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.003705
K_1393 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.003713
K_1394 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.003405
K_1395 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.003369
K_1396 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.003351
K_1397 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.003372
K_1398 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.002452
K_1399 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.002462
K_1400 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.002435
K_1401 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.002457
K_1402 X_NUC_13.L_CORE X_NUC_65.L_CORE 0.004235
K_1403 X_NUC_13.L_CORE X_NUC_66.L_CORE 0.004248
K_1404 X_NUC_13.L_CORE X_NUC_67.L_CORE 0.004193
K_1405 X_NUC_13.L_CORE X_NUC_68.L_CORE 0.004174
K_1406 X_NUC_13.L_CORE X_NUC_69.L_CORE 0.002526
K_1407 X_NUC_13.L_CORE X_NUC_70.L_CORE 0.002516
K_1408 X_NUC_13.L_CORE X_NUC_71.L_CORE 0.002497
K_1409 X_NUC_13.L_CORE X_NUC_72.L_CORE 0.002518
K_1410 X_NUC_13.L_CORE X_NUC_73.L_CORE 0.002722
K_1411 X_NUC_13.L_CORE X_NUC_74.L_CORE 0.002743
K_1412 X_NUC_13.L_CORE X_NUC_75.L_CORE 0.002707
K_1413 X_NUC_13.L_CORE X_NUC_76.L_CORE 0.002722
K_1414 X_NUC_13.L_CORE X_NUC_77.L_CORE 0.003309
K_1415 X_NUC_13.L_CORE X_NUC_78.L_CORE 0.003289
K_1416 X_NUC_13.L_CORE X_NUC_79.L_CORE 0.003263
K_1417 X_NUC_13.L_CORE X_NUC_80.L_CORE 0.003268
K_1418 X_NUC_13.L_CORE X_NUC_81.L_CORE 0.002301
K_1419 X_NUC_13.L_CORE X_NUC_82.L_CORE 0.002302
K_1420 X_NUC_13.L_CORE X_NUC_83.L_CORE 0.002280
K_1421 X_NUC_13.L_CORE X_NUC_84.L_CORE 0.002298
K_1422 X_NUC_13.L_CORE X_NUC_85.L_CORE 0.002994
K_1423 X_NUC_13.L_CORE X_NUC_86.L_CORE 0.003008
K_1424 X_NUC_13.L_CORE X_NUC_87.L_CORE 0.002971
K_1425 X_NUC_13.L_CORE X_NUC_88.L_CORE 0.002974
K_1426 X_NUC_13.L_CORE X_NUC_89.L_CORE 0.002572
K_1427 X_NUC_13.L_CORE X_NUC_90.L_CORE 0.002563
K_1428 X_NUC_13.L_CORE X_NUC_91.L_CORE 0.002542
K_1429 X_NUC_13.L_CORE X_NUC_92.L_CORE 0.002555
K_1430 X_NUC_13.L_CORE X_NUC_93.L_CORE 0.002392
K_1431 X_NUC_13.L_CORE X_NUC_94.L_CORE 0.002398
K_1432 X_NUC_13.L_CORE X_NUC_95.L_CORE 0.002372
K_1433 X_NUC_13.L_CORE X_NUC_96.L_CORE 0.002386
K_1434 X_NUC_13.L_CORE X_NUC_97.L_CORE 0.002653
K_1435 X_NUC_13.L_CORE X_NUC_98.L_CORE 0.002654
K_1436 X_NUC_13.L_CORE X_NUC_99.L_CORE 0.002627
K_1437 X_NUC_13.L_CORE X_NUC_100.L_CORE 0.002634
K_1438 X_NUC_13.L_CORE X_NUC_101.L_CORE 0.007060
K_1439 X_NUC_13.L_CORE X_NUC_102.L_CORE 0.004979
K_1440 X_NUC_13.L_CORE X_NUC_103.L_CORE 0.003366
K_1441 X_NUC_13.L_CORE X_NUC_104.L_CORE 0.023898
K_1442 X_NUC_13.L_CORE X_NUC_105.L_CORE 0.002940
K_1443 X_NUC_13.L_CORE X_NUC_106.L_CORE 0.003797
K_1444 X_NUC_13.L_CORE X_NUC_107.L_CORE 0.004862
K_1445 X_NUC_13.L_CORE X_NUC_108.L_CORE 0.002463
K_1446 X_NUC_13.L_CORE X_NUC_109.L_CORE 0.005147
K_1447 X_NUC_13.L_CORE X_NUC_110.L_CORE 0.002773
K_1448 X_NUC_13.L_CORE X_NUC_111.L_CORE 0.002573
K_1449 X_NUC_13.L_CORE X_NUC_112.L_CORE 0.004163
K_1450 X_NUC_13.L_CORE X_NUC_113.L_CORE 0.002234
K_1451 X_NUC_13.L_CORE X_NUC_114.L_CORE 0.002977
K_1452 X_NUC_13.L_CORE X_NUC_115.L_CORE 0.002744
K_1453 X_NUC_13.L_CORE X_NUC_116.L_CORE 0.002188
K_1454 X_NUC_13.L_CORE X_NUC_117.L_CORE 0.002913
K_1455 X_NUC_13.L_CORE X_NUC_118.L_CORE 0.002239
K_1456 X_NUC_13.L_CORE X_NUC_119.L_CORE 0.002314
K_1457 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_1458 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_1459 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.003378
K_1460 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.003364
K_1461 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.003342
K_1462 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.003395
K_1463 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.004315
K_1464 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.004394
K_1465 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.004322
K_1466 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.004366
K_1467 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.006258
K_1468 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.006096
K_1469 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.006102
K_1470 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.006163
K_1471 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.002799
K_1472 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.002808
K_1473 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.002780
K_1474 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.002816
K_1475 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.006834
K_1476 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.007008
K_1477 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.006850
K_1478 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.006793
K_1479 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.003274
K_1480 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.003245
K_1481 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.003228
K_1482 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.003266
K_1483 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.002937
K_1484 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.002965
K_1485 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.002926
K_1486 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.002954
K_1487 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006088
K_1488 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006005
K_1489 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.005964
K_1490 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.005921
K_1491 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.002538
K_1492 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.002535
K_1493 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.002514
K_1494 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.002542
K_1495 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.003666
K_1496 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.003715
K_1497 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.003657
K_1498 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.003664
K_1499 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.003441
K_1500 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.003405
K_1501 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.003386
K_1502 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.003408
K_1503 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.002441
K_1504 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.002452
K_1505 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.002425
K_1506 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.002447
K_1507 X_NUC_14.L_CORE X_NUC_65.L_CORE 0.004221
K_1508 X_NUC_14.L_CORE X_NUC_66.L_CORE 0.004235
K_1509 X_NUC_14.L_CORE X_NUC_67.L_CORE 0.004180
K_1510 X_NUC_14.L_CORE X_NUC_68.L_CORE 0.004161
K_1511 X_NUC_14.L_CORE X_NUC_69.L_CORE 0.002536
K_1512 X_NUC_14.L_CORE X_NUC_70.L_CORE 0.002526
K_1513 X_NUC_14.L_CORE X_NUC_71.L_CORE 0.002506
K_1514 X_NUC_14.L_CORE X_NUC_72.L_CORE 0.002528
K_1515 X_NUC_14.L_CORE X_NUC_73.L_CORE 0.002702
K_1516 X_NUC_14.L_CORE X_NUC_74.L_CORE 0.002722
K_1517 X_NUC_14.L_CORE X_NUC_75.L_CORE 0.002687
K_1518 X_NUC_14.L_CORE X_NUC_76.L_CORE 0.002701
K_1519 X_NUC_14.L_CORE X_NUC_77.L_CORE 0.003329
K_1520 X_NUC_14.L_CORE X_NUC_78.L_CORE 0.003309
K_1521 X_NUC_14.L_CORE X_NUC_79.L_CORE 0.003282
K_1522 X_NUC_14.L_CORE X_NUC_80.L_CORE 0.003287
K_1523 X_NUC_14.L_CORE X_NUC_81.L_CORE 0.002298
K_1524 X_NUC_14.L_CORE X_NUC_82.L_CORE 0.002301
K_1525 X_NUC_14.L_CORE X_NUC_83.L_CORE 0.002278
K_1526 X_NUC_14.L_CORE X_NUC_84.L_CORE 0.002296
K_1527 X_NUC_14.L_CORE X_NUC_85.L_CORE 0.002979
K_1528 X_NUC_14.L_CORE X_NUC_86.L_CORE 0.002994
K_1529 X_NUC_14.L_CORE X_NUC_87.L_CORE 0.002957
K_1530 X_NUC_14.L_CORE X_NUC_88.L_CORE 0.002960
K_1531 X_NUC_14.L_CORE X_NUC_89.L_CORE 0.002581
K_1532 X_NUC_14.L_CORE X_NUC_90.L_CORE 0.002572
K_1533 X_NUC_14.L_CORE X_NUC_91.L_CORE 0.002550
K_1534 X_NUC_14.L_CORE X_NUC_92.L_CORE 0.002564
K_1535 X_NUC_14.L_CORE X_NUC_93.L_CORE 0.002384
K_1536 X_NUC_14.L_CORE X_NUC_94.L_CORE 0.002392
K_1537 X_NUC_14.L_CORE X_NUC_95.L_CORE 0.002365
K_1538 X_NUC_14.L_CORE X_NUC_96.L_CORE 0.002379
K_1539 X_NUC_14.L_CORE X_NUC_97.L_CORE 0.002653
K_1540 X_NUC_14.L_CORE X_NUC_98.L_CORE 0.002653
K_1541 X_NUC_14.L_CORE X_NUC_99.L_CORE 0.002626
K_1542 X_NUC_14.L_CORE X_NUC_100.L_CORE 0.002634
K_1543 X_NUC_14.L_CORE X_NUC_101.L_CORE 0.006935
K_1544 X_NUC_14.L_CORE X_NUC_102.L_CORE 0.005048
K_1545 X_NUC_14.L_CORE X_NUC_103.L_CORE 0.003339
K_1546 X_NUC_14.L_CORE X_NUC_104.L_CORE 0.024262
K_1547 X_NUC_14.L_CORE X_NUC_105.L_CORE 0.002953
K_1548 X_NUC_14.L_CORE X_NUC_106.L_CORE 0.003736
K_1549 X_NUC_14.L_CORE X_NUC_107.L_CORE 0.004967
K_1550 X_NUC_14.L_CORE X_NUC_108.L_CORE 0.002457
K_1551 X_NUC_14.L_CORE X_NUC_109.L_CORE 0.005067
K_1552 X_NUC_14.L_CORE X_NUC_110.L_CORE 0.002795
K_1553 X_NUC_14.L_CORE X_NUC_111.L_CORE 0.002553
K_1554 X_NUC_14.L_CORE X_NUC_112.L_CORE 0.004196
K_1555 X_NUC_14.L_CORE X_NUC_113.L_CORE 0.002236
K_1556 X_NUC_14.L_CORE X_NUC_114.L_CORE 0.002951
K_1557 X_NUC_14.L_CORE X_NUC_115.L_CORE 0.002763
K_1558 X_NUC_14.L_CORE X_NUC_116.L_CORE 0.002181
K_1559 X_NUC_14.L_CORE X_NUC_117.L_CORE 0.002909
K_1560 X_NUC_14.L_CORE X_NUC_118.L_CORE 0.002243
K_1561 X_NUC_14.L_CORE X_NUC_119.L_CORE 0.002308
K_1562 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_1563 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.003400
K_1564 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.003385
K_1565 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.003364
K_1566 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.003417
K_1567 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.004386
K_1568 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.004467
K_1569 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.004394
K_1570 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.004439
K_1571 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.006248
K_1572 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.006083
K_1573 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.006096
K_1574 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.006153
K_1575 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.002827
K_1576 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.002836
K_1577 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.002808
K_1578 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.002845
K_1579 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.006987
K_1580 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.007169
K_1581 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.007008
K_1582 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.006943
K_1583 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.003291
K_1584 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.003261
K_1585 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.003245
K_1586 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.003283
K_1587 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.002975
K_1588 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.003004
K_1589 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.002965
K_1590 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.002993
K_1591 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006128
K_1592 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006041
K_1593 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006005
K_1594 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.005959
K_1595 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.002560
K_1596 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.002557
K_1597 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.002535
K_1598 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.002564
K_1599 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.003724
K_1600 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.003776
K_1601 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.003715
K_1602 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.003723
K_1603 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.003460
K_1604 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.003423
K_1605 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.003405
K_1606 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.003426
K_1607 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.002468
K_1608 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.002479
K_1609 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.002452
K_1610 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.002474
K_1611 X_NUC_15.L_CORE X_NUC_65.L_CORE 0.004276
K_1612 X_NUC_15.L_CORE X_NUC_66.L_CORE 0.004291
K_1613 X_NUC_15.L_CORE X_NUC_67.L_CORE 0.004235
K_1614 X_NUC_15.L_CORE X_NUC_68.L_CORE 0.004214
K_1615 X_NUC_15.L_CORE X_NUC_69.L_CORE 0.002556
K_1616 X_NUC_15.L_CORE X_NUC_70.L_CORE 0.002545
K_1617 X_NUC_15.L_CORE X_NUC_71.L_CORE 0.002526
K_1618 X_NUC_15.L_CORE X_NUC_72.L_CORE 0.002548
K_1619 X_NUC_15.L_CORE X_NUC_73.L_CORE 0.002737
K_1620 X_NUC_15.L_CORE X_NUC_74.L_CORE 0.002758
K_1621 X_NUC_15.L_CORE X_NUC_75.L_CORE 0.002722
K_1622 X_NUC_15.L_CORE X_NUC_76.L_CORE 0.002737
K_1623 X_NUC_15.L_CORE X_NUC_77.L_CORE 0.003356
K_1624 X_NUC_15.L_CORE X_NUC_78.L_CORE 0.003336
K_1625 X_NUC_15.L_CORE X_NUC_79.L_CORE 0.003309
K_1626 X_NUC_15.L_CORE X_NUC_80.L_CORE 0.003314
K_1627 X_NUC_15.L_CORE X_NUC_81.L_CORE 0.002321
K_1628 X_NUC_15.L_CORE X_NUC_82.L_CORE 0.002323
K_1629 X_NUC_15.L_CORE X_NUC_83.L_CORE 0.002301
K_1630 X_NUC_15.L_CORE X_NUC_84.L_CORE 0.002319
K_1631 X_NUC_15.L_CORE X_NUC_85.L_CORE 0.003017
K_1632 X_NUC_15.L_CORE X_NUC_86.L_CORE 0.003032
K_1633 X_NUC_15.L_CORE X_NUC_87.L_CORE 0.002994
K_1634 X_NUC_15.L_CORE X_NUC_88.L_CORE 0.002998
K_1635 X_NUC_15.L_CORE X_NUC_89.L_CORE 0.002603
K_1636 X_NUC_15.L_CORE X_NUC_90.L_CORE 0.002594
K_1637 X_NUC_15.L_CORE X_NUC_91.L_CORE 0.002572
K_1638 X_NUC_15.L_CORE X_NUC_92.L_CORE 0.002586
K_1639 X_NUC_15.L_CORE X_NUC_93.L_CORE 0.002411
K_1640 X_NUC_15.L_CORE X_NUC_94.L_CORE 0.002418
K_1641 X_NUC_15.L_CORE X_NUC_95.L_CORE 0.002392
K_1642 X_NUC_15.L_CORE X_NUC_96.L_CORE 0.002405
K_1643 X_NUC_15.L_CORE X_NUC_97.L_CORE 0.002681
K_1644 X_NUC_15.L_CORE X_NUC_98.L_CORE 0.002681
K_1645 X_NUC_15.L_CORE X_NUC_99.L_CORE 0.002653
K_1646 X_NUC_15.L_CORE X_NUC_100.L_CORE 0.002661
K_1647 X_NUC_15.L_CORE X_NUC_101.L_CORE 0.006982
K_1648 X_NUC_15.L_CORE X_NUC_102.L_CORE 0.005038
K_1649 X_NUC_15.L_CORE X_NUC_103.L_CORE 0.003372
K_1650 X_NUC_15.L_CORE X_NUC_104.L_CORE 0.022804
K_1651 X_NUC_15.L_CORE X_NUC_105.L_CORE 0.002969
K_1652 X_NUC_15.L_CORE X_NUC_106.L_CORE 0.003789
K_1653 X_NUC_15.L_CORE X_NUC_107.L_CORE 0.004955
K_1654 X_NUC_15.L_CORE X_NUC_108.L_CORE 0.002479
K_1655 X_NUC_15.L_CORE X_NUC_109.L_CORE 0.005142
K_1656 X_NUC_15.L_CORE X_NUC_110.L_CORE 0.002808
K_1657 X_NUC_15.L_CORE X_NUC_111.L_CORE 0.002583
K_1658 X_NUC_15.L_CORE X_NUC_112.L_CORE 0.004220
K_1659 X_NUC_15.L_CORE X_NUC_113.L_CORE 0.002254
K_1660 X_NUC_15.L_CORE X_NUC_114.L_CORE 0.002989
K_1661 X_NUC_15.L_CORE X_NUC_115.L_CORE 0.002780
K_1662 X_NUC_15.L_CORE X_NUC_116.L_CORE 0.002203
K_1663 X_NUC_15.L_CORE X_NUC_117.L_CORE 0.002939
K_1664 X_NUC_15.L_CORE X_NUC_118.L_CORE 0.002262
K_1665 X_NUC_15.L_CORE X_NUC_119.L_CORE 0.002332
K_1666 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.003347
K_1667 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.003333
K_1668 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.003312
K_1669 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.003364
K_1670 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.004341
K_1671 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.004421
K_1672 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.004348
K_1673 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.004394
K_1674 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.006185
K_1675 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.006025
K_1676 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.006035
K_1677 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.006096
K_1678 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.002791
K_1679 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.002799
K_1680 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.002772
K_1681 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.002808
K_1682 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.007049
K_1683 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.007236
K_1684 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.007066
K_1685 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.007008
K_1686 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.003252
K_1687 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.003223
K_1688 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.003207
K_1689 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.003245
K_1690 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.002947
K_1691 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.002975
K_1692 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.002937
K_1693 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.002965
K_1694 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006176
K_1695 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006087
K_1696 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006047
K_1697 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006005
K_1698 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.002531
K_1699 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.002528
K_1700 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.002507
K_1701 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.002535
K_1702 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.003716
K_1703 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.003767
K_1704 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.003707
K_1705 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.003715
K_1706 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.003438
K_1707 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.003401
K_1708 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.003383
K_1709 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.003405
K_1710 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.002445
K_1711 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.002456
K_1712 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.002429
K_1713 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.002452
K_1714 X_NUC_16.L_CORE X_NUC_65.L_CORE 0.004298
K_1715 X_NUC_16.L_CORE X_NUC_66.L_CORE 0.004312
K_1716 X_NUC_16.L_CORE X_NUC_67.L_CORE 0.004255
K_1717 X_NUC_16.L_CORE X_NUC_68.L_CORE 0.004235
K_1718 X_NUC_16.L_CORE X_NUC_69.L_CORE 0.002533
K_1719 X_NUC_16.L_CORE X_NUC_70.L_CORE 0.002523
K_1720 X_NUC_16.L_CORE X_NUC_71.L_CORE 0.002504
K_1721 X_NUC_16.L_CORE X_NUC_72.L_CORE 0.002526
K_1722 X_NUC_16.L_CORE X_NUC_73.L_CORE 0.002722
K_1723 X_NUC_16.L_CORE X_NUC_74.L_CORE 0.002743
K_1724 X_NUC_16.L_CORE X_NUC_75.L_CORE 0.002708
K_1725 X_NUC_16.L_CORE X_NUC_76.L_CORE 0.002722
K_1726 X_NUC_16.L_CORE X_NUC_77.L_CORE 0.003351
K_1727 X_NUC_16.L_CORE X_NUC_78.L_CORE 0.003331
K_1728 X_NUC_16.L_CORE X_NUC_79.L_CORE 0.003304
K_1729 X_NUC_16.L_CORE X_NUC_80.L_CORE 0.003309
K_1730 X_NUC_16.L_CORE X_NUC_81.L_CORE 0.002302
K_1731 X_NUC_16.L_CORE X_NUC_82.L_CORE 0.002304
K_1732 X_NUC_16.L_CORE X_NUC_83.L_CORE 0.002282
K_1733 X_NUC_16.L_CORE X_NUC_84.L_CORE 0.002301
K_1734 X_NUC_16.L_CORE X_NUC_85.L_CORE 0.003013
K_1735 X_NUC_16.L_CORE X_NUC_86.L_CORE 0.003028
K_1736 X_NUC_16.L_CORE X_NUC_87.L_CORE 0.002990
K_1737 X_NUC_16.L_CORE X_NUC_88.L_CORE 0.002994
K_1738 X_NUC_16.L_CORE X_NUC_89.L_CORE 0.002588
K_1739 X_NUC_16.L_CORE X_NUC_90.L_CORE 0.002579
K_1740 X_NUC_16.L_CORE X_NUC_91.L_CORE 0.002558
K_1741 X_NUC_16.L_CORE X_NUC_92.L_CORE 0.002572
K_1742 X_NUC_16.L_CORE X_NUC_93.L_CORE 0.002397
K_1743 X_NUC_16.L_CORE X_NUC_94.L_CORE 0.002404
K_1744 X_NUC_16.L_CORE X_NUC_95.L_CORE 0.002378
K_1745 X_NUC_16.L_CORE X_NUC_96.L_CORE 0.002392
K_1746 X_NUC_16.L_CORE X_NUC_97.L_CORE 0.002672
K_1747 X_NUC_16.L_CORE X_NUC_98.L_CORE 0.002673
K_1748 X_NUC_16.L_CORE X_NUC_99.L_CORE 0.002645
K_1749 X_NUC_16.L_CORE X_NUC_100.L_CORE 0.002653
K_1750 X_NUC_16.L_CORE X_NUC_101.L_CORE 0.006834
K_1751 X_NUC_16.L_CORE X_NUC_102.L_CORE 0.004945
K_1752 X_NUC_16.L_CORE X_NUC_103.L_CORE 0.003326
K_1753 X_NUC_16.L_CORE X_NUC_104.L_CORE 0.025583
K_1754 X_NUC_16.L_CORE X_NUC_105.L_CORE 0.002929
K_1755 X_NUC_16.L_CORE X_NUC_106.L_CORE 0.003763
K_1756 X_NUC_16.L_CORE X_NUC_107.L_CORE 0.004936
K_1757 X_NUC_16.L_CORE X_NUC_108.L_CORE 0.002452
K_1758 X_NUC_16.L_CORE X_NUC_109.L_CORE 0.005191
K_1759 X_NUC_16.L_CORE X_NUC_110.L_CORE 0.002782
K_1760 X_NUC_16.L_CORE X_NUC_111.L_CORE 0.002564
K_1761 X_NUC_16.L_CORE X_NUC_112.L_CORE 0.004244
K_1762 X_NUC_16.L_CORE X_NUC_113.L_CORE 0.002234
K_1763 X_NUC_16.L_CORE X_NUC_114.L_CORE 0.002985
K_1764 X_NUC_16.L_CORE X_NUC_115.L_CORE 0.002768
K_1765 X_NUC_16.L_CORE X_NUC_116.L_CORE 0.002188
K_1766 X_NUC_16.L_CORE X_NUC_117.L_CORE 0.002941
K_1767 X_NUC_16.L_CORE X_NUC_118.L_CORE 0.002249
K_1768 X_NUC_16.L_CORE X_NUC_119.L_CORE 0.002323
K_1769 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_1770 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_1771 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_1772 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.003082
K_1773 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.003120
K_1774 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.003112
K_1775 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.003086
K_1776 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.004080
K_1777 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.004057
K_1778 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.004098
K_1779 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.004023
K_1780 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.005783
K_1781 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.005931
K_1782 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.005794
K_1783 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.005845
K_1784 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.002642
K_1785 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.002658
K_1786 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.002660
K_1787 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.002631
K_1788 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.006973
K_1789 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.006813
K_1790 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.006837
K_1791 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.006753
K_1792 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.003105
K_1793 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.003148
K_1794 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.003120
K_1795 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.003111
K_1796 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.002847
K_1797 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.002846
K_1798 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.002855
K_1799 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.002819
K_1800 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006158
K_1801 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006200
K_1802 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.006030
K_1803 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.006109
K_1804 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.002449
K_1805 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.002469
K_1806 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.002460
K_1807 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.002442
K_1808 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.003676
K_1809 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.003648
K_1810 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.003653
K_1811 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.003613
K_1812 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.003368
K_1813 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.003409
K_1814 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.003360
K_1815 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.003366
K_1816 X_NUC_17.L_CORE X_NUC_65.L_CORE 0.002398
K_1817 X_NUC_17.L_CORE X_NUC_66.L_CORE 0.002406
K_1818 X_NUC_17.L_CORE X_NUC_67.L_CORE 0.002403
K_1819 X_NUC_17.L_CORE X_NUC_68.L_CORE 0.002381
K_1820 X_NUC_17.L_CORE X_NUC_69.L_CORE 0.004309
K_1821 X_NUC_17.L_CORE X_NUC_70.L_CORE 0.004289
K_1822 X_NUC_17.L_CORE X_NUC_71.L_CORE 0.004239
K_1823 X_NUC_17.L_CORE X_NUC_72.L_CORE 0.004238
K_1824 X_NUC_17.L_CORE X_NUC_73.L_CORE 0.002495
K_1825 X_NUC_17.L_CORE X_NUC_74.L_CORE 0.002517
K_1826 X_NUC_17.L_CORE X_NUC_75.L_CORE 0.002498
K_1827 X_NUC_17.L_CORE X_NUC_76.L_CORE 0.002488
K_1828 X_NUC_17.L_CORE X_NUC_77.L_CORE 0.002707
K_1829 X_NUC_17.L_CORE X_NUC_78.L_CORE 0.002703
K_1830 X_NUC_17.L_CORE X_NUC_79.L_CORE 0.002699
K_1831 X_NUC_17.L_CORE X_NUC_80.L_CORE 0.002675
K_1832 X_NUC_17.L_CORE X_NUC_81.L_CORE 0.003318
K_1833 X_NUC_17.L_CORE X_NUC_82.L_CORE 0.003338
K_1834 X_NUC_17.L_CORE X_NUC_83.L_CORE 0.003291
K_1835 X_NUC_17.L_CORE X_NUC_84.L_CORE 0.003296
K_1836 X_NUC_17.L_CORE X_NUC_85.L_CORE 0.002301
K_1837 X_NUC_17.L_CORE X_NUC_86.L_CORE 0.002312
K_1838 X_NUC_17.L_CORE X_NUC_87.L_CORE 0.002301
K_1839 X_NUC_17.L_CORE X_NUC_88.L_CORE 0.002286
K_1840 X_NUC_17.L_CORE X_NUC_89.L_CORE 0.002984
K_1841 X_NUC_17.L_CORE X_NUC_90.L_CORE 0.002979
K_1842 X_NUC_17.L_CORE X_NUC_91.L_CORE 0.002961
K_1843 X_NUC_17.L_CORE X_NUC_92.L_CORE 0.002946
K_1844 X_NUC_17.L_CORE X_NUC_93.L_CORE 0.002584
K_1845 X_NUC_17.L_CORE X_NUC_94.L_CORE 0.002599
K_1846 X_NUC_17.L_CORE X_NUC_95.L_CORE 0.002576
K_1847 X_NUC_17.L_CORE X_NUC_96.L_CORE 0.002569
K_1848 X_NUC_17.L_CORE X_NUC_97.L_CORE 0.002454
K_1849 X_NUC_17.L_CORE X_NUC_98.L_CORE 0.002459
K_1850 X_NUC_17.L_CORE X_NUC_99.L_CORE 0.002446
K_1851 X_NUC_17.L_CORE X_NUC_100.L_CORE 0.002432
K_1852 X_NUC_17.L_CORE X_NUC_101.L_CORE 0.003817
K_1853 X_NUC_17.L_CORE X_NUC_102.L_CORE 0.006527
K_1854 X_NUC_17.L_CORE X_NUC_103.L_CORE 0.004388
K_1855 X_NUC_17.L_CORE X_NUC_104.L_CORE 0.002982
K_1856 X_NUC_17.L_CORE X_NUC_105.L_CORE 0.021534
K_1857 X_NUC_17.L_CORE X_NUC_106.L_CORE 0.002731
K_1858 X_NUC_17.L_CORE X_NUC_107.L_CORE 0.003513
K_1859 X_NUC_17.L_CORE X_NUC_108.L_CORE 0.004737
K_1860 X_NUC_17.L_CORE X_NUC_109.L_CORE 0.002341
K_1861 X_NUC_17.L_CORE X_NUC_110.L_CORE 0.004995
K_1862 X_NUC_17.L_CORE X_NUC_111.L_CORE 0.002704
K_1863 X_NUC_17.L_CORE X_NUC_112.L_CORE 0.002486
K_1864 X_NUC_17.L_CORE X_NUC_113.L_CORE 0.004173
K_1865 X_NUC_17.L_CORE X_NUC_114.L_CORE 0.002197
K_1866 X_NUC_17.L_CORE X_NUC_115.L_CORE 0.002924
K_1867 X_NUC_17.L_CORE X_NUC_116.L_CORE 0.002737
K_1868 X_NUC_17.L_CORE X_NUC_117.L_CORE 0.002187
K_1869 X_NUC_17.L_CORE X_NUC_118.L_CORE 0.002831
K_1870 X_NUC_17.L_CORE X_NUC_119.L_CORE 0.002292
K_1871 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_1872 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_1873 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.003044
K_1874 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.003082
K_1875 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.003073
K_1876 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.003049
K_1877 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.004102
K_1878 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.004080
K_1879 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.004121
K_1880 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.004045
K_1881 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.005641
K_1882 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.005783
K_1883 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.005653
K_1884 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.005700
K_1885 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.002625
K_1886 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.002642
K_1887 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.002643
K_1888 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.002615
K_1889 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.007136
K_1890 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.006973
K_1891 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.006995
K_1892 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.006905
K_1893 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.003063
K_1894 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.003105
K_1895 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.003077
K_1896 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.003069
K_1897 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.002847
K_1898 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.002847
K_1899 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.002856
K_1900 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.002820
K_1901 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.006111
K_1902 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006158
K_1903 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.005988
K_1904 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.006066
K_1905 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.002429
K_1906 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.002449
K_1907 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.002440
K_1908 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.002423
K_1909 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.003703
K_1910 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.003676
K_1911 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.003680
K_1912 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.003639
K_1913 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.003327
K_1914 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.003368
K_1915 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.003320
K_1916 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.003325
K_1917 X_NUC_18.L_CORE X_NUC_65.L_CORE 0.002391
K_1918 X_NUC_18.L_CORE X_NUC_66.L_CORE 0.002398
K_1919 X_NUC_18.L_CORE X_NUC_67.L_CORE 0.002396
K_1920 X_NUC_18.L_CORE X_NUC_68.L_CORE 0.002373
K_1921 X_NUC_18.L_CORE X_NUC_69.L_CORE 0.004328
K_1922 X_NUC_18.L_CORE X_NUC_70.L_CORE 0.004309
K_1923 X_NUC_18.L_CORE X_NUC_71.L_CORE 0.004258
K_1924 X_NUC_18.L_CORE X_NUC_72.L_CORE 0.004257
K_1925 X_NUC_18.L_CORE X_NUC_73.L_CORE 0.002474
K_1926 X_NUC_18.L_CORE X_NUC_74.L_CORE 0.002495
K_1927 X_NUC_18.L_CORE X_NUC_75.L_CORE 0.002477
K_1928 X_NUC_18.L_CORE X_NUC_76.L_CORE 0.002467
K_1929 X_NUC_18.L_CORE X_NUC_77.L_CORE 0.002710
K_1930 X_NUC_18.L_CORE X_NUC_78.L_CORE 0.002707
K_1931 X_NUC_18.L_CORE X_NUC_79.L_CORE 0.002703
K_1932 X_NUC_18.L_CORE X_NUC_80.L_CORE 0.002679
K_1933 X_NUC_18.L_CORE X_NUC_81.L_CORE 0.003299
K_1934 X_NUC_18.L_CORE X_NUC_82.L_CORE 0.003318
K_1935 X_NUC_18.L_CORE X_NUC_83.L_CORE 0.003272
K_1936 X_NUC_18.L_CORE X_NUC_84.L_CORE 0.003277
K_1937 X_NUC_18.L_CORE X_NUC_85.L_CORE 0.002290
K_1938 X_NUC_18.L_CORE X_NUC_86.L_CORE 0.002301
K_1939 X_NUC_18.L_CORE X_NUC_87.L_CORE 0.002290
K_1940 X_NUC_18.L_CORE X_NUC_88.L_CORE 0.002276
K_1941 X_NUC_18.L_CORE X_NUC_89.L_CORE 0.002988
K_1942 X_NUC_18.L_CORE X_NUC_90.L_CORE 0.002984
K_1943 X_NUC_18.L_CORE X_NUC_91.L_CORE 0.002965
K_1944 X_NUC_18.L_CORE X_NUC_92.L_CORE 0.002950
K_1945 X_NUC_18.L_CORE X_NUC_93.L_CORE 0.002569
K_1946 X_NUC_18.L_CORE X_NUC_94.L_CORE 0.002584
K_1947 X_NUC_18.L_CORE X_NUC_95.L_CORE 0.002561
K_1948 X_NUC_18.L_CORE X_NUC_96.L_CORE 0.002554
K_1949 X_NUC_18.L_CORE X_NUC_97.L_CORE 0.002448
K_1950 X_NUC_18.L_CORE X_NUC_98.L_CORE 0.002454
K_1951 X_NUC_18.L_CORE X_NUC_99.L_CORE 0.002440
K_1952 X_NUC_18.L_CORE X_NUC_100.L_CORE 0.002427
K_1953 X_NUC_18.L_CORE X_NUC_101.L_CORE 0.003777
K_1954 X_NUC_18.L_CORE X_NUC_102.L_CORE 0.006578
K_1955 X_NUC_18.L_CORE X_NUC_103.L_CORE 0.004300
K_1956 X_NUC_18.L_CORE X_NUC_104.L_CORE 0.002973
K_1957 X_NUC_18.L_CORE X_NUC_105.L_CORE 0.022853
K_1958 X_NUC_18.L_CORE X_NUC_106.L_CORE 0.002701
K_1959 X_NUC_18.L_CORE X_NUC_107.L_CORE 0.003536
K_1960 X_NUC_18.L_CORE X_NUC_108.L_CORE 0.004653
K_1961 X_NUC_18.L_CORE X_NUC_109.L_CORE 0.002328
K_1962 X_NUC_18.L_CORE X_NUC_110.L_CORE 0.005077
K_1963 X_NUC_18.L_CORE X_NUC_111.L_CORE 0.002674
K_1964 X_NUC_18.L_CORE X_NUC_112.L_CORE 0.002488
K_1965 X_NUC_18.L_CORE X_NUC_113.L_CORE 0.004160
K_1966 X_NUC_18.L_CORE X_NUC_114.L_CORE 0.002182
K_1967 X_NUC_18.L_CORE X_NUC_115.L_CORE 0.002937
K_1968 X_NUC_18.L_CORE X_NUC_116.L_CORE 0.002717
K_1969 X_NUC_18.L_CORE X_NUC_117.L_CORE 0.002181
K_1970 X_NUC_18.L_CORE X_NUC_118.L_CORE 0.002832
K_1971 X_NUC_18.L_CORE X_NUC_119.L_CORE 0.002282
K_1972 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_1973 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.003052
K_1974 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.003090
K_1975 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.003082
K_1976 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.003057
K_1977 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.004061
K_1978 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.004039
K_1979 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.004080
K_1980 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.004005
K_1981 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.005767
K_1982 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.005917
K_1983 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.005783
K_1984 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.005831
K_1985 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.002624
K_1986 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.002640
K_1987 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.002642
K_1988 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.002613
K_1989 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.007108
K_1990 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.006943
K_1991 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.006973
K_1992 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.006879
K_1993 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.003089
K_1994 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.003132
K_1995 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.003105
K_1996 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.003095
K_1997 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.002838
K_1998 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.002838
K_1999 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.002847
K_2000 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.002811
K_2001 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006289
K_2002 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006337
K_2003 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006158
K_2004 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.006239
K_2005 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.002438
K_2006 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.002458
K_2007 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.002449
K_2008 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.002431
K_2009 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.003698
K_2010 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.003670
K_2011 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.003676
K_2012 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.003634
K_2013 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.003374
K_2014 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.003417
K_2015 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.003368
K_2016 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.003373
K_2017 X_NUC_19.L_CORE X_NUC_65.L_CORE 0.002393
K_2018 X_NUC_19.L_CORE X_NUC_66.L_CORE 0.002400
K_2019 X_NUC_19.L_CORE X_NUC_67.L_CORE 0.002398
K_2020 X_NUC_19.L_CORE X_NUC_68.L_CORE 0.002376
K_2021 X_NUC_19.L_CORE X_NUC_69.L_CORE 0.004381
K_2022 X_NUC_19.L_CORE X_NUC_70.L_CORE 0.004361
K_2023 X_NUC_19.L_CORE X_NUC_71.L_CORE 0.004309
K_2024 X_NUC_19.L_CORE X_NUC_72.L_CORE 0.004308
K_2025 X_NUC_19.L_CORE X_NUC_73.L_CORE 0.002492
K_2026 X_NUC_19.L_CORE X_NUC_74.L_CORE 0.002514
K_2027 X_NUC_19.L_CORE X_NUC_75.L_CORE 0.002495
K_2028 X_NUC_19.L_CORE X_NUC_76.L_CORE 0.002485
K_2029 X_NUC_19.L_CORE X_NUC_77.L_CORE 0.002714
K_2030 X_NUC_19.L_CORE X_NUC_78.L_CORE 0.002710
K_2031 X_NUC_19.L_CORE X_NUC_79.L_CORE 0.002707
K_2032 X_NUC_19.L_CORE X_NUC_80.L_CORE 0.002682
K_2033 X_NUC_19.L_CORE X_NUC_81.L_CORE 0.003346
K_2034 X_NUC_19.L_CORE X_NUC_82.L_CORE 0.003366
K_2035 X_NUC_19.L_CORE X_NUC_83.L_CORE 0.003318
K_2036 X_NUC_19.L_CORE X_NUC_84.L_CORE 0.003323
K_2037 X_NUC_19.L_CORE X_NUC_85.L_CORE 0.002300
K_2038 X_NUC_19.L_CORE X_NUC_86.L_CORE 0.002311
K_2039 X_NUC_19.L_CORE X_NUC_87.L_CORE 0.002301
K_2040 X_NUC_19.L_CORE X_NUC_88.L_CORE 0.002286
K_2041 X_NUC_19.L_CORE X_NUC_89.L_CORE 0.003007
K_2042 X_NUC_19.L_CORE X_NUC_90.L_CORE 0.003003
K_2043 X_NUC_19.L_CORE X_NUC_91.L_CORE 0.002984
K_2044 X_NUC_19.L_CORE X_NUC_92.L_CORE 0.002969
K_2045 X_NUC_19.L_CORE X_NUC_93.L_CORE 0.002592
K_2046 X_NUC_19.L_CORE X_NUC_94.L_CORE 0.002608
K_2047 X_NUC_19.L_CORE X_NUC_95.L_CORE 0.002584
K_2048 X_NUC_19.L_CORE X_NUC_96.L_CORE 0.002577
K_2049 X_NUC_19.L_CORE X_NUC_97.L_CORE 0.002461
K_2050 X_NUC_19.L_CORE X_NUC_98.L_CORE 0.002467
K_2051 X_NUC_19.L_CORE X_NUC_99.L_CORE 0.002454
K_2052 X_NUC_19.L_CORE X_NUC_100.L_CORE 0.002440
K_2053 X_NUC_19.L_CORE X_NUC_101.L_CORE 0.003755
K_2054 X_NUC_19.L_CORE X_NUC_102.L_CORE 0.006402
K_2055 X_NUC_19.L_CORE X_NUC_103.L_CORE 0.004326
K_2056 X_NUC_19.L_CORE X_NUC_104.L_CORE 0.002956
K_2057 X_NUC_19.L_CORE X_NUC_105.L_CORE 0.023544
K_2058 X_NUC_19.L_CORE X_NUC_106.L_CORE 0.002709
K_2059 X_NUC_19.L_CORE X_NUC_107.L_CORE 0.003507
K_2060 X_NUC_19.L_CORE X_NUC_108.L_CORE 0.004750
K_2061 X_NUC_19.L_CORE X_NUC_109.L_CORE 0.002328
K_2062 X_NUC_19.L_CORE X_NUC_110.L_CORE 0.005084
K_2063 X_NUC_19.L_CORE X_NUC_111.L_CORE 0.002697
K_2064 X_NUC_19.L_CORE X_NUC_112.L_CORE 0.002484
K_2065 X_NUC_19.L_CORE X_NUC_113.L_CORE 0.004238
K_2066 X_NUC_19.L_CORE X_NUC_114.L_CORE 0.002191
K_2067 X_NUC_19.L_CORE X_NUC_115.L_CORE 0.002943
K_2068 X_NUC_19.L_CORE X_NUC_116.L_CORE 0.002748
K_2069 X_NUC_19.L_CORE X_NUC_117.L_CORE 0.002188
K_2070 X_NUC_19.L_CORE X_NUC_118.L_CORE 0.002856
K_2071 X_NUC_19.L_CORE X_NUC_119.L_CORE 0.002299
K_2072 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.003076
K_2073 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.003115
K_2074 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.003107
K_2075 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.003082
K_2076 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.004138
K_2077 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.004114
K_2078 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.004157
K_2079 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.004080
K_2080 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.005719
K_2081 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.005865
K_2082 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.005732
K_2083 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.005783
K_2084 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.002652
K_2085 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.002669
K_2086 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.002671
K_2087 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.002642
K_2088 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.007207
K_2089 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.007035
K_2090 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.007062
K_2091 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.006973
K_2092 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.003098
K_2093 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.003142
K_2094 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.003114
K_2095 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.003105
K_2096 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.002875
K_2097 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.002875
K_2098 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.002884
K_2099 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.002847
K_2100 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006203
K_2101 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.006249
K_2102 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006075
K_2103 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006158
K_2104 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.002456
K_2105 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.002476
K_2106 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.002467
K_2107 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.002449
K_2108 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.003741
K_2109 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.003712
K_2110 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.003717
K_2111 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.003676
K_2112 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.003369
K_2113 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.003411
K_2114 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.003362
K_2115 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.003368
K_2116 X_NUC_20.L_CORE X_NUC_65.L_CORE 0.002416
K_2117 X_NUC_20.L_CORE X_NUC_66.L_CORE 0.002423
K_2118 X_NUC_20.L_CORE X_NUC_67.L_CORE 0.002421
K_2119 X_NUC_20.L_CORE X_NUC_68.L_CORE 0.002398
K_2120 X_NUC_20.L_CORE X_NUC_69.L_CORE 0.004382
K_2121 X_NUC_20.L_CORE X_NUC_70.L_CORE 0.004361
K_2122 X_NUC_20.L_CORE X_NUC_71.L_CORE 0.004309
K_2123 X_NUC_20.L_CORE X_NUC_72.L_CORE 0.004309
K_2124 X_NUC_20.L_CORE X_NUC_73.L_CORE 0.002502
K_2125 X_NUC_20.L_CORE X_NUC_74.L_CORE 0.002524
K_2126 X_NUC_20.L_CORE X_NUC_75.L_CORE 0.002505
K_2127 X_NUC_20.L_CORE X_NUC_76.L_CORE 0.002495
K_2128 X_NUC_20.L_CORE X_NUC_77.L_CORE 0.002739
K_2129 X_NUC_20.L_CORE X_NUC_78.L_CORE 0.002735
K_2130 X_NUC_20.L_CORE X_NUC_79.L_CORE 0.002731
K_2131 X_NUC_20.L_CORE X_NUC_80.L_CORE 0.002707
K_2132 X_NUC_20.L_CORE X_NUC_81.L_CORE 0.003341
K_2133 X_NUC_20.L_CORE X_NUC_82.L_CORE 0.003361
K_2134 X_NUC_20.L_CORE X_NUC_83.L_CORE 0.003313
K_2135 X_NUC_20.L_CORE X_NUC_84.L_CORE 0.003318
K_2136 X_NUC_20.L_CORE X_NUC_85.L_CORE 0.002315
K_2137 X_NUC_20.L_CORE X_NUC_86.L_CORE 0.002326
K_2138 X_NUC_20.L_CORE X_NUC_87.L_CORE 0.002316
K_2139 X_NUC_20.L_CORE X_NUC_88.L_CORE 0.002301
K_2140 X_NUC_20.L_CORE X_NUC_89.L_CORE 0.003022
K_2141 X_NUC_20.L_CORE X_NUC_90.L_CORE 0.003017
K_2142 X_NUC_20.L_CORE X_NUC_91.L_CORE 0.002998
K_2143 X_NUC_20.L_CORE X_NUC_92.L_CORE 0.002984
K_2144 X_NUC_20.L_CORE X_NUC_93.L_CORE 0.002599
K_2145 X_NUC_20.L_CORE X_NUC_94.L_CORE 0.002615
K_2146 X_NUC_20.L_CORE X_NUC_95.L_CORE 0.002591
K_2147 X_NUC_20.L_CORE X_NUC_96.L_CORE 0.002584
K_2148 X_NUC_20.L_CORE X_NUC_97.L_CORE 0.002476
K_2149 X_NUC_20.L_CORE X_NUC_98.L_CORE 0.002481
K_2150 X_NUC_20.L_CORE X_NUC_99.L_CORE 0.002468
K_2151 X_NUC_20.L_CORE X_NUC_100.L_CORE 0.002454
K_2152 X_NUC_20.L_CORE X_NUC_101.L_CORE 0.003805
K_2153 X_NUC_20.L_CORE X_NUC_102.L_CORE 0.006575
K_2154 X_NUC_20.L_CORE X_NUC_103.L_CORE 0.004337
K_2155 X_NUC_20.L_CORE X_NUC_104.L_CORE 0.002997
K_2156 X_NUC_20.L_CORE X_NUC_105.L_CORE 0.021569
K_2157 X_NUC_20.L_CORE X_NUC_106.L_CORE 0.002727
K_2158 X_NUC_20.L_CORE X_NUC_107.L_CORE 0.003561
K_2159 X_NUC_20.L_CORE X_NUC_108.L_CORE 0.004702
K_2160 X_NUC_20.L_CORE X_NUC_109.L_CORE 0.002351
K_2161 X_NUC_20.L_CORE X_NUC_110.L_CORE 0.005111
K_2162 X_NUC_20.L_CORE X_NUC_111.L_CORE 0.002702
K_2163 X_NUC_20.L_CORE X_NUC_112.L_CORE 0.002510
K_2164 X_NUC_20.L_CORE X_NUC_113.L_CORE 0.004205
K_2165 X_NUC_20.L_CORE X_NUC_114.L_CORE 0.002205
K_2166 X_NUC_20.L_CORE X_NUC_115.L_CORE 0.002965
K_2167 X_NUC_20.L_CORE X_NUC_116.L_CORE 0.002747
K_2168 X_NUC_20.L_CORE X_NUC_117.L_CORE 0.002203
K_2169 X_NUC_20.L_CORE X_NUC_118.L_CORE 0.002861
K_2170 X_NUC_20.L_CORE X_NUC_119.L_CORE 0.002307
K_2171 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_2172 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_2173 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_2174 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.002886
K_2175 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.002847
K_2176 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.002868
K_2177 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.002861
K_2178 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.003856
K_2179 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.003824
K_2180 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.003802
K_2181 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.003864
K_2182 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.005545
K_2183 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.005471
K_2184 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.005536
K_2185 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.005420
K_2186 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.002523
K_2187 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.002495
K_2188 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.002500
K_2189 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.002509
K_2190 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.006920
K_2191 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.006958
K_2192 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.006755
K_2193 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.006928
K_2194 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.003004
K_2195 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.002968
K_2196 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.002986
K_2197 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.002966
K_2198 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.002763
K_2199 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.002740
K_2200 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.002730
K_2201 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.002755
K_2202 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.006262
K_2203 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.006267
K_2204 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.006194
K_2205 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.006107
K_2206 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.002391
K_2207 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.002366
K_2208 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.002371
K_2209 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.002371
K_2210 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.003647
K_2211 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.003635
K_2212 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.003589
K_2213 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.003636
K_2214 X_NUC_21.L_CORE X_NUC_65.L_CORE 0.003343
K_2215 X_NUC_21.L_CORE X_NUC_66.L_CORE 0.003314
K_2216 X_NUC_21.L_CORE X_NUC_67.L_CORE 0.003319
K_2217 X_NUC_21.L_CORE X_NUC_68.L_CORE 0.003290
K_2218 X_NUC_21.L_CORE X_NUC_69.L_CORE 0.002368
K_2219 X_NUC_21.L_CORE X_NUC_70.L_CORE 0.002348
K_2220 X_NUC_21.L_CORE X_NUC_71.L_CORE 0.002343
K_2221 X_NUC_21.L_CORE X_NUC_72.L_CORE 0.002354
K_2222 X_NUC_21.L_CORE X_NUC_73.L_CORE 0.004345
K_2223 X_NUC_21.L_CORE X_NUC_74.L_CORE 0.004350
K_2224 X_NUC_21.L_CORE X_NUC_75.L_CORE 0.004278
K_2225 X_NUC_21.L_CORE X_NUC_76.L_CORE 0.004292
K_2226 X_NUC_21.L_CORE X_NUC_77.L_CORE 0.002485
K_2227 X_NUC_21.L_CORE X_NUC_78.L_CORE 0.002463
K_2228 X_NUC_21.L_CORE X_NUC_79.L_CORE 0.002464
K_2229 X_NUC_21.L_CORE X_NUC_80.L_CORE 0.002458
K_2230 X_NUC_21.L_CORE X_NUC_81.L_CORE 0.002707
K_2231 X_NUC_21.L_CORE X_NUC_82.L_CORE 0.002691
K_2232 X_NUC_21.L_CORE X_NUC_83.L_CORE 0.002672
K_2233 X_NUC_21.L_CORE X_NUC_84.L_CORE 0.002691
K_2234 X_NUC_21.L_CORE X_NUC_85.L_CORE 0.003309
K_2235 X_NUC_21.L_CORE X_NUC_86.L_CORE 0.003294
K_2236 X_NUC_21.L_CORE X_NUC_87.L_CORE 0.003275
K_2237 X_NUC_21.L_CORE X_NUC_88.L_CORE 0.003261
K_2238 X_NUC_21.L_CORE X_NUC_89.L_CORE 0.002329
K_2239 X_NUC_21.L_CORE X_NUC_90.L_CORE 0.002311
K_2240 X_NUC_21.L_CORE X_NUC_91.L_CORE 0.002306
K_2241 X_NUC_21.L_CORE X_NUC_92.L_CORE 0.002309
K_2242 X_NUC_21.L_CORE X_NUC_93.L_CORE 0.002948
K_2243 X_NUC_21.L_CORE X_NUC_94.L_CORE 0.002937
K_2244 X_NUC_21.L_CORE X_NUC_95.L_CORE 0.002910
K_2245 X_NUC_21.L_CORE X_NUC_96.L_CORE 0.002921
K_2246 X_NUC_21.L_CORE X_NUC_97.L_CORE 0.002611
K_2247 X_NUC_21.L_CORE X_NUC_98.L_CORE 0.002594
K_2248 X_NUC_21.L_CORE X_NUC_99.L_CORE 0.002583
K_2249 X_NUC_21.L_CORE X_NUC_100.L_CORE 0.002582
K_2250 X_NUC_21.L_CORE X_NUC_101.L_CORE 0.006009
K_2251 X_NUC_21.L_CORE X_NUC_102.L_CORE 0.003060
K_2252 X_NUC_21.L_CORE X_NUC_103.L_CORE 0.006017
K_2253 X_NUC_21.L_CORE X_NUC_104.L_CORE 0.003905
K_2254 X_NUC_21.L_CORE X_NUC_105.L_CORE 0.002724
K_2255 X_NUC_21.L_CORE X_NUC_106.L_CORE 0.021465
K_2256 X_NUC_21.L_CORE X_NUC_107.L_CORE 0.002544
K_2257 X_NUC_21.L_CORE X_NUC_108.L_CORE 0.003345
K_2258 X_NUC_21.L_CORE X_NUC_109.L_CORE 0.004510
K_2259 X_NUC_21.L_CORE X_NUC_110.L_CORE 0.002238
K_2260 X_NUC_21.L_CORE X_NUC_111.L_CORE 0.004969
K_2261 X_NUC_21.L_CORE X_NUC_112.L_CORE 0.002613
K_2262 X_NUC_21.L_CORE X_NUC_113.L_CORE 0.002432
K_2263 X_NUC_21.L_CORE X_NUC_114.L_CORE 0.004119
K_2264 X_NUC_21.L_CORE X_NUC_115.L_CORE 0.002162
K_2265 X_NUC_21.L_CORE X_NUC_116.L_CORE 0.002898
K_2266 X_NUC_21.L_CORE X_NUC_117.L_CORE 0.002698
K_2267 X_NUC_21.L_CORE X_NUC_118.L_CORE 0.002213
K_2268 X_NUC_21.L_CORE X_NUC_119.L_CORE 0.002672
K_2269 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_2270 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_2271 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.002926
K_2272 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.002886
K_2273 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.002907
K_2274 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.002901
K_2275 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.003888
K_2276 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.003856
K_2277 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.003833
K_2278 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.003897
K_2279 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.005617
K_2280 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.005545
K_2281 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.005611
K_2282 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.005489
K_2283 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.002552
K_2284 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.002523
K_2285 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.002529
K_2286 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.002538
K_2287 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.006875
K_2288 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.006920
K_2289 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.006717
K_2290 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.006887
K_2291 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.003040
K_2292 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.003004
K_2293 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.003022
K_2294 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.003002
K_2295 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.002787
K_2296 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.002763
K_2297 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.002753
K_2298 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.002779
K_2299 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.006251
K_2300 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.006262
K_2301 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.006186
K_2302 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.006100
K_2303 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.002417
K_2304 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.002391
K_2305 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.002396
K_2306 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.002396
K_2307 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.003657
K_2308 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.003647
K_2309 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.003600
K_2310 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.003647
K_2311 X_NUC_22.L_CORE X_NUC_65.L_CORE 0.003371
K_2312 X_NUC_22.L_CORE X_NUC_66.L_CORE 0.003343
K_2313 X_NUC_22.L_CORE X_NUC_67.L_CORE 0.003347
K_2314 X_NUC_22.L_CORE X_NUC_68.L_CORE 0.003318
K_2315 X_NUC_22.L_CORE X_NUC_69.L_CORE 0.002389
K_2316 X_NUC_22.L_CORE X_NUC_70.L_CORE 0.002368
K_2317 X_NUC_22.L_CORE X_NUC_71.L_CORE 0.002364
K_2318 X_NUC_22.L_CORE X_NUC_72.L_CORE 0.002375
K_2319 X_NUC_22.L_CORE X_NUC_73.L_CORE 0.004338
K_2320 X_NUC_22.L_CORE X_NUC_74.L_CORE 0.004345
K_2321 X_NUC_22.L_CORE X_NUC_75.L_CORE 0.004272
K_2322 X_NUC_22.L_CORE X_NUC_76.L_CORE 0.004287
K_2323 X_NUC_22.L_CORE X_NUC_77.L_CORE 0.002508
K_2324 X_NUC_22.L_CORE X_NUC_78.L_CORE 0.002485
K_2325 X_NUC_22.L_CORE X_NUC_79.L_CORE 0.002487
K_2326 X_NUC_22.L_CORE X_NUC_80.L_CORE 0.002481
K_2327 X_NUC_22.L_CORE X_NUC_81.L_CORE 0.002722
K_2328 X_NUC_22.L_CORE X_NUC_82.L_CORE 0.002707
K_2329 X_NUC_22.L_CORE X_NUC_83.L_CORE 0.002687
K_2330 X_NUC_22.L_CORE X_NUC_84.L_CORE 0.002706
K_2331 X_NUC_22.L_CORE X_NUC_85.L_CORE 0.003324
K_2332 X_NUC_22.L_CORE X_NUC_86.L_CORE 0.003309
K_2333 X_NUC_22.L_CORE X_NUC_87.L_CORE 0.003289
K_2334 X_NUC_22.L_CORE X_NUC_88.L_CORE 0.003275
K_2335 X_NUC_22.L_CORE X_NUC_89.L_CORE 0.002348
K_2336 X_NUC_22.L_CORE X_NUC_90.L_CORE 0.002329
K_2337 X_NUC_22.L_CORE X_NUC_91.L_CORE 0.002324
K_2338 X_NUC_22.L_CORE X_NUC_92.L_CORE 0.002328
K_2339 X_NUC_22.L_CORE X_NUC_93.L_CORE 0.002959
K_2340 X_NUC_22.L_CORE X_NUC_94.L_CORE 0.002948
K_2341 X_NUC_22.L_CORE X_NUC_95.L_CORE 0.002921
K_2342 X_NUC_22.L_CORE X_NUC_96.L_CORE 0.002932
K_2343 X_NUC_22.L_CORE X_NUC_97.L_CORE 0.002627
K_2344 X_NUC_22.L_CORE X_NUC_98.L_CORE 0.002611
K_2345 X_NUC_22.L_CORE X_NUC_99.L_CORE 0.002599
K_2346 X_NUC_22.L_CORE X_NUC_100.L_CORE 0.002598
K_2347 X_NUC_22.L_CORE X_NUC_101.L_CORE 0.006138
K_2348 X_NUC_22.L_CORE X_NUC_102.L_CORE 0.003103
K_2349 X_NUC_22.L_CORE X_NUC_103.L_CORE 0.006068
K_2350 X_NUC_22.L_CORE X_NUC_104.L_CORE 0.003964
K_2351 X_NUC_22.L_CORE X_NUC_105.L_CORE 0.002754
K_2352 X_NUC_22.L_CORE X_NUC_106.L_CORE 0.019644
K_2353 X_NUC_22.L_CORE X_NUC_107.L_CORE 0.002574
K_2354 X_NUC_22.L_CORE X_NUC_108.L_CORE 0.003364
K_2355 X_NUC_22.L_CORE X_NUC_109.L_CORE 0.004543
K_2356 X_NUC_22.L_CORE X_NUC_110.L_CORE 0.002261
K_2357 X_NUC_22.L_CORE X_NUC_111.L_CORE 0.004936
K_2358 X_NUC_22.L_CORE X_NUC_112.L_CORE 0.002638
K_2359 X_NUC_22.L_CORE X_NUC_113.L_CORE 0.002448
K_2360 X_NUC_22.L_CORE X_NUC_114.L_CORE 0.004115
K_2361 X_NUC_22.L_CORE X_NUC_115.L_CORE 0.002181
K_2362 X_NUC_22.L_CORE X_NUC_116.L_CORE 0.002905
K_2363 X_NUC_22.L_CORE X_NUC_117.L_CORE 0.002714
K_2364 X_NUC_22.L_CORE X_NUC_118.L_CORE 0.002227
K_2365 X_NUC_22.L_CORE X_NUC_119.L_CORE 0.002681
K_2366 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_2367 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.002903
K_2368 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.002864
K_2369 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.002886
K_2370 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.002879
K_2371 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.003911
K_2372 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.003878
K_2373 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.003856
K_2374 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.003920
K_2375 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.005549
K_2376 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.005477
K_2377 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.005545
K_2378 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.005425
K_2379 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.002546
K_2380 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.002517
K_2381 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.002523
K_2382 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.002532
K_2383 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.007089
K_2384 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.007134
K_2385 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.006920
K_2386 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.007102
K_2387 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.003021
K_2388 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.002985
K_2389 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.003004
K_2390 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.002984
K_2391 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.002797
K_2392 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.002773
K_2393 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.002763
K_2394 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.002789
K_2395 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.006327
K_2396 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.006335
K_2397 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.006262
K_2398 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.006170
K_2399 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.002411
K_2400 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.002386
K_2401 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.002391
K_2402 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.002391
K_2403 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.003706
K_2404 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.003694
K_2405 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.003647
K_2406 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.003695
K_2407 X_NUC_23.L_CORE X_NUC_65.L_CORE 0.003366
K_2408 X_NUC_23.L_CORE X_NUC_66.L_CORE 0.003337
K_2409 X_NUC_23.L_CORE X_NUC_67.L_CORE 0.003343
K_2410 X_NUC_23.L_CORE X_NUC_68.L_CORE 0.003313
K_2411 X_NUC_23.L_CORE X_NUC_69.L_CORE 0.002394
K_2412 X_NUC_23.L_CORE X_NUC_70.L_CORE 0.002373
K_2413 X_NUC_23.L_CORE X_NUC_71.L_CORE 0.002368
K_2414 X_NUC_23.L_CORE X_NUC_72.L_CORE 0.002380
K_2415 X_NUC_23.L_CORE X_NUC_73.L_CORE 0.004413
K_2416 X_NUC_23.L_CORE X_NUC_74.L_CORE 0.004419
K_2417 X_NUC_23.L_CORE X_NUC_75.L_CORE 0.004345
K_2418 X_NUC_23.L_CORE X_NUC_76.L_CORE 0.004359
K_2419 X_NUC_23.L_CORE X_NUC_77.L_CORE 0.002506
K_2420 X_NUC_23.L_CORE X_NUC_78.L_CORE 0.002483
K_2421 X_NUC_23.L_CORE X_NUC_79.L_CORE 0.002485
K_2422 X_NUC_23.L_CORE X_NUC_80.L_CORE 0.002479
K_2423 X_NUC_23.L_CORE X_NUC_81.L_CORE 0.002742
K_2424 X_NUC_23.L_CORE X_NUC_82.L_CORE 0.002726
K_2425 X_NUC_23.L_CORE X_NUC_83.L_CORE 0.002707
K_2426 X_NUC_23.L_CORE X_NUC_84.L_CORE 0.002726
K_2427 X_NUC_23.L_CORE X_NUC_85.L_CORE 0.003344
K_2428 X_NUC_23.L_CORE X_NUC_86.L_CORE 0.003329
K_2429 X_NUC_23.L_CORE X_NUC_87.L_CORE 0.003309
K_2430 X_NUC_23.L_CORE X_NUC_88.L_CORE 0.003295
K_2431 X_NUC_23.L_CORE X_NUC_89.L_CORE 0.002353
K_2432 X_NUC_23.L_CORE X_NUC_90.L_CORE 0.002335
K_2433 X_NUC_23.L_CORE X_NUC_91.L_CORE 0.002329
K_2434 X_NUC_23.L_CORE X_NUC_92.L_CORE 0.002333
K_2435 X_NUC_23.L_CORE X_NUC_93.L_CORE 0.002987
K_2436 X_NUC_23.L_CORE X_NUC_94.L_CORE 0.002976
K_2437 X_NUC_23.L_CORE X_NUC_95.L_CORE 0.002948
K_2438 X_NUC_23.L_CORE X_NUC_96.L_CORE 0.002960
K_2439 X_NUC_23.L_CORE X_NUC_97.L_CORE 0.002638
K_2440 X_NUC_23.L_CORE X_NUC_98.L_CORE 0.002621
K_2441 X_NUC_23.L_CORE X_NUC_99.L_CORE 0.002611
K_2442 X_NUC_23.L_CORE X_NUC_100.L_CORE 0.002609
K_2443 X_NUC_23.L_CORE X_NUC_101.L_CORE 0.005979
K_2444 X_NUC_23.L_CORE X_NUC_102.L_CORE 0.003076
K_2445 X_NUC_23.L_CORE X_NUC_103.L_CORE 0.006075
K_2446 X_NUC_23.L_CORE X_NUC_104.L_CORE 0.003905
K_2447 X_NUC_23.L_CORE X_NUC_105.L_CORE 0.002749
K_2448 X_NUC_23.L_CORE X_NUC_106.L_CORE 0.020808
K_2449 X_NUC_23.L_CORE X_NUC_107.L_CORE 0.002558
K_2450 X_NUC_23.L_CORE X_NUC_108.L_CORE 0.003388
K_2451 X_NUC_23.L_CORE X_NUC_109.L_CORE 0.004515
K_2452 X_NUC_23.L_CORE X_NUC_110.L_CORE 0.002258
K_2453 X_NUC_23.L_CORE X_NUC_111.L_CORE 0.005053
K_2454 X_NUC_23.L_CORE X_NUC_112.L_CORE 0.002628
K_2455 X_NUC_23.L_CORE X_NUC_113.L_CORE 0.002459
K_2456 X_NUC_23.L_CORE X_NUC_114.L_CORE 0.004158
K_2457 X_NUC_23.L_CORE X_NUC_115.L_CORE 0.002180
K_2458 X_NUC_23.L_CORE X_NUC_116.L_CORE 0.002936
K_2459 X_NUC_23.L_CORE X_NUC_117.L_CORE 0.002721
K_2460 X_NUC_23.L_CORE X_NUC_118.L_CORE 0.002236
K_2461 X_NUC_23.L_CORE X_NUC_119.L_CORE 0.002702
K_2462 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.002910
K_2463 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.002870
K_2464 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.002892
K_2465 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.002886
K_2466 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.003847
K_2467 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.003815
K_2468 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.003794
K_2469 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.003856
K_2470 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.005674
K_2471 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.005598
K_2472 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.005668
K_2473 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.005545
K_2474 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.002536
K_2475 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.002508
K_2476 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.002514
K_2477 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.002523
K_2478 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.006904
K_2479 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.006945
K_2480 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.006744
K_2481 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.006920
K_2482 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.003042
K_2483 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.003005
K_2484 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.003023
K_2485 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.003004
K_2486 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.002771
K_2487 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.002747
K_2488 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.002738
K_2489 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.002763
K_2490 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.006424
K_2491 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.006432
K_2492 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.006353
K_2493 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.006262
K_2494 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.002411
K_2495 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.002385
K_2496 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.002391
K_2497 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.002391
K_2498 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.003656
K_2499 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.003645
K_2500 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.003599
K_2501 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.003647
K_2502 X_NUC_24.L_CORE X_NUC_65.L_CORE 0.003397
K_2503 X_NUC_24.L_CORE X_NUC_66.L_CORE 0.003368
K_2504 X_NUC_24.L_CORE X_NUC_67.L_CORE 0.003373
K_2505 X_NUC_24.L_CORE X_NUC_68.L_CORE 0.003343
K_2506 X_NUC_24.L_CORE X_NUC_69.L_CORE 0.002383
K_2507 X_NUC_24.L_CORE X_NUC_70.L_CORE 0.002362
K_2508 X_NUC_24.L_CORE X_NUC_71.L_CORE 0.002357
K_2509 X_NUC_24.L_CORE X_NUC_72.L_CORE 0.002368
K_2510 X_NUC_24.L_CORE X_NUC_73.L_CORE 0.004397
K_2511 X_NUC_24.L_CORE X_NUC_74.L_CORE 0.004403
K_2512 X_NUC_24.L_CORE X_NUC_75.L_CORE 0.004329
K_2513 X_NUC_24.L_CORE X_NUC_76.L_CORE 0.004345
K_2514 X_NUC_24.L_CORE X_NUC_77.L_CORE 0.002513
K_2515 X_NUC_24.L_CORE X_NUC_78.L_CORE 0.002489
K_2516 X_NUC_24.L_CORE X_NUC_79.L_CORE 0.002491
K_2517 X_NUC_24.L_CORE X_NUC_80.L_CORE 0.002485
K_2518 X_NUC_24.L_CORE X_NUC_81.L_CORE 0.002722
K_2519 X_NUC_24.L_CORE X_NUC_82.L_CORE 0.002707
K_2520 X_NUC_24.L_CORE X_NUC_83.L_CORE 0.002687
K_2521 X_NUC_24.L_CORE X_NUC_84.L_CORE 0.002707
K_2522 X_NUC_24.L_CORE X_NUC_85.L_CORE 0.003359
K_2523 X_NUC_24.L_CORE X_NUC_86.L_CORE 0.003343
K_2524 X_NUC_24.L_CORE X_NUC_87.L_CORE 0.003323
K_2525 X_NUC_24.L_CORE X_NUC_88.L_CORE 0.003309
K_2526 X_NUC_24.L_CORE X_NUC_89.L_CORE 0.002350
K_2527 X_NUC_24.L_CORE X_NUC_90.L_CORE 0.002331
K_2528 X_NUC_24.L_CORE X_NUC_91.L_CORE 0.002325
K_2529 X_NUC_24.L_CORE X_NUC_92.L_CORE 0.002329
K_2530 X_NUC_24.L_CORE X_NUC_93.L_CORE 0.002975
K_2531 X_NUC_24.L_CORE X_NUC_94.L_CORE 0.002964
K_2532 X_NUC_24.L_CORE X_NUC_95.L_CORE 0.002936
K_2533 X_NUC_24.L_CORE X_NUC_96.L_CORE 0.002948
K_2534 X_NUC_24.L_CORE X_NUC_97.L_CORE 0.002640
K_2535 X_NUC_24.L_CORE X_NUC_98.L_CORE 0.002623
K_2536 X_NUC_24.L_CORE X_NUC_99.L_CORE 0.002612
K_2537 X_NUC_24.L_CORE X_NUC_100.L_CORE 0.002611
K_2538 X_NUC_24.L_CORE X_NUC_101.L_CORE 0.005997
K_2539 X_NUC_24.L_CORE X_NUC_102.L_CORE 0.003069
K_2540 X_NUC_24.L_CORE X_NUC_103.L_CORE 0.005922
K_2541 X_NUC_24.L_CORE X_NUC_104.L_CORE 0.003949
K_2542 X_NUC_24.L_CORE X_NUC_105.L_CORE 0.002728
K_2543 X_NUC_24.L_CORE X_NUC_106.L_CORE 0.021243
K_2544 X_NUC_24.L_CORE X_NUC_107.L_CORE 0.002564
K_2545 X_NUC_24.L_CORE X_NUC_108.L_CORE 0.003339
K_2546 X_NUC_24.L_CORE X_NUC_109.L_CORE 0.004600
K_2547 X_NUC_24.L_CORE X_NUC_110.L_CORE 0.002250
K_2548 X_NUC_24.L_CORE X_NUC_111.L_CORE 0.004978
K_2549 X_NUC_24.L_CORE X_NUC_112.L_CORE 0.002644
K_2550 X_NUC_24.L_CORE X_NUC_113.L_CORE 0.002440
K_2551 X_NUC_24.L_CORE X_NUC_114.L_CORE 0.004186
K_2552 X_NUC_24.L_CORE X_NUC_115.L_CORE 0.002180
K_2553 X_NUC_24.L_CORE X_NUC_116.L_CORE 0.002913
K_2554 X_NUC_24.L_CORE X_NUC_117.L_CORE 0.002733
K_2555 X_NUC_24.L_CORE X_NUC_118.L_CORE 0.002229
K_2556 X_NUC_24.L_CORE X_NUC_119.L_CORE 0.002698
K_2557 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_2558 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_2559 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_2560 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.002744
K_2561 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.002767
K_2562 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.002740
K_2563 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.002769
K_2564 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.003693
K_2565 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.003755
K_2566 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.003728
K_2567 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.003706
K_2568 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.005365
K_2569 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.005341
K_2570 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.005262
K_2571 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.005390
K_2572 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.002437
K_2573 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.002463
K_2574 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.002441
K_2575 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.002453
K_2576 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.006867
K_2577 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.006966
K_2578 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.006893
K_2579 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.006746
K_2580 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.002932
K_2581 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.002945
K_2582 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.002911
K_2583 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.002948
K_2584 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.002706
K_2585 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.002739
K_2586 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.002715
K_2587 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.002713
K_2588 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.006329
K_2589 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.006271
K_2590 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.006150
K_2591 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.006217
K_2592 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.002355
K_2593 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.002374
K_2594 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.002349
K_2595 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.002366
K_2596 X_NUC_25.L_CORE X_NUC_65.L_CORE 0.003629
K_2597 X_NUC_25.L_CORE X_NUC_66.L_CORE 0.003671
K_2598 X_NUC_25.L_CORE X_NUC_67.L_CORE 0.003634
K_2599 X_NUC_25.L_CORE X_NUC_68.L_CORE 0.003608
K_2600 X_NUC_25.L_CORE X_NUC_69.L_CORE 0.003330
K_2601 X_NUC_25.L_CORE X_NUC_70.L_CORE 0.003333
K_2602 X_NUC_25.L_CORE X_NUC_71.L_CORE 0.003288
K_2603 X_NUC_25.L_CORE X_NUC_72.L_CORE 0.003328
K_2604 X_NUC_25.L_CORE X_NUC_73.L_CORE 0.002359
K_2605 X_NUC_25.L_CORE X_NUC_74.L_CORE 0.002382
K_2606 X_NUC_25.L_CORE X_NUC_75.L_CORE 0.002358
K_2607 X_NUC_25.L_CORE X_NUC_76.L_CORE 0.002364
K_2608 X_NUC_25.L_CORE X_NUC_77.L_CORE 0.004345
K_2609 X_NUC_25.L_CORE X_NUC_78.L_CORE 0.004357
K_2610 X_NUC_25.L_CORE X_NUC_79.L_CORE 0.004293
K_2611 X_NUC_25.L_CORE X_NUC_80.L_CORE 0.004283
K_2612 X_NUC_25.L_CORE X_NUC_81.L_CORE 0.002495
K_2613 X_NUC_25.L_CORE X_NUC_82.L_CORE 0.002509
K_2614 X_NUC_25.L_CORE X_NUC_83.L_CORE 0.002479
K_2615 X_NUC_25.L_CORE X_NUC_84.L_CORE 0.002499
K_2616 X_NUC_25.L_CORE X_NUC_85.L_CORE 0.002722
K_2617 X_NUC_25.L_CORE X_NUC_86.L_CORE 0.002747
K_2618 X_NUC_25.L_CORE X_NUC_87.L_CORE 0.002718
K_2619 X_NUC_25.L_CORE X_NUC_88.L_CORE 0.002715
K_2620 X_NUC_25.L_CORE X_NUC_89.L_CORE 0.003279
K_2621 X_NUC_25.L_CORE X_NUC_90.L_CORE 0.003285
K_2622 X_NUC_25.L_CORE X_NUC_91.L_CORE 0.003239
K_2623 X_NUC_25.L_CORE X_NUC_92.L_CORE 0.003258
K_2624 X_NUC_25.L_CORE X_NUC_93.L_CORE 0.002396
K_2625 X_NUC_25.L_CORE X_NUC_94.L_CORE 0.002412
K_2626 X_NUC_25.L_CORE X_NUC_95.L_CORE 0.002385
K_2627 X_NUC_25.L_CORE X_NUC_96.L_CORE 0.002395
K_2628 X_NUC_25.L_CORE X_NUC_97.L_CORE 0.002864
K_2629 X_NUC_25.L_CORE X_NUC_98.L_CORE 0.002880
K_2630 X_NUC_25.L_CORE X_NUC_99.L_CORE 0.002845
K_2631 X_NUC_25.L_CORE X_NUC_100.L_CORE 0.002849
K_2632 X_NUC_25.L_CORE X_NUC_101.L_CORE 0.003885
K_2633 X_NUC_25.L_CORE X_NUC_102.L_CORE 0.006790
K_2634 X_NUC_25.L_CORE X_NUC_103.L_CORE 0.002750
K_2635 X_NUC_25.L_CORE X_NUC_104.L_CORE 0.005709
K_2636 X_NUC_25.L_CORE X_NUC_105.L_CORE 0.003667
K_2637 X_NUC_25.L_CORE X_NUC_106.L_CORE 0.002593
K_2638 X_NUC_25.L_CORE X_NUC_107.L_CORE 0.018400
K_2639 X_NUC_25.L_CORE X_NUC_108.L_CORE 0.002458
K_2640 X_NUC_25.L_CORE X_NUC_109.L_CORE 0.003256
K_2641 X_NUC_25.L_CORE X_NUC_110.L_CORE 0.004385
K_2642 X_NUC_25.L_CORE X_NUC_111.L_CORE 0.002204
K_2643 X_NUC_25.L_CORE X_NUC_112.L_CORE 0.004878
K_2644 X_NUC_25.L_CORE X_NUC_113.L_CORE 0.002591
K_2645 X_NUC_25.L_CORE X_NUC_114.L_CORE 0.002429
K_2646 X_NUC_25.L_CORE X_NUC_115.L_CORE 0.004029
K_2647 X_NUC_25.L_CORE X_NUC_116.L_CORE 0.002186
K_2648 X_NUC_25.L_CORE X_NUC_117.L_CORE 0.002884
K_2649 X_NUC_25.L_CORE X_NUC_118.L_CORE 0.002690
K_2650 X_NUC_25.L_CORE X_NUC_119.L_CORE 0.002328
K_2651 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_2652 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_2653 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.002722
K_2654 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.002744
K_2655 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.002718
K_2656 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.002746
K_2657 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.003633
K_2658 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.003693
K_2659 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.003667
K_2660 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.003646
K_2661 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.005385
K_2662 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.005365
K_2663 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.005283
K_2664 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.005413
K_2665 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.002412
K_2666 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.002437
K_2667 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.002416
K_2668 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.002427
K_2669 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.006764
K_2670 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.006867
K_2671 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.006793
K_2672 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.006652
K_2673 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.002918
K_2674 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.002932
K_2675 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.002898
K_2676 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.002934
K_2677 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.002673
K_2678 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.002706
K_2679 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.002682
K_2680 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.002680
K_2681 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.006384
K_2682 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.006329
K_2683 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.006203
K_2684 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.006271
K_2685 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.002337
K_2686 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.002355
K_2687 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.002331
K_2688 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.002347
K_2689 X_NUC_26.L_CORE X_NUC_65.L_CORE 0.003587
K_2690 X_NUC_26.L_CORE X_NUC_66.L_CORE 0.003629
K_2691 X_NUC_26.L_CORE X_NUC_67.L_CORE 0.003592
K_2692 X_NUC_26.L_CORE X_NUC_68.L_CORE 0.003568
K_2693 X_NUC_26.L_CORE X_NUC_69.L_CORE 0.003327
K_2694 X_NUC_26.L_CORE X_NUC_70.L_CORE 0.003330
K_2695 X_NUC_26.L_CORE X_NUC_71.L_CORE 0.003285
K_2696 X_NUC_26.L_CORE X_NUC_72.L_CORE 0.003325
K_2697 X_NUC_26.L_CORE X_NUC_73.L_CORE 0.002337
K_2698 X_NUC_26.L_CORE X_NUC_74.L_CORE 0.002359
K_2699 X_NUC_26.L_CORE X_NUC_75.L_CORE 0.002336
K_2700 X_NUC_26.L_CORE X_NUC_76.L_CORE 0.002341
K_2701 X_NUC_26.L_CORE X_NUC_77.L_CORE 0.004331
K_2702 X_NUC_26.L_CORE X_NUC_78.L_CORE 0.004345
K_2703 X_NUC_26.L_CORE X_NUC_79.L_CORE 0.004281
K_2704 X_NUC_26.L_CORE X_NUC_80.L_CORE 0.004271
K_2705 X_NUC_26.L_CORE X_NUC_81.L_CORE 0.002482
K_2706 X_NUC_26.L_CORE X_NUC_82.L_CORE 0.002495
K_2707 X_NUC_26.L_CORE X_NUC_83.L_CORE 0.002466
K_2708 X_NUC_26.L_CORE X_NUC_84.L_CORE 0.002485
K_2709 X_NUC_26.L_CORE X_NUC_85.L_CORE 0.002697
K_2710 X_NUC_26.L_CORE X_NUC_86.L_CORE 0.002722
K_2711 X_NUC_26.L_CORE X_NUC_87.L_CORE 0.002693
K_2712 X_NUC_26.L_CORE X_NUC_88.L_CORE 0.002691
K_2713 X_NUC_26.L_CORE X_NUC_89.L_CORE 0.003272
K_2714 X_NUC_26.L_CORE X_NUC_90.L_CORE 0.003279
K_2715 X_NUC_26.L_CORE X_NUC_91.L_CORE 0.003233
K_2716 X_NUC_26.L_CORE X_NUC_92.L_CORE 0.003252
K_2717 X_NUC_26.L_CORE X_NUC_93.L_CORE 0.002379
K_2718 X_NUC_26.L_CORE X_NUC_94.L_CORE 0.002396
K_2719 X_NUC_26.L_CORE X_NUC_95.L_CORE 0.002369
K_2720 X_NUC_26.L_CORE X_NUC_96.L_CORE 0.002378
K_2721 X_NUC_26.L_CORE X_NUC_97.L_CORE 0.002847
K_2722 X_NUC_26.L_CORE X_NUC_98.L_CORE 0.002864
K_2723 X_NUC_26.L_CORE X_NUC_99.L_CORE 0.002829
K_2724 X_NUC_26.L_CORE X_NUC_100.L_CORE 0.002832
K_2725 X_NUC_26.L_CORE X_NUC_101.L_CORE 0.003824
K_2726 X_NUC_26.L_CORE X_NUC_102.L_CORE 0.006743
K_2727 X_NUC_26.L_CORE X_NUC_103.L_CORE 0.002721
K_2728 X_NUC_26.L_CORE X_NUC_104.L_CORE 0.005587
K_2729 X_NUC_26.L_CORE X_NUC_105.L_CORE 0.003656
K_2730 X_NUC_26.L_CORE X_NUC_106.L_CORE 0.002561
K_2731 X_NUC_26.L_CORE X_NUC_107.L_CORE 0.019680
K_2732 X_NUC_26.L_CORE X_NUC_108.L_CORE 0.002441
K_2733 X_NUC_26.L_CORE X_NUC_109.L_CORE 0.003213
K_2734 X_NUC_26.L_CORE X_NUC_110.L_CORE 0.004411
K_2735 X_NUC_26.L_CORE X_NUC_111.L_CORE 0.002184
K_2736 X_NUC_26.L_CORE X_NUC_112.L_CORE 0.004849
K_2737 X_NUC_26.L_CORE X_NUC_113.L_CORE 0.002583
K_2738 X_NUC_26.L_CORE X_NUC_114.L_CORE 0.002405
K_2739 X_NUC_26.L_CORE X_NUC_115.L_CORE 0.004042
K_2740 X_NUC_26.L_CORE X_NUC_116.L_CORE 0.002172
K_2741 X_NUC_26.L_CORE X_NUC_117.L_CORE 0.002864
K_2742 X_NUC_26.L_CORE X_NUC_118.L_CORE 0.002684
K_2743 X_NUC_26.L_CORE X_NUC_119.L_CORE 0.002314
K_2744 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_2745 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.002748
K_2746 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.002771
K_2747 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.002744
K_2748 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.002773
K_2749 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.003657
K_2750 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.003718
K_2751 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.003693
K_2752 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.003670
K_2753 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.005470
K_2754 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.005447
K_2755 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.005365
K_2756 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.005499
K_2757 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.002434
K_2758 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.002460
K_2759 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.002437
K_2760 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.002449
K_2761 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.006833
K_2762 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.006935
K_2763 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.006867
K_2764 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.006717
K_2765 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.002952
K_2766 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.002966
K_2767 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.002932
K_2768 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.002969
K_2769 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.002696
K_2770 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.002729
K_2771 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.002706
K_2772 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.002703
K_2773 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.006519
K_2774 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.006458
K_2775 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.006329
K_2776 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.006399
K_2777 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.002361
K_2778 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.002380
K_2779 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.002355
K_2780 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.002372
K_2781 X_NUC_27.L_CORE X_NUC_65.L_CORE 0.003623
K_2782 X_NUC_27.L_CORE X_NUC_66.L_CORE 0.003665
K_2783 X_NUC_27.L_CORE X_NUC_67.L_CORE 0.003629
K_2784 X_NUC_27.L_CORE X_NUC_68.L_CORE 0.003603
K_2785 X_NUC_27.L_CORE X_NUC_69.L_CORE 0.003374
K_2786 X_NUC_27.L_CORE X_NUC_70.L_CORE 0.003377
K_2787 X_NUC_27.L_CORE X_NUC_71.L_CORE 0.003330
K_2788 X_NUC_27.L_CORE X_NUC_72.L_CORE 0.003372
K_2789 X_NUC_27.L_CORE X_NUC_73.L_CORE 0.002360
K_2790 X_NUC_27.L_CORE X_NUC_74.L_CORE 0.002383
K_2791 X_NUC_27.L_CORE X_NUC_75.L_CORE 0.002359
K_2792 X_NUC_27.L_CORE X_NUC_76.L_CORE 0.002365
K_2793 X_NUC_27.L_CORE X_NUC_77.L_CORE 0.004396
K_2794 X_NUC_27.L_CORE X_NUC_78.L_CORE 0.004410
K_2795 X_NUC_27.L_CORE X_NUC_79.L_CORE 0.004345
K_2796 X_NUC_27.L_CORE X_NUC_80.L_CORE 0.004334
K_2797 X_NUC_27.L_CORE X_NUC_81.L_CORE 0.002511
K_2798 X_NUC_27.L_CORE X_NUC_82.L_CORE 0.002525
K_2799 X_NUC_27.L_CORE X_NUC_83.L_CORE 0.002495
K_2800 X_NUC_27.L_CORE X_NUC_84.L_CORE 0.002515
K_2801 X_NUC_27.L_CORE X_NUC_85.L_CORE 0.002726
K_2802 X_NUC_27.L_CORE X_NUC_86.L_CORE 0.002752
K_2803 X_NUC_27.L_CORE X_NUC_87.L_CORE 0.002722
K_2804 X_NUC_27.L_CORE X_NUC_88.L_CORE 0.002720
K_2805 X_NUC_27.L_CORE X_NUC_89.L_CORE 0.003319
K_2806 X_NUC_27.L_CORE X_NUC_90.L_CORE 0.003326
K_2807 X_NUC_27.L_CORE X_NUC_91.L_CORE 0.003279
K_2808 X_NUC_27.L_CORE X_NUC_92.L_CORE 0.003299
K_2809 X_NUC_27.L_CORE X_NUC_93.L_CORE 0.002406
K_2810 X_NUC_27.L_CORE X_NUC_94.L_CORE 0.002423
K_2811 X_NUC_27.L_CORE X_NUC_95.L_CORE 0.002396
K_2812 X_NUC_27.L_CORE X_NUC_96.L_CORE 0.002405
K_2813 X_NUC_27.L_CORE X_NUC_97.L_CORE 0.002882
K_2814 X_NUC_27.L_CORE X_NUC_98.L_CORE 0.002900
K_2815 X_NUC_27.L_CORE X_NUC_99.L_CORE 0.002864
K_2816 X_NUC_27.L_CORE X_NUC_100.L_CORE 0.002868
K_2817 X_NUC_27.L_CORE X_NUC_101.L_CORE 0.003834
K_2818 X_NUC_27.L_CORE X_NUC_102.L_CORE 0.006732
K_2819 X_NUC_27.L_CORE X_NUC_103.L_CORE 0.002740
K_2820 X_NUC_27.L_CORE X_NUC_104.L_CORE 0.005575
K_2821 X_NUC_27.L_CORE X_NUC_105.L_CORE 0.003689
K_2822 X_NUC_27.L_CORE X_NUC_106.L_CORE 0.002579
K_2823 X_NUC_27.L_CORE X_NUC_107.L_CORE 0.019253
K_2824 X_NUC_27.L_CORE X_NUC_108.L_CORE 0.002464
K_2825 X_NUC_27.L_CORE X_NUC_109.L_CORE 0.003233
K_2826 X_NUC_27.L_CORE X_NUC_110.L_CORE 0.004469
K_2827 X_NUC_27.L_CORE X_NUC_111.L_CORE 0.002203
K_2828 X_NUC_27.L_CORE X_NUC_112.L_CORE 0.004892
K_2829 X_NUC_27.L_CORE X_NUC_113.L_CORE 0.002612
K_2830 X_NUC_27.L_CORE X_NUC_114.L_CORE 0.002426
K_2831 X_NUC_27.L_CORE X_NUC_115.L_CORE 0.004099
K_2832 X_NUC_27.L_CORE X_NUC_116.L_CORE 0.002194
K_2833 X_NUC_27.L_CORE X_NUC_117.L_CORE 0.002893
K_2834 X_NUC_27.L_CORE X_NUC_118.L_CORE 0.002717
K_2835 X_NUC_27.L_CORE X_NUC_119.L_CORE 0.002339
K_2836 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.002720
K_2837 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.002742
K_2838 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.002716
K_2839 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.002744
K_2840 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.003679
K_2841 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.003741
K_2842 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.003715
K_2843 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.003693
K_2844 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.005336
K_2845 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.005314
K_2846 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.005237
K_2847 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.005365
K_2848 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.002422
K_2849 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.002448
K_2850 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.002426
K_2851 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.002437
K_2852 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.006987
K_2853 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.007096
K_2854 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.007019
K_2855 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.006867
K_2856 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.002915
K_2857 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.002928
K_2858 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.002895
K_2859 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.002932
K_2860 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.002698
K_2861 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.002732
K_2862 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.002707
K_2863 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.002706
K_2864 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.006442
K_2865 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.006384
K_2866 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.006257
K_2867 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.006329
K_2868 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.002344
K_2869 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.002363
K_2870 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.002339
K_2871 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.002355
K_2872 X_NUC_28.L_CORE X_NUC_65.L_CORE 0.003648
K_2873 X_NUC_28.L_CORE X_NUC_66.L_CORE 0.003692
K_2874 X_NUC_28.L_CORE X_NUC_67.L_CORE 0.003654
K_2875 X_NUC_28.L_CORE X_NUC_68.L_CORE 0.003629
K_2876 X_NUC_28.L_CORE X_NUC_69.L_CORE 0.003332
K_2877 X_NUC_28.L_CORE X_NUC_70.L_CORE 0.003335
K_2878 X_NUC_28.L_CORE X_NUC_71.L_CORE 0.003290
K_2879 X_NUC_28.L_CORE X_NUC_72.L_CORE 0.003330
K_2880 X_NUC_28.L_CORE X_NUC_73.L_CORE 0.002354
K_2881 X_NUC_28.L_CORE X_NUC_74.L_CORE 0.002377
K_2882 X_NUC_28.L_CORE X_NUC_75.L_CORE 0.002353
K_2883 X_NUC_28.L_CORE X_NUC_76.L_CORE 0.002359
K_2884 X_NUC_28.L_CORE X_NUC_77.L_CORE 0.004407
K_2885 X_NUC_28.L_CORE X_NUC_78.L_CORE 0.004420
K_2886 X_NUC_28.L_CORE X_NUC_79.L_CORE 0.004354
K_2887 X_NUC_28.L_CORE X_NUC_80.L_CORE 0.004345
K_2888 X_NUC_28.L_CORE X_NUC_81.L_CORE 0.002491
K_2889 X_NUC_28.L_CORE X_NUC_82.L_CORE 0.002505
K_2890 X_NUC_28.L_CORE X_NUC_83.L_CORE 0.002476
K_2891 X_NUC_28.L_CORE X_NUC_84.L_CORE 0.002495
K_2892 X_NUC_28.L_CORE X_NUC_85.L_CORE 0.002729
K_2893 X_NUC_28.L_CORE X_NUC_86.L_CORE 0.002754
K_2894 X_NUC_28.L_CORE X_NUC_87.L_CORE 0.002724
K_2895 X_NUC_28.L_CORE X_NUC_88.L_CORE 0.002722
K_2896 X_NUC_28.L_CORE X_NUC_89.L_CORE 0.003299
K_2897 X_NUC_28.L_CORE X_NUC_90.L_CORE 0.003305
K_2898 X_NUC_28.L_CORE X_NUC_91.L_CORE 0.003258
K_2899 X_NUC_28.L_CORE X_NUC_92.L_CORE 0.003279
K_2900 X_NUC_28.L_CORE X_NUC_93.L_CORE 0.002396
K_2901 X_NUC_28.L_CORE X_NUC_94.L_CORE 0.002413
K_2902 X_NUC_28.L_CORE X_NUC_95.L_CORE 0.002385
K_2903 X_NUC_28.L_CORE X_NUC_96.L_CORE 0.002396
K_2904 X_NUC_28.L_CORE X_NUC_97.L_CORE 0.002878
K_2905 X_NUC_28.L_CORE X_NUC_98.L_CORE 0.002895
K_2906 X_NUC_28.L_CORE X_NUC_99.L_CORE 0.002859
K_2907 X_NUC_28.L_CORE X_NUC_100.L_CORE 0.002864
K_2908 X_NUC_28.L_CORE X_NUC_101.L_CORE 0.003824
K_2909 X_NUC_28.L_CORE X_NUC_102.L_CORE 0.006588
K_2910 X_NUC_28.L_CORE X_NUC_103.L_CORE 0.002720
K_2911 X_NUC_28.L_CORE X_NUC_104.L_CORE 0.005656
K_2912 X_NUC_28.L_CORE X_NUC_105.L_CORE 0.003626
K_2913 X_NUC_28.L_CORE X_NUC_106.L_CORE 0.002575
K_2914 X_NUC_28.L_CORE X_NUC_107.L_CORE 0.020067
K_2915 X_NUC_28.L_CORE X_NUC_108.L_CORE 0.002441
K_2916 X_NUC_28.L_CORE X_NUC_109.L_CORE 0.003254
K_2917 X_NUC_28.L_CORE X_NUC_110.L_CORE 0.004389
K_2918 X_NUC_28.L_CORE X_NUC_111.L_CORE 0.002194
K_2919 X_NUC_28.L_CORE X_NUC_112.L_CORE 0.004961
K_2920 X_NUC_28.L_CORE X_NUC_113.L_CORE 0.002584
K_2921 X_NUC_28.L_CORE X_NUC_114.L_CORE 0.002428
K_2922 X_NUC_28.L_CORE X_NUC_115.L_CORE 0.004079
K_2923 X_NUC_28.L_CORE X_NUC_116.L_CORE 0.002182
K_2924 X_NUC_28.L_CORE X_NUC_117.L_CORE 0.002902
K_2925 X_NUC_28.L_CORE X_NUC_118.L_CORE 0.002699
K_2926 X_NUC_28.L_CORE X_NUC_119.L_CORE 0.002333
K_2927 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_2928 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_2929 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_2930 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.002641
K_2931 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.002644
K_2932 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.002658
K_2933 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.002625
K_2934 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.003574
K_2935 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.003518
K_2936 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.003552
K_2937 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.003529
K_2938 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.005231
K_2939 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.005330
K_2940 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.005295
K_2941 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.005213
K_2942 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.002377
K_2943 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.002366
K_2944 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.002381
K_2945 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.002356
K_2946 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.006823
K_2947 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.006648
K_2948 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.006629
K_2949 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.006658
K_2950 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.002883
K_2951 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.002897
K_2952 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.002899
K_2953 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.002864
K_2954 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.002669
K_2955 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.002644
K_2956 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.002659
K_2957 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.002639
K_2958 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.006367
K_2959 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.006451
K_2960 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.006300
K_2961 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.006273
K_2962 X_NUC_29.L_CORE X_NUC_65.L_CORE 0.002338
K_2963 X_NUC_29.L_CORE X_NUC_66.L_CORE 0.002335
K_2964 X_NUC_29.L_CORE X_NUC_67.L_CORE 0.002342
K_2965 X_NUC_29.L_CORE X_NUC_68.L_CORE 0.002318
K_2966 X_NUC_29.L_CORE X_NUC_69.L_CORE 0.003623
K_2967 X_NUC_29.L_CORE X_NUC_70.L_CORE 0.003576
K_2968 X_NUC_29.L_CORE X_NUC_71.L_CORE 0.003578
K_2969 X_NUC_29.L_CORE X_NUC_72.L_CORE 0.003565
K_2970 X_NUC_29.L_CORE X_NUC_73.L_CORE 0.003330
K_2971 X_NUC_29.L_CORE X_NUC_74.L_CORE 0.003353
K_2972 X_NUC_29.L_CORE X_NUC_75.L_CORE 0.003334
K_2973 X_NUC_29.L_CORE X_NUC_76.L_CORE 0.003301
K_2974 X_NUC_29.L_CORE X_NUC_77.L_CORE 0.002368
K_2975 X_NUC_29.L_CORE X_NUC_78.L_CORE 0.002356
K_2976 X_NUC_29.L_CORE X_NUC_79.L_CORE 0.002363
K_2977 X_NUC_29.L_CORE X_NUC_80.L_CORE 0.002343
K_2978 X_NUC_29.L_CORE X_NUC_81.L_CORE 0.004309
K_2979 X_NUC_29.L_CORE X_NUC_82.L_CORE 0.004291
K_2980 X_NUC_29.L_CORE X_NUC_83.L_CORE 0.004244
K_2981 X_NUC_29.L_CORE X_NUC_84.L_CORE 0.004235
K_2982 X_NUC_29.L_CORE X_NUC_85.L_CORE 0.002526
K_2983 X_NUC_29.L_CORE X_NUC_86.L_CORE 0.002528
K_2984 X_NUC_29.L_CORE X_NUC_87.L_CORE 0.002526
K_2985 X_NUC_29.L_CORE X_NUC_88.L_CORE 0.002502
K_2986 X_NUC_29.L_CORE X_NUC_89.L_CORE 0.002755
K_2987 X_NUC_29.L_CORE X_NUC_90.L_CORE 0.002736
K_2988 X_NUC_29.L_CORE X_NUC_91.L_CORE 0.002735
K_2989 X_NUC_29.L_CORE X_NUC_92.L_CORE 0.002719
K_2990 X_NUC_29.L_CORE X_NUC_93.L_CORE 0.003218
K_2991 X_NUC_29.L_CORE X_NUC_94.L_CORE 0.003222
K_2992 X_NUC_29.L_CORE X_NUC_95.L_CORE 0.003199
K_2993 X_NUC_29.L_CORE X_NUC_96.L_CORE 0.003178
K_2994 X_NUC_29.L_CORE X_NUC_97.L_CORE 0.002536
K_2995 X_NUC_29.L_CORE X_NUC_98.L_CORE 0.002530
K_2996 X_NUC_29.L_CORE X_NUC_99.L_CORE 0.002526
K_2997 X_NUC_29.L_CORE X_NUC_100.L_CORE 0.002507
K_2998 X_NUC_29.L_CORE X_NUC_101.L_CORE 0.003488
K_2999 X_NUC_29.L_CORE X_NUC_102.L_CORE 0.003390
K_3000 X_NUC_29.L_CORE X_NUC_103.L_CORE 0.007069
K_3001 X_NUC_29.L_CORE X_NUC_104.L_CORE 0.002519
K_3002 X_NUC_29.L_CORE X_NUC_105.L_CORE 0.005289
K_3003 X_NUC_29.L_CORE X_NUC_106.L_CORE 0.003489
K_3004 X_NUC_29.L_CORE X_NUC_107.L_CORE 0.002454
K_3005 X_NUC_29.L_CORE X_NUC_108.L_CORE 0.017838
K_3006 X_NUC_29.L_CORE X_NUC_109.L_CORE 0.002376
K_3007 X_NUC_29.L_CORE X_NUC_110.L_CORE 0.003130
K_3008 X_NUC_29.L_CORE X_NUC_111.L_CORE 0.004335
K_3009 X_NUC_29.L_CORE X_NUC_112.L_CORE 0.002158
K_3010 X_NUC_29.L_CORE X_NUC_113.L_CORE 0.004739
K_3011 X_NUC_29.L_CORE X_NUC_114.L_CORE 0.002577
K_3012 X_NUC_29.L_CORE X_NUC_115.L_CORE 0.002407
K_3013 X_NUC_29.L_CORE X_NUC_116.L_CORE 0.003930
K_3014 X_NUC_29.L_CORE X_NUC_117.L_CORE 0.002214
K_3015 X_NUC_29.L_CORE X_NUC_118.L_CORE 0.002833
K_3016 X_NUC_29.L_CORE X_NUC_119.L_CORE 0.002658
K_3017 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_3018 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_3019 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.002639
K_3020 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.002641
K_3021 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.002656
K_3022 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.002622
K_3023 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.003630
K_3024 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.003574
K_3025 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.003608
K_3026 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.003584
K_3027 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.005135
K_3028 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.005231
K_3029 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.005196
K_3030 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.005119
K_3031 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.002387
K_3032 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.002377
K_3033 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.002391
K_3034 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.002366
K_3035 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.007003
K_3036 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.006823
K_3037 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.006798
K_3038 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.006829
K_3039 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.002869
K_3040 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.002883
K_3041 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.002885
K_3042 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.002850
K_3043 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.002694
K_3044 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.002669
K_3045 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.002684
K_3046 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.002663
K_3047 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.006281
K_3048 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.006367
K_3049 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.006219
K_3050 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.006193
K_3051 X_NUC_30.L_CORE X_NUC_65.L_CORE 0.002340
K_3052 X_NUC_30.L_CORE X_NUC_66.L_CORE 0.002338
K_3053 X_NUC_30.L_CORE X_NUC_67.L_CORE 0.002344
K_3054 X_NUC_30.L_CORE X_NUC_68.L_CORE 0.002320
K_3055 X_NUC_30.L_CORE X_NUC_69.L_CORE 0.003670
K_3056 X_NUC_30.L_CORE X_NUC_70.L_CORE 0.003623
K_3057 X_NUC_30.L_CORE X_NUC_71.L_CORE 0.003624
K_3058 X_NUC_30.L_CORE X_NUC_72.L_CORE 0.003611
K_3059 X_NUC_30.L_CORE X_NUC_73.L_CORE 0.003307
K_3060 X_NUC_30.L_CORE X_NUC_74.L_CORE 0.003330
K_3061 X_NUC_30.L_CORE X_NUC_75.L_CORE 0.003311
K_3062 X_NUC_30.L_CORE X_NUC_76.L_CORE 0.003278
K_3063 X_NUC_30.L_CORE X_NUC_77.L_CORE 0.002381
K_3064 X_NUC_30.L_CORE X_NUC_78.L_CORE 0.002368
K_3065 X_NUC_30.L_CORE X_NUC_79.L_CORE 0.002375
K_3066 X_NUC_30.L_CORE X_NUC_80.L_CORE 0.002355
K_3067 X_NUC_30.L_CORE X_NUC_81.L_CORE 0.004326
K_3068 X_NUC_30.L_CORE X_NUC_82.L_CORE 0.004309
K_3069 X_NUC_30.L_CORE X_NUC_83.L_CORE 0.004261
K_3070 X_NUC_30.L_CORE X_NUC_84.L_CORE 0.004252
K_3071 X_NUC_30.L_CORE X_NUC_85.L_CORE 0.002523
K_3072 X_NUC_30.L_CORE X_NUC_86.L_CORE 0.002526
K_3073 X_NUC_30.L_CORE X_NUC_87.L_CORE 0.002523
K_3074 X_NUC_30.L_CORE X_NUC_88.L_CORE 0.002500
K_3075 X_NUC_30.L_CORE X_NUC_89.L_CORE 0.002773
K_3076 X_NUC_30.L_CORE X_NUC_90.L_CORE 0.002755
K_3077 X_NUC_30.L_CORE X_NUC_91.L_CORE 0.002754
K_3078 X_NUC_30.L_CORE X_NUC_92.L_CORE 0.002737
K_3079 X_NUC_30.L_CORE X_NUC_93.L_CORE 0.003213
K_3080 X_NUC_30.L_CORE X_NUC_94.L_CORE 0.003218
K_3081 X_NUC_30.L_CORE X_NUC_95.L_CORE 0.003195
K_3082 X_NUC_30.L_CORE X_NUC_96.L_CORE 0.003174
K_3083 X_NUC_30.L_CORE X_NUC_97.L_CORE 0.002542
K_3084 X_NUC_30.L_CORE X_NUC_98.L_CORE 0.002536
K_3085 X_NUC_30.L_CORE X_NUC_99.L_CORE 0.002532
K_3086 X_NUC_30.L_CORE X_NUC_100.L_CORE 0.002513
K_3087 X_NUC_30.L_CORE X_NUC_101.L_CORE 0.003488
K_3088 X_NUC_30.L_CORE X_NUC_102.L_CORE 0.003427
K_3089 X_NUC_30.L_CORE X_NUC_103.L_CORE 0.006955
K_3090 X_NUC_30.L_CORE X_NUC_104.L_CORE 0.002526
K_3091 X_NUC_30.L_CORE X_NUC_105.L_CORE 0.005422
K_3092 X_NUC_30.L_CORE X_NUC_106.L_CORE 0.003457
K_3093 X_NUC_30.L_CORE X_NUC_107.L_CORE 0.002473
K_3094 X_NUC_30.L_CORE X_NUC_108.L_CORE 0.017493
K_3095 X_NUC_30.L_CORE X_NUC_109.L_CORE 0.002373
K_3096 X_NUC_30.L_CORE X_NUC_110.L_CORE 0.003174
K_3097 X_NUC_30.L_CORE X_NUC_111.L_CORE 0.004269
K_3098 X_NUC_30.L_CORE X_NUC_112.L_CORE 0.002166
K_3099 X_NUC_30.L_CORE X_NUC_113.L_CORE 0.004802
K_3100 X_NUC_30.L_CORE X_NUC_114.L_CORE 0.002566
K_3101 X_NUC_30.L_CORE X_NUC_115.L_CORE 0.002425
K_3102 X_NUC_30.L_CORE X_NUC_116.L_CORE 0.003913
K_3103 X_NUC_30.L_CORE X_NUC_117.L_CORE 0.002217
K_3104 X_NUC_30.L_CORE X_NUC_118.L_CORE 0.002851
K_3105 X_NUC_30.L_CORE X_NUC_119.L_CORE 0.002657
K_3106 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_3107 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.002625
K_3108 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.002627
K_3109 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.002641
K_3110 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.002608
K_3111 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.003595
K_3112 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.003539
K_3113 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.003574
K_3114 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.003549
K_3115 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.005167
K_3116 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.005264
K_3117 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.005231
K_3118 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.005151
K_3119 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.002373
K_3120 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.002363
K_3121 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.002377
K_3122 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.002352
K_3123 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.007026
K_3124 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.006840
K_3125 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.006823
K_3126 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.006850
K_3127 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.002867
K_3128 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.002881
K_3129 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.002883
K_3130 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.002848
K_3131 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.002679
K_3132 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.002654
K_3133 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.002669
K_3134 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.002648
K_3135 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.006431
K_3136 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.006520
K_3137 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.006367
K_3138 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.006336
K_3139 X_NUC_31.L_CORE X_NUC_65.L_CORE 0.002334
K_3140 X_NUC_31.L_CORE X_NUC_66.L_CORE 0.002331
K_3141 X_NUC_31.L_CORE X_NUC_67.L_CORE 0.002338
K_3142 X_NUC_31.L_CORE X_NUC_68.L_CORE 0.002314
K_3143 X_NUC_31.L_CORE X_NUC_69.L_CORE 0.003669
K_3144 X_NUC_31.L_CORE X_NUC_70.L_CORE 0.003620
K_3145 X_NUC_31.L_CORE X_NUC_71.L_CORE 0.003623
K_3146 X_NUC_31.L_CORE X_NUC_72.L_CORE 0.003610
K_3147 X_NUC_31.L_CORE X_NUC_73.L_CORE 0.003325
K_3148 X_NUC_31.L_CORE X_NUC_74.L_CORE 0.003349
K_3149 X_NUC_31.L_CORE X_NUC_75.L_CORE 0.003330
K_3150 X_NUC_31.L_CORE X_NUC_76.L_CORE 0.003297
K_3151 X_NUC_31.L_CORE X_NUC_77.L_CORE 0.002374
K_3152 X_NUC_31.L_CORE X_NUC_78.L_CORE 0.002362
K_3153 X_NUC_31.L_CORE X_NUC_79.L_CORE 0.002368
K_3154 X_NUC_31.L_CORE X_NUC_80.L_CORE 0.002349
K_3155 X_NUC_31.L_CORE X_NUC_81.L_CORE 0.004376
K_3156 X_NUC_31.L_CORE X_NUC_82.L_CORE 0.004358
K_3157 X_NUC_31.L_CORE X_NUC_83.L_CORE 0.004309
K_3158 X_NUC_31.L_CORE X_NUC_84.L_CORE 0.004299
K_3159 X_NUC_31.L_CORE X_NUC_85.L_CORE 0.002526
K_3160 X_NUC_31.L_CORE X_NUC_86.L_CORE 0.002528
K_3161 X_NUC_31.L_CORE X_NUC_87.L_CORE 0.002526
K_3162 X_NUC_31.L_CORE X_NUC_88.L_CORE 0.002502
K_3163 X_NUC_31.L_CORE X_NUC_89.L_CORE 0.002774
K_3164 X_NUC_31.L_CORE X_NUC_90.L_CORE 0.002755
K_3165 X_NUC_31.L_CORE X_NUC_91.L_CORE 0.002755
K_3166 X_NUC_31.L_CORE X_NUC_92.L_CORE 0.002738
K_3167 X_NUC_31.L_CORE X_NUC_93.L_CORE 0.003236
K_3168 X_NUC_31.L_CORE X_NUC_94.L_CORE 0.003240
K_3169 X_NUC_31.L_CORE X_NUC_95.L_CORE 0.003218
K_3170 X_NUC_31.L_CORE X_NUC_96.L_CORE 0.003196
K_3171 X_NUC_31.L_CORE X_NUC_97.L_CORE 0.002546
K_3172 X_NUC_31.L_CORE X_NUC_98.L_CORE 0.002540
K_3173 X_NUC_31.L_CORE X_NUC_99.L_CORE 0.002536
K_3174 X_NUC_31.L_CORE X_NUC_100.L_CORE 0.002517
K_3175 X_NUC_31.L_CORE X_NUC_101.L_CORE 0.003442
K_3176 X_NUC_31.L_CORE X_NUC_102.L_CORE 0.003375
K_3177 X_NUC_31.L_CORE X_NUC_103.L_CORE 0.006838
K_3178 X_NUC_31.L_CORE X_NUC_104.L_CORE 0.002504
K_3179 X_NUC_31.L_CORE X_NUC_105.L_CORE 0.005325
K_3180 X_NUC_31.L_CORE X_NUC_106.L_CORE 0.003446
K_3181 X_NUC_31.L_CORE X_NUC_107.L_CORE 0.002453
K_3182 X_NUC_31.L_CORE X_NUC_108.L_CORE 0.018998
K_3183 X_NUC_31.L_CORE X_NUC_109.L_CORE 0.002364
K_3184 X_NUC_31.L_CORE X_NUC_110.L_CORE 0.003154
K_3185 X_NUC_31.L_CORE X_NUC_111.L_CORE 0.004312
K_3186 X_NUC_31.L_CORE X_NUC_112.L_CORE 0.002157
K_3187 X_NUC_31.L_CORE X_NUC_113.L_CORE 0.004843
K_3188 X_NUC_31.L_CORE X_NUC_114.L_CORE 0.002570
K_3189 X_NUC_31.L_CORE X_NUC_115.L_CORE 0.002418
K_3190 X_NUC_31.L_CORE X_NUC_116.L_CORE 0.003967
K_3191 X_NUC_31.L_CORE X_NUC_117.L_CORE 0.002216
K_3192 X_NUC_31.L_CORE X_NUC_118.L_CORE 0.002860
K_3193 X_NUC_31.L_CORE X_NUC_119.L_CORE 0.002669
K_3194 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.002658
K_3195 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.002660
K_3196 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.002675
K_3197 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.002641
K_3198 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.003619
K_3199 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.003563
K_3200 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.003597
K_3201 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.003574
K_3202 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.005247
K_3203 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.005348
K_3204 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.005312
K_3205 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.005231
K_3206 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.002398
K_3207 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.002387
K_3208 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.002402
K_3209 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.002377
K_3210 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.006992
K_3211 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.006809
K_3212 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.006788
K_3213 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.006823
K_3214 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.002902
K_3215 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.002917
K_3216 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.002919
K_3217 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.002883
K_3218 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.002700
K_3219 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.002675
K_3220 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.002690
K_3221 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.002669
K_3222 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.006460
K_3223 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.006551
K_3224 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.006393
K_3225 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.006367
K_3226 X_NUC_32.L_CORE X_NUC_65.L_CORE 0.002358
K_3227 X_NUC_32.L_CORE X_NUC_66.L_CORE 0.002356
K_3228 X_NUC_32.L_CORE X_NUC_67.L_CORE 0.002362
K_3229 X_NUC_32.L_CORE X_NUC_68.L_CORE 0.002338
K_3230 X_NUC_32.L_CORE X_NUC_69.L_CORE 0.003682
K_3231 X_NUC_32.L_CORE X_NUC_70.L_CORE 0.003633
K_3232 X_NUC_32.L_CORE X_NUC_71.L_CORE 0.003635
K_3233 X_NUC_32.L_CORE X_NUC_72.L_CORE 0.003623
K_3234 X_NUC_32.L_CORE X_NUC_73.L_CORE 0.003360
K_3235 X_NUC_32.L_CORE X_NUC_74.L_CORE 0.003384
K_3236 X_NUC_32.L_CORE X_NUC_75.L_CORE 0.003364
K_3237 X_NUC_32.L_CORE X_NUC_76.L_CORE 0.003330
K_3238 X_NUC_32.L_CORE X_NUC_77.L_CORE 0.002394
K_3239 X_NUC_32.L_CORE X_NUC_78.L_CORE 0.002382
K_3240 X_NUC_32.L_CORE X_NUC_79.L_CORE 0.002388
K_3241 X_NUC_32.L_CORE X_NUC_80.L_CORE 0.002368
K_3242 X_NUC_32.L_CORE X_NUC_81.L_CORE 0.004385
K_3243 X_NUC_32.L_CORE X_NUC_82.L_CORE 0.004367
K_3244 X_NUC_32.L_CORE X_NUC_83.L_CORE 0.004317
K_3245 X_NUC_32.L_CORE X_NUC_84.L_CORE 0.004309
K_3246 X_NUC_32.L_CORE X_NUC_85.L_CORE 0.002550
K_3247 X_NUC_32.L_CORE X_NUC_86.L_CORE 0.002553
K_3248 X_NUC_32.L_CORE X_NUC_87.L_CORE 0.002550
K_3249 X_NUC_32.L_CORE X_NUC_88.L_CORE 0.002526
K_3250 X_NUC_32.L_CORE X_NUC_89.L_CORE 0.002791
K_3251 X_NUC_32.L_CORE X_NUC_90.L_CORE 0.002772
K_3252 X_NUC_32.L_CORE X_NUC_91.L_CORE 0.002771
K_3253 X_NUC_32.L_CORE X_NUC_92.L_CORE 0.002755
K_3254 X_NUC_32.L_CORE X_NUC_93.L_CORE 0.003258
K_3255 X_NUC_32.L_CORE X_NUC_94.L_CORE 0.003263
K_3256 X_NUC_32.L_CORE X_NUC_95.L_CORE 0.003239
K_3257 X_NUC_32.L_CORE X_NUC_96.L_CORE 0.003218
K_3258 X_NUC_32.L_CORE X_NUC_97.L_CORE 0.002566
K_3259 X_NUC_32.L_CORE X_NUC_98.L_CORE 0.002560
K_3260 X_NUC_32.L_CORE X_NUC_99.L_CORE 0.002556
K_3261 X_NUC_32.L_CORE X_NUC_100.L_CORE 0.002536
K_3262 X_NUC_32.L_CORE X_NUC_101.L_CORE 0.003492
K_3263 X_NUC_32.L_CORE X_NUC_102.L_CORE 0.003409
K_3264 X_NUC_32.L_CORE X_NUC_103.L_CORE 0.006968
K_3265 X_NUC_32.L_CORE X_NUC_104.L_CORE 0.002534
K_3266 X_NUC_32.L_CORE X_NUC_105.L_CORE 0.005338
K_3267 X_NUC_32.L_CORE X_NUC_106.L_CORE 0.003495
K_3268 X_NUC_32.L_CORE X_NUC_107.L_CORE 0.002475
K_3269 X_NUC_32.L_CORE X_NUC_108.L_CORE 0.017770
K_3270 X_NUC_32.L_CORE X_NUC_109.L_CORE 0.002391
K_3271 X_NUC_32.L_CORE X_NUC_110.L_CORE 0.003168
K_3272 X_NUC_32.L_CORE X_NUC_111.L_CORE 0.004354
K_3273 X_NUC_32.L_CORE X_NUC_112.L_CORE 0.002177
K_3274 X_NUC_32.L_CORE X_NUC_113.L_CORE 0.004823
K_3275 X_NUC_32.L_CORE X_NUC_114.L_CORE 0.002596
K_3276 X_NUC_32.L_CORE X_NUC_115.L_CORE 0.002434
K_3277 X_NUC_32.L_CORE X_NUC_116.L_CORE 0.003978
K_3278 X_NUC_32.L_CORE X_NUC_117.L_CORE 0.002235
K_3279 X_NUC_32.L_CORE X_NUC_118.L_CORE 0.002871
K_3280 X_NUC_32.L_CORE X_NUC_119.L_CORE 0.002687
K_3281 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_3282 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_3283 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_3284 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.002567
K_3285 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.002544
K_3286 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.002544
K_3287 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.002565
K_3288 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.003488
K_3289 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.003512
K_3290 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.003468
K_3291 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.003522
K_3292 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.005137
K_3293 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.005018
K_3294 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.005054
K_3295 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.005051
K_3296 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.002336
K_3297 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.002328
K_3298 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.002317
K_3299 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.002341
K_3300 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.006791
K_3301 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.006937
K_3302 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.006716
K_3303 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.006820
K_3304 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.002856
K_3305 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.002822
K_3306 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.002822
K_3307 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.002839
K_3308 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.002652
K_3309 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.002655
K_3310 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.002630
K_3311 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.002661
K_3312 X_NUC_33.L_CORE X_NUC_65.L_CORE 0.006379
K_3313 X_NUC_33.L_CORE X_NUC_66.L_CORE 0.006292
K_3314 X_NUC_33.L_CORE X_NUC_67.L_CORE 0.006227
K_3315 X_NUC_33.L_CORE X_NUC_68.L_CORE 0.006206
K_3316 X_NUC_33.L_CORE X_NUC_69.L_CORE 0.002338
K_3317 X_NUC_33.L_CORE X_NUC_70.L_CORE 0.002323
K_3318 X_NUC_33.L_CORE X_NUC_71.L_CORE 0.002314
K_3319 X_NUC_33.L_CORE X_NUC_72.L_CORE 0.002334
K_3320 X_NUC_33.L_CORE X_NUC_73.L_CORE 0.003629
K_3321 X_NUC_33.L_CORE X_NUC_74.L_CORE 0.003652
K_3322 X_NUC_33.L_CORE X_NUC_75.L_CORE 0.003591
K_3323 X_NUC_33.L_CORE X_NUC_76.L_CORE 0.003633
K_3324 X_NUC_33.L_CORE X_NUC_77.L_CORE 0.003343
K_3325 X_NUC_33.L_CORE X_NUC_78.L_CORE 0.003303
K_3326 X_NUC_33.L_CORE X_NUC_79.L_CORE 0.003293
K_3327 X_NUC_33.L_CORE X_NUC_80.L_CORE 0.003305
K_3328 X_NUC_33.L_CORE X_NUC_81.L_CORE 0.002398
K_3329 X_NUC_33.L_CORE X_NUC_82.L_CORE 0.002393
K_3330 X_NUC_33.L_CORE X_NUC_83.L_CORE 0.002374
K_3331 X_NUC_33.L_CORE X_NUC_84.L_CORE 0.002398
K_3332 X_NUC_33.L_CORE X_NUC_85.L_CORE 0.004235
K_3333 X_NUC_33.L_CORE X_NUC_86.L_CORE 0.004236
K_3334 X_NUC_33.L_CORE X_NUC_87.L_CORE 0.004166
K_3335 X_NUC_33.L_CORE X_NUC_88.L_CORE 0.004190
K_3336 X_NUC_33.L_CORE X_NUC_89.L_CORE 0.002582
K_3337 X_NUC_33.L_CORE X_NUC_90.L_CORE 0.002564
K_3338 X_NUC_33.L_CORE X_NUC_91.L_CORE 0.002550
K_3339 X_NUC_33.L_CORE X_NUC_92.L_CORE 0.002567
K_3340 X_NUC_33.L_CORE X_NUC_93.L_CORE 0.002807
K_3341 X_NUC_33.L_CORE X_NUC_94.L_CORE 0.002806
K_3342 X_NUC_33.L_CORE X_NUC_95.L_CORE 0.002775
K_3343 X_NUC_33.L_CORE X_NUC_96.L_CORE 0.002800
K_3344 X_NUC_33.L_CORE X_NUC_97.L_CORE 0.003091
K_3345 X_NUC_33.L_CORE X_NUC_98.L_CORE 0.003076
K_3346 X_NUC_33.L_CORE X_NUC_99.L_CORE 0.003047
K_3347 X_NUC_33.L_CORE X_NUC_100.L_CORE 0.003065
K_3348 X_NUC_33.L_CORE X_NUC_101.L_CORE 0.004711
K_3349 X_NUC_33.L_CORE X_NUC_102.L_CORE 0.003072
K_3350 X_NUC_33.L_CORE X_NUC_103.L_CORE 0.003147
K_3351 X_NUC_33.L_CORE X_NUC_104.L_CORE 0.006994
K_3352 X_NUC_33.L_CORE X_NUC_105.L_CORE 0.002374
K_3353 X_NUC_33.L_CORE X_NUC_106.L_CORE 0.005185
K_3354 X_NUC_33.L_CORE X_NUC_107.L_CORE 0.003315
K_3355 X_NUC_33.L_CORE X_NUC_108.L_CORE 0.002386
K_3356 X_NUC_33.L_CORE X_NUC_109.L_CORE 0.016615
K_3357 X_NUC_33.L_CORE X_NUC_110.L_CORE 0.002317
K_3358 X_NUC_33.L_CORE X_NUC_111.L_CORE 0.003110
K_3359 X_NUC_33.L_CORE X_NUC_112.L_CORE 0.004197
K_3360 X_NUC_33.L_CORE X_NUC_113.L_CORE 0.002147
K_3361 X_NUC_33.L_CORE X_NUC_114.L_CORE 0.004697
K_3362 X_NUC_33.L_CORE X_NUC_115.L_CORE 0.002565
K_3363 X_NUC_33.L_CORE X_NUC_116.L_CORE 0.002439
K_3364 X_NUC_33.L_CORE X_NUC_117.L_CORE 0.003761
K_3365 X_NUC_33.L_CORE X_NUC_118.L_CORE 0.002288
K_3366 X_NUC_33.L_CORE X_NUC_119.L_CORE 0.002784
K_3367 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_3368 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_3369 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.002590
K_3370 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.002567
K_3371 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.002566
K_3372 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.002588
K_3373 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.003465
K_3374 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.003488
K_3375 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.003445
K_3376 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.003498
K_3377 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.005262
K_3378 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.005137
K_3379 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.005175
K_3380 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.005171
K_3381 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.002345
K_3382 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.002336
K_3383 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.002326
K_3384 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.002350
K_3385 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.006648
K_3386 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.006791
K_3387 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.006580
K_3388 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.006678
K_3389 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.002889
K_3390 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.002856
K_3391 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.002855
K_3392 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.002872
K_3393 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.002648
K_3394 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.002652
K_3395 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.002626
K_3396 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.002658
K_3397 X_NUC_34.L_CORE X_NUC_65.L_CORE 0.006465
K_3398 X_NUC_34.L_CORE X_NUC_66.L_CORE 0.006379
K_3399 X_NUC_34.L_CORE X_NUC_67.L_CORE 0.006310
K_3400 X_NUC_34.L_CORE X_NUC_68.L_CORE 0.006287
K_3401 X_NUC_34.L_CORE X_NUC_69.L_CORE 0.002352
K_3402 X_NUC_34.L_CORE X_NUC_70.L_CORE 0.002338
K_3403 X_NUC_34.L_CORE X_NUC_71.L_CORE 0.002328
K_3404 X_NUC_34.L_CORE X_NUC_72.L_CORE 0.002348
K_3405 X_NUC_34.L_CORE X_NUC_73.L_CORE 0.003605
K_3406 X_NUC_34.L_CORE X_NUC_74.L_CORE 0.003629
K_3407 X_NUC_34.L_CORE X_NUC_75.L_CORE 0.003568
K_3408 X_NUC_34.L_CORE X_NUC_76.L_CORE 0.003610
K_3409 X_NUC_34.L_CORE X_NUC_77.L_CORE 0.003383
K_3410 X_NUC_34.L_CORE X_NUC_78.L_CORE 0.003343
K_3411 X_NUC_34.L_CORE X_NUC_79.L_CORE 0.003332
K_3412 X_NUC_34.L_CORE X_NUC_80.L_CORE 0.003344
K_3413 X_NUC_34.L_CORE X_NUC_81.L_CORE 0.002403
K_3414 X_NUC_34.L_CORE X_NUC_82.L_CORE 0.002398
K_3415 X_NUC_34.L_CORE X_NUC_83.L_CORE 0.002379
K_3416 X_NUC_34.L_CORE X_NUC_84.L_CORE 0.002402
K_3417 X_NUC_34.L_CORE X_NUC_85.L_CORE 0.004233
K_3418 X_NUC_34.L_CORE X_NUC_86.L_CORE 0.004235
K_3419 X_NUC_34.L_CORE X_NUC_87.L_CORE 0.004165
K_3420 X_NUC_34.L_CORE X_NUC_88.L_CORE 0.004188
K_3421 X_NUC_34.L_CORE X_NUC_89.L_CORE 0.002600
K_3422 X_NUC_34.L_CORE X_NUC_90.L_CORE 0.002582
K_3423 X_NUC_34.L_CORE X_NUC_91.L_CORE 0.002568
K_3424 X_NUC_34.L_CORE X_NUC_92.L_CORE 0.002585
K_3425 X_NUC_34.L_CORE X_NUC_93.L_CORE 0.002806
K_3426 X_NUC_34.L_CORE X_NUC_94.L_CORE 0.002807
K_3427 X_NUC_34.L_CORE X_NUC_95.L_CORE 0.002774
K_3428 X_NUC_34.L_CORE X_NUC_96.L_CORE 0.002800
K_3429 X_NUC_34.L_CORE X_NUC_97.L_CORE 0.003105
K_3430 X_NUC_34.L_CORE X_NUC_98.L_CORE 0.003091
K_3431 X_NUC_34.L_CORE X_NUC_99.L_CORE 0.003061
K_3432 X_NUC_34.L_CORE X_NUC_100.L_CORE 0.003079
K_3433 X_NUC_34.L_CORE X_NUC_101.L_CORE 0.004727
K_3434 X_NUC_34.L_CORE X_NUC_102.L_CORE 0.003103
K_3435 X_NUC_34.L_CORE X_NUC_103.L_CORE 0.003141
K_3436 X_NUC_34.L_CORE X_NUC_104.L_CORE 0.007186
K_3437 X_NUC_34.L_CORE X_NUC_105.L_CORE 0.002388
K_3438 X_NUC_34.L_CORE X_NUC_106.L_CORE 0.005098
K_3439 X_NUC_34.L_CORE X_NUC_107.L_CORE 0.003367
K_3440 X_NUC_34.L_CORE X_NUC_108.L_CORE 0.002387
K_3441 X_NUC_34.L_CORE X_NUC_109.L_CORE 0.016249
K_3442 X_NUC_34.L_CORE X_NUC_110.L_CORE 0.002336
K_3443 X_NUC_34.L_CORE X_NUC_111.L_CORE 0.003089
K_3444 X_NUC_34.L_CORE X_NUC_112.L_CORE 0.004269
K_3445 X_NUC_34.L_CORE X_NUC_113.L_CORE 0.002154
K_3446 X_NUC_34.L_CORE X_NUC_114.L_CORE 0.004647
K_3447 X_NUC_34.L_CORE X_NUC_115.L_CORE 0.002590
K_3448 X_NUC_34.L_CORE X_NUC_116.L_CORE 0.002437
K_3449 X_NUC_34.L_CORE X_NUC_117.L_CORE 0.003780
K_3450 X_NUC_34.L_CORE X_NUC_118.L_CORE 0.002299
K_3451 X_NUC_34.L_CORE X_NUC_119.L_CORE 0.002785
K_3452 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_3453 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.002590
K_3454 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.002567
K_3455 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.002567
K_3456 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.002589
K_3457 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.003508
K_3458 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.003532
K_3459 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.003488
K_3460 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.003542
K_3461 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.005221
K_3462 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.005097
K_3463 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.005137
K_3464 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.005132
K_3465 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.002356
K_3466 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.002347
K_3467 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.002336
K_3468 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.002361
K_3469 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.006862
K_3470 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.007016
K_3471 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.006791
K_3472 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.006896
K_3473 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.002889
K_3474 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.002855
K_3475 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.002856
K_3476 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.002872
K_3477 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.002673
K_3478 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.002677
K_3479 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.002652
K_3480 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.002684
K_3481 X_NUC_35.L_CORE X_NUC_65.L_CORE 0.006537
K_3482 X_NUC_35.L_CORE X_NUC_66.L_CORE 0.006446
K_3483 X_NUC_35.L_CORE X_NUC_67.L_CORE 0.006379
K_3484 X_NUC_35.L_CORE X_NUC_68.L_CORE 0.006354
K_3485 X_NUC_35.L_CORE X_NUC_69.L_CORE 0.002362
K_3486 X_NUC_35.L_CORE X_NUC_70.L_CORE 0.002347
K_3487 X_NUC_35.L_CORE X_NUC_71.L_CORE 0.002338
K_3488 X_NUC_35.L_CORE X_NUC_72.L_CORE 0.002358
K_3489 X_NUC_35.L_CORE X_NUC_73.L_CORE 0.003667
K_3490 X_NUC_35.L_CORE X_NUC_74.L_CORE 0.003691
K_3491 X_NUC_35.L_CORE X_NUC_75.L_CORE 0.003629
K_3492 X_NUC_35.L_CORE X_NUC_76.L_CORE 0.003672
K_3493 X_NUC_35.L_CORE X_NUC_77.L_CORE 0.003393
K_3494 X_NUC_35.L_CORE X_NUC_78.L_CORE 0.003353
K_3495 X_NUC_35.L_CORE X_NUC_79.L_CORE 0.003343
K_3496 X_NUC_35.L_CORE X_NUC_80.L_CORE 0.003354
K_3497 X_NUC_35.L_CORE X_NUC_81.L_CORE 0.002422
K_3498 X_NUC_35.L_CORE X_NUC_82.L_CORE 0.002417
K_3499 X_NUC_35.L_CORE X_NUC_83.L_CORE 0.002398
K_3500 X_NUC_35.L_CORE X_NUC_84.L_CORE 0.002422
K_3501 X_NUC_35.L_CORE X_NUC_85.L_CORE 0.004306
K_3502 X_NUC_35.L_CORE X_NUC_86.L_CORE 0.004308
K_3503 X_NUC_35.L_CORE X_NUC_87.L_CORE 0.004235
K_3504 X_NUC_35.L_CORE X_NUC_88.L_CORE 0.004259
K_3505 X_NUC_35.L_CORE X_NUC_89.L_CORE 0.002614
K_3506 X_NUC_35.L_CORE X_NUC_90.L_CORE 0.002596
K_3507 X_NUC_35.L_CORE X_NUC_91.L_CORE 0.002582
K_3508 X_NUC_35.L_CORE X_NUC_92.L_CORE 0.002599
K_3509 X_NUC_35.L_CORE X_NUC_93.L_CORE 0.002840
K_3510 X_NUC_35.L_CORE X_NUC_94.L_CORE 0.002840
K_3511 X_NUC_35.L_CORE X_NUC_95.L_CORE 0.002807
K_3512 X_NUC_35.L_CORE X_NUC_96.L_CORE 0.002833
K_3513 X_NUC_35.L_CORE X_NUC_97.L_CORE 0.003136
K_3514 X_NUC_35.L_CORE X_NUC_98.L_CORE 0.003121
K_3515 X_NUC_35.L_CORE X_NUC_99.L_CORE 0.003091
K_3516 X_NUC_35.L_CORE X_NUC_100.L_CORE 0.003109
K_3517 X_NUC_35.L_CORE X_NUC_101.L_CORE 0.004693
K_3518 X_NUC_35.L_CORE X_NUC_102.L_CORE 0.003087
K_3519 X_NUC_35.L_CORE X_NUC_103.L_CORE 0.003154
K_3520 X_NUC_35.L_CORE X_NUC_104.L_CORE 0.006982
K_3521 X_NUC_35.L_CORE X_NUC_105.L_CORE 0.002390
K_3522 X_NUC_35.L_CORE X_NUC_106.L_CORE 0.005170
K_3523 X_NUC_35.L_CORE X_NUC_107.L_CORE 0.003346
K_3524 X_NUC_35.L_CORE X_NUC_108.L_CORE 0.002401
K_3525 X_NUC_35.L_CORE X_NUC_109.L_CORE 0.016699
K_3526 X_NUC_35.L_CORE X_NUC_110.L_CORE 0.002338
K_3527 X_NUC_35.L_CORE X_NUC_111.L_CORE 0.003129
K_3528 X_NUC_35.L_CORE X_NUC_112.L_CORE 0.004259
K_3529 X_NUC_35.L_CORE X_NUC_113.L_CORE 0.002166
K_3530 X_NUC_35.L_CORE X_NUC_114.L_CORE 0.004750
K_3531 X_NUC_35.L_CORE X_NUC_115.L_CORE 0.002595
K_3532 X_NUC_35.L_CORE X_NUC_116.L_CORE 0.002461
K_3533 X_NUC_35.L_CORE X_NUC_117.L_CORE 0.003820
K_3534 X_NUC_35.L_CORE X_NUC_118.L_CORE 0.002313
K_3535 X_NUC_35.L_CORE X_NUC_119.L_CORE 0.002817
K_3536 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.002568
K_3537 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.002546
K_3538 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.002545
K_3539 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.002567
K_3540 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.003455
K_3541 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.003478
K_3542 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.003436
K_3543 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.003488
K_3544 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.005225
K_3545 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.005101
K_3546 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.005139
K_3547 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.005137
K_3548 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.002331
K_3549 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.002323
K_3550 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.002312
K_3551 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.002336
K_3552 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.006756
K_3553 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.006902
K_3554 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.006685
K_3555 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.006791
K_3556 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.002872
K_3557 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.002839
K_3558 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.002839
K_3559 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.002856
K_3560 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.002641
K_3561 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.002645
K_3562 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.002620
K_3563 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.002652
K_3564 X_NUC_36.L_CORE X_NUC_65.L_CORE 0.006562
K_3565 X_NUC_36.L_CORE X_NUC_66.L_CORE 0.006470
K_3566 X_NUC_36.L_CORE X_NUC_67.L_CORE 0.006400
K_3567 X_NUC_36.L_CORE X_NUC_68.L_CORE 0.006379
K_3568 X_NUC_36.L_CORE X_NUC_69.L_CORE 0.002342
K_3569 X_NUC_36.L_CORE X_NUC_70.L_CORE 0.002327
K_3570 X_NUC_36.L_CORE X_NUC_71.L_CORE 0.002318
K_3571 X_NUC_36.L_CORE X_NUC_72.L_CORE 0.002338
K_3572 X_NUC_36.L_CORE X_NUC_73.L_CORE 0.003623
K_3573 X_NUC_36.L_CORE X_NUC_74.L_CORE 0.003647
K_3574 X_NUC_36.L_CORE X_NUC_75.L_CORE 0.003586
K_3575 X_NUC_36.L_CORE X_NUC_76.L_CORE 0.003629
K_3576 X_NUC_36.L_CORE X_NUC_77.L_CORE 0.003381
K_3577 X_NUC_36.L_CORE X_NUC_78.L_CORE 0.003341
K_3578 X_NUC_36.L_CORE X_NUC_79.L_CORE 0.003331
K_3579 X_NUC_36.L_CORE X_NUC_80.L_CORE 0.003343
K_3580 X_NUC_36.L_CORE X_NUC_81.L_CORE 0.002398
K_3581 X_NUC_36.L_CORE X_NUC_82.L_CORE 0.002394
K_3582 X_NUC_36.L_CORE X_NUC_83.L_CORE 0.002375
K_3583 X_NUC_36.L_CORE X_NUC_84.L_CORE 0.002398
K_3584 X_NUC_36.L_CORE X_NUC_85.L_CORE 0.004280
K_3585 X_NUC_36.L_CORE X_NUC_86.L_CORE 0.004282
K_3586 X_NUC_36.L_CORE X_NUC_87.L_CORE 0.004210
K_3587 X_NUC_36.L_CORE X_NUC_88.L_CORE 0.004235
K_3588 X_NUC_36.L_CORE X_NUC_89.L_CORE 0.002596
K_3589 X_NUC_36.L_CORE X_NUC_90.L_CORE 0.002578
K_3590 X_NUC_36.L_CORE X_NUC_91.L_CORE 0.002564
K_3591 X_NUC_36.L_CORE X_NUC_92.L_CORE 0.002582
K_3592 X_NUC_36.L_CORE X_NUC_93.L_CORE 0.002813
K_3593 X_NUC_36.L_CORE X_NUC_94.L_CORE 0.002813
K_3594 X_NUC_36.L_CORE X_NUC_95.L_CORE 0.002781
K_3595 X_NUC_36.L_CORE X_NUC_96.L_CORE 0.002807
K_3596 X_NUC_36.L_CORE X_NUC_97.L_CORE 0.003117
K_3597 X_NUC_36.L_CORE X_NUC_98.L_CORE 0.003102
K_3598 X_NUC_36.L_CORE X_NUC_99.L_CORE 0.003073
K_3599 X_NUC_36.L_CORE X_NUC_100.L_CORE 0.003091
K_3600 X_NUC_36.L_CORE X_NUC_101.L_CORE 0.004629
K_3601 X_NUC_36.L_CORE X_NUC_102.L_CORE 0.003060
K_3602 X_NUC_36.L_CORE X_NUC_103.L_CORE 0.003111
K_3603 X_NUC_36.L_CORE X_NUC_104.L_CORE 0.006988
K_3604 X_NUC_36.L_CORE X_NUC_105.L_CORE 0.002367
K_3605 X_NUC_36.L_CORE X_NUC_106.L_CORE 0.005081
K_3606 X_NUC_36.L_CORE X_NUC_107.L_CORE 0.003334
K_3607 X_NUC_36.L_CORE X_NUC_108.L_CORE 0.002373
K_3608 X_NUC_36.L_CORE X_NUC_109.L_CORE 0.017591
K_3609 X_NUC_36.L_CORE X_NUC_110.L_CORE 0.002321
K_3610 X_NUC_36.L_CORE X_NUC_111.L_CORE 0.003090
K_3611 X_NUC_36.L_CORE X_NUC_112.L_CORE 0.004270
K_3612 X_NUC_36.L_CORE X_NUC_113.L_CORE 0.002146
K_3613 X_NUC_36.L_CORE X_NUC_114.L_CORE 0.004717
K_3614 X_NUC_36.L_CORE X_NUC_115.L_CORE 0.002583
K_3615 X_NUC_36.L_CORE X_NUC_116.L_CORE 0.002437
K_3616 X_NUC_36.L_CORE X_NUC_117.L_CORE 0.003814
K_3617 X_NUC_36.L_CORE X_NUC_118.L_CORE 0.002297
K_3618 X_NUC_36.L_CORE X_NUC_119.L_CORE 0.002798
K_3619 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_3620 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_3621 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_3622 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.002515
K_3623 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.002546
K_3624 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.002529
K_3625 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.002529
K_3626 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.003431
K_3627 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.003449
K_3628 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.003462
K_3629 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.003409
K_3630 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.005077
K_3631 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.005165
K_3632 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.005056
K_3633 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.005138
K_3634 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.002313
K_3635 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.002336
K_3636 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.002327
K_3637 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.002315
K_3638 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.006775
K_3639 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.006747
K_3640 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.006756
K_3641 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.006587
K_3642 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.002846
K_3643 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.002883
K_3644 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.002851
K_3645 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.002861
K_3646 X_NUC_37.L_CORE X_NUC_65.L_CORE 0.002652
K_3647 X_NUC_37.L_CORE X_NUC_66.L_CORE 0.002671
K_3648 X_NUC_37.L_CORE X_NUC_67.L_CORE 0.002666
K_3649 X_NUC_37.L_CORE X_NUC_68.L_CORE 0.002640
K_3650 X_NUC_37.L_CORE X_NUC_69.L_CORE 0.006367
K_3651 X_NUC_37.L_CORE X_NUC_70.L_CORE 0.006425
K_3652 X_NUC_37.L_CORE X_NUC_71.L_CORE 0.006242
K_3653 X_NUC_37.L_CORE X_NUC_72.L_CORE 0.006306
K_3654 X_NUC_37.L_CORE X_NUC_73.L_CORE 0.002355
K_3655 X_NUC_37.L_CORE X_NUC_74.L_CORE 0.002380
K_3656 X_NUC_37.L_CORE X_NUC_75.L_CORE 0.002363
K_3657 X_NUC_37.L_CORE X_NUC_76.L_CORE 0.002358
K_3658 X_NUC_37.L_CORE X_NUC_77.L_CORE 0.003647
K_3659 X_NUC_37.L_CORE X_NUC_78.L_CORE 0.003660
K_3660 X_NUC_37.L_CORE X_NUC_79.L_CORE 0.003648
K_3661 X_NUC_37.L_CORE X_NUC_80.L_CORE 0.003602
K_3662 X_NUC_37.L_CORE X_NUC_81.L_CORE 0.003368
K_3663 X_NUC_37.L_CORE X_NUC_82.L_CORE 0.003406
K_3664 X_NUC_37.L_CORE X_NUC_83.L_CORE 0.003354
K_3665 X_NUC_37.L_CORE X_NUC_84.L_CORE 0.003370
K_3666 X_NUC_37.L_CORE X_NUC_85.L_CORE 0.002452
K_3667 X_NUC_37.L_CORE X_NUC_86.L_CORE 0.002472
K_3668 X_NUC_37.L_CORE X_NUC_87.L_CORE 0.002458
K_3669 X_NUC_37.L_CORE X_NUC_88.L_CORE 0.002444
K_3670 X_NUC_37.L_CORE X_NUC_89.L_CORE 0.004115
K_3671 X_NUC_37.L_CORE X_NUC_90.L_CORE 0.004137
K_3672 X_NUC_37.L_CORE X_NUC_91.L_CORE 0.004082
K_3673 X_NUC_37.L_CORE X_NUC_92.L_CORE 0.004063
K_3674 X_NUC_37.L_CORE X_NUC_93.L_CORE 0.002673
K_3675 X_NUC_37.L_CORE X_NUC_94.L_CORE 0.002699
K_3676 X_NUC_37.L_CORE X_NUC_95.L_CORE 0.002671
K_3677 X_NUC_37.L_CORE X_NUC_96.L_CORE 0.002669
K_3678 X_NUC_37.L_CORE X_NUC_97.L_CORE 0.002888
K_3679 X_NUC_37.L_CORE X_NUC_98.L_CORE 0.002908
K_3680 X_NUC_37.L_CORE X_NUC_99.L_CORE 0.002885
K_3681 X_NUC_37.L_CORE X_NUC_100.L_CORE 0.002869
K_3682 X_NUC_37.L_CORE X_NUC_101.L_CORE 0.002966
K_3683 X_NUC_37.L_CORE X_NUC_102.L_CORE 0.005488
K_3684 X_NUC_37.L_CORE X_NUC_103.L_CORE 0.002879
K_3685 X_NUC_37.L_CORE X_NUC_104.L_CORE 0.002980
K_3686 X_NUC_37.L_CORE X_NUC_105.L_CORE 0.007165
K_3687 X_NUC_37.L_CORE X_NUC_106.L_CORE 0.002296
K_3688 X_NUC_37.L_CORE X_NUC_107.L_CORE 0.004986
K_3689 X_NUC_37.L_CORE X_NUC_108.L_CORE 0.003273
K_3690 X_NUC_37.L_CORE X_NUC_109.L_CORE 0.002345
K_3691 X_NUC_37.L_CORE X_NUC_110.L_CORE 0.014997
K_3692 X_NUC_37.L_CORE X_NUC_111.L_CORE 0.002313
K_3693 X_NUC_37.L_CORE X_NUC_112.L_CORE 0.003079
K_3694 X_NUC_37.L_CORE X_NUC_113.L_CORE 0.004209
K_3695 X_NUC_37.L_CORE X_NUC_114.L_CORE 0.002170
K_3696 X_NUC_37.L_CORE X_NUC_115.L_CORE 0.004560
K_3697 X_NUC_37.L_CORE X_NUC_116.L_CORE 0.002619
K_3698 X_NUC_37.L_CORE X_NUC_117.L_CORE 0.002495
K_3699 X_NUC_37.L_CORE X_NUC_118.L_CORE 0.003577
K_3700 X_NUC_37.L_CORE X_NUC_119.L_CORE 0.002467
K_3701 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_3702 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_3703 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.002485
K_3704 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.002515
K_3705 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.002499
K_3706 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.002499
K_3707 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.003413
K_3708 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.003431
K_3709 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.003443
K_3710 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.003391
K_3711 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.004990
K_3712 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.005077
K_3713 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.004971
K_3714 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.005049
K_3715 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.002291
K_3716 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.002313
K_3717 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.002305
K_3718 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.002293
K_3719 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.006797
K_3720 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.006775
K_3721 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.006780
K_3722 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.006610
K_3723 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.002811
K_3724 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.002846
K_3725 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.002816
K_3726 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.002825
K_3727 X_NUC_38.L_CORE X_NUC_65.L_CORE 0.002633
K_3728 X_NUC_38.L_CORE X_NUC_66.L_CORE 0.002652
K_3729 X_NUC_38.L_CORE X_NUC_67.L_CORE 0.002647
K_3730 X_NUC_38.L_CORE X_NUC_68.L_CORE 0.002622
K_3731 X_NUC_38.L_CORE X_NUC_69.L_CORE 0.006305
K_3732 X_NUC_38.L_CORE X_NUC_70.L_CORE 0.006367
K_3733 X_NUC_38.L_CORE X_NUC_71.L_CORE 0.006186
K_3734 X_NUC_38.L_CORE X_NUC_72.L_CORE 0.006249
K_3735 X_NUC_38.L_CORE X_NUC_73.L_CORE 0.002331
K_3736 X_NUC_38.L_CORE X_NUC_74.L_CORE 0.002355
K_3737 X_NUC_38.L_CORE X_NUC_75.L_CORE 0.002339
K_3738 X_NUC_38.L_CORE X_NUC_76.L_CORE 0.002334
K_3739 X_NUC_38.L_CORE X_NUC_77.L_CORE 0.003632
K_3740 X_NUC_38.L_CORE X_NUC_78.L_CORE 0.003647
K_3741 X_NUC_38.L_CORE X_NUC_79.L_CORE 0.003634
K_3742 X_NUC_38.L_CORE X_NUC_80.L_CORE 0.003588
K_3743 X_NUC_38.L_CORE X_NUC_81.L_CORE 0.003329
K_3744 X_NUC_38.L_CORE X_NUC_82.L_CORE 0.003368
K_3745 X_NUC_38.L_CORE X_NUC_83.L_CORE 0.003316
K_3746 X_NUC_38.L_CORE X_NUC_84.L_CORE 0.003332
K_3747 X_NUC_38.L_CORE X_NUC_85.L_CORE 0.002431
K_3748 X_NUC_38.L_CORE X_NUC_86.L_CORE 0.002452
K_3749 X_NUC_38.L_CORE X_NUC_87.L_CORE 0.002438
K_3750 X_NUC_38.L_CORE X_NUC_88.L_CORE 0.002424
K_3751 X_NUC_38.L_CORE X_NUC_89.L_CORE 0.004092
K_3752 X_NUC_38.L_CORE X_NUC_90.L_CORE 0.004115
K_3753 X_NUC_38.L_CORE X_NUC_91.L_CORE 0.004060
K_3754 X_NUC_38.L_CORE X_NUC_92.L_CORE 0.004042
K_3755 X_NUC_38.L_CORE X_NUC_93.L_CORE 0.002648
K_3756 X_NUC_38.L_CORE X_NUC_94.L_CORE 0.002673
K_3757 X_NUC_38.L_CORE X_NUC_95.L_CORE 0.002646
K_3758 X_NUC_38.L_CORE X_NUC_96.L_CORE 0.002644
K_3759 X_NUC_38.L_CORE X_NUC_97.L_CORE 0.002867
K_3760 X_NUC_38.L_CORE X_NUC_98.L_CORE 0.002888
K_3761 X_NUC_38.L_CORE X_NUC_99.L_CORE 0.002864
K_3762 X_NUC_38.L_CORE X_NUC_100.L_CORE 0.002848
K_3763 X_NUC_38.L_CORE X_NUC_101.L_CORE 0.002935
K_3764 X_NUC_38.L_CORE X_NUC_102.L_CORE 0.005440
K_3765 X_NUC_38.L_CORE X_NUC_103.L_CORE 0.002843
K_3766 X_NUC_38.L_CORE X_NUC_104.L_CORE 0.002959
K_3767 X_NUC_38.L_CORE X_NUC_105.L_CORE 0.007037
K_3768 X_NUC_38.L_CORE X_NUC_106.L_CORE 0.002272
K_3769 X_NUC_38.L_CORE X_NUC_107.L_CORE 0.004992
K_3770 X_NUC_38.L_CORE X_NUC_108.L_CORE 0.003229
K_3771 X_NUC_38.L_CORE X_NUC_109.L_CORE 0.002326
K_3772 X_NUC_38.L_CORE X_NUC_110.L_CORE 0.015583
K_3773 X_NUC_38.L_CORE X_NUC_111.L_CORE 0.002288
K_3774 X_NUC_38.L_CORE X_NUC_112.L_CORE 0.003067
K_3775 X_NUC_38.L_CORE X_NUC_113.L_CORE 0.004161
K_3776 X_NUC_38.L_CORE X_NUC_114.L_CORE 0.002151
K_3777 X_NUC_38.L_CORE X_NUC_115.L_CORE 0.004566
K_3778 X_NUC_38.L_CORE X_NUC_116.L_CORE 0.002593
K_3779 X_NUC_38.L_CORE X_NUC_117.L_CORE 0.002479
K_3780 X_NUC_38.L_CORE X_NUC_118.L_CORE 0.003556
K_3781 X_NUC_38.L_CORE X_NUC_119.L_CORE 0.002447
K_3782 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_3783 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.002500
K_3784 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.002531
K_3785 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.002515
K_3786 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.002514
K_3787 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.003400
K_3788 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.003418
K_3789 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.003431
K_3790 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.003379
K_3791 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.005096
K_3792 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.005187
K_3793 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.005077
K_3794 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.005159
K_3795 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.002299
K_3796 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.002321
K_3797 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.002313
K_3798 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.002301
K_3799 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.006788
K_3800 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.006763
K_3801 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.006775
K_3802 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.006602
K_3803 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.002841
K_3804 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.002878
K_3805 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.002846
K_3806 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.002856
K_3807 X_NUC_39.L_CORE X_NUC_65.L_CORE 0.002637
K_3808 X_NUC_39.L_CORE X_NUC_66.L_CORE 0.002656
K_3809 X_NUC_39.L_CORE X_NUC_67.L_CORE 0.002652
K_3810 X_NUC_39.L_CORE X_NUC_68.L_CORE 0.002626
K_3811 X_NUC_39.L_CORE X_NUC_69.L_CORE 0.006494
K_3812 X_NUC_39.L_CORE X_NUC_70.L_CORE 0.006558
K_3813 X_NUC_39.L_CORE X_NUC_71.L_CORE 0.006367
K_3814 X_NUC_39.L_CORE X_NUC_72.L_CORE 0.006432
K_3815 X_NUC_39.L_CORE X_NUC_73.L_CORE 0.002347
K_3816 X_NUC_39.L_CORE X_NUC_74.L_CORE 0.002372
K_3817 X_NUC_39.L_CORE X_NUC_75.L_CORE 0.002355
K_3818 X_NUC_39.L_CORE X_NUC_76.L_CORE 0.002350
K_3819 X_NUC_39.L_CORE X_NUC_77.L_CORE 0.003644
K_3820 X_NUC_39.L_CORE X_NUC_78.L_CORE 0.003658
K_3821 X_NUC_39.L_CORE X_NUC_79.L_CORE 0.003647
K_3822 X_NUC_39.L_CORE X_NUC_80.L_CORE 0.003600
K_3823 X_NUC_39.L_CORE X_NUC_81.L_CORE 0.003381
K_3824 X_NUC_39.L_CORE X_NUC_82.L_CORE 0.003420
K_3825 X_NUC_39.L_CORE X_NUC_83.L_CORE 0.003368
K_3826 X_NUC_39.L_CORE X_NUC_84.L_CORE 0.003383
K_3827 X_NUC_39.L_CORE X_NUC_85.L_CORE 0.002445
K_3828 X_NUC_39.L_CORE X_NUC_86.L_CORE 0.002465
K_3829 X_NUC_39.L_CORE X_NUC_87.L_CORE 0.002452
K_3830 X_NUC_39.L_CORE X_NUC_88.L_CORE 0.002437
K_3831 X_NUC_39.L_CORE X_NUC_89.L_CORE 0.004147
K_3832 X_NUC_39.L_CORE X_NUC_90.L_CORE 0.004170
K_3833 X_NUC_39.L_CORE X_NUC_91.L_CORE 0.004115
K_3834 X_NUC_39.L_CORE X_NUC_92.L_CORE 0.004095
K_3835 X_NUC_39.L_CORE X_NUC_93.L_CORE 0.002675
K_3836 X_NUC_39.L_CORE X_NUC_94.L_CORE 0.002701
K_3837 X_NUC_39.L_CORE X_NUC_95.L_CORE 0.002673
K_3838 X_NUC_39.L_CORE X_NUC_96.L_CORE 0.002671
K_3839 X_NUC_39.L_CORE X_NUC_97.L_CORE 0.002890
K_3840 X_NUC_39.L_CORE X_NUC_98.L_CORE 0.002911
K_3841 X_NUC_39.L_CORE X_NUC_99.L_CORE 0.002888
K_3842 X_NUC_39.L_CORE X_NUC_100.L_CORE 0.002871
K_3843 X_NUC_39.L_CORE X_NUC_101.L_CORE 0.002926
K_3844 X_NUC_39.L_CORE X_NUC_102.L_CORE 0.005351
K_3845 X_NUC_39.L_CORE X_NUC_103.L_CORE 0.002852
K_3846 X_NUC_39.L_CORE X_NUC_104.L_CORE 0.002943
K_3847 X_NUC_39.L_CORE X_NUC_105.L_CORE 0.007084
K_3848 X_NUC_39.L_CORE X_NUC_106.L_CORE 0.002278
K_3849 X_NUC_39.L_CORE X_NUC_107.L_CORE 0.004920
K_3850 X_NUC_39.L_CORE X_NUC_108.L_CORE 0.003264
K_3851 X_NUC_39.L_CORE X_NUC_109.L_CORE 0.002327
K_3852 X_NUC_39.L_CORE X_NUC_110.L_CORE 0.016099
K_3853 X_NUC_39.L_CORE X_NUC_111.L_CORE 0.002304
K_3854 X_NUC_39.L_CORE X_NUC_112.L_CORE 0.003063
K_3855 X_NUC_39.L_CORE X_NUC_113.L_CORE 0.004245
K_3856 X_NUC_39.L_CORE X_NUC_114.L_CORE 0.002161
K_3857 X_NUC_39.L_CORE X_NUC_115.L_CORE 0.004595
K_3858 X_NUC_39.L_CORE X_NUC_116.L_CORE 0.002622
K_3859 X_NUC_39.L_CORE X_NUC_117.L_CORE 0.002490
K_3860 X_NUC_39.L_CORE X_NUC_118.L_CORE 0.003609
K_3861 X_NUC_39.L_CORE X_NUC_119.L_CORE 0.002469
K_3862 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.002501
K_3863 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.002531
K_3864 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.002515
K_3865 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.002515
K_3866 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.003453
K_3867 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.003472
K_3868 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.003485
K_3869 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.003431
K_3870 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.005015
K_3871 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.005102
K_3872 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.004996
K_3873 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.005077
K_3874 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.002311
K_3875 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.002333
K_3876 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.002325
K_3877 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.002313
K_3878 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.006973
K_3879 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.006946
K_3880 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.006955
K_3881 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.006775
K_3882 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.002832
K_3883 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.002868
K_3884 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.002837
K_3885 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.002846
K_3886 X_NUC_40.L_CORE X_NUC_65.L_CORE 0.002662
K_3887 X_NUC_40.L_CORE X_NUC_66.L_CORE 0.002682
K_3888 X_NUC_40.L_CORE X_NUC_67.L_CORE 0.002677
K_3889 X_NUC_40.L_CORE X_NUC_68.L_CORE 0.002652
K_3890 X_NUC_40.L_CORE X_NUC_69.L_CORE 0.006424
K_3891 X_NUC_40.L_CORE X_NUC_70.L_CORE 0.006486
K_3892 X_NUC_40.L_CORE X_NUC_71.L_CORE 0.006298
K_3893 X_NUC_40.L_CORE X_NUC_72.L_CORE 0.006367
K_3894 X_NUC_40.L_CORE X_NUC_73.L_CORE 0.002352
K_3895 X_NUC_40.L_CORE X_NUC_74.L_CORE 0.002377
K_3896 X_NUC_40.L_CORE X_NUC_75.L_CORE 0.002360
K_3897 X_NUC_40.L_CORE X_NUC_76.L_CORE 0.002355
K_3898 X_NUC_40.L_CORE X_NUC_77.L_CORE 0.003692
K_3899 X_NUC_40.L_CORE X_NUC_78.L_CORE 0.003707
K_3900 X_NUC_40.L_CORE X_NUC_79.L_CORE 0.003694
K_3901 X_NUC_40.L_CORE X_NUC_80.L_CORE 0.003647
K_3902 X_NUC_40.L_CORE X_NUC_81.L_CORE 0.003365
K_3903 X_NUC_40.L_CORE X_NUC_82.L_CORE 0.003404
K_3904 X_NUC_40.L_CORE X_NUC_83.L_CORE 0.003352
K_3905 X_NUC_40.L_CORE X_NUC_84.L_CORE 0.003368
K_3906 X_NUC_40.L_CORE X_NUC_85.L_CORE 0.002459
K_3907 X_NUC_40.L_CORE X_NUC_86.L_CORE 0.002480
K_3908 X_NUC_40.L_CORE X_NUC_87.L_CORE 0.002466
K_3909 X_NUC_40.L_CORE X_NUC_88.L_CORE 0.002452
K_3910 X_NUC_40.L_CORE X_NUC_89.L_CORE 0.004167
K_3911 X_NUC_40.L_CORE X_NUC_90.L_CORE 0.004191
K_3912 X_NUC_40.L_CORE X_NUC_91.L_CORE 0.004134
K_3913 X_NUC_40.L_CORE X_NUC_92.L_CORE 0.004115
K_3914 X_NUC_40.L_CORE X_NUC_93.L_CORE 0.002677
K_3915 X_NUC_40.L_CORE X_NUC_94.L_CORE 0.002704
K_3916 X_NUC_40.L_CORE X_NUC_95.L_CORE 0.002676
K_3917 X_NUC_40.L_CORE X_NUC_96.L_CORE 0.002673
K_3918 X_NUC_40.L_CORE X_NUC_97.L_CORE 0.002907
K_3919 X_NUC_40.L_CORE X_NUC_98.L_CORE 0.002928
K_3920 X_NUC_40.L_CORE X_NUC_99.L_CORE 0.002904
K_3921 X_NUC_40.L_CORE X_NUC_100.L_CORE 0.002888
K_3922 X_NUC_40.L_CORE X_NUC_101.L_CORE 0.002943
K_3923 X_NUC_40.L_CORE X_NUC_102.L_CORE 0.005407
K_3924 X_NUC_40.L_CORE X_NUC_103.L_CORE 0.002849
K_3925 X_NUC_40.L_CORE X_NUC_104.L_CORE 0.002977
K_3926 X_NUC_40.L_CORE X_NUC_105.L_CORE 0.006932
K_3927 X_NUC_40.L_CORE X_NUC_106.L_CORE 0.002286
K_3928 X_NUC_40.L_CORE X_NUC_107.L_CORE 0.005038
K_3929 X_NUC_40.L_CORE X_NUC_108.L_CORE 0.003239
K_3930 X_NUC_40.L_CORE X_NUC_109.L_CORE 0.002346
K_3931 X_NUC_40.L_CORE X_NUC_110.L_CORE 0.015821
K_3932 X_NUC_40.L_CORE X_NUC_111.L_CORE 0.002303
K_3933 X_NUC_40.L_CORE X_NUC_112.L_CORE 0.003105
K_3934 X_NUC_40.L_CORE X_NUC_113.L_CORE 0.004192
K_3935 X_NUC_40.L_CORE X_NUC_114.L_CORE 0.002171
K_3936 X_NUC_40.L_CORE X_NUC_115.L_CORE 0.004651
K_3937 X_NUC_40.L_CORE X_NUC_116.L_CORE 0.002616
K_3938 X_NUC_40.L_CORE X_NUC_117.L_CORE 0.002509
K_3939 X_NUC_40.L_CORE X_NUC_118.L_CORE 0.003606
K_3940 X_NUC_40.L_CORE X_NUC_119.L_CORE 0.002475
K_3941 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_3942 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_3943 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_3944 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.002482
K_3945 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.002460
K_3946 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.002480
K_3947 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.002460
K_3948 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.003398
K_3949 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.003350
K_3950 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.003357
K_3951 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.003382
K_3952 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.005048
K_3953 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.005034
K_3954 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.005076
K_3955 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.004961
K_3956 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.002305
K_3957 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.002281
K_3958 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.002294
K_3959 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.002287
K_3960 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.006775
K_3961 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.006665
K_3962 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.006565
K_3963 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.006697
K_3964 X_NUC_41.L_CORE X_NUC_65.L_CORE 0.002856
K_3965 X_NUC_41.L_CORE X_NUC_66.L_CORE 0.002835
K_3966 X_NUC_41.L_CORE X_NUC_67.L_CORE 0.002852
K_3967 X_NUC_41.L_CORE X_NUC_68.L_CORE 0.002822
K_3968 X_NUC_41.L_CORE X_NUC_69.L_CORE 0.002669
K_3969 X_NUC_41.L_CORE X_NUC_70.L_CORE 0.002638
K_3970 X_NUC_41.L_CORE X_NUC_71.L_CORE 0.002643
K_3971 X_NUC_41.L_CORE X_NUC_72.L_CORE 0.002648
K_3972 X_NUC_41.L_CORE X_NUC_73.L_CORE 0.006329
K_3973 X_NUC_41.L_CORE X_NUC_74.L_CORE 0.006313
K_3974 X_NUC_41.L_CORE X_NUC_75.L_CORE 0.006246
K_3975 X_NUC_41.L_CORE X_NUC_76.L_CORE 0.006162
K_3976 X_NUC_41.L_CORE X_NUC_77.L_CORE 0.002391
K_3977 X_NUC_41.L_CORE X_NUC_78.L_CORE 0.002369
K_3978 X_NUC_41.L_CORE X_NUC_79.L_CORE 0.002379
K_3979 X_NUC_41.L_CORE X_NUC_80.L_CORE 0.002367
K_3980 X_NUC_41.L_CORE X_NUC_81.L_CORE 0.003676
K_3981 X_NUC_41.L_CORE X_NUC_82.L_CORE 0.003631
K_3982 X_NUC_41.L_CORE X_NUC_83.L_CORE 0.003614
K_3983 X_NUC_41.L_CORE X_NUC_84.L_CORE 0.003635
K_3984 X_NUC_41.L_CORE X_NUC_85.L_CORE 0.003405
K_3985 X_NUC_41.L_CORE X_NUC_86.L_CORE 0.003384
K_3986 X_NUC_41.L_CORE X_NUC_87.L_CORE 0.003387
K_3987 X_NUC_41.L_CORE X_NUC_88.L_CORE 0.003351
K_3988 X_NUC_41.L_CORE X_NUC_89.L_CORE 0.002536
K_3989 X_NUC_41.L_CORE X_NUC_90.L_CORE 0.002510
K_3990 X_NUC_41.L_CORE X_NUC_91.L_CORE 0.002514
K_3991 X_NUC_41.L_CORE X_NUC_92.L_CORE 0.002510
K_3992 X_NUC_41.L_CORE X_NUC_93.L_CORE 0.003931
K_3993 X_NUC_41.L_CORE X_NUC_94.L_CORE 0.003897
K_3994 X_NUC_41.L_CORE X_NUC_95.L_CORE 0.003871
K_3995 X_NUC_41.L_CORE X_NUC_96.L_CORE 0.003866
K_3996 X_NUC_41.L_CORE X_NUC_97.L_CORE 0.002835
K_3997 X_NUC_41.L_CORE X_NUC_98.L_CORE 0.002811
K_3998 X_NUC_41.L_CORE X_NUC_99.L_CORE 0.002812
K_3999 X_NUC_41.L_CORE X_NUC_100.L_CORE 0.002798
K_4000 X_NUC_41.L_CORE X_NUC_101.L_CORE 0.003576
K_4001 X_NUC_41.L_CORE X_NUC_102.L_CORE 0.002593
K_4002 X_NUC_41.L_CORE X_NUC_103.L_CORE 0.005935
K_4003 X_NUC_41.L_CORE X_NUC_104.L_CORE 0.002702
K_4004 X_NUC_41.L_CORE X_NUC_105.L_CORE 0.002832
K_4005 X_NUC_41.L_CORE X_NUC_106.L_CORE 0.007111
K_4006 X_NUC_41.L_CORE X_NUC_107.L_CORE 0.002208
K_4007 X_NUC_41.L_CORE X_NUC_108.L_CORE 0.004851
K_4008 X_NUC_41.L_CORE X_NUC_109.L_CORE 0.003187
K_4009 X_NUC_41.L_CORE X_NUC_110.L_CORE 0.002295
K_4010 X_NUC_41.L_CORE X_NUC_111.L_CORE 0.014414
K_4011 X_NUC_41.L_CORE X_NUC_112.L_CORE 0.002286
K_4012 X_NUC_41.L_CORE X_NUC_113.L_CORE 0.003053
K_4013 X_NUC_41.L_CORE X_NUC_114.L_CORE 0.004153
K_4014 X_NUC_41.L_CORE X_NUC_115.L_CORE 0.002182
K_4015 X_NUC_41.L_CORE X_NUC_116.L_CORE 0.004419
K_4016 X_NUC_41.L_CORE X_NUC_117.L_CORE 0.002652
K_4017 X_NUC_41.L_CORE X_NUC_118.L_CORE 0.002562
K_4018 X_NUC_41.L_CORE X_NUC_119.L_CORE 0.003247
K_4019 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_4020 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_4021 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.002504
K_4022 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.002482
K_4023 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.002502
K_4024 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.002482
K_4025 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.003448
K_4026 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.003398
K_4027 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.003405
K_4028 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.003431
K_4029 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.005058
K_4030 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.005048
K_4031 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.005089
K_4032 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.004972
K_4033 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.002330
K_4034 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.002305
K_4035 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.002318
K_4036 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.002311
K_4037 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.006883
K_4038 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.006775
K_4039 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.006666
K_4040 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.006805
K_4041 X_NUC_42.L_CORE X_NUC_65.L_CORE 0.002876
K_4042 X_NUC_42.L_CORE X_NUC_66.L_CORE 0.002856
K_4043 X_NUC_42.L_CORE X_NUC_67.L_CORE 0.002873
K_4044 X_NUC_42.L_CORE X_NUC_68.L_CORE 0.002842
K_4045 X_NUC_42.L_CORE X_NUC_69.L_CORE 0.002701
K_4046 X_NUC_42.L_CORE X_NUC_70.L_CORE 0.002669
K_4047 X_NUC_42.L_CORE X_NUC_71.L_CORE 0.002674
K_4048 X_NUC_42.L_CORE X_NUC_72.L_CORE 0.002680
K_4049 X_NUC_42.L_CORE X_NUC_73.L_CORE 0.006340
K_4050 X_NUC_42.L_CORE X_NUC_74.L_CORE 0.006329
K_4051 X_NUC_42.L_CORE X_NUC_75.L_CORE 0.006259
K_4052 X_NUC_42.L_CORE X_NUC_76.L_CORE 0.006174
K_4053 X_NUC_42.L_CORE X_NUC_77.L_CORE 0.002413
K_4054 X_NUC_42.L_CORE X_NUC_78.L_CORE 0.002391
K_4055 X_NUC_42.L_CORE X_NUC_79.L_CORE 0.002401
K_4056 X_NUC_42.L_CORE X_NUC_80.L_CORE 0.002388
K_4057 X_NUC_42.L_CORE X_NUC_81.L_CORE 0.003721
K_4058 X_NUC_42.L_CORE X_NUC_82.L_CORE 0.003676
K_4059 X_NUC_42.L_CORE X_NUC_83.L_CORE 0.003657
K_4060 X_NUC_42.L_CORE X_NUC_84.L_CORE 0.003679
K_4061 X_NUC_42.L_CORE X_NUC_85.L_CORE 0.003425
K_4062 X_NUC_42.L_CORE X_NUC_86.L_CORE 0.003405
K_4063 X_NUC_42.L_CORE X_NUC_87.L_CORE 0.003407
K_4064 X_NUC_42.L_CORE X_NUC_88.L_CORE 0.003371
K_4065 X_NUC_42.L_CORE X_NUC_89.L_CORE 0.002562
K_4066 X_NUC_42.L_CORE X_NUC_90.L_CORE 0.002536
K_4067 X_NUC_42.L_CORE X_NUC_91.L_CORE 0.002539
K_4068 X_NUC_42.L_CORE X_NUC_92.L_CORE 0.002535
K_4069 X_NUC_42.L_CORE X_NUC_93.L_CORE 0.003964
K_4070 X_NUC_42.L_CORE X_NUC_94.L_CORE 0.003931
K_4071 X_NUC_42.L_CORE X_NUC_95.L_CORE 0.003903
K_4072 X_NUC_42.L_CORE X_NUC_96.L_CORE 0.003898
K_4073 X_NUC_42.L_CORE X_NUC_97.L_CORE 0.002859
K_4074 X_NUC_42.L_CORE X_NUC_98.L_CORE 0.002835
K_4075 X_NUC_42.L_CORE X_NUC_99.L_CORE 0.002835
K_4076 X_NUC_42.L_CORE X_NUC_100.L_CORE 0.002821
K_4077 X_NUC_42.L_CORE X_NUC_101.L_CORE 0.003609
K_4078 X_NUC_42.L_CORE X_NUC_102.L_CORE 0.002622
K_4079 X_NUC_42.L_CORE X_NUC_103.L_CORE 0.006011
K_4080 X_NUC_42.L_CORE X_NUC_104.L_CORE 0.002724
K_4081 X_NUC_42.L_CORE X_NUC_105.L_CORE 0.002868
K_4082 X_NUC_42.L_CORE X_NUC_106.L_CORE 0.007081
K_4083 X_NUC_42.L_CORE X_NUC_107.L_CORE 0.002230
K_4084 X_NUC_42.L_CORE X_NUC_108.L_CORE 0.004923
K_4085 X_NUC_42.L_CORE X_NUC_109.L_CORE 0.003203
K_4086 X_NUC_42.L_CORE X_NUC_110.L_CORE 0.002320
K_4087 X_NUC_42.L_CORE X_NUC_111.L_CORE 0.013999
K_4088 X_NUC_42.L_CORE X_NUC_112.L_CORE 0.002304
K_4089 X_NUC_42.L_CORE X_NUC_113.L_CORE 0.003089
K_4090 X_NUC_42.L_CORE X_NUC_114.L_CORE 0.004158
K_4091 X_NUC_42.L_CORE X_NUC_115.L_CORE 0.002203
K_4092 X_NUC_42.L_CORE X_NUC_116.L_CORE 0.004454
K_4093 X_NUC_42.L_CORE X_NUC_117.L_CORE 0.002669
K_4094 X_NUC_42.L_CORE X_NUC_118.L_CORE 0.002586
K_4095 X_NUC_42.L_CORE X_NUC_119.L_CORE 0.003267
K_4096 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_4097 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.002484
K_4098 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.002462
K_4099 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.002482
K_4100 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.002463
K_4101 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.003440
K_4102 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.003391
K_4103 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.003398
K_4104 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.003424
K_4105 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.005016
K_4106 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.005005
K_4107 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.005048
K_4108 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.004933
K_4109 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.002317
K_4110 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.002293
K_4111 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.002305
K_4112 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.002299
K_4113 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.006999
K_4114 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.006882
K_4115 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.006775
K_4116 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.006917
K_4117 X_NUC_43.L_CORE X_NUC_65.L_CORE 0.002858
K_4118 X_NUC_43.L_CORE X_NUC_66.L_CORE 0.002838
K_4119 X_NUC_43.L_CORE X_NUC_67.L_CORE 0.002856
K_4120 X_NUC_43.L_CORE X_NUC_68.L_CORE 0.002825
K_4121 X_NUC_43.L_CORE X_NUC_69.L_CORE 0.002696
K_4122 X_NUC_43.L_CORE X_NUC_70.L_CORE 0.002664
K_4123 X_NUC_43.L_CORE X_NUC_71.L_CORE 0.002669
K_4124 X_NUC_43.L_CORE X_NUC_72.L_CORE 0.002675
K_4125 X_NUC_43.L_CORE X_NUC_73.L_CORE 0.006410
K_4126 X_NUC_43.L_CORE X_NUC_74.L_CORE 0.006396
K_4127 X_NUC_43.L_CORE X_NUC_75.L_CORE 0.006329
K_4128 X_NUC_43.L_CORE X_NUC_76.L_CORE 0.006239
K_4129 X_NUC_43.L_CORE X_NUC_77.L_CORE 0.002403
K_4130 X_NUC_43.L_CORE X_NUC_78.L_CORE 0.002381
K_4131 X_NUC_43.L_CORE X_NUC_79.L_CORE 0.002391
K_4132 X_NUC_43.L_CORE X_NUC_80.L_CORE 0.002378
K_4133 X_NUC_43.L_CORE X_NUC_81.L_CORE 0.003740
K_4134 X_NUC_43.L_CORE X_NUC_82.L_CORE 0.003694
K_4135 X_NUC_43.L_CORE X_NUC_83.L_CORE 0.003676
K_4136 X_NUC_43.L_CORE X_NUC_84.L_CORE 0.003698
K_4137 X_NUC_43.L_CORE X_NUC_85.L_CORE 0.003422
K_4138 X_NUC_43.L_CORE X_NUC_86.L_CORE 0.003401
K_4139 X_NUC_43.L_CORE X_NUC_87.L_CORE 0.003405
K_4140 X_NUC_43.L_CORE X_NUC_88.L_CORE 0.003368
K_4141 X_NUC_43.L_CORE X_NUC_89.L_CORE 0.002559
K_4142 X_NUC_43.L_CORE X_NUC_90.L_CORE 0.002533
K_4143 X_NUC_43.L_CORE X_NUC_91.L_CORE 0.002536
K_4144 X_NUC_43.L_CORE X_NUC_92.L_CORE 0.002532
K_4145 X_NUC_43.L_CORE X_NUC_93.L_CORE 0.003992
K_4146 X_NUC_43.L_CORE X_NUC_94.L_CORE 0.003958
K_4147 X_NUC_43.L_CORE X_NUC_95.L_CORE 0.003931
K_4148 X_NUC_43.L_CORE X_NUC_96.L_CORE 0.003925
K_4149 X_NUC_43.L_CORE X_NUC_97.L_CORE 0.002859
K_4150 X_NUC_43.L_CORE X_NUC_98.L_CORE 0.002835
K_4151 X_NUC_43.L_CORE X_NUC_99.L_CORE 0.002835
K_4152 X_NUC_43.L_CORE X_NUC_100.L_CORE 0.002821
K_4153 X_NUC_43.L_CORE X_NUC_101.L_CORE 0.003547
K_4154 X_NUC_43.L_CORE X_NUC_102.L_CORE 0.002594
K_4155 X_NUC_43.L_CORE X_NUC_103.L_CORE 0.005885
K_4156 X_NUC_43.L_CORE X_NUC_104.L_CORE 0.002693
K_4157 X_NUC_43.L_CORE X_NUC_105.L_CORE 0.002847
K_4158 X_NUC_43.L_CORE X_NUC_106.L_CORE 0.006914
K_4159 X_NUC_43.L_CORE X_NUC_107.L_CORE 0.002212
K_4160 X_NUC_43.L_CORE X_NUC_108.L_CORE 0.004925
K_4161 X_NUC_43.L_CORE X_NUC_109.L_CORE 0.003173
K_4162 X_NUC_43.L_CORE X_NUC_110.L_CORE 0.002309
K_4163 X_NUC_43.L_CORE X_NUC_111.L_CORE 0.014922
K_4164 X_NUC_43.L_CORE X_NUC_112.L_CORE 0.002290
K_4165 X_NUC_43.L_CORE X_NUC_113.L_CORE 0.003093
K_4166 X_NUC_43.L_CORE X_NUC_114.L_CORE 0.004156
K_4167 X_NUC_43.L_CORE X_NUC_115.L_CORE 0.002196
K_4168 X_NUC_43.L_CORE X_NUC_116.L_CORE 0.004512
K_4169 X_NUC_43.L_CORE X_NUC_117.L_CORE 0.002664
K_4170 X_NUC_43.L_CORE X_NUC_118.L_CORE 0.002589
K_4171 X_NUC_43.L_CORE X_NUC_119.L_CORE 0.003283
K_4172 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.002504
K_4173 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.002481
K_4174 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.002502
K_4175 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.002482
K_4176 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.003414
K_4177 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.003366
K_4178 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.003372
K_4179 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.003398
K_4180 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.005136
K_4181 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.005124
K_4182 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.005168
K_4183 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.005048
K_4184 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.002324
K_4185 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.002299
K_4186 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.002312
K_4187 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.002305
K_4188 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.006849
K_4189 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.006739
K_4190 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.006635
K_4191 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.006775
K_4192 X_NUC_44.L_CORE X_NUC_65.L_CORE 0.002890
K_4193 X_NUC_44.L_CORE X_NUC_66.L_CORE 0.002869
K_4194 X_NUC_44.L_CORE X_NUC_67.L_CORE 0.002887
K_4195 X_NUC_44.L_CORE X_NUC_68.L_CORE 0.002856
K_4196 X_NUC_44.L_CORE X_NUC_69.L_CORE 0.002690
K_4197 X_NUC_44.L_CORE X_NUC_70.L_CORE 0.002658
K_4198 X_NUC_44.L_CORE X_NUC_71.L_CORE 0.002663
K_4199 X_NUC_44.L_CORE X_NUC_72.L_CORE 0.002669
K_4200 X_NUC_44.L_CORE X_NUC_73.L_CORE 0.006505
K_4201 X_NUC_44.L_CORE X_NUC_74.L_CORE 0.006491
K_4202 X_NUC_44.L_CORE X_NUC_75.L_CORE 0.006418
K_4203 X_NUC_44.L_CORE X_NUC_76.L_CORE 0.006329
K_4204 X_NUC_44.L_CORE X_NUC_77.L_CORE 0.002416
K_4205 X_NUC_44.L_CORE X_NUC_78.L_CORE 0.002394
K_4206 X_NUC_44.L_CORE X_NUC_79.L_CORE 0.002404
K_4207 X_NUC_44.L_CORE X_NUC_80.L_CORE 0.002391
K_4208 X_NUC_44.L_CORE X_NUC_81.L_CORE 0.003716
K_4209 X_NUC_44.L_CORE X_NUC_82.L_CORE 0.003671
K_4210 X_NUC_44.L_CORE X_NUC_83.L_CORE 0.003653
K_4211 X_NUC_44.L_CORE X_NUC_84.L_CORE 0.003676
K_4212 X_NUC_44.L_CORE X_NUC_85.L_CORE 0.003460
K_4213 X_NUC_44.L_CORE X_NUC_86.L_CORE 0.003438
K_4214 X_NUC_44.L_CORE X_NUC_87.L_CORE 0.003442
K_4215 X_NUC_44.L_CORE X_NUC_88.L_CORE 0.003405
K_4216 X_NUC_44.L_CORE X_NUC_89.L_CORE 0.002563
K_4217 X_NUC_44.L_CORE X_NUC_90.L_CORE 0.002537
K_4218 X_NUC_44.L_CORE X_NUC_91.L_CORE 0.002540
K_4219 X_NUC_44.L_CORE X_NUC_92.L_CORE 0.002536
K_4220 X_NUC_44.L_CORE X_NUC_93.L_CORE 0.003998
K_4221 X_NUC_44.L_CORE X_NUC_94.L_CORE 0.003963
K_4222 X_NUC_44.L_CORE X_NUC_95.L_CORE 0.003935
K_4223 X_NUC_44.L_CORE X_NUC_96.L_CORE 0.003931
K_4224 X_NUC_44.L_CORE X_NUC_97.L_CORE 0.002874
K_4225 X_NUC_44.L_CORE X_NUC_98.L_CORE 0.002849
K_4226 X_NUC_44.L_CORE X_NUC_99.L_CORE 0.002850
K_4227 X_NUC_44.L_CORE X_NUC_100.L_CORE 0.002835
K_4228 X_NUC_44.L_CORE X_NUC_101.L_CORE 0.003575
K_4229 X_NUC_44.L_CORE X_NUC_102.L_CORE 0.002600
K_4230 X_NUC_44.L_CORE X_NUC_103.L_CORE 0.005851
K_4231 X_NUC_44.L_CORE X_NUC_104.L_CORE 0.002718
K_4232 X_NUC_44.L_CORE X_NUC_105.L_CORE 0.002836
K_4233 X_NUC_44.L_CORE X_NUC_106.L_CORE 0.007116
K_4234 X_NUC_44.L_CORE X_NUC_107.L_CORE 0.002222
K_4235 X_NUC_44.L_CORE X_NUC_108.L_CORE 0.004836
K_4236 X_NUC_44.L_CORE X_NUC_109.L_CORE 0.003219
K_4237 X_NUC_44.L_CORE X_NUC_110.L_CORE 0.002308
K_4238 X_NUC_44.L_CORE X_NUC_111.L_CORE 0.014750
K_4239 X_NUC_44.L_CORE X_NUC_112.L_CORE 0.002307
K_4240 X_NUC_44.L_CORE X_NUC_113.L_CORE 0.003071
K_4241 X_NUC_44.L_CORE X_NUC_114.L_CORE 0.004225
K_4242 X_NUC_44.L_CORE X_NUC_115.L_CORE 0.002201
K_4243 X_NUC_44.L_CORE X_NUC_116.L_CORE 0.004477
K_4244 X_NUC_44.L_CORE X_NUC_117.L_CORE 0.002686
K_4245 X_NUC_44.L_CORE X_NUC_118.L_CORE 0.002587
K_4246 X_NUC_44.L_CORE X_NUC_119.L_CORE 0.003296
K_4247 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_4248 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_4249 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_4250 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.002466
K_4251 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.002469
K_4252 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.002452
K_4253 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.002481
K_4254 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.003387
K_4255 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.003441
K_4256 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.003402
K_4257 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.003416
K_4258 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.005048
K_4259 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.004979
K_4260 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.004944
K_4261 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.005037
K_4262 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.002313
K_4263 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.002327
K_4264 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.002306
K_4265 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.002328
K_4266 X_NUC_45.L_CORE X_NUC_65.L_CORE 0.006791
K_4267 X_NUC_45.L_CORE X_NUC_66.L_CORE 0.006972
K_4268 X_NUC_45.L_CORE X_NUC_67.L_CORE 0.006794
K_4269 X_NUC_45.L_CORE X_NUC_68.L_CORE 0.006774
K_4270 X_NUC_45.L_CORE X_NUC_69.L_CORE 0.002883
K_4271 X_NUC_45.L_CORE X_NUC_70.L_CORE 0.002878
K_4272 X_NUC_45.L_CORE X_NUC_71.L_CORE 0.002853
K_4273 X_NUC_45.L_CORE X_NUC_72.L_CORE 0.002891
K_4274 X_NUC_45.L_CORE X_NUC_73.L_CORE 0.002706
K_4275 X_NUC_45.L_CORE X_NUC_74.L_CORE 0.002734
K_4276 X_NUC_45.L_CORE X_NUC_75.L_CORE 0.002702
K_4277 X_NUC_45.L_CORE X_NUC_76.L_CORE 0.002720
K_4278 X_NUC_45.L_CORE X_NUC_77.L_CORE 0.006262
K_4279 X_NUC_45.L_CORE X_NUC_78.L_CORE 0.006221
K_4280 X_NUC_45.L_CORE X_NUC_79.L_CORE 0.006089
K_4281 X_NUC_45.L_CORE X_NUC_80.L_CORE 0.006168
K_4282 X_NUC_45.L_CORE X_NUC_81.L_CORE 0.002449
K_4283 X_NUC_45.L_CORE X_NUC_82.L_CORE 0.002457
K_4284 X_NUC_45.L_CORE X_NUC_83.L_CORE 0.002433
K_4285 X_NUC_45.L_CORE X_NUC_84.L_CORE 0.002458
K_4286 X_NUC_45.L_CORE X_NUC_85.L_CORE 0.003715
K_4287 X_NUC_45.L_CORE X_NUC_86.L_CORE 0.003763
K_4288 X_NUC_45.L_CORE X_NUC_87.L_CORE 0.003699
K_4289 X_NUC_45.L_CORE X_NUC_88.L_CORE 0.003717
K_4290 X_NUC_45.L_CORE X_NUC_89.L_CORE 0.003453
K_4291 X_NUC_45.L_CORE X_NUC_90.L_CORE 0.003447
K_4292 X_NUC_45.L_CORE X_NUC_91.L_CORE 0.003403
K_4293 X_NUC_45.L_CORE X_NUC_92.L_CORE 0.003444
K_4294 X_NUC_45.L_CORE X_NUC_93.L_CORE 0.002670
K_4295 X_NUC_45.L_CORE X_NUC_94.L_CORE 0.002687
K_4296 X_NUC_45.L_CORE X_NUC_95.L_CORE 0.002654
K_4297 X_NUC_45.L_CORE X_NUC_96.L_CORE 0.002676
K_4298 X_NUC_45.L_CORE X_NUC_97.L_CORE 0.003622
K_4299 X_NUC_45.L_CORE X_NUC_98.L_CORE 0.003641
K_4300 X_NUC_45.L_CORE X_NUC_99.L_CORE 0.003580
K_4301 X_NUC_45.L_CORE X_NUC_100.L_CORE 0.003610
K_4302 X_NUC_45.L_CORE X_NUC_101.L_CORE 0.003351
K_4303 X_NUC_45.L_CORE X_NUC_102.L_CORE 0.003612
K_4304 X_NUC_45.L_CORE X_NUC_103.L_CORE 0.002437
K_4305 X_NUC_45.L_CORE X_NUC_104.L_CORE 0.006419
K_4306 X_NUC_45.L_CORE X_NUC_105.L_CORE 0.002613
K_4307 X_NUC_45.L_CORE X_NUC_106.L_CORE 0.002785
K_4308 X_NUC_45.L_CORE X_NUC_107.L_CORE 0.007012
K_4309 X_NUC_45.L_CORE X_NUC_108.L_CORE 0.002182
K_4310 X_NUC_45.L_CORE X_NUC_109.L_CORE 0.004884
K_4311 X_NUC_45.L_CORE X_NUC_110.L_CORE 0.003158
K_4312 X_NUC_45.L_CORE X_NUC_111.L_CORE 0.002309
K_4313 X_NUC_45.L_CORE X_NUC_112.L_CORE 0.013107
K_4314 X_NUC_45.L_CORE X_NUC_113.L_CORE 0.002311
K_4315 X_NUC_45.L_CORE X_NUC_114.L_CORE 0.003114
K_4316 X_NUC_45.L_CORE X_NUC_115.L_CORE 0.004122
K_4317 X_NUC_45.L_CORE X_NUC_116.L_CORE 0.002257
K_4318 X_NUC_45.L_CORE X_NUC_117.L_CORE 0.004300
K_4319 X_NUC_45.L_CORE X_NUC_118.L_CORE 0.002751
K_4320 X_NUC_45.L_CORE X_NUC_119.L_CORE 0.002741
K_4321 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_4322 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_4323 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.002463
K_4324 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.002466
K_4325 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.002449
K_4326 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.002478
K_4327 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.003335
K_4328 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.003387
K_4329 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.003350
K_4330 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.003363
K_4331 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.005116
K_4332 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.005048
K_4333 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.005010
K_4334 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.005107
K_4335 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.002299
K_4336 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.002313
K_4337 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.002293
K_4338 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.002314
K_4339 X_NUC_46.L_CORE X_NUC_65.L_CORE 0.006617
K_4340 X_NUC_46.L_CORE X_NUC_66.L_CORE 0.006791
K_4341 X_NUC_46.L_CORE X_NUC_67.L_CORE 0.006623
K_4342 X_NUC_46.L_CORE X_NUC_68.L_CORE 0.006604
K_4343 X_NUC_46.L_CORE X_NUC_69.L_CORE 0.002888
K_4344 X_NUC_46.L_CORE X_NUC_70.L_CORE 0.002883
K_4345 X_NUC_46.L_CORE X_NUC_71.L_CORE 0.002859
K_4346 X_NUC_46.L_CORE X_NUC_72.L_CORE 0.002896
K_4347 X_NUC_46.L_CORE X_NUC_73.L_CORE 0.002678
K_4348 X_NUC_46.L_CORE X_NUC_74.L_CORE 0.002706
K_4349 X_NUC_46.L_CORE X_NUC_75.L_CORE 0.002675
K_4350 X_NUC_46.L_CORE X_NUC_76.L_CORE 0.002692
K_4351 X_NUC_46.L_CORE X_NUC_77.L_CORE 0.006298
K_4352 X_NUC_46.L_CORE X_NUC_78.L_CORE 0.006262
K_4353 X_NUC_46.L_CORE X_NUC_79.L_CORE 0.006125
K_4354 X_NUC_46.L_CORE X_NUC_80.L_CORE 0.006205
K_4355 X_NUC_46.L_CORE X_NUC_81.L_CORE 0.002441
K_4356 X_NUC_46.L_CORE X_NUC_82.L_CORE 0.002449
K_4357 X_NUC_46.L_CORE X_NUC_83.L_CORE 0.002425
K_4358 X_NUC_46.L_CORE X_NUC_84.L_CORE 0.002450
K_4359 X_NUC_46.L_CORE X_NUC_85.L_CORE 0.003668
K_4360 X_NUC_46.L_CORE X_NUC_86.L_CORE 0.003715
K_4361 X_NUC_46.L_CORE X_NUC_87.L_CORE 0.003653
K_4362 X_NUC_46.L_CORE X_NUC_88.L_CORE 0.003670
K_4363 X_NUC_46.L_CORE X_NUC_89.L_CORE 0.003458
K_4364 X_NUC_46.L_CORE X_NUC_90.L_CORE 0.003453
K_4365 X_NUC_46.L_CORE X_NUC_91.L_CORE 0.003408
K_4366 X_NUC_46.L_CORE X_NUC_92.L_CORE 0.003450
K_4367 X_NUC_46.L_CORE X_NUC_93.L_CORE 0.002653
K_4368 X_NUC_46.L_CORE X_NUC_94.L_CORE 0.002670
K_4369 X_NUC_46.L_CORE X_NUC_95.L_CORE 0.002637
K_4370 X_NUC_46.L_CORE X_NUC_96.L_CORE 0.002659
K_4371 X_NUC_46.L_CORE X_NUC_97.L_CORE 0.003603
K_4372 X_NUC_46.L_CORE X_NUC_98.L_CORE 0.003622
K_4373 X_NUC_46.L_CORE X_NUC_99.L_CORE 0.003562
K_4374 X_NUC_46.L_CORE X_NUC_100.L_CORE 0.003591
K_4375 X_NUC_46.L_CORE X_NUC_101.L_CORE 0.003323
K_4376 X_NUC_46.L_CORE X_NUC_102.L_CORE 0.003620
K_4377 X_NUC_46.L_CORE X_NUC_103.L_CORE 0.002421
K_4378 X_NUC_46.L_CORE X_NUC_104.L_CORE 0.006325
K_4379 X_NUC_46.L_CORE X_NUC_105.L_CORE 0.002615
K_4380 X_NUC_46.L_CORE X_NUC_106.L_CORE 0.002752
K_4381 X_NUC_46.L_CORE X_NUC_107.L_CORE 0.007190
K_4382 X_NUC_46.L_CORE X_NUC_108.L_CORE 0.002174
K_4383 X_NUC_46.L_CORE X_NUC_109.L_CORE 0.004773
K_4384 X_NUC_46.L_CORE X_NUC_110.L_CORE 0.003177
K_4385 X_NUC_46.L_CORE X_NUC_111.L_CORE 0.002290
K_4386 X_NUC_46.L_CORE X_NUC_112.L_CORE 0.013238
K_4387 X_NUC_46.L_CORE X_NUC_113.L_CORE 0.002308
K_4388 X_NUC_46.L_CORE X_NUC_114.L_CORE 0.003072
K_4389 X_NUC_46.L_CORE X_NUC_115.L_CORE 0.004158
K_4390 X_NUC_46.L_CORE X_NUC_116.L_CORE 0.002245
K_4391 X_NUC_46.L_CORE X_NUC_117.L_CORE 0.004257
K_4392 X_NUC_46.L_CORE X_NUC_118.L_CORE 0.002750
K_4393 X_NUC_46.L_CORE X_NUC_119.L_CORE 0.002723
K_4394 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_4395 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.002480
K_4396 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.002483
K_4397 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.002466
K_4398 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.002495
K_4399 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.003372
K_4400 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.003426
K_4401 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.003387
K_4402 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.003401
K_4403 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.005155
K_4404 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.005083
K_4405 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.005048
K_4406 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.005145
K_4407 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.002320
K_4408 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.002334
K_4409 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.002313
K_4410 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.002335
K_4411 X_NUC_47.L_CORE X_NUC_65.L_CORE 0.006782
K_4412 X_NUC_47.L_CORE X_NUC_66.L_CORE 0.006966
K_4413 X_NUC_47.L_CORE X_NUC_67.L_CORE 0.006791
K_4414 X_NUC_47.L_CORE X_NUC_68.L_CORE 0.006768
K_4415 X_NUC_47.L_CORE X_NUC_69.L_CORE 0.002914
K_4416 X_NUC_47.L_CORE X_NUC_70.L_CORE 0.002908
K_4417 X_NUC_47.L_CORE X_NUC_71.L_CORE 0.002883
K_4418 X_NUC_47.L_CORE X_NUC_72.L_CORE 0.002922
K_4419 X_NUC_47.L_CORE X_NUC_73.L_CORE 0.002709
K_4420 X_NUC_47.L_CORE X_NUC_74.L_CORE 0.002737
K_4421 X_NUC_47.L_CORE X_NUC_75.L_CORE 0.002706
K_4422 X_NUC_47.L_CORE X_NUC_76.L_CORE 0.002724
K_4423 X_NUC_47.L_CORE X_NUC_77.L_CORE 0.006444
K_4424 X_NUC_47.L_CORE X_NUC_78.L_CORE 0.006403
K_4425 X_NUC_47.L_CORE X_NUC_79.L_CORE 0.006262
K_4426 X_NUC_47.L_CORE X_NUC_80.L_CORE 0.006344
K_4427 X_NUC_47.L_CORE X_NUC_81.L_CORE 0.002465
K_4428 X_NUC_47.L_CORE X_NUC_82.L_CORE 0.002474
K_4429 X_NUC_47.L_CORE X_NUC_83.L_CORE 0.002449
K_4430 X_NUC_47.L_CORE X_NUC_84.L_CORE 0.002475
K_4431 X_NUC_47.L_CORE X_NUC_85.L_CORE 0.003730
K_4432 X_NUC_47.L_CORE X_NUC_86.L_CORE 0.003779
K_4433 X_NUC_47.L_CORE X_NUC_87.L_CORE 0.003715
K_4434 X_NUC_47.L_CORE X_NUC_88.L_CORE 0.003733
K_4435 X_NUC_47.L_CORE X_NUC_89.L_CORE 0.003504
K_4436 X_NUC_47.L_CORE X_NUC_90.L_CORE 0.003499
K_4437 X_NUC_47.L_CORE X_NUC_91.L_CORE 0.003453
K_4438 X_NUC_47.L_CORE X_NUC_92.L_CORE 0.003496
K_4439 X_NUC_47.L_CORE X_NUC_93.L_CORE 0.002686
K_4440 X_NUC_47.L_CORE X_NUC_94.L_CORE 0.002704
K_4441 X_NUC_47.L_CORE X_NUC_95.L_CORE 0.002670
K_4442 X_NUC_47.L_CORE X_NUC_96.L_CORE 0.002693
K_4443 X_NUC_47.L_CORE X_NUC_97.L_CORE 0.003665
K_4444 X_NUC_47.L_CORE X_NUC_98.L_CORE 0.003685
K_4445 X_NUC_47.L_CORE X_NUC_99.L_CORE 0.003622
K_4446 X_NUC_47.L_CORE X_NUC_100.L_CORE 0.003653
K_4447 X_NUC_47.L_CORE X_NUC_101.L_CORE 0.003322
K_4448 X_NUC_47.L_CORE X_NUC_102.L_CORE 0.003608
K_4449 X_NUC_47.L_CORE X_NUC_103.L_CORE 0.002432
K_4450 X_NUC_47.L_CORE X_NUC_104.L_CORE 0.006253
K_4451 X_NUC_47.L_CORE X_NUC_105.L_CORE 0.002623
K_4452 X_NUC_47.L_CORE X_NUC_106.L_CORE 0.002769
K_4453 X_NUC_47.L_CORE X_NUC_107.L_CORE 0.007089
K_4454 X_NUC_47.L_CORE X_NUC_108.L_CORE 0.002187
K_4455 X_NUC_47.L_CORE X_NUC_109.L_CORE 0.004816
K_4456 X_NUC_47.L_CORE X_NUC_110.L_CORE 0.003191
K_4457 X_NUC_47.L_CORE X_NUC_111.L_CORE 0.002310
K_4458 X_NUC_47.L_CORE X_NUC_112.L_CORE 0.013609
K_4459 X_NUC_47.L_CORE X_NUC_113.L_CORE 0.002326
K_4460 X_NUC_47.L_CORE X_NUC_114.L_CORE 0.003110
K_4461 X_NUC_47.L_CORE X_NUC_115.L_CORE 0.004204
K_4462 X_NUC_47.L_CORE X_NUC_116.L_CORE 0.002267
K_4463 X_NUC_47.L_CORE X_NUC_117.L_CORE 0.004338
K_4464 X_NUC_47.L_CORE X_NUC_118.L_CORE 0.002781
K_4465 X_NUC_47.L_CORE X_NUC_119.L_CORE 0.002759
K_4466 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.002451
K_4467 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.002454
K_4468 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.002437
K_4469 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.002466
K_4470 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.003358
K_4471 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.003411
K_4472 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.003373
K_4473 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.003387
K_4474 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.005055
K_4475 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.004988
K_4476 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.004953
K_4477 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.005048
K_4478 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.002299
K_4479 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.002312
K_4480 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.002292
K_4481 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.002313
K_4482 X_NUC_48.L_CORE X_NUC_65.L_CORE 0.006801
K_4483 X_NUC_48.L_CORE X_NUC_66.L_CORE 0.006987
K_4484 X_NUC_48.L_CORE X_NUC_67.L_CORE 0.006808
K_4485 X_NUC_48.L_CORE X_NUC_68.L_CORE 0.006791
K_4486 X_NUC_48.L_CORE X_NUC_69.L_CORE 0.002875
K_4487 X_NUC_48.L_CORE X_NUC_70.L_CORE 0.002870
K_4488 X_NUC_48.L_CORE X_NUC_71.L_CORE 0.002846
K_4489 X_NUC_48.L_CORE X_NUC_72.L_CORE 0.002883
K_4490 X_NUC_48.L_CORE X_NUC_73.L_CORE 0.002691
K_4491 X_NUC_48.L_CORE X_NUC_74.L_CORE 0.002718
K_4492 X_NUC_48.L_CORE X_NUC_75.L_CORE 0.002687
K_4493 X_NUC_48.L_CORE X_NUC_76.L_CORE 0.002706
K_4494 X_NUC_48.L_CORE X_NUC_77.L_CORE 0.006355
K_4495 X_NUC_48.L_CORE X_NUC_78.L_CORE 0.006315
K_4496 X_NUC_48.L_CORE X_NUC_79.L_CORE 0.006177
K_4497 X_NUC_48.L_CORE X_NUC_80.L_CORE 0.006262
K_4498 X_NUC_48.L_CORE X_NUC_81.L_CORE 0.002440
K_4499 X_NUC_48.L_CORE X_NUC_82.L_CORE 0.002448
K_4500 X_NUC_48.L_CORE X_NUC_83.L_CORE 0.002424
K_4501 X_NUC_48.L_CORE X_NUC_84.L_CORE 0.002449
K_4502 X_NUC_48.L_CORE X_NUC_85.L_CORE 0.003712
K_4503 X_NUC_48.L_CORE X_NUC_86.L_CORE 0.003761
K_4504 X_NUC_48.L_CORE X_NUC_87.L_CORE 0.003697
K_4505 X_NUC_48.L_CORE X_NUC_88.L_CORE 0.003715
K_4506 X_NUC_48.L_CORE X_NUC_89.L_CORE 0.003461
K_4507 X_NUC_48.L_CORE X_NUC_90.L_CORE 0.003455
K_4508 X_NUC_48.L_CORE X_NUC_91.L_CORE 0.003411
K_4509 X_NUC_48.L_CORE X_NUC_92.L_CORE 0.003453
K_4510 X_NUC_48.L_CORE X_NUC_93.L_CORE 0.002663
K_4511 X_NUC_48.L_CORE X_NUC_94.L_CORE 0.002681
K_4512 X_NUC_48.L_CORE X_NUC_95.L_CORE 0.002647
K_4513 X_NUC_48.L_CORE X_NUC_96.L_CORE 0.002670
K_4514 X_NUC_48.L_CORE X_NUC_97.L_CORE 0.003633
K_4515 X_NUC_48.L_CORE X_NUC_98.L_CORE 0.003653
K_4516 X_NUC_48.L_CORE X_NUC_99.L_CORE 0.003592
K_4517 X_NUC_48.L_CORE X_NUC_100.L_CORE 0.003622
K_4518 X_NUC_48.L_CORE X_NUC_101.L_CORE 0.003298
K_4519 X_NUC_48.L_CORE X_NUC_102.L_CORE 0.003564
K_4520 X_NUC_48.L_CORE X_NUC_103.L_CORE 0.002411
K_4521 X_NUC_48.L_CORE X_NUC_104.L_CORE 0.006251
K_4522 X_NUC_48.L_CORE X_NUC_105.L_CORE 0.002592
K_4523 X_NUC_48.L_CORE X_NUC_106.L_CORE 0.002755
K_4524 X_NUC_48.L_CORE X_NUC_107.L_CORE 0.006965
K_4525 X_NUC_48.L_CORE X_NUC_108.L_CORE 0.002166
K_4526 X_NUC_48.L_CORE X_NUC_109.L_CORE 0.004833
K_4527 X_NUC_48.L_CORE X_NUC_110.L_CORE 0.003147
K_4528 X_NUC_48.L_CORE X_NUC_111.L_CORE 0.002293
K_4529 X_NUC_48.L_CORE X_NUC_112.L_CORE 0.013894
K_4530 X_NUC_48.L_CORE X_NUC_113.L_CORE 0.002301
K_4531 X_NUC_48.L_CORE X_NUC_114.L_CORE 0.003100
K_4532 X_NUC_48.L_CORE X_NUC_115.L_CORE 0.004149
K_4533 X_NUC_48.L_CORE X_NUC_116.L_CORE 0.002248
K_4534 X_NUC_48.L_CORE X_NUC_117.L_CORE 0.004328
K_4535 X_NUC_48.L_CORE X_NUC_118.L_CORE 0.002752
K_4536 X_NUC_48.L_CORE X_NUC_119.L_CORE 0.002740
K_4537 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_4538 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_4539 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_4540 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.002466
K_4541 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.002483
K_4542 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.002486
K_4543 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.002462
K_4544 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.003398
K_4545 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.003369
K_4546 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.003402
K_4547 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.003356
K_4548 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.005077
K_4549 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.005196
K_4550 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.005125
K_4551 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.005097
K_4552 X_NUC_49.L_CORE X_NUC_65.L_CORE 0.002336
K_4553 X_NUC_49.L_CORE X_NUC_66.L_CORE 0.002341
K_4554 X_NUC_49.L_CORE X_NUC_67.L_CORE 0.002348
K_4555 X_NUC_49.L_CORE X_NUC_68.L_CORE 0.002323
K_4556 X_NUC_49.L_CORE X_NUC_69.L_CORE 0.006823
K_4557 X_NUC_49.L_CORE X_NUC_70.L_CORE 0.006685
K_4558 X_NUC_49.L_CORE X_NUC_71.L_CORE 0.006716
K_4559 X_NUC_49.L_CORE X_NUC_72.L_CORE 0.006609
K_4560 X_NUC_49.L_CORE X_NUC_73.L_CORE 0.002932
K_4561 X_NUC_49.L_CORE X_NUC_74.L_CORE 0.002962
K_4562 X_NUC_49.L_CORE X_NUC_75.L_CORE 0.002950
K_4563 X_NUC_49.L_CORE X_NUC_76.L_CORE 0.002925
K_4564 X_NUC_49.L_CORE X_NUC_77.L_CORE 0.002763
K_4565 X_NUC_49.L_CORE X_NUC_78.L_CORE 0.002755
K_4566 X_NUC_49.L_CORE X_NUC_79.L_CORE 0.002767
K_4567 X_NUC_49.L_CORE X_NUC_80.L_CORE 0.002734
K_4568 X_NUC_49.L_CORE X_NUC_81.L_CORE 0.006158
K_4569 X_NUC_49.L_CORE X_NUC_82.L_CORE 0.006237
K_4570 X_NUC_49.L_CORE X_NUC_83.L_CORE 0.006110
K_4571 X_NUC_49.L_CORE X_NUC_84.L_CORE 0.006062
K_4572 X_NUC_49.L_CORE X_NUC_85.L_CORE 0.002535
K_4573 X_NUC_49.L_CORE X_NUC_86.L_CORE 0.002547
K_4574 X_NUC_49.L_CORE X_NUC_87.L_CORE 0.002545
K_4575 X_NUC_49.L_CORE X_NUC_88.L_CORE 0.002519
K_4576 X_NUC_49.L_CORE X_NUC_89.L_CORE 0.003762
K_4577 X_NUC_49.L_CORE X_NUC_90.L_CORE 0.003743
K_4578 X_NUC_49.L_CORE X_NUC_91.L_CORE 0.003744
K_4579 X_NUC_49.L_CORE X_NUC_92.L_CORE 0.003698
K_4580 X_NUC_49.L_CORE X_NUC_93.L_CORE 0.003507
K_4581 X_NUC_49.L_CORE X_NUC_94.L_CORE 0.003537
K_4582 X_NUC_49.L_CORE X_NUC_95.L_CORE 0.003509
K_4583 X_NUC_49.L_CORE X_NUC_96.L_CORE 0.003478
K_4584 X_NUC_49.L_CORE X_NUC_97.L_CORE 0.002914
K_4585 X_NUC_49.L_CORE X_NUC_98.L_CORE 0.002919
K_4586 X_NUC_49.L_CORE X_NUC_99.L_CORE 0.002915
K_4587 X_NUC_49.L_CORE X_NUC_100.L_CORE 0.002883
K_4588 X_NUC_49.L_CORE X_NUC_101.L_CORE 0.002695
K_4589 X_NUC_49.L_CORE X_NUC_102.L_CORE 0.003310
K_4590 X_NUC_49.L_CORE X_NUC_103.L_CORE 0.003614
K_4591 X_NUC_49.L_CORE X_NUC_104.L_CORE 0.002320
K_4592 X_NUC_49.L_CORE X_NUC_105.L_CORE 0.006656
K_4593 X_NUC_49.L_CORE X_NUC_106.L_CORE 0.002560
K_4594 X_NUC_49.L_CORE X_NUC_107.L_CORE 0.002711
K_4595 X_NUC_49.L_CORE X_NUC_108.L_CORE 0.007240
K_4596 X_NUC_49.L_CORE X_NUC_109.L_CORE 0.002162
K_4597 X_NUC_49.L_CORE X_NUC_110.L_CORE 0.004762
K_4598 X_NUC_49.L_CORE X_NUC_111.L_CORE 0.003189
K_4599 X_NUC_49.L_CORE X_NUC_112.L_CORE 0.002310
K_4600 X_NUC_49.L_CORE X_NUC_113.L_CORE 0.012158
K_4601 X_NUC_49.L_CORE X_NUC_114.L_CORE 0.002354
K_4602 X_NUC_49.L_CORE X_NUC_115.L_CORE 0.003128
K_4603 X_NUC_49.L_CORE X_NUC_116.L_CORE 0.004161
K_4604 X_NUC_49.L_CORE X_NUC_117.L_CORE 0.002349
K_4605 X_NUC_49.L_CORE X_NUC_118.L_CORE 0.004057
K_4606 X_NUC_49.L_CORE X_NUC_119.L_CORE 0.002909
K_4607 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_4608 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_4609 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.002449
K_4610 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.002466
K_4611 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.002468
K_4612 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.002445
K_4613 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.003428
K_4614 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.003398
K_4615 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.003432
K_4616 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.003385
K_4617 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.004963
K_4618 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.005077
K_4619 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.005009
K_4620 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.004983
K_4621 X_NUC_50.L_CORE X_NUC_65.L_CORE 0.002332
K_4622 X_NUC_50.L_CORE X_NUC_66.L_CORE 0.002336
K_4623 X_NUC_50.L_CORE X_NUC_67.L_CORE 0.002344
K_4624 X_NUC_50.L_CORE X_NUC_68.L_CORE 0.002318
K_4625 X_NUC_50.L_CORE X_NUC_69.L_CORE 0.006962
K_4626 X_NUC_50.L_CORE X_NUC_70.L_CORE 0.006823
K_4627 X_NUC_50.L_CORE X_NUC_71.L_CORE 0.006852
K_4628 X_NUC_50.L_CORE X_NUC_72.L_CORE 0.006738
K_4629 X_NUC_50.L_CORE X_NUC_73.L_CORE 0.002902
K_4630 X_NUC_50.L_CORE X_NUC_74.L_CORE 0.002932
K_4631 X_NUC_50.L_CORE X_NUC_75.L_CORE 0.002920
K_4632 X_NUC_50.L_CORE X_NUC_76.L_CORE 0.002895
K_4633 X_NUC_50.L_CORE X_NUC_77.L_CORE 0.002771
K_4634 X_NUC_50.L_CORE X_NUC_78.L_CORE 0.002763
K_4635 X_NUC_50.L_CORE X_NUC_79.L_CORE 0.002775
K_4636 X_NUC_50.L_CORE X_NUC_80.L_CORE 0.002742
K_4637 X_NUC_50.L_CORE X_NUC_81.L_CORE 0.006077
K_4638 X_NUC_50.L_CORE X_NUC_82.L_CORE 0.006158
K_4639 X_NUC_50.L_CORE X_NUC_83.L_CORE 0.006033
K_4640 X_NUC_50.L_CORE X_NUC_84.L_CORE 0.005988
K_4641 X_NUC_50.L_CORE X_NUC_85.L_CORE 0.002524
K_4642 X_NUC_50.L_CORE X_NUC_86.L_CORE 0.002535
K_4643 X_NUC_50.L_CORE X_NUC_87.L_CORE 0.002534
K_4644 X_NUC_50.L_CORE X_NUC_88.L_CORE 0.002508
K_4645 X_NUC_50.L_CORE X_NUC_89.L_CORE 0.003780
K_4646 X_NUC_50.L_CORE X_NUC_90.L_CORE 0.003762
K_4647 X_NUC_50.L_CORE X_NUC_91.L_CORE 0.003763
K_4648 X_NUC_50.L_CORE X_NUC_92.L_CORE 0.003716
K_4649 X_NUC_50.L_CORE X_NUC_93.L_CORE 0.003477
K_4650 X_NUC_50.L_CORE X_NUC_94.L_CORE 0.003507
K_4651 X_NUC_50.L_CORE X_NUC_95.L_CORE 0.003480
K_4652 X_NUC_50.L_CORE X_NUC_96.L_CORE 0.003449
K_4653 X_NUC_50.L_CORE X_NUC_97.L_CORE 0.002909
K_4654 X_NUC_50.L_CORE X_NUC_98.L_CORE 0.002914
K_4655 X_NUC_50.L_CORE X_NUC_99.L_CORE 0.002910
K_4656 X_NUC_50.L_CORE X_NUC_100.L_CORE 0.002879
K_4657 X_NUC_50.L_CORE X_NUC_101.L_CORE 0.002685
K_4658 X_NUC_50.L_CORE X_NUC_102.L_CORE 0.003324
K_4659 X_NUC_50.L_CORE X_NUC_103.L_CORE 0.003573
K_4660 X_NUC_50.L_CORE X_NUC_104.L_CORE 0.002318
K_4661 X_NUC_50.L_CORE X_NUC_105.L_CORE 0.006750
K_4662 X_NUC_50.L_CORE X_NUC_106.L_CORE 0.002538
K_4663 X_NUC_50.L_CORE X_NUC_107.L_CORE 0.002725
K_4664 X_NUC_50.L_CORE X_NUC_108.L_CORE 0.007015
K_4665 X_NUC_50.L_CORE X_NUC_109.L_CORE 0.002154
K_4666 X_NUC_50.L_CORE X_NUC_110.L_CORE 0.004854
K_4667 X_NUC_50.L_CORE X_NUC_111.L_CORE 0.003145
K_4668 X_NUC_50.L_CORE X_NUC_112.L_CORE 0.002313
K_4669 X_NUC_50.L_CORE X_NUC_113.L_CORE 0.012198
K_4670 X_NUC_50.L_CORE X_NUC_114.L_CORE 0.002338
K_4671 X_NUC_50.L_CORE X_NUC_115.L_CORE 0.003151
K_4672 X_NUC_50.L_CORE X_NUC_116.L_CORE 0.004102
K_4673 X_NUC_50.L_CORE X_NUC_117.L_CORE 0.002344
K_4674 X_NUC_50.L_CORE X_NUC_118.L_CORE 0.004070
K_4675 X_NUC_50.L_CORE X_NUC_119.L_CORE 0.002893
K_4676 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_4677 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.002447
K_4678 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.002464
K_4679 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.002466
K_4680 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.002443
K_4681 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.003394
K_4682 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.003365
K_4683 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.003398
K_4684 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.003352
K_4685 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.005028
K_4686 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.005145
K_4687 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.005077
K_4688 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.005049
K_4689 X_NUC_51.L_CORE X_NUC_65.L_CORE 0.002324
K_4690 X_NUC_51.L_CORE X_NUC_66.L_CORE 0.002329
K_4691 X_NUC_51.L_CORE X_NUC_67.L_CORE 0.002336
K_4692 X_NUC_51.L_CORE X_NUC_68.L_CORE 0.002311
K_4693 X_NUC_51.L_CORE X_NUC_69.L_CORE 0.006927
K_4694 X_NUC_51.L_CORE X_NUC_70.L_CORE 0.006786
K_4695 X_NUC_51.L_CORE X_NUC_71.L_CORE 0.006823
K_4696 X_NUC_51.L_CORE X_NUC_72.L_CORE 0.006707
K_4697 X_NUC_51.L_CORE X_NUC_73.L_CORE 0.002913
K_4698 X_NUC_51.L_CORE X_NUC_74.L_CORE 0.002942
K_4699 X_NUC_51.L_CORE X_NUC_75.L_CORE 0.002932
K_4700 X_NUC_51.L_CORE X_NUC_76.L_CORE 0.002906
K_4701 X_NUC_51.L_CORE X_NUC_77.L_CORE 0.002759
K_4702 X_NUC_51.L_CORE X_NUC_78.L_CORE 0.002751
K_4703 X_NUC_51.L_CORE X_NUC_79.L_CORE 0.002763
K_4704 X_NUC_51.L_CORE X_NUC_80.L_CORE 0.002730
K_4705 X_NUC_51.L_CORE X_NUC_81.L_CORE 0.006202
K_4706 X_NUC_51.L_CORE X_NUC_82.L_CORE 0.006285
K_4707 X_NUC_51.L_CORE X_NUC_83.L_CORE 0.006158
K_4708 X_NUC_51.L_CORE X_NUC_84.L_CORE 0.006107
K_4709 X_NUC_51.L_CORE X_NUC_85.L_CORE 0.002525
K_4710 X_NUC_51.L_CORE X_NUC_86.L_CORE 0.002537
K_4711 X_NUC_51.L_CORE X_NUC_87.L_CORE 0.002535
K_4712 X_NUC_51.L_CORE X_NUC_88.L_CORE 0.002510
K_4713 X_NUC_51.L_CORE X_NUC_89.L_CORE 0.003778
K_4714 X_NUC_51.L_CORE X_NUC_90.L_CORE 0.003759
K_4715 X_NUC_51.L_CORE X_NUC_91.L_CORE 0.003762
K_4716 X_NUC_51.L_CORE X_NUC_92.L_CORE 0.003714
K_4717 X_NUC_51.L_CORE X_NUC_93.L_CORE 0.003504
K_4718 X_NUC_51.L_CORE X_NUC_94.L_CORE 0.003534
K_4719 X_NUC_51.L_CORE X_NUC_95.L_CORE 0.003507
K_4720 X_NUC_51.L_CORE X_NUC_96.L_CORE 0.003475
K_4721 X_NUC_51.L_CORE X_NUC_97.L_CORE 0.002913
K_4722 X_NUC_51.L_CORE X_NUC_98.L_CORE 0.002918
K_4723 X_NUC_51.L_CORE X_NUC_99.L_CORE 0.002914
K_4724 X_NUC_51.L_CORE X_NUC_100.L_CORE 0.002883
K_4725 X_NUC_51.L_CORE X_NUC_101.L_CORE 0.002663
K_4726 X_NUC_51.L_CORE X_NUC_102.L_CORE 0.003274
K_4727 X_NUC_51.L_CORE X_NUC_103.L_CORE 0.003554
K_4728 X_NUC_51.L_CORE X_NUC_104.L_CORE 0.002300
K_4729 X_NUC_51.L_CORE X_NUC_105.L_CORE 0.006547
K_4730 X_NUC_51.L_CORE X_NUC_106.L_CORE 0.002533
K_4731 X_NUC_51.L_CORE X_NUC_107.L_CORE 0.002697
K_4732 X_NUC_51.L_CORE X_NUC_108.L_CORE 0.007079
K_4733 X_NUC_51.L_CORE X_NUC_109.L_CORE 0.002146
K_4734 X_NUC_51.L_CORE X_NUC_110.L_CORE 0.004777
K_4735 X_NUC_51.L_CORE X_NUC_111.L_CORE 0.003160
K_4736 X_NUC_51.L_CORE X_NUC_112.L_CORE 0.002301
K_4737 X_NUC_51.L_CORE X_NUC_113.L_CORE 0.012776
K_4738 X_NUC_51.L_CORE X_NUC_114.L_CORE 0.002340
K_4739 X_NUC_51.L_CORE X_NUC_115.L_CORE 0.003135
K_4740 X_NUC_51.L_CORE X_NUC_116.L_CORE 0.004160
K_4741 X_NUC_51.L_CORE X_NUC_117.L_CORE 0.002343
K_4742 X_NUC_51.L_CORE X_NUC_118.L_CORE 0.004092
K_4743 X_NUC_51.L_CORE X_NUC_119.L_CORE 0.002908
K_4744 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.002470
K_4745 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.002487
K_4746 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.002490
K_4747 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.002466
K_4748 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.003441
K_4749 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.003411
K_4750 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.003445
K_4751 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.003398
K_4752 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.005054
K_4753 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.005173
K_4754 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.005103
K_4755 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.005077
K_4756 X_NUC_52.L_CORE X_NUC_65.L_CORE 0.002350
K_4757 X_NUC_52.L_CORE X_NUC_66.L_CORE 0.002354
K_4758 X_NUC_52.L_CORE X_NUC_67.L_CORE 0.002362
K_4759 X_NUC_52.L_CORE X_NUC_68.L_CORE 0.002336
K_4760 X_NUC_52.L_CORE X_NUC_69.L_CORE 0.007051
K_4761 X_NUC_52.L_CORE X_NUC_70.L_CORE 0.006902
K_4762 X_NUC_52.L_CORE X_NUC_71.L_CORE 0.006937
K_4763 X_NUC_52.L_CORE X_NUC_72.L_CORE 0.006823
K_4764 X_NUC_52.L_CORE X_NUC_73.L_CORE 0.002938
K_4765 X_NUC_52.L_CORE X_NUC_74.L_CORE 0.002969
K_4766 X_NUC_52.L_CORE X_NUC_75.L_CORE 0.002957
K_4767 X_NUC_52.L_CORE X_NUC_76.L_CORE 0.002932
K_4768 X_NUC_52.L_CORE X_NUC_77.L_CORE 0.002793
K_4769 X_NUC_52.L_CORE X_NUC_78.L_CORE 0.002785
K_4770 X_NUC_52.L_CORE X_NUC_79.L_CORE 0.002797
K_4771 X_NUC_52.L_CORE X_NUC_80.L_CORE 0.002763
K_4772 X_NUC_52.L_CORE X_NUC_81.L_CORE 0.006253
K_4773 X_NUC_52.L_CORE X_NUC_82.L_CORE 0.006338
K_4774 X_NUC_52.L_CORE X_NUC_83.L_CORE 0.006205
K_4775 X_NUC_52.L_CORE X_NUC_84.L_CORE 0.006158
K_4776 X_NUC_52.L_CORE X_NUC_85.L_CORE 0.002551
K_4777 X_NUC_52.L_CORE X_NUC_86.L_CORE 0.002563
K_4778 X_NUC_52.L_CORE X_NUC_87.L_CORE 0.002561
K_4779 X_NUC_52.L_CORE X_NUC_88.L_CORE 0.002535
K_4780 X_NUC_52.L_CORE X_NUC_89.L_CORE 0.003827
K_4781 X_NUC_52.L_CORE X_NUC_90.L_CORE 0.003808
K_4782 X_NUC_52.L_CORE X_NUC_91.L_CORE 0.003810
K_4783 X_NUC_52.L_CORE X_NUC_92.L_CORE 0.003762
K_4784 X_NUC_52.L_CORE X_NUC_93.L_CORE 0.003536
K_4785 X_NUC_52.L_CORE X_NUC_94.L_CORE 0.003567
K_4786 X_NUC_52.L_CORE X_NUC_95.L_CORE 0.003539
K_4787 X_NUC_52.L_CORE X_NUC_96.L_CORE 0.003507
K_4788 X_NUC_52.L_CORE X_NUC_97.L_CORE 0.002946
K_4789 X_NUC_52.L_CORE X_NUC_98.L_CORE 0.002951
K_4790 X_NUC_52.L_CORE X_NUC_99.L_CORE 0.002947
K_4791 X_NUC_52.L_CORE X_NUC_100.L_CORE 0.002914
K_4792 X_NUC_52.L_CORE X_NUC_101.L_CORE 0.002687
K_4793 X_NUC_52.L_CORE X_NUC_102.L_CORE 0.003309
K_4794 X_NUC_52.L_CORE X_NUC_103.L_CORE 0.003576
K_4795 X_NUC_52.L_CORE X_NUC_104.L_CORE 0.002324
K_4796 X_NUC_52.L_CORE X_NUC_105.L_CORE 0.006598
K_4797 X_NUC_52.L_CORE X_NUC_106.L_CORE 0.002554
K_4798 X_NUC_52.L_CORE X_NUC_107.L_CORE 0.002728
K_4799 X_NUC_52.L_CORE X_NUC_108.L_CORE 0.007043
K_4800 X_NUC_52.L_CORE X_NUC_109.L_CORE 0.002167
K_4801 X_NUC_52.L_CORE X_NUC_110.L_CORE 0.004838
K_4802 X_NUC_52.L_CORE X_NUC_111.L_CORE 0.003179
K_4803 X_NUC_52.L_CORE X_NUC_112.L_CORE 0.002327
K_4804 X_NUC_52.L_CORE X_NUC_113.L_CORE 0.012606
K_4805 X_NUC_52.L_CORE X_NUC_114.L_CORE 0.002361
K_4806 X_NUC_52.L_CORE X_NUC_115.L_CORE 0.003172
K_4807 X_NUC_52.L_CORE X_NUC_116.L_CORE 0.004180
K_4808 X_NUC_52.L_CORE X_NUC_117.L_CORE 0.002366
K_4809 X_NUC_52.L_CORE X_NUC_118.L_CORE 0.004132
K_4810 X_NUC_52.L_CORE X_NUC_119.L_CORE 0.002933
K_4811 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_4812 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_4813 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_4814 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.002482
K_4815 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.002453
K_4816 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.002464
K_4817 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.002470
K_4818 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.003431
K_4819 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.003420
K_4820 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.003394
K_4821 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.003449
K_4822 X_NUC_53.L_CORE X_NUC_65.L_CORE 0.005137
K_4823 X_NUC_53.L_CORE X_NUC_66.L_CORE 0.005031
K_4824 X_NUC_53.L_CORE X_NUC_67.L_CORE 0.005087
K_4825 X_NUC_53.L_CORE X_NUC_68.L_CORE 0.005032
K_4826 X_NUC_53.L_CORE X_NUC_69.L_CORE 0.002377
K_4827 X_NUC_53.L_CORE X_NUC_70.L_CORE 0.002356
K_4828 X_NUC_53.L_CORE X_NUC_71.L_CORE 0.002355
K_4829 X_NUC_53.L_CORE X_NUC_72.L_CORE 0.002371
K_4830 X_NUC_53.L_CORE X_NUC_73.L_CORE 0.006867
K_4831 X_NUC_53.L_CORE X_NUC_74.L_CORE 0.006876
K_4832 X_NUC_53.L_CORE X_NUC_75.L_CORE 0.006690
K_4833 X_NUC_53.L_CORE X_NUC_76.L_CORE 0.006864
K_4834 X_NUC_53.L_CORE X_NUC_77.L_CORE 0.003004
K_4835 X_NUC_53.L_CORE X_NUC_78.L_CORE 0.002963
K_4836 X_NUC_53.L_CORE X_NUC_79.L_CORE 0.002974
K_4837 X_NUC_53.L_CORE X_NUC_80.L_CORE 0.002973
K_4838 X_NUC_53.L_CORE X_NUC_81.L_CORE 0.002847
K_4839 X_NUC_53.L_CORE X_NUC_82.L_CORE 0.002828
K_4840 X_NUC_53.L_CORE X_NUC_83.L_CORE 0.002813
K_4841 X_NUC_53.L_CORE X_NUC_84.L_CORE 0.002844
K_4842 X_NUC_53.L_CORE X_NUC_85.L_CORE 0.006005
K_4843 X_NUC_53.L_CORE X_NUC_86.L_CORE 0.005910
K_4844 X_NUC_53.L_CORE X_NUC_87.L_CORE 0.005859
K_4845 X_NUC_53.L_CORE X_NUC_88.L_CORE 0.005856
K_4846 X_NUC_53.L_CORE X_NUC_89.L_CORE 0.002662
K_4847 X_NUC_53.L_CORE X_NUC_90.L_CORE 0.002634
K_4848 X_NUC_53.L_CORE X_NUC_91.L_CORE 0.002632
K_4849 X_NUC_53.L_CORE X_NUC_92.L_CORE 0.002644
K_4850 X_NUC_53.L_CORE X_NUC_93.L_CORE 0.003805
K_4851 X_NUC_53.L_CORE X_NUC_94.L_CORE 0.003779
K_4852 X_NUC_53.L_CORE X_NUC_95.L_CORE 0.003738
K_4853 X_NUC_53.L_CORE X_NUC_96.L_CORE 0.003782
K_4854 X_NUC_53.L_CORE X_NUC_97.L_CORE 0.003545
K_4855 X_NUC_53.L_CORE X_NUC_98.L_CORE 0.003503
K_4856 X_NUC_53.L_CORE X_NUC_99.L_CORE 0.003489
K_4857 X_NUC_53.L_CORE X_NUC_100.L_CORE 0.003501
K_4858 X_NUC_53.L_CORE X_NUC_101.L_CORE 0.003465
K_4859 X_NUC_53.L_CORE X_NUC_102.L_CORE 0.002444
K_4860 X_NUC_53.L_CORE X_NUC_103.L_CORE 0.003276
K_4861 X_NUC_53.L_CORE X_NUC_104.L_CORE 0.003547
K_4862 X_NUC_53.L_CORE X_NUC_105.L_CORE 0.002240
K_4863 X_NUC_53.L_CORE X_NUC_106.L_CORE 0.007021
K_4864 X_NUC_53.L_CORE X_NUC_107.L_CORE 0.002497
K_4865 X_NUC_53.L_CORE X_NUC_108.L_CORE 0.002687
K_4866 X_NUC_53.L_CORE X_NUC_109.L_CORE 0.007112
K_4867 X_NUC_53.L_CORE X_NUC_110.L_CORE 0.002146
K_4868 X_NUC_53.L_CORE X_NUC_111.L_CORE 0.004838
K_4869 X_NUC_53.L_CORE X_NUC_112.L_CORE 0.003169
K_4870 X_NUC_53.L_CORE X_NUC_113.L_CORE 0.002337
K_4871 X_NUC_53.L_CORE X_NUC_114.L_CORE 0.011230
K_4872 X_NUC_53.L_CORE X_NUC_115.L_CORE 0.002395
K_4873 X_NUC_53.L_CORE X_NUC_116.L_CORE 0.003210
K_4874 X_NUC_53.L_CORE X_NUC_117.L_CORE 0.004092
K_4875 X_NUC_53.L_CORE X_NUC_118.L_CORE 0.002492
K_4876 X_NUC_53.L_CORE X_NUC_119.L_CORE 0.003702
K_4877 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_4878 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_4879 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.002511
K_4880 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.002482
K_4881 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.002493
K_4882 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.002499
K_4883 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.003441
K_4884 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.003431
K_4885 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.003404
K_4886 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.003459
K_4887 X_NUC_54.L_CORE X_NUC_65.L_CORE 0.005247
K_4888 X_NUC_54.L_CORE X_NUC_66.L_CORE 0.005137
K_4889 X_NUC_54.L_CORE X_NUC_67.L_CORE 0.005195
K_4890 X_NUC_54.L_CORE X_NUC_68.L_CORE 0.005137
K_4891 X_NUC_54.L_CORE X_NUC_69.L_CORE 0.002398
K_4892 X_NUC_54.L_CORE X_NUC_70.L_CORE 0.002377
K_4893 X_NUC_54.L_CORE X_NUC_71.L_CORE 0.002376
K_4894 X_NUC_54.L_CORE X_NUC_72.L_CORE 0.002393
K_4895 X_NUC_54.L_CORE X_NUC_73.L_CORE 0.006850
K_4896 X_NUC_54.L_CORE X_NUC_74.L_CORE 0.006867
K_4897 X_NUC_54.L_CORE X_NUC_75.L_CORE 0.006678
K_4898 X_NUC_54.L_CORE X_NUC_76.L_CORE 0.006852
K_4899 X_NUC_54.L_CORE X_NUC_77.L_CORE 0.003045
K_4900 X_NUC_54.L_CORE X_NUC_78.L_CORE 0.003004
K_4901 X_NUC_54.L_CORE X_NUC_79.L_CORE 0.003015
K_4902 X_NUC_54.L_CORE X_NUC_80.L_CORE 0.003014
K_4903 X_NUC_54.L_CORE X_NUC_81.L_CORE 0.002865
K_4904 X_NUC_54.L_CORE X_NUC_82.L_CORE 0.002847
K_4905 X_NUC_54.L_CORE X_NUC_83.L_CORE 0.002831
K_4906 X_NUC_54.L_CORE X_NUC_84.L_CORE 0.002862
K_4907 X_NUC_54.L_CORE X_NUC_85.L_CORE 0.006099
K_4908 X_NUC_54.L_CORE X_NUC_86.L_CORE 0.006005
K_4909 X_NUC_54.L_CORE X_NUC_87.L_CORE 0.005950
K_4910 X_NUC_54.L_CORE X_NUC_88.L_CORE 0.005946
K_4911 X_NUC_54.L_CORE X_NUC_89.L_CORE 0.002691
K_4912 X_NUC_54.L_CORE X_NUC_90.L_CORE 0.002662
K_4913 X_NUC_54.L_CORE X_NUC_91.L_CORE 0.002660
K_4914 X_NUC_54.L_CORE X_NUC_92.L_CORE 0.002672
K_4915 X_NUC_54.L_CORE X_NUC_93.L_CORE 0.003830
K_4916 X_NUC_54.L_CORE X_NUC_94.L_CORE 0.003805
K_4917 X_NUC_54.L_CORE X_NUC_95.L_CORE 0.003762
K_4918 X_NUC_54.L_CORE X_NUC_96.L_CORE 0.003807
K_4919 X_NUC_54.L_CORE X_NUC_97.L_CORE 0.003588
K_4920 X_NUC_54.L_CORE X_NUC_98.L_CORE 0.003545
K_4921 X_NUC_54.L_CORE X_NUC_99.L_CORE 0.003531
K_4922 X_NUC_54.L_CORE X_NUC_100.L_CORE 0.003543
K_4923 X_NUC_54.L_CORE X_NUC_101.L_CORE 0.003491
K_4924 X_NUC_54.L_CORE X_NUC_102.L_CORE 0.002467
K_4925 X_NUC_54.L_CORE X_NUC_103.L_CORE 0.003285
K_4926 X_NUC_54.L_CORE X_NUC_104.L_CORE 0.003592
K_4927 X_NUC_54.L_CORE X_NUC_105.L_CORE 0.002257
K_4928 X_NUC_54.L_CORE X_NUC_106.L_CORE 0.006960
K_4929 X_NUC_54.L_CORE X_NUC_107.L_CORE 0.002526
K_4930 X_NUC_54.L_CORE X_NUC_108.L_CORE 0.002697
K_4931 X_NUC_54.L_CORE X_NUC_109.L_CORE 0.007252
K_4932 X_NUC_54.L_CORE X_NUC_110.L_CORE 0.002166
K_4933 X_NUC_54.L_CORE X_NUC_111.L_CORE 0.004811
K_4934 X_NUC_54.L_CORE X_NUC_112.L_CORE 0.003216
K_4935 X_NUC_54.L_CORE X_NUC_113.L_CORE 0.002352
K_4936 X_NUC_54.L_CORE X_NUC_114.L_CORE 0.011183
K_4937 X_NUC_54.L_CORE X_NUC_115.L_CORE 0.002421
K_4938 X_NUC_54.L_CORE X_NUC_116.L_CORE 0.003220
K_4939 X_NUC_54.L_CORE X_NUC_117.L_CORE 0.004149
K_4940 X_NUC_54.L_CORE X_NUC_118.L_CORE 0.002514
K_4941 X_NUC_54.L_CORE X_NUC_119.L_CORE 0.003727
K_4942 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_4943 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.002500
K_4944 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.002471
K_4945 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.002482
K_4946 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.002488
K_4947 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.003469
K_4948 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.003458
K_4949 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.003431
K_4950 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.003487
K_4951 X_NUC_55.L_CORE X_NUC_65.L_CORE 0.005185
K_4952 X_NUC_55.L_CORE X_NUC_66.L_CORE 0.005078
K_4953 X_NUC_55.L_CORE X_NUC_67.L_CORE 0.005137
K_4954 X_NUC_55.L_CORE X_NUC_68.L_CORE 0.005079
K_4955 X_NUC_55.L_CORE X_NUC_69.L_CORE 0.002399
K_4956 X_NUC_55.L_CORE X_NUC_70.L_CORE 0.002377
K_4957 X_NUC_55.L_CORE X_NUC_71.L_CORE 0.002377
K_4958 X_NUC_55.L_CORE X_NUC_72.L_CORE 0.002393
K_4959 X_NUC_55.L_CORE X_NUC_73.L_CORE 0.007050
K_4960 X_NUC_55.L_CORE X_NUC_74.L_CORE 0.007064
K_4961 X_NUC_55.L_CORE X_NUC_75.L_CORE 0.006867
K_4962 X_NUC_55.L_CORE X_NUC_76.L_CORE 0.007052
K_4963 X_NUC_55.L_CORE X_NUC_77.L_CORE 0.003034
K_4964 X_NUC_55.L_CORE X_NUC_78.L_CORE 0.002992
K_4965 X_NUC_55.L_CORE X_NUC_79.L_CORE 0.003004
K_4966 X_NUC_55.L_CORE X_NUC_80.L_CORE 0.003003
K_4967 X_NUC_55.L_CORE X_NUC_81.L_CORE 0.002882
K_4968 X_NUC_55.L_CORE X_NUC_82.L_CORE 0.002863
K_4969 X_NUC_55.L_CORE X_NUC_83.L_CORE 0.002847
K_4970 X_NUC_55.L_CORE X_NUC_84.L_CORE 0.002879
K_4971 X_NUC_55.L_CORE X_NUC_85.L_CORE 0.006156
K_4972 X_NUC_55.L_CORE X_NUC_86.L_CORE 0.006056
K_4973 X_NUC_55.L_CORE X_NUC_87.L_CORE 0.006005
K_4974 X_NUC_55.L_CORE X_NUC_88.L_CORE 0.005999
K_4975 X_NUC_55.L_CORE X_NUC_89.L_CORE 0.002693
K_4976 X_NUC_55.L_CORE X_NUC_90.L_CORE 0.002664
K_4977 X_NUC_55.L_CORE X_NUC_91.L_CORE 0.002662
K_4978 X_NUC_55.L_CORE X_NUC_92.L_CORE 0.002675
K_4979 X_NUC_55.L_CORE X_NUC_93.L_CORE 0.003874
K_4980 X_NUC_55.L_CORE X_NUC_94.L_CORE 0.003847
K_4981 X_NUC_55.L_CORE X_NUC_95.L_CORE 0.003805
K_4982 X_NUC_55.L_CORE X_NUC_96.L_CORE 0.003850
K_4983 X_NUC_55.L_CORE X_NUC_97.L_CORE 0.003602
K_4984 X_NUC_55.L_CORE X_NUC_98.L_CORE 0.003558
K_4985 X_NUC_55.L_CORE X_NUC_99.L_CORE 0.003545
K_4986 X_NUC_55.L_CORE X_NUC_100.L_CORE 0.003557
K_4987 X_NUC_55.L_CORE X_NUC_101.L_CORE 0.003448
K_4988 X_NUC_55.L_CORE X_NUC_102.L_CORE 0.002449
K_4989 X_NUC_55.L_CORE X_NUC_103.L_CORE 0.003275
K_4990 X_NUC_55.L_CORE X_NUC_104.L_CORE 0.003535
K_4991 X_NUC_55.L_CORE X_NUC_105.L_CORE 0.002251
K_4992 X_NUC_55.L_CORE X_NUC_106.L_CORE 0.006906
K_4993 X_NUC_55.L_CORE X_NUC_107.L_CORE 0.002506
K_4994 X_NUC_55.L_CORE X_NUC_108.L_CORE 0.002704
K_4995 X_NUC_55.L_CORE X_NUC_109.L_CORE 0.007035
K_4996 X_NUC_55.L_CORE X_NUC_110.L_CORE 0.002161
K_4997 X_NUC_55.L_CORE X_NUC_111.L_CORE 0.004883
K_4998 X_NUC_55.L_CORE X_NUC_112.L_CORE 0.003188
K_4999 X_NUC_55.L_CORE X_NUC_113.L_CORE 0.002358
K_5000 X_NUC_55.L_CORE X_NUC_114.L_CORE 0.011631
K_5001 X_NUC_55.L_CORE X_NUC_115.L_CORE 0.002416
K_5002 X_NUC_55.L_CORE X_NUC_116.L_CORE 0.003253
K_5003 X_NUC_55.L_CORE X_NUC_117.L_CORE 0.004151
K_5004 X_NUC_55.L_CORE X_NUC_118.L_CORE 0.002521
K_5005 X_NUC_55.L_CORE X_NUC_119.L_CORE 0.003768
K_5006 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.002494
K_5007 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.002466
K_5008 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.002476
K_5009 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.002482
K_5010 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.003413
K_5011 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.003403
K_5012 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.003377
K_5013 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.003431
K_5014 X_NUC_56.L_CORE X_NUC_65.L_CORE 0.005246
K_5015 X_NUC_56.L_CORE X_NUC_66.L_CORE 0.005135
K_5016 X_NUC_56.L_CORE X_NUC_67.L_CORE 0.005194
K_5017 X_NUC_56.L_CORE X_NUC_68.L_CORE 0.005137
K_5018 X_NUC_56.L_CORE X_NUC_69.L_CORE 0.002382
K_5019 X_NUC_56.L_CORE X_NUC_70.L_CORE 0.002361
K_5020 X_NUC_56.L_CORE X_NUC_71.L_CORE 0.002361
K_5021 X_NUC_56.L_CORE X_NUC_72.L_CORE 0.002377
K_5022 X_NUC_56.L_CORE X_NUC_73.L_CORE 0.006862
K_5023 X_NUC_56.L_CORE X_NUC_74.L_CORE 0.006875
K_5024 X_NUC_56.L_CORE X_NUC_75.L_CORE 0.006689
K_5025 X_NUC_56.L_CORE X_NUC_76.L_CORE 0.006867
K_5026 X_NUC_56.L_CORE X_NUC_77.L_CORE 0.003034
K_5027 X_NUC_56.L_CORE X_NUC_78.L_CORE 0.002993
K_5028 X_NUC_56.L_CORE X_NUC_79.L_CORE 0.003004
K_5029 X_NUC_56.L_CORE X_NUC_80.L_CORE 0.003004
K_5030 X_NUC_56.L_CORE X_NUC_81.L_CORE 0.002850
K_5031 X_NUC_56.L_CORE X_NUC_82.L_CORE 0.002831
K_5032 X_NUC_56.L_CORE X_NUC_83.L_CORE 0.002816
K_5033 X_NUC_56.L_CORE X_NUC_84.L_CORE 0.002847
K_5034 X_NUC_56.L_CORE X_NUC_85.L_CORE 0.006160
K_5035 X_NUC_56.L_CORE X_NUC_86.L_CORE 0.006060
K_5036 X_NUC_56.L_CORE X_NUC_87.L_CORE 0.006006
K_5037 X_NUC_56.L_CORE X_NUC_88.L_CORE 0.006005
K_5038 X_NUC_56.L_CORE X_NUC_89.L_CORE 0.002680
K_5039 X_NUC_56.L_CORE X_NUC_90.L_CORE 0.002652
K_5040 X_NUC_56.L_CORE X_NUC_91.L_CORE 0.002649
K_5041 X_NUC_56.L_CORE X_NUC_92.L_CORE 0.002662
K_5042 X_NUC_56.L_CORE X_NUC_93.L_CORE 0.003827
K_5043 X_NUC_56.L_CORE X_NUC_94.L_CORE 0.003801
K_5044 X_NUC_56.L_CORE X_NUC_95.L_CORE 0.003759
K_5045 X_NUC_56.L_CORE X_NUC_96.L_CORE 0.003805
K_5046 X_NUC_56.L_CORE X_NUC_97.L_CORE 0.003589
K_5047 X_NUC_56.L_CORE X_NUC_98.L_CORE 0.003546
K_5048 X_NUC_56.L_CORE X_NUC_99.L_CORE 0.003532
K_5049 X_NUC_56.L_CORE X_NUC_100.L_CORE 0.003545
K_5050 X_NUC_56.L_CORE X_NUC_101.L_CORE 0.003436
K_5051 X_NUC_56.L_CORE X_NUC_102.L_CORE 0.002440
K_5052 X_NUC_56.L_CORE X_NUC_103.L_CORE 0.003238
K_5053 X_NUC_56.L_CORE X_NUC_104.L_CORE 0.003550
K_5054 X_NUC_56.L_CORE X_NUC_105.L_CORE 0.002235
K_5055 X_NUC_56.L_CORE X_NUC_106.L_CORE 0.006801
K_5056 X_NUC_56.L_CORE X_NUC_107.L_CORE 0.002506
K_5057 X_NUC_56.L_CORE X_NUC_108.L_CORE 0.002671
K_5058 X_NUC_56.L_CORE X_NUC_109.L_CORE 0.007221
K_5059 X_NUC_56.L_CORE X_NUC_110.L_CORE 0.002151
K_5060 X_NUC_56.L_CORE X_NUC_111.L_CORE 0.004774
K_5061 X_NUC_56.L_CORE X_NUC_112.L_CORE 0.003204
K_5062 X_NUC_56.L_CORE X_NUC_113.L_CORE 0.002337
K_5063 X_NUC_56.L_CORE X_NUC_114.L_CORE 0.011665
K_5064 X_NUC_56.L_CORE X_NUC_115.L_CORE 0.002411
K_5065 X_NUC_56.L_CORE X_NUC_116.L_CORE 0.003209
K_5066 X_NUC_56.L_CORE X_NUC_117.L_CORE 0.004169
K_5067 X_NUC_56.L_CORE X_NUC_118.L_CORE 0.002505
K_5068 X_NUC_56.L_CORE X_NUC_119.L_CORE 0.003738
K_5069 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.207973
K_5070 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.207973
K_5071 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.207973
K_5072 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.002515
K_5073 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.002541
K_5074 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.002519
K_5075 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.002535
K_5076 X_NUC_57.L_CORE X_NUC_65.L_CORE 0.003488
K_5077 X_NUC_57.L_CORE X_NUC_66.L_CORE 0.003536
K_5078 X_NUC_57.L_CORE X_NUC_67.L_CORE 0.003524
K_5079 X_NUC_57.L_CORE X_NUC_68.L_CORE 0.003489
K_5080 X_NUC_57.L_CORE X_NUC_69.L_CORE 0.005231
K_5081 X_NUC_57.L_CORE X_NUC_70.L_CORE 0.005275
K_5082 X_NUC_57.L_CORE X_NUC_71.L_CORE 0.005169
K_5083 X_NUC_57.L_CORE X_NUC_72.L_CORE 0.005287
K_5084 X_NUC_57.L_CORE X_NUC_73.L_CORE 0.002437
K_5085 X_NUC_57.L_CORE X_NUC_74.L_CORE 0.002466
K_5086 X_NUC_57.L_CORE X_NUC_75.L_CORE 0.002447
K_5087 X_NUC_57.L_CORE X_NUC_76.L_CORE 0.002449
K_5088 X_NUC_57.L_CORE X_NUC_77.L_CORE 0.006920
K_5089 X_NUC_57.L_CORE X_NUC_78.L_CORE 0.007044
K_5090 X_NUC_57.L_CORE X_NUC_79.L_CORE 0.006948
K_5091 X_NUC_57.L_CORE X_NUC_80.L_CORE 0.006815
K_5092 X_NUC_57.L_CORE X_NUC_81.L_CORE 0.003105
K_5093 X_NUC_57.L_CORE X_NUC_82.L_CORE 0.003138
K_5094 X_NUC_57.L_CORE X_NUC_83.L_CORE 0.003096
K_5095 X_NUC_57.L_CORE X_NUC_84.L_CORE 0.003125
K_5096 X_NUC_57.L_CORE X_NUC_85.L_CORE 0.002965
K_5097 X_NUC_57.L_CORE X_NUC_86.L_CORE 0.003003
K_5098 X_NUC_57.L_CORE X_NUC_87.L_CORE 0.002978
K_5099 X_NUC_57.L_CORE X_NUC_88.L_CORE 0.002967
K_5100 X_NUC_57.L_CORE X_NUC_89.L_CORE 0.005782
K_5101 X_NUC_57.L_CORE X_NUC_90.L_CORE 0.005858
K_5102 X_NUC_57.L_CORE X_NUC_91.L_CORE 0.005700
K_5103 X_NUC_57.L_CORE X_NUC_92.L_CORE 0.005754
K_5104 X_NUC_57.L_CORE X_NUC_93.L_CORE 0.002857
K_5105 X_NUC_57.L_CORE X_NUC_94.L_CORE 0.002891
K_5106 X_NUC_57.L_CORE X_NUC_95.L_CORE 0.002856
K_5107 X_NUC_57.L_CORE X_NUC_96.L_CORE 0.002866
K_5108 X_NUC_57.L_CORE X_NUC_97.L_CORE 0.003804
K_5109 X_NUC_57.L_CORE X_NUC_98.L_CORE 0.003856
K_5110 X_NUC_57.L_CORE X_NUC_99.L_CORE 0.003799
K_5111 X_NUC_57.L_CORE X_NUC_100.L_CORE 0.003794
K_5112 X_NUC_57.L_CORE X_NUC_101.L_CORE 0.002646
K_5113 X_NUC_57.L_CORE X_NUC_102.L_CORE 0.003887
K_5114 X_NUC_57.L_CORE X_NUC_103.L_CORE 0.002345
K_5115 X_NUC_57.L_CORE X_NUC_104.L_CORE 0.003268
K_5116 X_NUC_57.L_CORE X_NUC_105.L_CORE 0.003565
K_5117 X_NUC_57.L_CORE X_NUC_106.L_CORE 0.002218
K_5118 X_NUC_57.L_CORE X_NUC_107.L_CORE 0.007258
K_5119 X_NUC_57.L_CORE X_NUC_108.L_CORE 0.002507
K_5120 X_NUC_57.L_CORE X_NUC_109.L_CORE 0.002705
K_5121 X_NUC_57.L_CORE X_NUC_110.L_CORE 0.007259
K_5122 X_NUC_57.L_CORE X_NUC_111.L_CORE 0.002185
K_5123 X_NUC_57.L_CORE X_NUC_112.L_CORE 0.004908
K_5124 X_NUC_57.L_CORE X_NUC_113.L_CORE 0.003259
K_5125 X_NUC_57.L_CORE X_NUC_114.L_CORE 0.002415
K_5126 X_NUC_57.L_CORE X_NUC_115.L_CORE 0.010250
K_5127 X_NUC_57.L_CORE X_NUC_116.L_CORE 0.002516
K_5128 X_NUC_57.L_CORE X_NUC_117.L_CORE 0.003344
K_5129 X_NUC_57.L_CORE X_NUC_118.L_CORE 0.004099
K_5130 X_NUC_57.L_CORE X_NUC_119.L_CORE 0.002822
K_5131 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.207973
K_5132 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.207973
K_5133 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.002489
K_5134 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.002515
K_5135 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.002493
K_5136 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.002509
K_5137 X_NUC_58.L_CORE X_NUC_65.L_CORE 0.003442
K_5138 X_NUC_58.L_CORE X_NUC_66.L_CORE 0.003488
K_5139 X_NUC_58.L_CORE X_NUC_67.L_CORE 0.003477
K_5140 X_NUC_58.L_CORE X_NUC_68.L_CORE 0.003443
K_5141 X_NUC_58.L_CORE X_NUC_69.L_CORE 0.005186
K_5142 X_NUC_58.L_CORE X_NUC_70.L_CORE 0.005231
K_5143 X_NUC_58.L_CORE X_NUC_71.L_CORE 0.005126
K_5144 X_NUC_58.L_CORE X_NUC_72.L_CORE 0.005241
K_5145 X_NUC_58.L_CORE X_NUC_73.L_CORE 0.002410
K_5146 X_NUC_58.L_CORE X_NUC_74.L_CORE 0.002437
K_5147 X_NUC_58.L_CORE X_NUC_75.L_CORE 0.002419
K_5148 X_NUC_58.L_CORE X_NUC_76.L_CORE 0.002421
K_5149 X_NUC_58.L_CORE X_NUC_77.L_CORE 0.006794
K_5150 X_NUC_58.L_CORE X_NUC_78.L_CORE 0.006920
K_5151 X_NUC_58.L_CORE X_NUC_79.L_CORE 0.006825
K_5152 X_NUC_58.L_CORE X_NUC_80.L_CORE 0.006699
K_5153 X_NUC_58.L_CORE X_NUC_81.L_CORE 0.003072
K_5154 X_NUC_58.L_CORE X_NUC_82.L_CORE 0.003105
K_5155 X_NUC_58.L_CORE X_NUC_83.L_CORE 0.003064
K_5156 X_NUC_58.L_CORE X_NUC_84.L_CORE 0.003092
K_5157 X_NUC_58.L_CORE X_NUC_85.L_CORE 0.002927
K_5158 X_NUC_58.L_CORE X_NUC_86.L_CORE 0.002965
K_5159 X_NUC_58.L_CORE X_NUC_87.L_CORE 0.002940
K_5160 X_NUC_58.L_CORE X_NUC_88.L_CORE 0.002930
K_5161 X_NUC_58.L_CORE X_NUC_89.L_CORE 0.005704
K_5162 X_NUC_58.L_CORE X_NUC_90.L_CORE 0.005782
K_5163 X_NUC_58.L_CORE X_NUC_91.L_CORE 0.005628
K_5164 X_NUC_58.L_CORE X_NUC_92.L_CORE 0.005680
K_5165 X_NUC_58.L_CORE X_NUC_93.L_CORE 0.002824
K_5166 X_NUC_58.L_CORE X_NUC_94.L_CORE 0.002857
K_5167 X_NUC_58.L_CORE X_NUC_95.L_CORE 0.002823
K_5168 X_NUC_58.L_CORE X_NUC_96.L_CORE 0.002833
K_5169 X_NUC_58.L_CORE X_NUC_97.L_CORE 0.003752
K_5170 X_NUC_58.L_CORE X_NUC_98.L_CORE 0.003804
K_5171 X_NUC_58.L_CORE X_NUC_99.L_CORE 0.003749
K_5172 X_NUC_58.L_CORE X_NUC_100.L_CORE 0.003743
K_5173 X_NUC_58.L_CORE X_NUC_101.L_CORE 0.002622
K_5174 X_NUC_58.L_CORE X_NUC_102.L_CORE 0.003865
K_5175 X_NUC_58.L_CORE X_NUC_103.L_CORE 0.002324
K_5176 X_NUC_58.L_CORE X_NUC_104.L_CORE 0.003237
K_5177 X_NUC_58.L_CORE X_NUC_105.L_CORE 0.003545
K_5178 X_NUC_58.L_CORE X_NUC_106.L_CORE 0.002196
K_5179 X_NUC_58.L_CORE X_NUC_107.L_CORE 0.007244
K_5180 X_NUC_58.L_CORE X_NUC_108.L_CORE 0.002486
K_5181 X_NUC_58.L_CORE X_NUC_109.L_CORE 0.002675
K_5182 X_NUC_58.L_CORE X_NUC_110.L_CORE 0.007292
K_5183 X_NUC_58.L_CORE X_NUC_111.L_CORE 0.002163
K_5184 X_NUC_58.L_CORE X_NUC_112.L_CORE 0.004852
K_5185 X_NUC_58.L_CORE X_NUC_113.L_CORE 0.003234
K_5186 X_NUC_58.L_CORE X_NUC_114.L_CORE 0.002388
K_5187 X_NUC_58.L_CORE X_NUC_115.L_CORE 0.010231
K_5188 X_NUC_58.L_CORE X_NUC_116.L_CORE 0.002491
K_5189 X_NUC_58.L_CORE X_NUC_117.L_CORE 0.003304
K_5190 X_NUC_58.L_CORE X_NUC_118.L_CORE 0.004062
K_5191 X_NUC_58.L_CORE X_NUC_119.L_CORE 0.002791
K_5192 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.207973
K_5193 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.002511
K_5194 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.002537
K_5195 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.002515
K_5196 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.002531
K_5197 X_NUC_59.L_CORE X_NUC_65.L_CORE 0.003453
K_5198 X_NUC_59.L_CORE X_NUC_66.L_CORE 0.003499
K_5199 X_NUC_59.L_CORE X_NUC_67.L_CORE 0.003488
K_5200 X_NUC_59.L_CORE X_NUC_68.L_CORE 0.003454
K_5201 X_NUC_59.L_CORE X_NUC_69.L_CORE 0.005293
K_5202 X_NUC_59.L_CORE X_NUC_70.L_CORE 0.005340
K_5203 X_NUC_59.L_CORE X_NUC_71.L_CORE 0.005231
K_5204 X_NUC_59.L_CORE X_NUC_72.L_CORE 0.005352
K_5205 X_NUC_59.L_CORE X_NUC_73.L_CORE 0.002428
K_5206 X_NUC_59.L_CORE X_NUC_74.L_CORE 0.002456
K_5207 X_NUC_59.L_CORE X_NUC_75.L_CORE 0.002437
K_5208 X_NUC_59.L_CORE X_NUC_76.L_CORE 0.002440
K_5209 X_NUC_59.L_CORE X_NUC_77.L_CORE 0.006884
K_5210 X_NUC_59.L_CORE X_NUC_78.L_CORE 0.007011
K_5211 X_NUC_59.L_CORE X_NUC_79.L_CORE 0.006920
K_5212 X_NUC_59.L_CORE X_NUC_80.L_CORE 0.006785
K_5213 X_NUC_59.L_CORE X_NUC_81.L_CORE 0.003114
K_5214 X_NUC_59.L_CORE X_NUC_82.L_CORE 0.003147
K_5215 X_NUC_59.L_CORE X_NUC_83.L_CORE 0.003105
K_5216 X_NUC_59.L_CORE X_NUC_84.L_CORE 0.003134
K_5217 X_NUC_59.L_CORE X_NUC_85.L_CORE 0.002951
K_5218 X_NUC_59.L_CORE X_NUC_86.L_CORE 0.002989
K_5219 X_NUC_59.L_CORE X_NUC_87.L_CORE 0.002965
K_5220 X_NUC_59.L_CORE X_NUC_88.L_CORE 0.002954
K_5221 X_NUC_59.L_CORE X_NUC_89.L_CORE 0.005862
K_5222 X_NUC_59.L_CORE X_NUC_90.L_CORE 0.005944
K_5223 X_NUC_59.L_CORE X_NUC_91.L_CORE 0.005782
K_5224 X_NUC_59.L_CORE X_NUC_92.L_CORE 0.005836
K_5225 X_NUC_59.L_CORE X_NUC_93.L_CORE 0.002858
K_5226 X_NUC_59.L_CORE X_NUC_94.L_CORE 0.002892
K_5227 X_NUC_59.L_CORE X_NUC_95.L_CORE 0.002857
K_5228 X_NUC_59.L_CORE X_NUC_96.L_CORE 0.002867
K_5229 X_NUC_59.L_CORE X_NUC_97.L_CORE 0.003807
K_5230 X_NUC_59.L_CORE X_NUC_98.L_CORE 0.003860
K_5231 X_NUC_59.L_CORE X_NUC_99.L_CORE 0.003804
K_5232 X_NUC_59.L_CORE X_NUC_100.L_CORE 0.003797
K_5233 X_NUC_59.L_CORE X_NUC_101.L_CORE 0.002616
K_5234 X_NUC_59.L_CORE X_NUC_102.L_CORE 0.003834
K_5235 X_NUC_59.L_CORE X_NUC_103.L_CORE 0.002330
K_5236 X_NUC_59.L_CORE X_NUC_104.L_CORE 0.003218
K_5237 X_NUC_59.L_CORE X_NUC_105.L_CORE 0.003552
K_5238 X_NUC_59.L_CORE X_NUC_106.L_CORE 0.002202
K_5239 X_NUC_59.L_CORE X_NUC_107.L_CORE 0.007040
K_5240 X_NUC_59.L_CORE X_NUC_108.L_CORE 0.002502
K_5241 X_NUC_59.L_CORE X_NUC_109.L_CORE 0.002677
K_5242 X_NUC_59.L_CORE X_NUC_110.L_CORE 0.007354
K_5243 X_NUC_59.L_CORE X_NUC_111.L_CORE 0.002176
K_5244 X_NUC_59.L_CORE X_NUC_112.L_CORE 0.004838
K_5245 X_NUC_59.L_CORE X_NUC_113.L_CORE 0.003274
K_5246 X_NUC_59.L_CORE X_NUC_114.L_CORE 0.002402
K_5247 X_NUC_59.L_CORE X_NUC_115.L_CORE 0.010612
K_5248 X_NUC_59.L_CORE X_NUC_116.L_CORE 0.002517
K_5249 X_NUC_59.L_CORE X_NUC_117.L_CORE 0.003331
K_5250 X_NUC_59.L_CORE X_NUC_118.L_CORE 0.004143
K_5251 X_NUC_59.L_CORE X_NUC_119.L_CORE 0.002824
K_5252 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.002495
K_5253 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.002521
K_5254 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.002499
K_5255 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.002515
K_5256 X_NUC_60.L_CORE X_NUC_65.L_CORE 0.003487
K_5257 X_NUC_60.L_CORE X_NUC_66.L_CORE 0.003535
K_5258 X_NUC_60.L_CORE X_NUC_67.L_CORE 0.003523
K_5259 X_NUC_60.L_CORE X_NUC_68.L_CORE 0.003488
K_5260 X_NUC_60.L_CORE X_NUC_69.L_CORE 0.005175
K_5261 X_NUC_60.L_CORE X_NUC_70.L_CORE 0.005218
K_5262 X_NUC_60.L_CORE X_NUC_71.L_CORE 0.005115
K_5263 X_NUC_60.L_CORE X_NUC_72.L_CORE 0.005231
K_5264 X_NUC_60.L_CORE X_NUC_73.L_CORE 0.002426
K_5265 X_NUC_60.L_CORE X_NUC_74.L_CORE 0.002454
K_5266 X_NUC_60.L_CORE X_NUC_75.L_CORE 0.002435
K_5267 X_NUC_60.L_CORE X_NUC_76.L_CORE 0.002437
K_5268 X_NUC_60.L_CORE X_NUC_77.L_CORE 0.007021
K_5269 X_NUC_60.L_CORE X_NUC_78.L_CORE 0.007155
K_5270 X_NUC_60.L_CORE X_NUC_79.L_CORE 0.007055
K_5271 X_NUC_60.L_CORE X_NUC_80.L_CORE 0.006920
K_5272 X_NUC_60.L_CORE X_NUC_81.L_CORE 0.003084
K_5273 X_NUC_60.L_CORE X_NUC_82.L_CORE 0.003117
K_5274 X_NUC_60.L_CORE X_NUC_83.L_CORE 0.003076
K_5275 X_NUC_60.L_CORE X_NUC_84.L_CORE 0.003105
K_5276 X_NUC_60.L_CORE X_NUC_85.L_CORE 0.002961
K_5277 X_NUC_60.L_CORE X_NUC_86.L_CORE 0.003000
K_5278 X_NUC_60.L_CORE X_NUC_87.L_CORE 0.002975
K_5279 X_NUC_60.L_CORE X_NUC_88.L_CORE 0.002965
K_5280 X_NUC_60.L_CORE X_NUC_89.L_CORE 0.005804
K_5281 X_NUC_60.L_CORE X_NUC_90.L_CORE 0.005884
K_5282 X_NUC_60.L_CORE X_NUC_91.L_CORE 0.005724
K_5283 X_NUC_60.L_CORE X_NUC_92.L_CORE 0.005782
K_5284 X_NUC_60.L_CORE X_NUC_93.L_CORE 0.002847
K_5285 X_NUC_60.L_CORE X_NUC_94.L_CORE 0.002881
K_5286 X_NUC_60.L_CORE X_NUC_95.L_CORE 0.002847
K_5287 X_NUC_60.L_CORE X_NUC_96.L_CORE 0.002857
K_5288 X_NUC_60.L_CORE X_NUC_97.L_CORE 0.003813
K_5289 X_NUC_60.L_CORE X_NUC_98.L_CORE 0.003866
K_5290 X_NUC_60.L_CORE X_NUC_99.L_CORE 0.003809
K_5291 X_NUC_60.L_CORE X_NUC_100.L_CORE 0.003804
K_5292 X_NUC_60.L_CORE X_NUC_101.L_CORE 0.002618
K_5293 X_NUC_60.L_CORE X_NUC_102.L_CORE 0.003823
K_5294 X_NUC_60.L_CORE X_NUC_103.L_CORE 0.002321
K_5295 X_NUC_60.L_CORE X_NUC_104.L_CORE 0.003242
K_5296 X_NUC_60.L_CORE X_NUC_105.L_CORE 0.003508
K_5297 X_NUC_60.L_CORE X_NUC_106.L_CORE 0.002202
K_5298 X_NUC_60.L_CORE X_NUC_107.L_CORE 0.007180
K_5299 X_NUC_60.L_CORE X_NUC_108.L_CORE 0.002482
K_5300 X_NUC_60.L_CORE X_NUC_109.L_CORE 0.002695
K_5301 X_NUC_60.L_CORE X_NUC_110.L_CORE 0.007113
K_5302 X_NUC_60.L_CORE X_NUC_111.L_CORE 0.002170
K_5303 X_NUC_60.L_CORE X_NUC_112.L_CORE 0.004938
K_5304 X_NUC_60.L_CORE X_NUC_113.L_CORE 0.003230
K_5305 X_NUC_60.L_CORE X_NUC_114.L_CORE 0.002408
K_5306 X_NUC_60.L_CORE X_NUC_115.L_CORE 0.010608
K_5307 X_NUC_60.L_CORE X_NUC_116.L_CORE 0.002503
K_5308 X_NUC_60.L_CORE X_NUC_117.L_CORE 0.003355
K_5309 X_NUC_60.L_CORE X_NUC_118.L_CORE 0.004100
K_5310 X_NUC_60.L_CORE X_NUC_119.L_CORE 0.002820
K_5311 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.207973
K_5312 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.207973
K_5313 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.207973
K_5314 X_NUC_61.L_CORE X_NUC_65.L_CORE 0.002567
K_5315 X_NUC_61.L_CORE X_NUC_66.L_CORE 0.002558
K_5316 X_NUC_61.L_CORE X_NUC_67.L_CORE 0.002576
K_5317 X_NUC_61.L_CORE X_NUC_68.L_CORE 0.002546
K_5318 X_NUC_61.L_CORE X_NUC_69.L_CORE 0.003574
K_5319 X_NUC_61.L_CORE X_NUC_70.L_CORE 0.003514
K_5320 X_NUC_61.L_CORE X_NUC_71.L_CORE 0.003541
K_5321 X_NUC_61.L_CORE X_NUC_72.L_CORE 0.003535
K_5322 X_NUC_61.L_CORE X_NUC_73.L_CORE 0.005365
K_5323 X_NUC_61.L_CORE X_NUC_74.L_CORE 0.005409
K_5324 X_NUC_61.L_CORE X_NUC_75.L_CORE 0.005422
K_5325 X_NUC_61.L_CORE X_NUC_76.L_CORE 0.005297
K_5326 X_NUC_61.L_CORE X_NUC_77.L_CORE 0.002523
K_5327 X_NUC_61.L_CORE X_NUC_78.L_CORE 0.002503
K_5328 X_NUC_61.L_CORE X_NUC_79.L_CORE 0.002520
K_5329 X_NUC_61.L_CORE X_NUC_80.L_CORE 0.002498
K_5330 X_NUC_61.L_CORE X_NUC_81.L_CORE 0.006973
K_5331 X_NUC_61.L_CORE X_NUC_82.L_CORE 0.006790
K_5332 X_NUC_61.L_CORE X_NUC_83.L_CORE 0.006784
K_5333 X_NUC_61.L_CORE X_NUC_84.L_CORE 0.006783
K_5334 X_NUC_61.L_CORE X_NUC_85.L_CORE 0.003245
K_5335 X_NUC_61.L_CORE X_NUC_86.L_CORE 0.003238
K_5336 X_NUC_61.L_CORE X_NUC_87.L_CORE 0.003253
K_5337 X_NUC_61.L_CORE X_NUC_88.L_CORE 0.003206
K_5338 X_NUC_61.L_CORE X_NUC_89.L_CORE 0.003131
K_5339 X_NUC_61.L_CORE X_NUC_90.L_CORE 0.003093
K_5340 X_NUC_61.L_CORE X_NUC_91.L_CORE 0.003110
K_5341 X_NUC_61.L_CORE X_NUC_92.L_CORE 0.003089
K_5342 X_NUC_61.L_CORE X_NUC_93.L_CORE 0.005447
K_5343 X_NUC_61.L_CORE X_NUC_94.L_CORE 0.005413
K_5344 X_NUC_61.L_CORE X_NUC_95.L_CORE 0.005396
K_5345 X_NUC_61.L_CORE X_NUC_96.L_CORE 0.005313
K_5346 X_NUC_61.L_CORE X_NUC_97.L_CORE 0.003215
K_5347 X_NUC_61.L_CORE X_NUC_98.L_CORE 0.003192
K_5348 X_NUC_61.L_CORE X_NUC_99.L_CORE 0.003203
K_5349 X_NUC_61.L_CORE X_NUC_100.L_CORE 0.003168
K_5350 X_NUC_61.L_CORE X_NUC_101.L_CORE 0.002699
K_5351 X_NUC_61.L_CORE X_NUC_102.L_CORE 0.002471
K_5352 X_NUC_61.L_CORE X_NUC_103.L_CORE 0.004150
K_5353 X_NUC_61.L_CORE X_NUC_104.L_CORE 0.002260
K_5354 X_NUC_61.L_CORE X_NUC_105.L_CORE 0.003218
K_5355 X_NUC_61.L_CORE X_NUC_106.L_CORE 0.003566
K_5356 X_NUC_61.L_CORE X_NUC_107.L_CORE 0.002180
K_5357 X_NUC_61.L_CORE X_NUC_108.L_CORE 0.007442
K_5358 X_NUC_61.L_CORE X_NUC_109.L_CORE 0.002502
K_5359 X_NUC_61.L_CORE X_NUC_110.L_CORE 0.002694
K_5360 X_NUC_61.L_CORE X_NUC_111.L_CORE 0.007521
K_5361 X_NUC_61.L_CORE X_NUC_112.L_CORE 0.002205
K_5362 X_NUC_61.L_CORE X_NUC_113.L_CORE 0.004923
K_5363 X_NUC_61.L_CORE X_NUC_114.L_CORE 0.003339
K_5364 X_NUC_61.L_CORE X_NUC_115.L_CORE 0.002476
K_5365 X_NUC_61.L_CORE X_NUC_116.L_CORE 0.009242
K_5366 X_NUC_61.L_CORE X_NUC_117.L_CORE 0.002642
K_5367 X_NUC_61.L_CORE X_NUC_118.L_CORE 0.003453
K_5368 X_NUC_61.L_CORE X_NUC_119.L_CORE 0.003926
K_5369 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.207973
K_5370 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.207973
K_5371 X_NUC_62.L_CORE X_NUC_65.L_CORE 0.002576
K_5372 X_NUC_62.L_CORE X_NUC_66.L_CORE 0.002567
K_5373 X_NUC_62.L_CORE X_NUC_67.L_CORE 0.002586
K_5374 X_NUC_62.L_CORE X_NUC_68.L_CORE 0.002555
K_5375 X_NUC_62.L_CORE X_NUC_69.L_CORE 0.003635
K_5376 X_NUC_62.L_CORE X_NUC_70.L_CORE 0.003574
K_5377 X_NUC_62.L_CORE X_NUC_71.L_CORE 0.003602
K_5378 X_NUC_62.L_CORE X_NUC_72.L_CORE 0.003595
K_5379 X_NUC_62.L_CORE X_NUC_73.L_CORE 0.005317
K_5380 X_NUC_62.L_CORE X_NUC_74.L_CORE 0.005365
K_5381 X_NUC_62.L_CORE X_NUC_75.L_CORE 0.005375
K_5382 X_NUC_62.L_CORE X_NUC_76.L_CORE 0.005254
K_5383 X_NUC_62.L_CORE X_NUC_77.L_CORE 0.002543
K_5384 X_NUC_62.L_CORE X_NUC_78.L_CORE 0.002523
K_5385 X_NUC_62.L_CORE X_NUC_79.L_CORE 0.002540
K_5386 X_NUC_62.L_CORE X_NUC_80.L_CORE 0.002518
K_5387 X_NUC_62.L_CORE X_NUC_81.L_CORE 0.007162
K_5388 X_NUC_62.L_CORE X_NUC_82.L_CORE 0.006973
K_5389 X_NUC_62.L_CORE X_NUC_83.L_CORE 0.006962
K_5390 X_NUC_62.L_CORE X_NUC_84.L_CORE 0.006961
K_5391 X_NUC_62.L_CORE X_NUC_85.L_CORE 0.003251
K_5392 X_NUC_62.L_CORE X_NUC_86.L_CORE 0.003245
K_5393 X_NUC_62.L_CORE X_NUC_87.L_CORE 0.003259
K_5394 X_NUC_62.L_CORE X_NUC_88.L_CORE 0.003212
K_5395 X_NUC_62.L_CORE X_NUC_89.L_CORE 0.003169
K_5396 X_NUC_62.L_CORE X_NUC_90.L_CORE 0.003131
K_5397 X_NUC_62.L_CORE X_NUC_91.L_CORE 0.003148
K_5398 X_NUC_62.L_CORE X_NUC_92.L_CORE 0.003126
K_5399 X_NUC_62.L_CORE X_NUC_93.L_CORE 0.005477
K_5400 X_NUC_62.L_CORE X_NUC_94.L_CORE 0.005447
K_5401 X_NUC_62.L_CORE X_NUC_95.L_CORE 0.005428
K_5402 X_NUC_62.L_CORE X_NUC_96.L_CORE 0.005344
K_5403 X_NUC_62.L_CORE X_NUC_97.L_CORE 0.003238
K_5404 X_NUC_62.L_CORE X_NUC_98.L_CORE 0.003215
K_5405 X_NUC_62.L_CORE X_NUC_99.L_CORE 0.003227
K_5406 X_NUC_62.L_CORE X_NUC_100.L_CORE 0.003191
K_5407 X_NUC_62.L_CORE X_NUC_101.L_CORE 0.002706
K_5408 X_NUC_62.L_CORE X_NUC_102.L_CORE 0.002490
K_5409 X_NUC_62.L_CORE X_NUC_103.L_CORE 0.004150
K_5410 X_NUC_62.L_CORE X_NUC_104.L_CORE 0.002268
K_5411 X_NUC_62.L_CORE X_NUC_105.L_CORE 0.003259
K_5412 X_NUC_62.L_CORE X_NUC_106.L_CORE 0.003546
K_5413 X_NUC_62.L_CORE X_NUC_107.L_CORE 0.002197
K_5414 X_NUC_62.L_CORE X_NUC_108.L_CORE 0.007555
K_5415 X_NUC_62.L_CORE X_NUC_109.L_CORE 0.002504
K_5416 X_NUC_62.L_CORE X_NUC_110.L_CORE 0.002728
K_5417 X_NUC_62.L_CORE X_NUC_111.L_CORE 0.007319
K_5418 X_NUC_62.L_CORE X_NUC_112.L_CORE 0.002217
K_5419 X_NUC_62.L_CORE X_NUC_113.L_CORE 0.005035
K_5420 X_NUC_62.L_CORE X_NUC_114.L_CORE 0.003328
K_5421 X_NUC_62.L_CORE X_NUC_115.L_CORE 0.002501
K_5422 X_NUC_62.L_CORE X_NUC_116.L_CORE 0.009286
K_5423 X_NUC_62.L_CORE X_NUC_117.L_CORE 0.002653
K_5424 X_NUC_62.L_CORE X_NUC_118.L_CORE 0.003499
K_5425 X_NUC_62.L_CORE X_NUC_119.L_CORE 0.003940
K_5426 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.207973
K_5427 X_NUC_63.L_CORE X_NUC_65.L_CORE 0.002557
K_5428 X_NUC_63.L_CORE X_NUC_66.L_CORE 0.002548
K_5429 X_NUC_63.L_CORE X_NUC_67.L_CORE 0.002567
K_5430 X_NUC_63.L_CORE X_NUC_68.L_CORE 0.002537
K_5431 X_NUC_63.L_CORE X_NUC_69.L_CORE 0.003606
K_5432 X_NUC_63.L_CORE X_NUC_70.L_CORE 0.003545
K_5433 X_NUC_63.L_CORE X_NUC_71.L_CORE 0.003574
K_5434 X_NUC_63.L_CORE X_NUC_72.L_CORE 0.003566
K_5435 X_NUC_63.L_CORE X_NUC_73.L_CORE 0.005306
K_5436 X_NUC_63.L_CORE X_NUC_74.L_CORE 0.005351
K_5437 X_NUC_63.L_CORE X_NUC_75.L_CORE 0.005365
K_5438 X_NUC_63.L_CORE X_NUC_76.L_CORE 0.005243
K_5439 X_NUC_63.L_CORE X_NUC_77.L_CORE 0.002526
K_5440 X_NUC_63.L_CORE X_NUC_78.L_CORE 0.002506
K_5441 X_NUC_63.L_CORE X_NUC_79.L_CORE 0.002523
K_5442 X_NUC_63.L_CORE X_NUC_80.L_CORE 0.002501
K_5443 X_NUC_63.L_CORE X_NUC_81.L_CORE 0.007169
K_5444 X_NUC_63.L_CORE X_NUC_82.L_CORE 0.006976
K_5445 X_NUC_63.L_CORE X_NUC_83.L_CORE 0.006973
K_5446 X_NUC_63.L_CORE X_NUC_84.L_CORE 0.006967
K_5447 X_NUC_63.L_CORE X_NUC_85.L_CORE 0.003236
K_5448 X_NUC_63.L_CORE X_NUC_86.L_CORE 0.003230
K_5449 X_NUC_63.L_CORE X_NUC_87.L_CORE 0.003245
K_5450 X_NUC_63.L_CORE X_NUC_88.L_CORE 0.003198
K_5451 X_NUC_63.L_CORE X_NUC_89.L_CORE 0.003152
K_5452 X_NUC_63.L_CORE X_NUC_90.L_CORE 0.003114
K_5453 X_NUC_63.L_CORE X_NUC_91.L_CORE 0.003131
K_5454 X_NUC_63.L_CORE X_NUC_92.L_CORE 0.003109
K_5455 X_NUC_63.L_CORE X_NUC_93.L_CORE 0.005494
K_5456 X_NUC_63.L_CORE X_NUC_94.L_CORE 0.005462
K_5457 X_NUC_63.L_CORE X_NUC_95.L_CORE 0.005447
K_5458 X_NUC_63.L_CORE X_NUC_96.L_CORE 0.005360
K_5459 X_NUC_63.L_CORE X_NUC_97.L_CORE 0.003226
K_5460 X_NUC_63.L_CORE X_NUC_98.L_CORE 0.003203
K_5461 X_NUC_63.L_CORE X_NUC_99.L_CORE 0.003215
K_5462 X_NUC_63.L_CORE X_NUC_100.L_CORE 0.003179
K_5463 X_NUC_63.L_CORE X_NUC_101.L_CORE 0.002673
K_5464 X_NUC_63.L_CORE X_NUC_102.L_CORE 0.002461
K_5465 X_NUC_63.L_CORE X_NUC_103.L_CORE 0.004084
K_5466 X_NUC_63.L_CORE X_NUC_104.L_CORE 0.002246
K_5467 X_NUC_63.L_CORE X_NUC_105.L_CORE 0.003218
K_5468 X_NUC_63.L_CORE X_NUC_106.L_CORE 0.003509
K_5469 X_NUC_63.L_CORE X_NUC_107.L_CORE 0.002177
K_5470 X_NUC_63.L_CORE X_NUC_108.L_CORE 0.007415
K_5471 X_NUC_63.L_CORE X_NUC_109.L_CORE 0.002484
K_5472 X_NUC_63.L_CORE X_NUC_110.L_CORE 0.002704
K_5473 X_NUC_63.L_CORE X_NUC_111.L_CORE 0.007303
K_5474 X_NUC_63.L_CORE X_NUC_112.L_CORE 0.002201
K_5475 X_NUC_63.L_CORE X_NUC_113.L_CORE 0.005007
K_5476 X_NUC_63.L_CORE X_NUC_114.L_CORE 0.003315
K_5477 X_NUC_63.L_CORE X_NUC_115.L_CORE 0.002485
K_5478 X_NUC_63.L_CORE X_NUC_116.L_CORE 0.009529
K_5479 X_NUC_63.L_CORE X_NUC_117.L_CORE 0.002641
K_5480 X_NUC_63.L_CORE X_NUC_118.L_CORE 0.003490
K_5481 X_NUC_63.L_CORE X_NUC_119.L_CORE 0.003946
K_5482 X_NUC_64.L_CORE X_NUC_65.L_CORE 0.002588
K_5483 X_NUC_64.L_CORE X_NUC_66.L_CORE 0.002578
K_5484 X_NUC_64.L_CORE X_NUC_67.L_CORE 0.002598
K_5485 X_NUC_64.L_CORE X_NUC_68.L_CORE 0.002567
K_5486 X_NUC_64.L_CORE X_NUC_69.L_CORE 0.003613
K_5487 X_NUC_64.L_CORE X_NUC_70.L_CORE 0.003552
K_5488 X_NUC_64.L_CORE X_NUC_71.L_CORE 0.003580
K_5489 X_NUC_64.L_CORE X_NUC_72.L_CORE 0.003574
K_5490 X_NUC_64.L_CORE X_NUC_73.L_CORE 0.005431
K_5491 X_NUC_64.L_CORE X_NUC_74.L_CORE 0.005479
K_5492 X_NUC_64.L_CORE X_NUC_75.L_CORE 0.005492
K_5493 X_NUC_64.L_CORE X_NUC_76.L_CORE 0.005365
K_5494 X_NUC_64.L_CORE X_NUC_77.L_CORE 0.002548
K_5495 X_NUC_64.L_CORE X_NUC_78.L_CORE 0.002528
K_5496 X_NUC_64.L_CORE X_NUC_79.L_CORE 0.002545
K_5497 X_NUC_64.L_CORE X_NUC_80.L_CORE 0.002523
K_5498 X_NUC_64.L_CORE X_NUC_81.L_CORE 0.007171
K_5499 X_NUC_64.L_CORE X_NUC_82.L_CORE 0.006977
K_5500 X_NUC_64.L_CORE X_NUC_83.L_CORE 0.006970
K_5501 X_NUC_64.L_CORE X_NUC_84.L_CORE 0.006973
K_5502 X_NUC_64.L_CORE X_NUC_85.L_CORE 0.003284
K_5503 X_NUC_64.L_CORE X_NUC_86.L_CORE 0.003278
K_5504 X_NUC_64.L_CORE X_NUC_87.L_CORE 0.003293
K_5505 X_NUC_64.L_CORE X_NUC_88.L_CORE 0.003245
K_5506 X_NUC_64.L_CORE X_NUC_89.L_CORE 0.003174
K_5507 X_NUC_64.L_CORE X_NUC_90.L_CORE 0.003135
K_5508 X_NUC_64.L_CORE X_NUC_91.L_CORE 0.003152
K_5509 X_NUC_64.L_CORE X_NUC_92.L_CORE 0.003131
K_5510 X_NUC_64.L_CORE X_NUC_93.L_CORE 0.005586
K_5511 X_NUC_64.L_CORE X_NUC_94.L_CORE 0.005552
K_5512 X_NUC_64.L_CORE X_NUC_95.L_CORE 0.005534
K_5513 X_NUC_64.L_CORE X_NUC_96.L_CORE 0.005447
K_5514 X_NUC_64.L_CORE X_NUC_97.L_CORE 0.003263
K_5515 X_NUC_64.L_CORE X_NUC_98.L_CORE 0.003239
K_5516 X_NUC_64.L_CORE X_NUC_99.L_CORE 0.003251
K_5517 X_NUC_64.L_CORE X_NUC_100.L_CORE 0.003215
K_5518 X_NUC_64.L_CORE X_NUC_101.L_CORE 0.002693
K_5519 X_NUC_64.L_CORE X_NUC_102.L_CORE 0.002473
K_5520 X_NUC_64.L_CORE X_NUC_103.L_CORE 0.004104
K_5521 X_NUC_64.L_CORE X_NUC_104.L_CORE 0.002266
K_5522 X_NUC_64.L_CORE X_NUC_105.L_CORE 0.003217
K_5523 X_NUC_64.L_CORE X_NUC_106.L_CORE 0.003555
K_5524 X_NUC_64.L_CORE X_NUC_107.L_CORE 0.002191
K_5525 X_NUC_64.L_CORE X_NUC_108.L_CORE 0.007292
K_5526 X_NUC_64.L_CORE X_NUC_109.L_CORE 0.002514
K_5527 X_NUC_64.L_CORE X_NUC_110.L_CORE 0.002710
K_5528 X_NUC_64.L_CORE X_NUC_111.L_CORE 0.007464
K_5529 X_NUC_64.L_CORE X_NUC_112.L_CORE 0.002221
K_5530 X_NUC_64.L_CORE X_NUC_113.L_CORE 0.004971
K_5531 X_NUC_64.L_CORE X_NUC_114.L_CORE 0.003367
K_5532 X_NUC_64.L_CORE X_NUC_115.L_CORE 0.002501
K_5533 X_NUC_64.L_CORE X_NUC_116.L_CORE 0.009591
K_5534 X_NUC_64.L_CORE X_NUC_117.L_CORE 0.002671
K_5535 X_NUC_64.L_CORE X_NUC_118.L_CORE 0.003506
K_5536 X_NUC_64.L_CORE X_NUC_119.L_CORE 0.003997
K_5537 X_NUC_65.L_CORE X_NUC_66.L_CORE 0.207973
K_5538 X_NUC_65.L_CORE X_NUC_67.L_CORE 0.207973
K_5539 X_NUC_65.L_CORE X_NUC_68.L_CORE 0.207973
K_5540 X_NUC_65.L_CORE X_NUC_69.L_CORE 0.002641
K_5541 X_NUC_65.L_CORE X_NUC_70.L_CORE 0.002627
K_5542 X_NUC_65.L_CORE X_NUC_71.L_CORE 0.002618
K_5543 X_NUC_65.L_CORE X_NUC_72.L_CORE 0.002648
K_5544 X_NUC_65.L_CORE X_NUC_73.L_CORE 0.003693
K_5545 X_NUC_65.L_CORE X_NUC_74.L_CORE 0.003735
K_5546 X_NUC_65.L_CORE X_NUC_75.L_CORE 0.003683
K_5547 X_NUC_65.L_CORE X_NUC_76.L_CORE 0.003733
K_5548 X_NUC_65.L_CORE X_NUC_77.L_CORE 0.005545
K_5549 X_NUC_65.L_CORE X_NUC_78.L_CORE 0.005423
K_5550 X_NUC_65.L_CORE X_NUC_79.L_CORE 0.005420
K_5551 X_NUC_65.L_CORE X_NUC_80.L_CORE 0.005486
K_5552 X_NUC_65.L_CORE X_NUC_81.L_CORE 0.002642
K_5553 X_NUC_65.L_CORE X_NUC_82.L_CORE 0.002641
K_5554 X_NUC_65.L_CORE X_NUC_83.L_CORE 0.002621
K_5555 X_NUC_65.L_CORE X_NUC_84.L_CORE 0.002654
K_5556 X_NUC_65.L_CORE X_NUC_85.L_CORE 0.007008
K_5557 X_NUC_65.L_CORE X_NUC_86.L_CORE 0.007130
K_5558 X_NUC_65.L_CORE X_NUC_87.L_CORE 0.006896
K_5559 X_NUC_65.L_CORE X_NUC_88.L_CORE 0.007034
K_5560 X_NUC_65.L_CORE X_NUC_89.L_CORE 0.003440
K_5561 X_NUC_65.L_CORE X_NUC_90.L_CORE 0.003411
K_5562 X_NUC_65.L_CORE X_NUC_91.L_CORE 0.003390
K_5563 X_NUC_65.L_CORE X_NUC_92.L_CORE 0.003433
K_5564 X_NUC_65.L_CORE X_NUC_93.L_CORE 0.003376
K_5565 X_NUC_65.L_CORE X_NUC_94.L_CORE 0.003388
K_5566 X_NUC_65.L_CORE X_NUC_95.L_CORE 0.003342
K_5567 X_NUC_65.L_CORE X_NUC_96.L_CORE 0.003390
K_5568 X_NUC_65.L_CORE X_NUC_97.L_CORE 0.004877
K_5569 X_NUC_65.L_CORE X_NUC_98.L_CORE 0.004857
K_5570 X_NUC_65.L_CORE X_NUC_99.L_CORE 0.004774
K_5571 X_NUC_65.L_CORE X_NUC_100.L_CORE 0.004852
K_5572 X_NUC_65.L_CORE X_NUC_101.L_CORE 0.002942
K_5573 X_NUC_65.L_CORE X_NUC_102.L_CORE 0.002626
K_5574 X_NUC_65.L_CORE X_NUC_103.L_CORE 0.002405
K_5575 X_NUC_65.L_CORE X_NUC_104.L_CORE 0.004353
K_5576 X_NUC_65.L_CORE X_NUC_105.L_CORE 0.002222
K_5577 X_NUC_65.L_CORE X_NUC_106.L_CORE 0.003257
K_5578 X_NUC_65.L_CORE X_NUC_107.L_CORE 0.003550
K_5579 X_NUC_65.L_CORE X_NUC_108.L_CORE 0.002192
K_5580 X_NUC_65.L_CORE X_NUC_109.L_CORE 0.007838
K_5581 X_NUC_65.L_CORE X_NUC_110.L_CORE 0.002522
K_5582 X_NUC_65.L_CORE X_NUC_111.L_CORE 0.002767
K_5583 X_NUC_65.L_CORE X_NUC_112.L_CORE 0.007485
K_5584 X_NUC_65.L_CORE X_NUC_113.L_CORE 0.002269
K_5585 X_NUC_65.L_CORE X_NUC_114.L_CORE 0.005181
K_5586 X_NUC_65.L_CORE X_NUC_115.L_CORE 0.003440
K_5587 X_NUC_65.L_CORE X_NUC_116.L_CORE 0.002621
K_5588 X_NUC_65.L_CORE X_NUC_117.L_CORE 0.008243
K_5589 X_NUC_65.L_CORE X_NUC_118.L_CORE 0.002867
K_5590 X_NUC_65.L_CORE X_NUC_119.L_CORE 0.003684
K_5591 X_NUC_66.L_CORE X_NUC_67.L_CORE 0.207973
K_5592 X_NUC_66.L_CORE X_NUC_68.L_CORE 0.207973
K_5593 X_NUC_66.L_CORE X_NUC_69.L_CORE 0.002656
K_5594 X_NUC_66.L_CORE X_NUC_70.L_CORE 0.002641
K_5595 X_NUC_66.L_CORE X_NUC_71.L_CORE 0.002632
K_5596 X_NUC_66.L_CORE X_NUC_72.L_CORE 0.002663
K_5597 X_NUC_66.L_CORE X_NUC_73.L_CORE 0.003651
K_5598 X_NUC_66.L_CORE X_NUC_74.L_CORE 0.003693
K_5599 X_NUC_66.L_CORE X_NUC_75.L_CORE 0.003642
K_5600 X_NUC_66.L_CORE X_NUC_76.L_CORE 0.003690
K_5601 X_NUC_66.L_CORE X_NUC_77.L_CORE 0.005670
K_5602 X_NUC_66.L_CORE X_NUC_78.L_CORE 0.005545
K_5603 X_NUC_66.L_CORE X_NUC_79.L_CORE 0.005540
K_5604 X_NUC_66.L_CORE X_NUC_80.L_CORE 0.005610
K_5605 X_NUC_66.L_CORE X_NUC_81.L_CORE 0.002642
K_5606 X_NUC_66.L_CORE X_NUC_82.L_CORE 0.002642
K_5607 X_NUC_66.L_CORE X_NUC_83.L_CORE 0.002621
K_5608 X_NUC_66.L_CORE X_NUC_84.L_CORE 0.002654
K_5609 X_NUC_66.L_CORE X_NUC_85.L_CORE 0.006885
K_5610 X_NUC_66.L_CORE X_NUC_86.L_CORE 0.007008
K_5611 X_NUC_66.L_CORE X_NUC_87.L_CORE 0.006782
K_5612 X_NUC_66.L_CORE X_NUC_88.L_CORE 0.006913
K_5613 X_NUC_66.L_CORE X_NUC_89.L_CORE 0.003469
K_5614 X_NUC_66.L_CORE X_NUC_90.L_CORE 0.003440
K_5615 X_NUC_66.L_CORE X_NUC_91.L_CORE 0.003417
K_5616 X_NUC_66.L_CORE X_NUC_92.L_CORE 0.003462
K_5617 X_NUC_66.L_CORE X_NUC_93.L_CORE 0.003363
K_5618 X_NUC_66.L_CORE X_NUC_94.L_CORE 0.003376
K_5619 X_NUC_66.L_CORE X_NUC_95.L_CORE 0.003330
K_5620 X_NUC_66.L_CORE X_NUC_96.L_CORE 0.003377
K_5621 X_NUC_66.L_CORE X_NUC_97.L_CORE 0.004894
K_5622 X_NUC_66.L_CORE X_NUC_98.L_CORE 0.004877
K_5623 X_NUC_66.L_CORE X_NUC_99.L_CORE 0.004791
K_5624 X_NUC_66.L_CORE X_NUC_100.L_CORE 0.004871
K_5625 X_NUC_66.L_CORE X_NUC_101.L_CORE 0.002937
K_5626 X_NUC_66.L_CORE X_NUC_102.L_CORE 0.002639
K_5627 X_NUC_66.L_CORE X_NUC_103.L_CORE 0.002397
K_5628 X_NUC_66.L_CORE X_NUC_104.L_CORE 0.004370
K_5629 X_NUC_66.L_CORE X_NUC_105.L_CORE 0.002229
K_5630 X_NUC_66.L_CORE X_NUC_106.L_CORE 0.003224
K_5631 X_NUC_66.L_CORE X_NUC_107.L_CORE 0.003599
K_5632 X_NUC_66.L_CORE X_NUC_108.L_CORE 0.002189
K_5633 X_NUC_66.L_CORE X_NUC_109.L_CORE 0.007645
K_5634 X_NUC_66.L_CORE X_NUC_110.L_CORE 0.002541
K_5635 X_NUC_66.L_CORE X_NUC_111.L_CORE 0.002745
K_5636 X_NUC_66.L_CORE X_NUC_112.L_CORE 0.007761
K_5637 X_NUC_66.L_CORE X_NUC_113.L_CORE 0.002274
K_5638 X_NUC_66.L_CORE X_NUC_114.L_CORE 0.005070
K_5639 X_NUC_66.L_CORE X_NUC_115.L_CORE 0.003485
K_5640 X_NUC_66.L_CORE X_NUC_116.L_CORE 0.002612
K_5641 X_NUC_66.L_CORE X_NUC_117.L_CORE 0.008252
K_5642 X_NUC_66.L_CORE X_NUC_118.L_CORE 0.002880
K_5643 X_NUC_66.L_CORE X_NUC_119.L_CORE 0.003670
K_5644 X_NUC_67.L_CORE X_NUC_68.L_CORE 0.207973
K_5645 X_NUC_67.L_CORE X_NUC_69.L_CORE 0.002665
K_5646 X_NUC_67.L_CORE X_NUC_70.L_CORE 0.002650
K_5647 X_NUC_67.L_CORE X_NUC_71.L_CORE 0.002641
K_5648 X_NUC_67.L_CORE X_NUC_72.L_CORE 0.002672
K_5649 X_NUC_67.L_CORE X_NUC_73.L_CORE 0.003702
K_5650 X_NUC_67.L_CORE X_NUC_74.L_CORE 0.003745
K_5651 X_NUC_67.L_CORE X_NUC_75.L_CORE 0.003693
K_5652 X_NUC_67.L_CORE X_NUC_76.L_CORE 0.003743
K_5653 X_NUC_67.L_CORE X_NUC_77.L_CORE 0.005673
K_5654 X_NUC_67.L_CORE X_NUC_78.L_CORE 0.005546
K_5655 X_NUC_67.L_CORE X_NUC_79.L_CORE 0.005545
K_5656 X_NUC_67.L_CORE X_NUC_80.L_CORE 0.005613
K_5657 X_NUC_67.L_CORE X_NUC_81.L_CORE 0.002663
K_5658 X_NUC_67.L_CORE X_NUC_82.L_CORE 0.002662
K_5659 X_NUC_67.L_CORE X_NUC_83.L_CORE 0.002642
K_5660 X_NUC_67.L_CORE X_NUC_84.L_CORE 0.002675
K_5661 X_NUC_67.L_CORE X_NUC_85.L_CORE 0.007118
K_5662 X_NUC_67.L_CORE X_NUC_86.L_CORE 0.007250
K_5663 X_NUC_67.L_CORE X_NUC_87.L_CORE 0.007008
K_5664 X_NUC_67.L_CORE X_NUC_88.L_CORE 0.007149
K_5665 X_NUC_67.L_CORE X_NUC_89.L_CORE 0.003492
K_5666 X_NUC_67.L_CORE X_NUC_90.L_CORE 0.003462
K_5667 X_NUC_67.L_CORE X_NUC_91.L_CORE 0.003440
K_5668 X_NUC_67.L_CORE X_NUC_92.L_CORE 0.003485
K_5669 X_NUC_67.L_CORE X_NUC_93.L_CORE 0.003410
K_5670 X_NUC_67.L_CORE X_NUC_94.L_CORE 0.003423
K_5671 X_NUC_67.L_CORE X_NUC_95.L_CORE 0.003376
K_5672 X_NUC_67.L_CORE X_NUC_96.L_CORE 0.003425
K_5673 X_NUC_67.L_CORE X_NUC_97.L_CORE 0.004984
K_5674 X_NUC_67.L_CORE X_NUC_98.L_CORE 0.004964
K_5675 X_NUC_67.L_CORE X_NUC_99.L_CORE 0.004877
K_5676 X_NUC_67.L_CORE X_NUC_100.L_CORE 0.004959
K_5677 X_NUC_67.L_CORE X_NUC_101.L_CORE 0.002923
K_5678 X_NUC_67.L_CORE X_NUC_102.L_CORE 0.002624
K_5679 X_NUC_67.L_CORE X_NUC_103.L_CORE 0.002399
K_5680 X_NUC_67.L_CORE X_NUC_104.L_CORE 0.004302
K_5681 X_NUC_67.L_CORE X_NUC_105.L_CORE 0.002228
K_5682 X_NUC_67.L_CORE X_NUC_106.L_CORE 0.003233
K_5683 X_NUC_67.L_CORE X_NUC_107.L_CORE 0.003561
K_5684 X_NUC_67.L_CORE X_NUC_108.L_CORE 0.002197
K_5685 X_NUC_67.L_CORE X_NUC_109.L_CORE 0.007574
K_5686 X_NUC_67.L_CORE X_NUC_110.L_CORE 0.002540
K_5687 X_NUC_67.L_CORE X_NUC_111.L_CORE 0.002767
K_5688 X_NUC_67.L_CORE X_NUC_112.L_CORE 0.007583
K_5689 X_NUC_67.L_CORE X_NUC_113.L_CORE 0.002284
K_5690 X_NUC_67.L_CORE X_NUC_114.L_CORE 0.005168
K_5691 X_NUC_67.L_CORE X_NUC_115.L_CORE 0.003488
K_5692 X_NUC_67.L_CORE X_NUC_116.L_CORE 0.002638
K_5693 X_NUC_67.L_CORE X_NUC_117.L_CORE 0.008529
K_5694 X_NUC_67.L_CORE X_NUC_118.L_CORE 0.002902
K_5695 X_NUC_67.L_CORE X_NUC_119.L_CORE 0.003731
K_5696 X_NUC_68.L_CORE X_NUC_69.L_CORE 0.002635
K_5697 X_NUC_68.L_CORE X_NUC_70.L_CORE 0.002620
K_5698 X_NUC_68.L_CORE X_NUC_71.L_CORE 0.002612
K_5699 X_NUC_68.L_CORE X_NUC_72.L_CORE 0.002641
K_5700 X_NUC_68.L_CORE X_NUC_73.L_CORE 0.003653
K_5701 X_NUC_68.L_CORE X_NUC_74.L_CORE 0.003694
K_5702 X_NUC_68.L_CORE X_NUC_75.L_CORE 0.003644
K_5703 X_NUC_68.L_CORE X_NUC_76.L_CORE 0.003693
K_5704 X_NUC_68.L_CORE X_NUC_77.L_CORE 0.005601
K_5705 X_NUC_68.L_CORE X_NUC_78.L_CORE 0.005478
K_5706 X_NUC_68.L_CORE X_NUC_79.L_CORE 0.005475
K_5707 X_NUC_68.L_CORE X_NUC_80.L_CORE 0.005545
K_5708 X_NUC_68.L_CORE X_NUC_81.L_CORE 0.002630
K_5709 X_NUC_68.L_CORE X_NUC_82.L_CORE 0.002629
K_5710 X_NUC_68.L_CORE X_NUC_83.L_CORE 0.002609
K_5711 X_NUC_68.L_CORE X_NUC_84.L_CORE 0.002642
K_5712 X_NUC_68.L_CORE X_NUC_85.L_CORE 0.006974
K_5713 X_NUC_68.L_CORE X_NUC_86.L_CORE 0.007098
K_5714 X_NUC_68.L_CORE X_NUC_87.L_CORE 0.006867
K_5715 X_NUC_68.L_CORE X_NUC_88.L_CORE 0.007008
K_5716 X_NUC_68.L_CORE X_NUC_89.L_CORE 0.003446
K_5717 X_NUC_68.L_CORE X_NUC_90.L_CORE 0.003418
K_5718 X_NUC_68.L_CORE X_NUC_91.L_CORE 0.003396
K_5719 X_NUC_68.L_CORE X_NUC_92.L_CORE 0.003440
K_5720 X_NUC_68.L_CORE X_NUC_93.L_CORE 0.003361
K_5721 X_NUC_68.L_CORE X_NUC_94.L_CORE 0.003374
K_5722 X_NUC_68.L_CORE X_NUC_95.L_CORE 0.003328
K_5723 X_NUC_68.L_CORE X_NUC_96.L_CORE 0.003376
K_5724 X_NUC_68.L_CORE X_NUC_97.L_CORE 0.004899
K_5725 X_NUC_68.L_CORE X_NUC_98.L_CORE 0.004880
K_5726 X_NUC_68.L_CORE X_NUC_99.L_CORE 0.004796
K_5727 X_NUC_68.L_CORE X_NUC_100.L_CORE 0.004877
K_5728 X_NUC_68.L_CORE X_NUC_101.L_CORE 0.002905
K_5729 X_NUC_68.L_CORE X_NUC_102.L_CORE 0.002606
K_5730 X_NUC_68.L_CORE X_NUC_103.L_CORE 0.002379
K_5731 X_NUC_68.L_CORE X_NUC_104.L_CORE 0.004296
K_5732 X_NUC_68.L_CORE X_NUC_105.L_CORE 0.002208
K_5733 X_NUC_68.L_CORE X_NUC_106.L_CORE 0.003208
K_5734 X_NUC_68.L_CORE X_NUC_107.L_CORE 0.003542
K_5735 X_NUC_68.L_CORE X_NUC_108.L_CORE 0.002175
K_5736 X_NUC_68.L_CORE X_NUC_109.L_CORE 0.007613
K_5737 X_NUC_68.L_CORE X_NUC_110.L_CORE 0.002516
K_5738 X_NUC_68.L_CORE X_NUC_111.L_CORE 0.002738
K_5739 X_NUC_68.L_CORE X_NUC_112.L_CORE 0.007603
K_5740 X_NUC_68.L_CORE X_NUC_113.L_CORE 0.002260
K_5741 X_NUC_68.L_CORE X_NUC_114.L_CORE 0.005114
K_5742 X_NUC_68.L_CORE X_NUC_115.L_CORE 0.003454
K_5743 X_NUC_68.L_CORE X_NUC_116.L_CORE 0.002607
K_5744 X_NUC_68.L_CORE X_NUC_117.L_CORE 0.008417
K_5745 X_NUC_68.L_CORE X_NUC_118.L_CORE 0.002868
K_5746 X_NUC_68.L_CORE X_NUC_119.L_CORE 0.003680
K_5747 X_NUC_69.L_CORE X_NUC_70.L_CORE 0.207973
K_5748 X_NUC_69.L_CORE X_NUC_71.L_CORE 0.207973
K_5749 X_NUC_69.L_CORE X_NUC_72.L_CORE 0.207973
K_5750 X_NUC_69.L_CORE X_NUC_73.L_CORE 0.002744
K_5751 X_NUC_69.L_CORE X_NUC_74.L_CORE 0.002778
K_5752 X_NUC_69.L_CORE X_NUC_75.L_CORE 0.002767
K_5753 X_NUC_69.L_CORE X_NUC_76.L_CORE 0.002753
K_5754 X_NUC_69.L_CORE X_NUC_77.L_CORE 0.003856
K_5755 X_NUC_69.L_CORE X_NUC_78.L_CORE 0.003859
K_5756 X_NUC_69.L_CORE X_NUC_79.L_CORE 0.003886
K_5757 X_NUC_69.L_CORE X_NUC_80.L_CORE 0.003816
K_5758 X_NUC_69.L_CORE X_NUC_81.L_CORE 0.005783
K_5759 X_NUC_69.L_CORE X_NUC_82.L_CORE 0.005937
K_5760 X_NUC_69.L_CORE X_NUC_83.L_CORE 0.005807
K_5761 X_NUC_69.L_CORE X_NUC_84.L_CORE 0.005837
K_5762 X_NUC_69.L_CORE X_NUC_85.L_CORE 0.002808
K_5763 X_NUC_69.L_CORE X_NUC_86.L_CORE 0.002833
K_5764 X_NUC_69.L_CORE X_NUC_87.L_CORE 0.002829
K_5765 X_NUC_69.L_CORE X_NUC_88.L_CORE 0.002801
K_5766 X_NUC_69.L_CORE X_NUC_89.L_CORE 0.006989
K_5767 X_NUC_69.L_CORE X_NUC_90.L_CORE 0.007015
K_5768 X_NUC_69.L_CORE X_NUC_91.L_CORE 0.006991
K_5769 X_NUC_69.L_CORE X_NUC_92.L_CORE 0.006814
K_5770 X_NUC_69.L_CORE X_NUC_93.L_CORE 0.003724
K_5771 X_NUC_69.L_CORE X_NUC_94.L_CORE 0.003782
K_5772 X_NUC_69.L_CORE X_NUC_95.L_CORE 0.003744
K_5773 X_NUC_69.L_CORE X_NUC_96.L_CORE 0.003724
K_5774 X_NUC_69.L_CORE X_NUC_97.L_CORE 0.003791
K_5775 X_NUC_69.L_CORE X_NUC_98.L_CORE 0.003825
K_5776 X_NUC_69.L_CORE X_NUC_99.L_CORE 0.003810
K_5777 X_NUC_69.L_CORE X_NUC_100.L_CORE 0.003760
K_5778 X_NUC_69.L_CORE X_NUC_101.L_CORE 0.002360
K_5779 X_NUC_69.L_CORE X_NUC_102.L_CORE 0.003108
K_5780 X_NUC_69.L_CORE X_NUC_103.L_CORE 0.002606
K_5781 X_NUC_69.L_CORE X_NUC_104.L_CORE 0.002363
K_5782 X_NUC_69.L_CORE X_NUC_105.L_CORE 0.004533
K_5783 X_NUC_69.L_CORE X_NUC_106.L_CORE 0.002222
K_5784 X_NUC_69.L_CORE X_NUC_107.L_CORE 0.003257
K_5785 X_NUC_69.L_CORE X_NUC_108.L_CORE 0.003638
K_5786 X_NUC_69.L_CORE X_NUC_109.L_CORE 0.002219
K_5787 X_NUC_69.L_CORE X_NUC_110.L_CORE 0.007886
K_5788 X_NUC_69.L_CORE X_NUC_111.L_CORE 0.002601
K_5789 X_NUC_69.L_CORE X_NUC_112.L_CORE 0.002831
K_5790 X_NUC_69.L_CORE X_NUC_113.L_CORE 0.007999
K_5791 X_NUC_69.L_CORE X_NUC_114.L_CORE 0.002372
K_5792 X_NUC_69.L_CORE X_NUC_115.L_CORE 0.005310
K_5793 X_NUC_69.L_CORE X_NUC_116.L_CORE 0.003676
K_5794 X_NUC_69.L_CORE X_NUC_117.L_CORE 0.002816
K_5795 X_NUC_69.L_CORE X_NUC_118.L_CORE 0.007183
K_5796 X_NUC_69.L_CORE X_NUC_119.L_CORE 0.003317
K_5797 X_NUC_70.L_CORE X_NUC_71.L_CORE 0.207973
K_5798 X_NUC_70.L_CORE X_NUC_72.L_CORE 0.207973
K_5799 X_NUC_70.L_CORE X_NUC_73.L_CORE 0.002711
K_5800 X_NUC_70.L_CORE X_NUC_74.L_CORE 0.002744
K_5801 X_NUC_70.L_CORE X_NUC_75.L_CORE 0.002733
K_5802 X_NUC_70.L_CORE X_NUC_76.L_CORE 0.002720
K_5803 X_NUC_70.L_CORE X_NUC_77.L_CORE 0.003852
K_5804 X_NUC_70.L_CORE X_NUC_78.L_CORE 0.003856
K_5805 X_NUC_70.L_CORE X_NUC_79.L_CORE 0.003882
K_5806 X_NUC_70.L_CORE X_NUC_80.L_CORE 0.003812
K_5807 X_NUC_70.L_CORE X_NUC_81.L_CORE 0.005636
K_5808 X_NUC_70.L_CORE X_NUC_82.L_CORE 0.005783
K_5809 X_NUC_70.L_CORE X_NUC_83.L_CORE 0.005660
K_5810 X_NUC_70.L_CORE X_NUC_84.L_CORE 0.005688
K_5811 X_NUC_70.L_CORE X_NUC_85.L_CORE 0.002783
K_5812 X_NUC_70.L_CORE X_NUC_86.L_CORE 0.002808
K_5813 X_NUC_70.L_CORE X_NUC_87.L_CORE 0.002803
K_5814 X_NUC_70.L_CORE X_NUC_88.L_CORE 0.002777
K_5815 X_NUC_70.L_CORE X_NUC_89.L_CORE 0.006955
K_5816 X_NUC_70.L_CORE X_NUC_90.L_CORE 0.006989
K_5817 X_NUC_70.L_CORE X_NUC_91.L_CORE 0.006961
K_5818 X_NUC_70.L_CORE X_NUC_92.L_CORE 0.006786
K_5819 X_NUC_70.L_CORE X_NUC_93.L_CORE 0.003666
K_5820 X_NUC_70.L_CORE X_NUC_94.L_CORE 0.003724
K_5821 X_NUC_70.L_CORE X_NUC_95.L_CORE 0.003686
K_5822 X_NUC_70.L_CORE X_NUC_96.L_CORE 0.003667
K_5823 X_NUC_70.L_CORE X_NUC_97.L_CORE 0.003756
K_5824 X_NUC_70.L_CORE X_NUC_98.L_CORE 0.003791
K_5825 X_NUC_70.L_CORE X_NUC_99.L_CORE 0.003776
K_5826 X_NUC_70.L_CORE X_NUC_100.L_CORE 0.003727
K_5827 X_NUC_70.L_CORE X_NUC_101.L_CORE 0.002347
K_5828 X_NUC_70.L_CORE X_NUC_102.L_CORE 0.003106
K_5829 X_NUC_70.L_CORE X_NUC_103.L_CORE 0.002583
K_5830 X_NUC_70.L_CORE X_NUC_104.L_CORE 0.002355
K_5831 X_NUC_70.L_CORE X_NUC_105.L_CORE 0.004522
K_5832 X_NUC_70.L_CORE X_NUC_106.L_CORE 0.002203
K_5833 X_NUC_70.L_CORE X_NUC_107.L_CORE 0.003266
K_5834 X_NUC_70.L_CORE X_NUC_108.L_CORE 0.003588
K_5835 X_NUC_70.L_CORE X_NUC_109.L_CORE 0.002206
K_5836 X_NUC_70.L_CORE X_NUC_110.L_CORE 0.008088
K_5837 X_NUC_70.L_CORE X_NUC_111.L_CORE 0.002569
K_5838 X_NUC_70.L_CORE X_NUC_112.L_CORE 0.002827
K_5839 X_NUC_70.L_CORE X_NUC_113.L_CORE 0.007795
K_5840 X_NUC_70.L_CORE X_NUC_114.L_CORE 0.002350
K_5841 X_NUC_70.L_CORE X_NUC_115.L_CORE 0.005354
K_5842 X_NUC_70.L_CORE X_NUC_116.L_CORE 0.003615
K_5843 X_NUC_70.L_CORE X_NUC_117.L_CORE 0.002799
K_5844 X_NUC_70.L_CORE X_NUC_118.L_CORE 0.007098
K_5845 X_NUC_70.L_CORE X_NUC_119.L_CORE 0.003278
K_5846 X_NUC_71.L_CORE X_NUC_72.L_CORE 0.207973
K_5847 X_NUC_71.L_CORE X_NUC_73.L_CORE 0.002722
K_5848 X_NUC_71.L_CORE X_NUC_74.L_CORE 0.002756
K_5849 X_NUC_71.L_CORE X_NUC_75.L_CORE 0.002744
K_5850 X_NUC_71.L_CORE X_NUC_76.L_CORE 0.002731
K_5851 X_NUC_71.L_CORE X_NUC_77.L_CORE 0.003825
K_5852 X_NUC_71.L_CORE X_NUC_78.L_CORE 0.003829
K_5853 X_NUC_71.L_CORE X_NUC_79.L_CORE 0.003856
K_5854 X_NUC_71.L_CORE X_NUC_80.L_CORE 0.003787
K_5855 X_NUC_71.L_CORE X_NUC_81.L_CORE 0.005755
K_5856 X_NUC_71.L_CORE X_NUC_82.L_CORE 0.005909
K_5857 X_NUC_71.L_CORE X_NUC_83.L_CORE 0.005783
K_5858 X_NUC_71.L_CORE X_NUC_84.L_CORE 0.005810
K_5859 X_NUC_71.L_CORE X_NUC_85.L_CORE 0.002787
K_5860 X_NUC_71.L_CORE X_NUC_86.L_CORE 0.002812
K_5861 X_NUC_71.L_CORE X_NUC_87.L_CORE 0.002808
K_5862 X_NUC_71.L_CORE X_NUC_88.L_CORE 0.002781
K_5863 X_NUC_71.L_CORE X_NUC_89.L_CORE 0.006979
K_5864 X_NUC_71.L_CORE X_NUC_90.L_CORE 0.007009
K_5865 X_NUC_71.L_CORE X_NUC_91.L_CORE 0.006989
K_5866 X_NUC_71.L_CORE X_NUC_92.L_CORE 0.006808
K_5867 X_NUC_71.L_CORE X_NUC_93.L_CORE 0.003703
K_5868 X_NUC_71.L_CORE X_NUC_94.L_CORE 0.003761
K_5869 X_NUC_71.L_CORE X_NUC_95.L_CORE 0.003724
K_5870 X_NUC_71.L_CORE X_NUC_96.L_CORE 0.003703
K_5871 X_NUC_71.L_CORE X_NUC_97.L_CORE 0.003770
K_5872 X_NUC_71.L_CORE X_NUC_98.L_CORE 0.003805
K_5873 X_NUC_71.L_CORE X_NUC_99.L_CORE 0.003791
K_5874 X_NUC_71.L_CORE X_NUC_100.L_CORE 0.003740
K_5875 X_NUC_71.L_CORE X_NUC_101.L_CORE 0.002333
K_5876 X_NUC_71.L_CORE X_NUC_102.L_CORE 0.003068
K_5877 X_NUC_71.L_CORE X_NUC_103.L_CORE 0.002577
K_5878 X_NUC_71.L_CORE X_NUC_104.L_CORE 0.002338
K_5879 X_NUC_71.L_CORE X_NUC_105.L_CORE 0.004468
K_5880 X_NUC_71.L_CORE X_NUC_106.L_CORE 0.002200
K_5881 X_NUC_71.L_CORE X_NUC_107.L_CORE 0.003222
K_5882 X_NUC_71.L_CORE X_NUC_108.L_CORE 0.003601
K_5883 X_NUC_71.L_CORE X_NUC_109.L_CORE 0.002199
K_5884 X_NUC_71.L_CORE X_NUC_110.L_CORE 0.007792
K_5885 X_NUC_71.L_CORE X_NUC_111.L_CORE 0.002579
K_5886 X_NUC_71.L_CORE X_NUC_112.L_CORE 0.002807
K_5887 X_NUC_71.L_CORE X_NUC_113.L_CORE 0.007992
K_5888 X_NUC_71.L_CORE X_NUC_114.L_CORE 0.002354
K_5889 X_NUC_71.L_CORE X_NUC_115.L_CORE 0.005292
K_5890 X_NUC_71.L_CORE X_NUC_116.L_CORE 0.003659
K_5891 X_NUC_71.L_CORE X_NUC_117.L_CORE 0.002798
K_5892 X_NUC_71.L_CORE X_NUC_118.L_CORE 0.007255
K_5893 X_NUC_71.L_CORE X_NUC_119.L_CORE 0.003304
K_5894 X_NUC_72.L_CORE X_NUC_73.L_CORE 0.002735
K_5895 X_NUC_72.L_CORE X_NUC_74.L_CORE 0.002769
K_5896 X_NUC_72.L_CORE X_NUC_75.L_CORE 0.002758
K_5897 X_NUC_72.L_CORE X_NUC_76.L_CORE 0.002744
K_5898 X_NUC_72.L_CORE X_NUC_77.L_CORE 0.003896
K_5899 X_NUC_72.L_CORE X_NUC_78.L_CORE 0.003900
K_5900 X_NUC_72.L_CORE X_NUC_79.L_CORE 0.003928
K_5901 X_NUC_72.L_CORE X_NUC_80.L_CORE 0.003856
K_5902 X_NUC_72.L_CORE X_NUC_81.L_CORE 0.005726
K_5903 X_NUC_72.L_CORE X_NUC_82.L_CORE 0.005878
K_5904 X_NUC_72.L_CORE X_NUC_83.L_CORE 0.005752
K_5905 X_NUC_72.L_CORE X_NUC_84.L_CORE 0.005783
K_5906 X_NUC_72.L_CORE X_NUC_85.L_CORE 0.002814
K_5907 X_NUC_72.L_CORE X_NUC_86.L_CORE 0.002840
K_5908 X_NUC_72.L_CORE X_NUC_87.L_CORE 0.002835
K_5909 X_NUC_72.L_CORE X_NUC_88.L_CORE 0.002808
K_5910 X_NUC_72.L_CORE X_NUC_89.L_CORE 0.007170
K_5911 X_NUC_72.L_CORE X_NUC_90.L_CORE 0.007203
K_5912 X_NUC_72.L_CORE X_NUC_91.L_CORE 0.007176
K_5913 X_NUC_72.L_CORE X_NUC_92.L_CORE 0.006989
K_5914 X_NUC_72.L_CORE X_NUC_93.L_CORE 0.003722
K_5915 X_NUC_72.L_CORE X_NUC_94.L_CORE 0.003782
K_5916 X_NUC_72.L_CORE X_NUC_95.L_CORE 0.003743
K_5917 X_NUC_72.L_CORE X_NUC_96.L_CORE 0.003724
K_5918 X_NUC_72.L_CORE X_NUC_97.L_CORE 0.003821
K_5919 X_NUC_72.L_CORE X_NUC_98.L_CORE 0.003857
K_5920 X_NUC_72.L_CORE X_NUC_99.L_CORE 0.003842
K_5921 X_NUC_72.L_CORE X_NUC_100.L_CORE 0.003791
K_5922 X_NUC_72.L_CORE X_NUC_101.L_CORE 0.002345
K_5923 X_NUC_72.L_CORE X_NUC_102.L_CORE 0.003086
K_5924 X_NUC_72.L_CORE X_NUC_103.L_CORE 0.002579
K_5925 X_NUC_72.L_CORE X_NUC_104.L_CORE 0.002358
K_5926 X_NUC_72.L_CORE X_NUC_105.L_CORE 0.004452
K_5927 X_NUC_72.L_CORE X_NUC_106.L_CORE 0.002210
K_5928 X_NUC_72.L_CORE X_NUC_107.L_CORE 0.003263
K_5929 X_NUC_72.L_CORE X_NUC_108.L_CORE 0.003580
K_5930 X_NUC_72.L_CORE X_NUC_109.L_CORE 0.002218
K_5931 X_NUC_72.L_CORE X_NUC_110.L_CORE 0.007885
K_5932 X_NUC_72.L_CORE X_NUC_111.L_CORE 0.002583
K_5933 X_NUC_72.L_CORE X_NUC_112.L_CORE 0.002845
K_5934 X_NUC_72.L_CORE X_NUC_113.L_CORE 0.007774
K_5935 X_NUC_72.L_CORE X_NUC_114.L_CORE 0.002370
K_5936 X_NUC_72.L_CORE X_NUC_115.L_CORE 0.005419
K_5937 X_NUC_72.L_CORE X_NUC_116.L_CORE 0.003655
K_5938 X_NUC_72.L_CORE X_NUC_117.L_CORE 0.002831
K_5939 X_NUC_72.L_CORE X_NUC_118.L_CORE 0.007338
K_5940 X_NUC_72.L_CORE X_NUC_119.L_CORE 0.003328
K_5941 X_NUC_73.L_CORE X_NUC_74.L_CORE 0.207973
K_5942 X_NUC_73.L_CORE X_NUC_75.L_CORE 0.207973
K_5943 X_NUC_73.L_CORE X_NUC_76.L_CORE 0.207973
K_5944 X_NUC_73.L_CORE X_NUC_77.L_CORE 0.002886
K_5945 X_NUC_73.L_CORE X_NUC_78.L_CORE 0.002849
K_5946 X_NUC_73.L_CORE X_NUC_79.L_CORE 0.002872
K_5947 X_NUC_73.L_CORE X_NUC_80.L_CORE 0.002859
K_5948 X_NUC_73.L_CORE X_NUC_81.L_CORE 0.004080
K_5949 X_NUC_73.L_CORE X_NUC_82.L_CORE 0.004023
K_5950 X_NUC_73.L_CORE X_NUC_83.L_CORE 0.004017
K_5951 X_NUC_73.L_CORE X_NUC_84.L_CORE 0.004070
K_5952 X_NUC_73.L_CORE X_NUC_85.L_CORE 0.006096
K_5953 X_NUC_73.L_CORE X_NUC_86.L_CORE 0.005988
K_5954 X_NUC_73.L_CORE X_NUC_87.L_CORE 0.006064
K_5955 X_NUC_73.L_CORE X_NUC_88.L_CORE 0.005940
K_5956 X_NUC_73.L_CORE X_NUC_89.L_CORE 0.003050
K_5957 X_NUC_73.L_CORE X_NUC_90.L_CORE 0.003007
K_5958 X_NUC_73.L_CORE X_NUC_91.L_CORE 0.003020
K_5959 X_NUC_73.L_CORE X_NUC_92.L_CORE 0.003023
K_5960 X_NUC_73.L_CORE X_NUC_93.L_CORE 0.006832
K_5961 X_NUC_73.L_CORE X_NUC_94.L_CORE 0.006676
K_5962 X_NUC_73.L_CORE X_NUC_95.L_CORE 0.006622
K_5963 X_NUC_73.L_CORE X_NUC_96.L_CORE 0.006702
K_5964 X_NUC_73.L_CORE X_NUC_97.L_CORE 0.004183
K_5965 X_NUC_73.L_CORE X_NUC_98.L_CORE 0.004111
K_5966 X_NUC_73.L_CORE X_NUC_99.L_CORE 0.004131
K_5967 X_NUC_73.L_CORE X_NUC_100.L_CORE 0.004112
K_5968 X_NUC_73.L_CORE X_NUC_101.L_CORE 0.002710
K_5969 X_NUC_73.L_CORE X_NUC_102.L_CORE 0.002212
K_5970 X_NUC_73.L_CORE X_NUC_103.L_CORE 0.003201
K_5971 X_NUC_73.L_CORE X_NUC_104.L_CORE 0.002570
K_5972 X_NUC_73.L_CORE X_NUC_105.L_CORE 0.002335
K_5973 X_NUC_73.L_CORE X_NUC_106.L_CORE 0.004661
K_5974 X_NUC_73.L_CORE X_NUC_107.L_CORE 0.002211
K_5975 X_NUC_73.L_CORE X_NUC_108.L_CORE 0.003292
K_5976 X_NUC_73.L_CORE X_NUC_109.L_CORE 0.003664
K_5977 X_NUC_73.L_CORE X_NUC_110.L_CORE 0.002245
K_5978 X_NUC_73.L_CORE X_NUC_111.L_CORE 0.008295
K_5979 X_NUC_73.L_CORE X_NUC_112.L_CORE 0.002653
K_5980 X_NUC_73.L_CORE X_NUC_113.L_CORE 0.002922
K_5981 X_NUC_73.L_CORE X_NUC_114.L_CORE 0.008269
K_5982 X_NUC_73.L_CORE X_NUC_115.L_CORE 0.002476
K_5983 X_NUC_73.L_CORE X_NUC_116.L_CORE 0.005584
K_5984 X_NUC_73.L_CORE X_NUC_117.L_CORE 0.003883
K_5985 X_NUC_73.L_CORE X_NUC_118.L_CORE 0.003089
K_5986 X_NUC_73.L_CORE X_NUC_119.L_CORE 0.005725
K_5987 X_NUC_74.L_CORE X_NUC_75.L_CORE 0.207973
K_5988 X_NUC_74.L_CORE X_NUC_76.L_CORE 0.207973
K_5989 X_NUC_74.L_CORE X_NUC_77.L_CORE 0.002924
K_5990 X_NUC_74.L_CORE X_NUC_78.L_CORE 0.002886
K_5991 X_NUC_74.L_CORE X_NUC_79.L_CORE 0.002910
K_5992 X_NUC_74.L_CORE X_NUC_80.L_CORE 0.002896
K_5993 X_NUC_74.L_CORE X_NUC_81.L_CORE 0.004138
K_5994 X_NUC_74.L_CORE X_NUC_82.L_CORE 0.004080
K_5995 X_NUC_74.L_CORE X_NUC_83.L_CORE 0.004073
K_5996 X_NUC_74.L_CORE X_NUC_84.L_CORE 0.004128
K_5997 X_NUC_74.L_CORE X_NUC_85.L_CORE 0.006204
K_5998 X_NUC_74.L_CORE X_NUC_86.L_CORE 0.006096
K_5999 X_NUC_74.L_CORE X_NUC_87.L_CORE 0.006173
K_6000 X_NUC_74.L_CORE X_NUC_88.L_CORE 0.006042
K_6001 X_NUC_74.L_CORE X_NUC_89.L_CORE 0.003094
K_6002 X_NUC_74.L_CORE X_NUC_90.L_CORE 0.003050
K_6003 X_NUC_74.L_CORE X_NUC_91.L_CORE 0.003063
K_6004 X_NUC_74.L_CORE X_NUC_92.L_CORE 0.003066
K_6005 X_NUC_74.L_CORE X_NUC_93.L_CORE 0.006993
K_6006 X_NUC_74.L_CORE X_NUC_94.L_CORE 0.006832
K_6007 X_NUC_74.L_CORE X_NUC_95.L_CORE 0.006772
K_6008 X_NUC_74.L_CORE X_NUC_96.L_CORE 0.006857
K_6009 X_NUC_74.L_CORE X_NUC_97.L_CORE 0.004257
K_6010 X_NUC_74.L_CORE X_NUC_98.L_CORE 0.004183
K_6011 X_NUC_74.L_CORE X_NUC_99.L_CORE 0.004203
K_6012 X_NUC_74.L_CORE X_NUC_100.L_CORE 0.004183
K_6013 X_NUC_74.L_CORE X_NUC_101.L_CORE 0.002723
K_6014 X_NUC_74.L_CORE X_NUC_102.L_CORE 0.002229
K_6015 X_NUC_74.L_CORE X_NUC_103.L_CORE 0.003211
K_6016 X_NUC_74.L_CORE X_NUC_104.L_CORE 0.002588
K_6017 X_NUC_74.L_CORE X_NUC_105.L_CORE 0.002354
K_6018 X_NUC_74.L_CORE X_NUC_106.L_CORE 0.004647
K_6019 X_NUC_74.L_CORE X_NUC_107.L_CORE 0.002232
K_6020 X_NUC_74.L_CORE X_NUC_108.L_CORE 0.003313
K_6021 X_NUC_74.L_CORE X_NUC_109.L_CORE 0.003684
K_6022 X_NUC_74.L_CORE X_NUC_110.L_CORE 0.002269
K_6023 X_NUC_74.L_CORE X_NUC_111.L_CORE 0.008184
K_6024 X_NUC_74.L_CORE X_NUC_112.L_CORE 0.002680
K_6025 X_NUC_74.L_CORE X_NUC_113.L_CORE 0.002952
K_6026 X_NUC_74.L_CORE X_NUC_114.L_CORE 0.008272
K_6027 X_NUC_74.L_CORE X_NUC_115.L_CORE 0.002505
K_6028 X_NUC_74.L_CORE X_NUC_116.L_CORE 0.005647
K_6029 X_NUC_74.L_CORE X_NUC_117.L_CORE 0.003934
K_6030 X_NUC_74.L_CORE X_NUC_118.L_CORE 0.003131
K_6031 X_NUC_74.L_CORE X_NUC_119.L_CORE 0.005829
K_6032 X_NUC_75.L_CORE X_NUC_76.L_CORE 0.207973
K_6033 X_NUC_75.L_CORE X_NUC_77.L_CORE 0.002899
K_6034 X_NUC_75.L_CORE X_NUC_78.L_CORE 0.002861
K_6035 X_NUC_75.L_CORE X_NUC_79.L_CORE 0.002886
K_6036 X_NUC_75.L_CORE X_NUC_80.L_CORE 0.002872
K_6037 X_NUC_75.L_CORE X_NUC_81.L_CORE 0.004145
K_6038 X_NUC_75.L_CORE X_NUC_82.L_CORE 0.004086
K_6039 X_NUC_75.L_CORE X_NUC_83.L_CORE 0.004080
K_6040 X_NUC_75.L_CORE X_NUC_84.L_CORE 0.004135
K_6041 X_NUC_75.L_CORE X_NUC_85.L_CORE 0.006122
K_6042 X_NUC_75.L_CORE X_NUC_86.L_CORE 0.006016
K_6043 X_NUC_75.L_CORE X_NUC_87.L_CORE 0.006096
K_6044 X_NUC_75.L_CORE X_NUC_88.L_CORE 0.005967
K_6045 X_NUC_75.L_CORE X_NUC_89.L_CORE 0.003080
K_6046 X_NUC_75.L_CORE X_NUC_90.L_CORE 0.003036
K_6047 X_NUC_75.L_CORE X_NUC_91.L_CORE 0.003050
K_6048 X_NUC_75.L_CORE X_NUC_92.L_CORE 0.003053
K_6049 X_NUC_75.L_CORE X_NUC_93.L_CORE 0.007056
K_6050 X_NUC_75.L_CORE X_NUC_94.L_CORE 0.006887
K_6051 X_NUC_75.L_CORE X_NUC_95.L_CORE 0.006832
K_6052 X_NUC_75.L_CORE X_NUC_96.L_CORE 0.006916
K_6053 X_NUC_75.L_CORE X_NUC_97.L_CORE 0.004235
K_6054 X_NUC_75.L_CORE X_NUC_98.L_CORE 0.004162
K_6055 X_NUC_75.L_CORE X_NUC_99.L_CORE 0.004183
K_6056 X_NUC_75.L_CORE X_NUC_100.L_CORE 0.004162
K_6057 X_NUC_75.L_CORE X_NUC_101.L_CORE 0.002691
K_6058 X_NUC_75.L_CORE X_NUC_102.L_CORE 0.002209
K_6059 X_NUC_75.L_CORE X_NUC_103.L_CORE 0.003183
K_6060 X_NUC_75.L_CORE X_NUC_104.L_CORE 0.002556
K_6061 X_NUC_75.L_CORE X_NUC_105.L_CORE 0.002340
K_6062 X_NUC_75.L_CORE X_NUC_106.L_CORE 0.004573
K_6063 X_NUC_75.L_CORE X_NUC_107.L_CORE 0.002212
K_6064 X_NUC_75.L_CORE X_NUC_108.L_CORE 0.003303
K_6065 X_NUC_75.L_CORE X_NUC_109.L_CORE 0.003626
K_6066 X_NUC_75.L_CORE X_NUC_110.L_CORE 0.002255
K_6067 X_NUC_75.L_CORE X_NUC_111.L_CORE 0.008204
K_6068 X_NUC_75.L_CORE X_NUC_112.L_CORE 0.002653
K_6069 X_NUC_75.L_CORE X_NUC_113.L_CORE 0.002949
K_6070 X_NUC_75.L_CORE X_NUC_114.L_CORE 0.008111
K_6071 X_NUC_75.L_CORE X_NUC_115.L_CORE 0.002491
K_6072 X_NUC_75.L_CORE X_NUC_116.L_CORE 0.005714
K_6073 X_NUC_75.L_CORE X_NUC_117.L_CORE 0.003900
K_6074 X_NUC_75.L_CORE X_NUC_118.L_CORE 0.003127
K_6075 X_NUC_75.L_CORE X_NUC_119.L_CORE 0.005864
K_6076 X_NUC_76.L_CORE X_NUC_77.L_CORE 0.002913
K_6077 X_NUC_76.L_CORE X_NUC_78.L_CORE 0.002875
K_6078 X_NUC_76.L_CORE X_NUC_79.L_CORE 0.002899
K_6079 X_NUC_76.L_CORE X_NUC_80.L_CORE 0.002886
K_6080 X_NUC_76.L_CORE X_NUC_81.L_CORE 0.004089
K_6081 X_NUC_76.L_CORE X_NUC_82.L_CORE 0.004032
K_6082 X_NUC_76.L_CORE X_NUC_83.L_CORE 0.004026
K_6083 X_NUC_76.L_CORE X_NUC_84.L_CORE 0.004080
K_6084 X_NUC_76.L_CORE X_NUC_85.L_CORE 0.006259
K_6085 X_NUC_76.L_CORE X_NUC_86.L_CORE 0.006145
K_6086 X_NUC_76.L_CORE X_NUC_87.L_CORE 0.006227
K_6087 X_NUC_76.L_CORE X_NUC_88.L_CORE 0.006096
K_6088 X_NUC_76.L_CORE X_NUC_89.L_CORE 0.003077
K_6089 X_NUC_76.L_CORE X_NUC_90.L_CORE 0.003033
K_6090 X_NUC_76.L_CORE X_NUC_91.L_CORE 0.003046
K_6091 X_NUC_76.L_CORE X_NUC_92.L_CORE 0.003050
K_6092 X_NUC_76.L_CORE X_NUC_93.L_CORE 0.006964
K_6093 X_NUC_76.L_CORE X_NUC_94.L_CORE 0.006801
K_6094 X_NUC_76.L_CORE X_NUC_95.L_CORE 0.006745
K_6095 X_NUC_76.L_CORE X_NUC_96.L_CORE 0.006832
K_6096 X_NUC_76.L_CORE X_NUC_97.L_CORE 0.004257
K_6097 X_NUC_76.L_CORE X_NUC_98.L_CORE 0.004182
K_6098 X_NUC_76.L_CORE X_NUC_99.L_CORE 0.004203
K_6099 X_NUC_76.L_CORE X_NUC_100.L_CORE 0.004183
K_6100 X_NUC_76.L_CORE X_NUC_101.L_CORE 0.002696
K_6101 X_NUC_76.L_CORE X_NUC_102.L_CORE 0.002209
K_6102 X_NUC_76.L_CORE X_NUC_103.L_CORE 0.003166
K_6103 X_NUC_76.L_CORE X_NUC_104.L_CORE 0.002571
K_6104 X_NUC_76.L_CORE X_NUC_105.L_CORE 0.002329
K_6105 X_NUC_76.L_CORE X_NUC_106.L_CORE 0.004595
K_6106 X_NUC_76.L_CORE X_NUC_107.L_CORE 0.002218
K_6107 X_NUC_76.L_CORE X_NUC_108.L_CORE 0.003264
K_6108 X_NUC_76.L_CORE X_NUC_109.L_CORE 0.003678
K_6109 X_NUC_76.L_CORE X_NUC_110.L_CORE 0.002250
K_6110 X_NUC_76.L_CORE X_NUC_111.L_CORE 0.007988
K_6111 X_NUC_76.L_CORE X_NUC_112.L_CORE 0.002673
K_6112 X_NUC_76.L_CORE X_NUC_113.L_CORE 0.002921
K_6113 X_NUC_76.L_CORE X_NUC_114.L_CORE 0.008440
K_6114 X_NUC_76.L_CORE X_NUC_115.L_CORE 0.002493
K_6115 X_NUC_76.L_CORE X_NUC_116.L_CORE 0.005582
K_6116 X_NUC_76.L_CORE X_NUC_117.L_CORE 0.003949
K_6117 X_NUC_76.L_CORE X_NUC_118.L_CORE 0.003114
K_6118 X_NUC_76.L_CORE X_NUC_119.L_CORE 0.005864
K_6119 X_NUC_77.L_CORE X_NUC_78.L_CORE 0.207973
K_6120 X_NUC_77.L_CORE X_NUC_79.L_CORE 0.207973
K_6121 X_NUC_77.L_CORE X_NUC_80.L_CORE 0.207973
K_6122 X_NUC_77.L_CORE X_NUC_81.L_CORE 0.003082
K_6123 X_NUC_77.L_CORE X_NUC_82.L_CORE 0.003103
K_6124 X_NUC_77.L_CORE X_NUC_83.L_CORE 0.003070
K_6125 X_NUC_77.L_CORE X_NUC_84.L_CORE 0.003111
K_6126 X_NUC_77.L_CORE X_NUC_85.L_CORE 0.004394
K_6127 X_NUC_77.L_CORE X_NUC_86.L_CORE 0.004488
K_6128 X_NUC_77.L_CORE X_NUC_87.L_CORE 0.004429
K_6129 X_NUC_77.L_CORE X_NUC_88.L_CORE 0.004429
K_6130 X_NUC_77.L_CORE X_NUC_89.L_CORE 0.006502
K_6131 X_NUC_77.L_CORE X_NUC_90.L_CORE 0.006506
K_6132 X_NUC_77.L_CORE X_NUC_91.L_CORE 0.006363
K_6133 X_NUC_77.L_CORE X_NUC_92.L_CORE 0.006550
K_6134 X_NUC_77.L_CORE X_NUC_93.L_CORE 0.003434
K_6135 X_NUC_77.L_CORE X_NUC_94.L_CORE 0.003477
K_6136 X_NUC_77.L_CORE X_NUC_95.L_CORE 0.003428
K_6137 X_NUC_77.L_CORE X_NUC_96.L_CORE 0.003463
K_6138 X_NUC_77.L_CORE X_NUC_97.L_CORE 0.006290
K_6139 X_NUC_77.L_CORE X_NUC_98.L_CORE 0.006433
K_6140 X_NUC_77.L_CORE X_NUC_99.L_CORE 0.006247
K_6141 X_NUC_77.L_CORE X_NUC_100.L_CORE 0.006322
K_6142 X_NUC_77.L_CORE X_NUC_101.L_CORE 0.002457
K_6143 X_NUC_77.L_CORE X_NUC_102.L_CORE 0.002832
K_6144 X_NUC_77.L_CORE X_NUC_103.L_CORE 0.002173
K_6145 X_NUC_77.L_CORE X_NUC_104.L_CORE 0.003284
K_6146 X_NUC_77.L_CORE X_NUC_105.L_CORE 0.002584
K_6147 X_NUC_77.L_CORE X_NUC_106.L_CORE 0.002365
K_6148 X_NUC_77.L_CORE X_NUC_107.L_CORE 0.004723
K_6149 X_NUC_77.L_CORE X_NUC_108.L_CORE 0.002259
K_6150 X_NUC_77.L_CORE X_NUC_109.L_CORE 0.003388
K_6151 X_NUC_77.L_CORE X_NUC_110.L_CORE 0.003750
K_6152 X_NUC_77.L_CORE X_NUC_111.L_CORE 0.002338
K_6153 X_NUC_77.L_CORE X_NUC_112.L_CORE 0.008537
K_6154 X_NUC_77.L_CORE X_NUC_113.L_CORE 0.002789
K_6155 X_NUC_77.L_CORE X_NUC_114.L_CORE 0.003115
K_6156 X_NUC_77.L_CORE X_NUC_115.L_CORE 0.008665
K_6157 X_NUC_77.L_CORE X_NUC_116.L_CORE 0.002691
K_6158 X_NUC_77.L_CORE X_NUC_117.L_CORE 0.006075
K_6159 X_NUC_77.L_CORE X_NUC_118.L_CORE 0.004304
K_6160 X_NUC_77.L_CORE X_NUC_119.L_CORE 0.003722
K_6161 X_NUC_78.L_CORE X_NUC_79.L_CORE 0.207973
K_6162 X_NUC_78.L_CORE X_NUC_80.L_CORE 0.207973
K_6163 X_NUC_78.L_CORE X_NUC_81.L_CORE 0.003061
K_6164 X_NUC_78.L_CORE X_NUC_82.L_CORE 0.003082
K_6165 X_NUC_78.L_CORE X_NUC_83.L_CORE 0.003049
K_6166 X_NUC_78.L_CORE X_NUC_84.L_CORE 0.003090
K_6167 X_NUC_78.L_CORE X_NUC_85.L_CORE 0.004304
K_6168 X_NUC_78.L_CORE X_NUC_86.L_CORE 0.004394
K_6169 X_NUC_78.L_CORE X_NUC_87.L_CORE 0.004338
K_6170 X_NUC_78.L_CORE X_NUC_88.L_CORE 0.004338
K_6171 X_NUC_78.L_CORE X_NUC_89.L_CORE 0.006493
K_6172 X_NUC_78.L_CORE X_NUC_90.L_CORE 0.006502
K_6173 X_NUC_78.L_CORE X_NUC_91.L_CORE 0.006357
K_6174 X_NUC_78.L_CORE X_NUC_92.L_CORE 0.006543
K_6175 X_NUC_78.L_CORE X_NUC_93.L_CORE 0.003392
K_6176 X_NUC_78.L_CORE X_NUC_94.L_CORE 0.003434
K_6177 X_NUC_78.L_CORE X_NUC_95.L_CORE 0.003386
K_6178 X_NUC_78.L_CORE X_NUC_96.L_CORE 0.003420
K_6179 X_NUC_78.L_CORE X_NUC_97.L_CORE 0.006152
K_6180 X_NUC_78.L_CORE X_NUC_98.L_CORE 0.006290
K_6181 X_NUC_78.L_CORE X_NUC_99.L_CORE 0.006114
K_6182 X_NUC_78.L_CORE X_NUC_100.L_CORE 0.006184
K_6183 X_NUC_78.L_CORE X_NUC_101.L_CORE 0.002444
K_6184 X_NUC_78.L_CORE X_NUC_102.L_CORE 0.002832
K_6185 X_NUC_78.L_CORE X_NUC_103.L_CORE 0.002160
K_6186 X_NUC_78.L_CORE X_NUC_104.L_CORE 0.003266
K_6187 X_NUC_78.L_CORE X_NUC_105.L_CORE 0.002583
K_6188 X_NUC_78.L_CORE X_NUC_106.L_CORE 0.002343
K_6189 X_NUC_78.L_CORE X_NUC_107.L_CORE 0.004760
K_6190 X_NUC_78.L_CORE X_NUC_108.L_CORE 0.002248
K_6191 X_NUC_78.L_CORE X_NUC_109.L_CORE 0.003345
K_6192 X_NUC_78.L_CORE X_NUC_110.L_CORE 0.003774
K_6193 X_NUC_78.L_CORE X_NUC_111.L_CORE 0.002316
K_6194 X_NUC_78.L_CORE X_NUC_112.L_CORE 0.008475
K_6195 X_NUC_78.L_CORE X_NUC_113.L_CORE 0.002781
K_6196 X_NUC_78.L_CORE X_NUC_114.L_CORE 0.003070
K_6197 X_NUC_78.L_CORE X_NUC_115.L_CORE 0.008909
K_6198 X_NUC_78.L_CORE X_NUC_116.L_CORE 0.002668
K_6199 X_NUC_78.L_CORE X_NUC_117.L_CORE 0.005922
K_6200 X_NUC_78.L_CORE X_NUC_118.L_CORE 0.004291
K_6201 X_NUC_78.L_CORE X_NUC_119.L_CORE 0.003670
K_6202 X_NUC_79.L_CORE X_NUC_80.L_CORE 0.207973
K_6203 X_NUC_79.L_CORE X_NUC_81.L_CORE 0.003093
K_6204 X_NUC_79.L_CORE X_NUC_82.L_CORE 0.003114
K_6205 X_NUC_79.L_CORE X_NUC_83.L_CORE 0.003082
K_6206 X_NUC_79.L_CORE X_NUC_84.L_CORE 0.003123
K_6207 X_NUC_79.L_CORE X_NUC_85.L_CORE 0.004358
K_6208 X_NUC_79.L_CORE X_NUC_86.L_CORE 0.004450
K_6209 X_NUC_79.L_CORE X_NUC_87.L_CORE 0.004394
K_6210 X_NUC_79.L_CORE X_NUC_88.L_CORE 0.004393
K_6211 X_NUC_79.L_CORE X_NUC_89.L_CORE 0.006645
K_6212 X_NUC_79.L_CORE X_NUC_90.L_CORE 0.006652
K_6213 X_NUC_79.L_CORE X_NUC_91.L_CORE 0.006502
K_6214 X_NUC_79.L_CORE X_NUC_92.L_CORE 0.006699
K_6215 X_NUC_79.L_CORE X_NUC_93.L_CORE 0.003439
K_6216 X_NUC_79.L_CORE X_NUC_94.L_CORE 0.003483
K_6217 X_NUC_79.L_CORE X_NUC_95.L_CORE 0.003434
K_6218 X_NUC_79.L_CORE X_NUC_96.L_CORE 0.003469
K_6219 X_NUC_79.L_CORE X_NUC_97.L_CORE 0.006329
K_6220 X_NUC_79.L_CORE X_NUC_98.L_CORE 0.006477
K_6221 X_NUC_79.L_CORE X_NUC_99.L_CORE 0.006290
K_6222 X_NUC_79.L_CORE X_NUC_100.L_CORE 0.006364
K_6223 X_NUC_79.L_CORE X_NUC_101.L_CORE 0.002435
K_6224 X_NUC_79.L_CORE X_NUC_102.L_CORE 0.002814
K_6225 X_NUC_79.L_CORE X_NUC_103.L_CORE 0.002161
K_6226 X_NUC_79.L_CORE X_NUC_104.L_CORE 0.003237
K_6227 X_NUC_79.L_CORE X_NUC_105.L_CORE 0.002581
K_6228 X_NUC_79.L_CORE X_NUC_106.L_CORE 0.002346
K_6229 X_NUC_79.L_CORE X_NUC_107.L_CORE 0.004671
K_6230 X_NUC_79.L_CORE X_NUC_108.L_CORE 0.002256
K_6231 X_NUC_79.L_CORE X_NUC_109.L_CORE 0.003338
K_6232 X_NUC_79.L_CORE X_NUC_110.L_CORE 0.003767
K_6233 X_NUC_79.L_CORE X_NUC_111.L_CORE 0.002329
K_6234 X_NUC_79.L_CORE X_NUC_112.L_CORE 0.008235
K_6235 X_NUC_79.L_CORE X_NUC_113.L_CORE 0.002800
K_6236 X_NUC_79.L_CORE X_NUC_114.L_CORE 0.003090
K_6237 X_NUC_79.L_CORE X_NUC_115.L_CORE 0.008948
K_6238 X_NUC_79.L_CORE X_NUC_116.L_CORE 0.002694
K_6239 X_NUC_79.L_CORE X_NUC_117.L_CORE 0.006018
K_6240 X_NUC_79.L_CORE X_NUC_118.L_CORE 0.004363
K_6241 X_NUC_79.L_CORE X_NUC_119.L_CORE 0.003730
K_6242 X_NUC_80.L_CORE X_NUC_81.L_CORE 0.003053
K_6243 X_NUC_80.L_CORE X_NUC_82.L_CORE 0.003073
K_6244 X_NUC_80.L_CORE X_NUC_83.L_CORE 0.003042
K_6245 X_NUC_80.L_CORE X_NUC_84.L_CORE 0.003082
K_6246 X_NUC_80.L_CORE X_NUC_85.L_CORE 0.004357
K_6247 X_NUC_80.L_CORE X_NUC_86.L_CORE 0.004450
K_6248 X_NUC_80.L_CORE X_NUC_87.L_CORE 0.004392
K_6249 X_NUC_80.L_CORE X_NUC_88.L_CORE 0.004394
K_6250 X_NUC_80.L_CORE X_NUC_89.L_CORE 0.006450
K_6251 X_NUC_80.L_CORE X_NUC_90.L_CORE 0.006456
K_6252 X_NUC_80.L_CORE X_NUC_91.L_CORE 0.006316
K_6253 X_NUC_80.L_CORE X_NUC_92.L_CORE 0.006502
K_6254 X_NUC_80.L_CORE X_NUC_93.L_CORE 0.003405
K_6255 X_NUC_80.L_CORE X_NUC_94.L_CORE 0.003448
K_6256 X_NUC_80.L_CORE X_NUC_95.L_CORE 0.003400
K_6257 X_NUC_80.L_CORE X_NUC_96.L_CORE 0.003434
K_6258 X_NUC_80.L_CORE X_NUC_97.L_CORE 0.006254
K_6259 X_NUC_80.L_CORE X_NUC_98.L_CORE 0.006396
K_6260 X_NUC_80.L_CORE X_NUC_99.L_CORE 0.006214
K_6261 X_NUC_80.L_CORE X_NUC_100.L_CORE 0.006290
K_6262 X_NUC_80.L_CORE X_NUC_101.L_CORE 0.002431
K_6263 X_NUC_80.L_CORE X_NUC_102.L_CORE 0.002800
K_6264 X_NUC_80.L_CORE X_NUC_103.L_CORE 0.002150
K_6265 X_NUC_80.L_CORE X_NUC_104.L_CORE 0.003248
K_6266 X_NUC_80.L_CORE X_NUC_105.L_CORE 0.002557
K_6267 X_NUC_80.L_CORE X_NUC_106.L_CORE 0.002342
K_6268 X_NUC_80.L_CORE X_NUC_107.L_CORE 0.004669
K_6269 X_NUC_80.L_CORE X_NUC_108.L_CORE 0.002237
K_6270 X_NUC_80.L_CORE X_NUC_109.L_CORE 0.003356
K_6271 X_NUC_80.L_CORE X_NUC_110.L_CORE 0.003713
K_6272 X_NUC_80.L_CORE X_NUC_111.L_CORE 0.002317
K_6273 X_NUC_80.L_CORE X_NUC_112.L_CORE 0.008498
K_6274 X_NUC_80.L_CORE X_NUC_113.L_CORE 0.002764
K_6275 X_NUC_80.L_CORE X_NUC_114.L_CORE 0.003090
K_6276 X_NUC_80.L_CORE X_NUC_115.L_CORE 0.008668
K_6277 X_NUC_80.L_CORE X_NUC_116.L_CORE 0.002669
K_6278 X_NUC_80.L_CORE X_NUC_117.L_CORE 0.006067
K_6279 X_NUC_80.L_CORE X_NUC_118.L_CORE 0.004281
K_6280 X_NUC_80.L_CORE X_NUC_119.L_CORE 0.003700
K_6281 X_NUC_81.L_CORE X_NUC_82.L_CORE 0.207973
K_6282 X_NUC_81.L_CORE X_NUC_83.L_CORE 0.207973
K_6283 X_NUC_81.L_CORE X_NUC_84.L_CORE 0.207973
K_6284 X_NUC_81.L_CORE X_NUC_85.L_CORE 0.003364
K_6285 X_NUC_81.L_CORE X_NUC_86.L_CORE 0.003378
K_6286 X_NUC_81.L_CORE X_NUC_87.L_CORE 0.003395
K_6287 X_NUC_81.L_CORE X_NUC_88.L_CORE 0.003342
K_6288 X_NUC_81.L_CORE X_NUC_89.L_CORE 0.004855
K_6289 X_NUC_81.L_CORE X_NUC_90.L_CORE 0.004776
K_6290 X_NUC_81.L_CORE X_NUC_91.L_CORE 0.004840
K_6291 X_NUC_81.L_CORE X_NUC_92.L_CORE 0.004764
K_6292 X_NUC_81.L_CORE X_NUC_93.L_CORE 0.007010
K_6293 X_NUC_81.L_CORE X_NUC_94.L_CORE 0.007128
K_6294 X_NUC_81.L_CORE X_NUC_95.L_CORE 0.007098
K_6295 X_NUC_81.L_CORE X_NUC_96.L_CORE 0.006914
K_6296 X_NUC_81.L_CORE X_NUC_97.L_CORE 0.004202
K_6297 X_NUC_81.L_CORE X_NUC_98.L_CORE 0.004191
K_6298 X_NUC_81.L_CORE X_NUC_99.L_CORE 0.004219
K_6299 X_NUC_81.L_CORE X_NUC_100.L_CORE 0.004140
K_6300 X_NUC_81.L_CORE X_NUC_101.L_CORE 0.002293
K_6301 X_NUC_81.L_CORE X_NUC_102.L_CORE 0.002433
K_6302 X_NUC_81.L_CORE X_NUC_103.L_CORE 0.002904
K_6303 X_NUC_81.L_CORE X_NUC_104.L_CORE 0.002150
K_6304 X_NUC_81.L_CORE X_NUC_105.L_CORE 0.003312
K_6305 X_NUC_81.L_CORE X_NUC_106.L_CORE 0.002617
K_6306 X_NUC_81.L_CORE X_NUC_107.L_CORE 0.002380
K_6307 X_NUC_81.L_CORE X_NUC_108.L_CORE 0.004802
K_6308 X_NUC_81.L_CORE X_NUC_109.L_CORE 0.002314
K_6309 X_NUC_81.L_CORE X_NUC_110.L_CORE 0.003432
K_6310 X_NUC_81.L_CORE X_NUC_111.L_CORE 0.003913
K_6311 X_NUC_81.L_CORE X_NUC_112.L_CORE 0.002426
K_6312 X_NUC_81.L_CORE X_NUC_113.L_CORE 0.008663
K_6313 X_NUC_81.L_CORE X_NUC_114.L_CORE 0.002966
K_6314 X_NUC_81.L_CORE X_NUC_115.L_CORE 0.003297
K_6315 X_NUC_81.L_CORE X_NUC_116.L_CORE 0.009722
K_6316 X_NUC_81.L_CORE X_NUC_117.L_CORE 0.002968
K_6317 X_NUC_81.L_CORE X_NUC_118.L_CORE 0.006413
K_6318 X_NUC_81.L_CORE X_NUC_119.L_CORE 0.004927
K_6319 X_NUC_82.L_CORE X_NUC_83.L_CORE 0.207973
K_6320 X_NUC_82.L_CORE X_NUC_84.L_CORE 0.207973
K_6321 X_NUC_82.L_CORE X_NUC_85.L_CORE 0.003350
K_6322 X_NUC_82.L_CORE X_NUC_86.L_CORE 0.003364
K_6323 X_NUC_82.L_CORE X_NUC_87.L_CORE 0.003381
K_6324 X_NUC_82.L_CORE X_NUC_88.L_CORE 0.003329
K_6325 X_NUC_82.L_CORE X_NUC_89.L_CORE 0.004934
K_6326 X_NUC_82.L_CORE X_NUC_90.L_CORE 0.004855
K_6327 X_NUC_82.L_CORE X_NUC_91.L_CORE 0.004920
K_6328 X_NUC_82.L_CORE X_NUC_92.L_CORE 0.004840
K_6329 X_NUC_82.L_CORE X_NUC_93.L_CORE 0.006889
K_6330 X_NUC_82.L_CORE X_NUC_94.L_CORE 0.007010
K_6331 X_NUC_82.L_CORE X_NUC_95.L_CORE 0.006977
K_6332 X_NUC_82.L_CORE X_NUC_96.L_CORE 0.006802
K_6333 X_NUC_82.L_CORE X_NUC_97.L_CORE 0.004213
K_6334 X_NUC_82.L_CORE X_NUC_98.L_CORE 0.004202
K_6335 X_NUC_82.L_CORE X_NUC_99.L_CORE 0.004230
K_6336 X_NUC_82.L_CORE X_NUC_100.L_CORE 0.004150
K_6337 X_NUC_82.L_CORE X_NUC_101.L_CORE 0.002291
K_6338 X_NUC_82.L_CORE X_NUC_102.L_CORE 0.002444
K_6339 X_NUC_82.L_CORE X_NUC_103.L_CORE 0.002891
K_6340 X_NUC_82.L_CORE X_NUC_104.L_CORE 0.002152
K_6341 X_NUC_82.L_CORE X_NUC_105.L_CORE 0.003336
K_6342 X_NUC_82.L_CORE X_NUC_106.L_CORE 0.002599
K_6343 X_NUC_82.L_CORE X_NUC_107.L_CORE 0.002394
K_6344 X_NUC_82.L_CORE X_NUC_108.L_CORE 0.004771
K_6345 X_NUC_82.L_CORE X_NUC_109.L_CORE 0.002308
K_6346 X_NUC_82.L_CORE X_NUC_110.L_CORE 0.003481
K_6347 X_NUC_82.L_CORE X_NUC_111.L_CORE 0.003852
K_6348 X_NUC_82.L_CORE X_NUC_112.L_CORE 0.002435
K_6349 X_NUC_82.L_CORE X_NUC_113.L_CORE 0.008910
K_6350 X_NUC_82.L_CORE X_NUC_114.L_CORE 0.002944
K_6351 X_NUC_82.L_CORE X_NUC_115.L_CORE 0.003336
K_6352 X_NUC_82.L_CORE X_NUC_116.L_CORE 0.009299
K_6353 X_NUC_82.L_CORE X_NUC_117.L_CORE 0.002968
K_6354 X_NUC_82.L_CORE X_NUC_118.L_CORE 0.006563
K_6355 X_NUC_82.L_CORE X_NUC_119.L_CORE 0.004890
K_6356 X_NUC_83.L_CORE X_NUC_84.L_CORE 0.207973
K_6357 X_NUC_83.L_CORE X_NUC_85.L_CORE 0.003333
K_6358 X_NUC_83.L_CORE X_NUC_86.L_CORE 0.003347
K_6359 X_NUC_83.L_CORE X_NUC_87.L_CORE 0.003364
K_6360 X_NUC_83.L_CORE X_NUC_88.L_CORE 0.003312
K_6361 X_NUC_83.L_CORE X_NUC_89.L_CORE 0.004867
K_6362 X_NUC_83.L_CORE X_NUC_90.L_CORE 0.004789
K_6363 X_NUC_83.L_CORE X_NUC_91.L_CORE 0.004855
K_6364 X_NUC_83.L_CORE X_NUC_92.L_CORE 0.004776
K_6365 X_NUC_83.L_CORE X_NUC_93.L_CORE 0.006917
K_6366 X_NUC_83.L_CORE X_NUC_94.L_CORE 0.007035
K_6367 X_NUC_83.L_CORE X_NUC_95.L_CORE 0.007010
K_6368 X_NUC_83.L_CORE X_NUC_96.L_CORE 0.006829
K_6369 X_NUC_83.L_CORE X_NUC_97.L_CORE 0.004185
K_6370 X_NUC_83.L_CORE X_NUC_98.L_CORE 0.004174
K_6371 X_NUC_83.L_CORE X_NUC_99.L_CORE 0.004202
K_6372 X_NUC_83.L_CORE X_NUC_100.L_CORE 0.004123
K_6373 X_NUC_83.L_CORE X_NUC_101.L_CORE 0.002271
K_6374 X_NUC_83.L_CORE X_NUC_102.L_CORE 0.002416
K_6375 X_NUC_83.L_CORE X_NUC_103.L_CORE 0.002868
K_6376 X_NUC_83.L_CORE X_NUC_104.L_CORE 0.002133
K_6377 X_NUC_83.L_CORE X_NUC_105.L_CORE 0.003291
K_6378 X_NUC_83.L_CORE X_NUC_106.L_CORE 0.002584
K_6379 X_NUC_83.L_CORE X_NUC_107.L_CORE 0.002368
K_6380 X_NUC_83.L_CORE X_NUC_108.L_CORE 0.004733
K_6381 X_NUC_83.L_CORE X_NUC_109.L_CORE 0.002293
K_6382 X_NUC_83.L_CORE X_NUC_110.L_CORE 0.003430
K_6383 X_NUC_83.L_CORE X_NUC_111.L_CORE 0.003848
K_6384 X_NUC_83.L_CORE X_NUC_112.L_CORE 0.002414
K_6385 X_NUC_83.L_CORE X_NUC_113.L_CORE 0.008743
K_6386 X_NUC_83.L_CORE X_NUC_114.L_CORE 0.002934
K_6387 X_NUC_83.L_CORE X_NUC_115.L_CORE 0.003297
K_6388 X_NUC_83.L_CORE X_NUC_116.L_CORE 0.009525
K_6389 X_NUC_83.L_CORE X_NUC_117.L_CORE 0.002951
K_6390 X_NUC_83.L_CORE X_NUC_118.L_CORE 0.006502
K_6391 X_NUC_83.L_CORE X_NUC_119.L_CORE 0.004900
K_6392 X_NUC_84.L_CORE X_NUC_85.L_CORE 0.003385
K_6393 X_NUC_84.L_CORE X_NUC_86.L_CORE 0.003400
K_6394 X_NUC_84.L_CORE X_NUC_87.L_CORE 0.003417
K_6395 X_NUC_84.L_CORE X_NUC_88.L_CORE 0.003364
K_6396 X_NUC_84.L_CORE X_NUC_89.L_CORE 0.004949
K_6397 X_NUC_84.L_CORE X_NUC_90.L_CORE 0.004867
K_6398 X_NUC_84.L_CORE X_NUC_91.L_CORE 0.004934
K_6399 X_NUC_84.L_CORE X_NUC_92.L_CORE 0.004855
K_6400 X_NUC_84.L_CORE X_NUC_93.L_CORE 0.007101
K_6401 X_NUC_84.L_CORE X_NUC_94.L_CORE 0.007229
K_6402 X_NUC_84.L_CORE X_NUC_95.L_CORE 0.007197
K_6403 X_NUC_84.L_CORE X_NUC_96.L_CORE 0.007010
K_6404 X_NUC_84.L_CORE X_NUC_97.L_CORE 0.004266
K_6405 X_NUC_84.L_CORE X_NUC_98.L_CORE 0.004255
K_6406 X_NUC_84.L_CORE X_NUC_99.L_CORE 0.004284
K_6407 X_NUC_84.L_CORE X_NUC_100.L_CORE 0.004202
K_6408 X_NUC_84.L_CORE X_NUC_101.L_CORE 0.002283
K_6409 X_NUC_84.L_CORE X_NUC_102.L_CORE 0.002427
K_6410 X_NUC_84.L_CORE X_NUC_103.L_CORE 0.002874
K_6411 X_NUC_84.L_CORE X_NUC_104.L_CORE 0.002150
K_6412 X_NUC_84.L_CORE X_NUC_105.L_CORE 0.003290
K_6413 X_NUC_84.L_CORE X_NUC_106.L_CORE 0.002603
K_6414 X_NUC_84.L_CORE X_NUC_107.L_CORE 0.002386
K_6415 X_NUC_84.L_CORE X_NUC_108.L_CORE 0.004700
K_6416 X_NUC_84.L_CORE X_NUC_109.L_CORE 0.002316
K_6417 X_NUC_84.L_CORE X_NUC_110.L_CORE 0.003444
K_6418 X_NUC_84.L_CORE X_NUC_111.L_CORE 0.003871
K_6419 X_NUC_84.L_CORE X_NUC_112.L_CORE 0.002440
K_6420 X_NUC_84.L_CORE X_NUC_113.L_CORE 0.008553
K_6421 X_NUC_84.L_CORE X_NUC_114.L_CORE 0.002970
K_6422 X_NUC_84.L_CORE X_NUC_115.L_CORE 0.003333
K_6423 X_NUC_84.L_CORE X_NUC_116.L_CORE 0.009585
K_6424 X_NUC_84.L_CORE X_NUC_117.L_CORE 0.002993
K_6425 X_NUC_84.L_CORE X_NUC_118.L_CORE 0.006604
K_6426 X_NUC_84.L_CORE X_NUC_119.L_CORE 0.004997
K_6427 X_NUC_85.L_CORE X_NUC_86.L_CORE 0.207973
K_6428 X_NUC_85.L_CORE X_NUC_87.L_CORE 0.207973
K_6429 X_NUC_85.L_CORE X_NUC_88.L_CORE 0.207973
K_6430 X_NUC_85.L_CORE X_NUC_89.L_CORE 0.003799
K_6431 X_NUC_85.L_CORE X_NUC_90.L_CORE 0.003742
K_6432 X_NUC_85.L_CORE X_NUC_91.L_CORE 0.003748
K_6433 X_NUC_85.L_CORE X_NUC_92.L_CORE 0.003785
K_6434 X_NUC_85.L_CORE X_NUC_93.L_CORE 0.005591
K_6435 X_NUC_85.L_CORE X_NUC_94.L_CORE 0.005585
K_6436 X_NUC_85.L_CORE X_NUC_95.L_CORE 0.005495
K_6437 X_NUC_85.L_CORE X_NUC_96.L_CORE 0.005641
K_6438 X_NUC_85.L_CORE X_NUC_97.L_CORE 0.007441
K_6439 X_NUC_85.L_CORE X_NUC_98.L_CORE 0.007232
K_6440 X_NUC_85.L_CORE X_NUC_99.L_CORE 0.007207
K_6441 X_NUC_85.L_CORE X_NUC_100.L_CORE 0.007320
K_6442 X_NUC_85.L_CORE X_NUC_101.L_CORE 0.002517
K_6443 X_NUC_85.L_CORE X_NUC_102.L_CORE 0.002234
K_6444 X_NUC_85.L_CORE X_NUC_103.L_CORE 0.002444
K_6445 X_NUC_85.L_CORE X_NUC_104.L_CORE 0.002930
K_6446 X_NUC_85.L_CORE X_NUC_105.L_CORE 0.002163
K_6447 X_NUC_85.L_CORE X_NUC_106.L_CORE 0.003366
K_6448 X_NUC_85.L_CORE X_NUC_107.L_CORE 0.002641
K_6449 X_NUC_85.L_CORE X_NUC_108.L_CORE 0.002447
K_6450 X_NUC_85.L_CORE X_NUC_109.L_CORE 0.004784
K_6451 X_NUC_85.L_CORE X_NUC_110.L_CORE 0.002391
K_6452 X_NUC_85.L_CORE X_NUC_111.L_CORE 0.003594
K_6453 X_NUC_85.L_CORE X_NUC_112.L_CORE 0.004010
K_6454 X_NUC_85.L_CORE X_NUC_113.L_CORE 0.002576
K_6455 X_NUC_85.L_CORE X_NUC_114.L_CORE 0.009242
K_6456 X_NUC_85.L_CORE X_NUC_115.L_CORE 0.003181
K_6457 X_NUC_85.L_CORE X_NUC_116.L_CORE 0.003655
K_6458 X_NUC_85.L_CORE X_NUC_117.L_CORE 0.010335
K_6459 X_NUC_85.L_CORE X_NUC_118.L_CORE 0.003442
K_6460 X_NUC_85.L_CORE X_NUC_119.L_CORE 0.006897
K_6461 X_NUC_86.L_CORE X_NUC_87.L_CORE 0.207973
K_6462 X_NUC_86.L_CORE X_NUC_88.L_CORE 0.207973
K_6463 X_NUC_86.L_CORE X_NUC_89.L_CORE 0.003858
K_6464 X_NUC_86.L_CORE X_NUC_90.L_CORE 0.003799
K_6465 X_NUC_86.L_CORE X_NUC_91.L_CORE 0.003805
K_6466 X_NUC_86.L_CORE X_NUC_92.L_CORE 0.003844
K_6467 X_NUC_86.L_CORE X_NUC_93.L_CORE 0.005592
K_6468 X_NUC_86.L_CORE X_NUC_94.L_CORE 0.005591
K_6469 X_NUC_86.L_CORE X_NUC_95.L_CORE 0.005498
K_6470 X_NUC_86.L_CORE X_NUC_96.L_CORE 0.005644
K_6471 X_NUC_86.L_CORE X_NUC_97.L_CORE 0.007658
K_6472 X_NUC_86.L_CORE X_NUC_98.L_CORE 0.007441
K_6473 X_NUC_86.L_CORE X_NUC_99.L_CORE 0.007409
K_6474 X_NUC_86.L_CORE X_NUC_100.L_CORE 0.007532
K_6475 X_NUC_86.L_CORE X_NUC_101.L_CORE 0.002520
K_6476 X_NUC_86.L_CORE X_NUC_102.L_CORE 0.002246
K_6477 X_NUC_86.L_CORE X_NUC_103.L_CORE 0.002442
K_6478 X_NUC_86.L_CORE X_NUC_104.L_CORE 0.002944
K_6479 X_NUC_86.L_CORE X_NUC_105.L_CORE 0.002173
K_6480 X_NUC_86.L_CORE X_NUC_106.L_CORE 0.003342
K_6481 X_NUC_86.L_CORE X_NUC_107.L_CORE 0.002667
K_6482 X_NUC_86.L_CORE X_NUC_108.L_CORE 0.002448
K_6483 X_NUC_86.L_CORE X_NUC_109.L_CORE 0.004777
K_6484 X_NUC_86.L_CORE X_NUC_110.L_CORE 0.002412
K_6485 X_NUC_86.L_CORE X_NUC_111.L_CORE 0.003563
K_6486 X_NUC_86.L_CORE X_NUC_112.L_CORE 0.004074
K_6487 X_NUC_86.L_CORE X_NUC_113.L_CORE 0.002588
K_6488 X_NUC_86.L_CORE X_NUC_114.L_CORE 0.008890
K_6489 X_NUC_86.L_CORE X_NUC_115.L_CORE 0.003228
K_6490 X_NUC_86.L_CORE X_NUC_116.L_CORE 0.003649
K_6491 X_NUC_86.L_CORE X_NUC_117.L_CORE 0.010771
K_6492 X_NUC_86.L_CORE X_NUC_118.L_CORE 0.003479
K_6493 X_NUC_86.L_CORE X_NUC_119.L_CORE 0.006916
K_6494 X_NUC_87.L_CORE X_NUC_88.L_CORE 0.207973
K_6495 X_NUC_87.L_CORE X_NUC_89.L_CORE 0.003851
K_6496 X_NUC_87.L_CORE X_NUC_90.L_CORE 0.003792
K_6497 X_NUC_87.L_CORE X_NUC_91.L_CORE 0.003799
K_6498 X_NUC_87.L_CORE X_NUC_92.L_CORE 0.003837
K_6499 X_NUC_87.L_CORE X_NUC_93.L_CORE 0.005687
K_6500 X_NUC_87.L_CORE X_NUC_94.L_CORE 0.005684
K_6501 X_NUC_87.L_CORE X_NUC_95.L_CORE 0.005591
K_6502 X_NUC_87.L_CORE X_NUC_96.L_CORE 0.005742
K_6503 X_NUC_87.L_CORE X_NUC_97.L_CORE 0.007688
K_6504 X_NUC_87.L_CORE X_NUC_98.L_CORE 0.007464
K_6505 X_NUC_87.L_CORE X_NUC_99.L_CORE 0.007441
K_6506 X_NUC_87.L_CORE X_NUC_100.L_CORE 0.007560
K_6507 X_NUC_87.L_CORE X_NUC_101.L_CORE 0.002500
K_6508 X_NUC_87.L_CORE X_NUC_102.L_CORE 0.002230
K_6509 X_NUC_87.L_CORE X_NUC_103.L_CORE 0.002434
K_6510 X_NUC_87.L_CORE X_NUC_104.L_CORE 0.002906
K_6511 X_NUC_87.L_CORE X_NUC_105.L_CORE 0.002165
K_6512 X_NUC_87.L_CORE X_NUC_106.L_CORE 0.003327
K_6513 X_NUC_87.L_CORE X_NUC_107.L_CORE 0.002639
K_6514 X_NUC_87.L_CORE X_NUC_108.L_CORE 0.002450
K_6515 X_NUC_87.L_CORE X_NUC_109.L_CORE 0.004688
K_6516 X_NUC_87.L_CORE X_NUC_110.L_CORE 0.002401
K_6517 X_NUC_87.L_CORE X_NUC_111.L_CORE 0.003581
K_6518 X_NUC_87.L_CORE X_NUC_112.L_CORE 0.004004
K_6519 X_NUC_87.L_CORE X_NUC_113.L_CORE 0.002592
K_6520 X_NUC_87.L_CORE X_NUC_114.L_CORE 0.008930
K_6521 X_NUC_87.L_CORE X_NUC_115.L_CORE 0.003208
K_6522 X_NUC_87.L_CORE X_NUC_116.L_CORE 0.003684
K_6523 X_NUC_87.L_CORE X_NUC_117.L_CORE 0.010518
K_6524 X_NUC_87.L_CORE X_NUC_118.L_CORE 0.003489
K_6525 X_NUC_87.L_CORE X_NUC_119.L_CORE 0.007097
K_6526 X_NUC_88.L_CORE X_NUC_89.L_CORE 0.003812
K_6527 X_NUC_88.L_CORE X_NUC_90.L_CORE 0.003755
K_6528 X_NUC_88.L_CORE X_NUC_91.L_CORE 0.003761
K_6529 X_NUC_88.L_CORE X_NUC_92.L_CORE 0.003799
K_6530 X_NUC_88.L_CORE X_NUC_93.L_CORE 0.005538
K_6531 X_NUC_88.L_CORE X_NUC_94.L_CORE 0.005535
K_6532 X_NUC_88.L_CORE X_NUC_95.L_CORE 0.005447
K_6533 X_NUC_88.L_CORE X_NUC_96.L_CORE 0.005591
K_6534 X_NUC_88.L_CORE X_NUC_97.L_CORE 0.007558
K_6535 X_NUC_88.L_CORE X_NUC_98.L_CORE 0.007344
K_6536 X_NUC_88.L_CORE X_NUC_99.L_CORE 0.007318
K_6537 X_NUC_88.L_CORE X_NUC_100.L_CORE 0.007441
K_6538 X_NUC_88.L_CORE X_NUC_101.L_CORE 0.002495
K_6539 X_NUC_88.L_CORE X_NUC_102.L_CORE 0.002223
K_6540 X_NUC_88.L_CORE X_NUC_103.L_CORE 0.002418
K_6541 X_NUC_88.L_CORE X_NUC_104.L_CORE 0.002915
K_6542 X_NUC_88.L_CORE X_NUC_105.L_CORE 0.002151
K_6543 X_NUC_88.L_CORE X_NUC_106.L_CORE 0.003315
K_6544 X_NUC_88.L_CORE X_NUC_107.L_CORE 0.002639
K_6545 X_NUC_88.L_CORE X_NUC_108.L_CORE 0.002425
K_6546 X_NUC_88.L_CORE X_NUC_109.L_CORE 0.004741
K_6547 X_NUC_88.L_CORE X_NUC_110.L_CORE 0.002387
K_6548 X_NUC_88.L_CORE X_NUC_111.L_CORE 0.003537
K_6549 X_NUC_88.L_CORE X_NUC_112.L_CORE 0.004033
K_6550 X_NUC_88.L_CORE X_NUC_113.L_CORE 0.002563
K_6551 X_NUC_88.L_CORE X_NUC_114.L_CORE 0.008934
K_6552 X_NUC_88.L_CORE X_NUC_115.L_CORE 0.003195
K_6553 X_NUC_88.L_CORE X_NUC_116.L_CORE 0.003620
K_6554 X_NUC_88.L_CORE X_NUC_117.L_CORE 0.010792
K_6555 X_NUC_88.L_CORE X_NUC_118.L_CORE 0.003447
K_6556 X_NUC_88.L_CORE X_NUC_119.L_CORE 0.006900
K_6557 X_NUC_89.L_CORE X_NUC_90.L_CORE 0.207973
K_6558 X_NUC_89.L_CORE X_NUC_91.L_CORE 0.207973
K_6559 X_NUC_89.L_CORE X_NUC_92.L_CORE 0.207973
K_6560 X_NUC_89.L_CORE X_NUC_93.L_CORE 0.004566
K_6561 X_NUC_89.L_CORE X_NUC_94.L_CORE 0.004667
K_6562 X_NUC_89.L_CORE X_NUC_95.L_CORE 0.004602
K_6563 X_NUC_89.L_CORE X_NUC_96.L_CORE 0.004617
K_6564 X_NUC_89.L_CORE X_NUC_97.L_CORE 0.006968
K_6565 X_NUC_89.L_CORE X_NUC_98.L_CORE 0.007155
K_6566 X_NUC_89.L_CORE X_NUC_99.L_CORE 0.007085
K_6567 X_NUC_89.L_CORE X_NUC_100.L_CORE 0.006949
K_6568 X_NUC_89.L_CORE X_NUC_101.L_CORE 0.002205
K_6569 X_NUC_89.L_CORE X_NUC_102.L_CORE 0.002618
K_6570 X_NUC_89.L_CORE X_NUC_103.L_CORE 0.002245
K_6571 X_NUC_89.L_CORE X_NUC_104.L_CORE 0.002467
K_6572 X_NUC_89.L_CORE X_NUC_105.L_CORE 0.002957
K_6573 X_NUC_89.L_CORE X_NUC_106.L_CORE 0.002227
K_6574 X_NUC_89.L_CORE X_NUC_107.L_CORE 0.003356
K_6575 X_NUC_89.L_CORE X_NUC_108.L_CORE 0.002735
K_6576 X_NUC_89.L_CORE X_NUC_109.L_CORE 0.002553
K_6577 X_NUC_89.L_CORE X_NUC_110.L_CORE 0.004684
K_6578 X_NUC_89.L_CORE X_NUC_111.L_CORE 0.002552
K_6579 X_NUC_89.L_CORE X_NUC_112.L_CORE 0.003743
K_6580 X_NUC_89.L_CORE X_NUC_113.L_CORE 0.004264
K_6581 X_NUC_89.L_CORE X_NUC_114.L_CORE 0.002826
K_6582 X_NUC_89.L_CORE X_NUC_115.L_CORE 0.009144
K_6583 X_NUC_89.L_CORE X_NUC_116.L_CORE 0.003619
K_6584 X_NUC_89.L_CORE X_NUC_117.L_CORE 0.004224
K_6585 X_NUC_89.L_CORE X_NUC_118.L_CORE 0.012236
K_6586 X_NUC_89.L_CORE X_NUC_119.L_CORE 0.004624
K_6587 X_NUC_90.L_CORE X_NUC_91.L_CORE 0.207973
K_6588 X_NUC_90.L_CORE X_NUC_92.L_CORE 0.207973
K_6589 X_NUC_90.L_CORE X_NUC_93.L_CORE 0.004469
K_6590 X_NUC_90.L_CORE X_NUC_94.L_CORE 0.004566
K_6591 X_NUC_90.L_CORE X_NUC_95.L_CORE 0.004504
K_6592 X_NUC_90.L_CORE X_NUC_96.L_CORE 0.004518
K_6593 X_NUC_90.L_CORE X_NUC_97.L_CORE 0.006788
K_6594 X_NUC_90.L_CORE X_NUC_98.L_CORE 0.006968
K_6595 X_NUC_90.L_CORE X_NUC_99.L_CORE 0.006900
K_6596 X_NUC_90.L_CORE X_NUC_100.L_CORE 0.006774
K_6597 X_NUC_90.L_CORE X_NUC_101.L_CORE 0.002195
K_6598 X_NUC_90.L_CORE X_NUC_102.L_CORE 0.002618
K_6599 X_NUC_90.L_CORE X_NUC_103.L_CORE 0.002231
K_6600 X_NUC_90.L_CORE X_NUC_104.L_CORE 0.002459
K_6601 X_NUC_90.L_CORE X_NUC_105.L_CORE 0.002956
K_6602 X_NUC_90.L_CORE X_NUC_106.L_CORE 0.002209
K_6603 X_NUC_90.L_CORE X_NUC_107.L_CORE 0.003370
K_6604 X_NUC_90.L_CORE X_NUC_108.L_CORE 0.002716
K_6605 X_NUC_90.L_CORE X_NUC_109.L_CORE 0.002534
K_6606 X_NUC_90.L_CORE X_NUC_110.L_CORE 0.004734
K_6607 X_NUC_90.L_CORE X_NUC_111.L_CORE 0.002524
K_6608 X_NUC_90.L_CORE X_NUC_112.L_CORE 0.003739
K_6609 X_NUC_90.L_CORE X_NUC_113.L_CORE 0.004239
K_6610 X_NUC_90.L_CORE X_NUC_114.L_CORE 0.002792
K_6611 X_NUC_90.L_CORE X_NUC_115.L_CORE 0.009451
K_6612 X_NUC_90.L_CORE X_NUC_116.L_CORE 0.003564
K_6613 X_NUC_90.L_CORE X_NUC_117.L_CORE 0.004173
K_6614 X_NUC_90.L_CORE X_NUC_118.L_CORE 0.011979
K_6615 X_NUC_90.L_CORE X_NUC_119.L_CORE 0.004528
K_6616 X_NUC_91.L_CORE X_NUC_92.L_CORE 0.207973
K_6617 X_NUC_91.L_CORE X_NUC_93.L_CORE 0.004529
K_6618 X_NUC_91.L_CORE X_NUC_94.L_CORE 0.004628
K_6619 X_NUC_91.L_CORE X_NUC_95.L_CORE 0.004566
K_6620 X_NUC_91.L_CORE X_NUC_96.L_CORE 0.004580
K_6621 X_NUC_91.L_CORE X_NUC_97.L_CORE 0.006849
K_6622 X_NUC_91.L_CORE X_NUC_98.L_CORE 0.007030
K_6623 X_NUC_91.L_CORE X_NUC_99.L_CORE 0.006968
K_6624 X_NUC_91.L_CORE X_NUC_100.L_CORE 0.006835
K_6625 X_NUC_91.L_CORE X_NUC_101.L_CORE 0.002183
K_6626 X_NUC_91.L_CORE X_NUC_102.L_CORE 0.002594
K_6627 X_NUC_91.L_CORE X_NUC_103.L_CORE 0.002227
K_6628 X_NUC_91.L_CORE X_NUC_104.L_CORE 0.002439
K_6629 X_NUC_91.L_CORE X_NUC_105.L_CORE 0.002939
K_6630 X_NUC_91.L_CORE X_NUC_106.L_CORE 0.002206
K_6631 X_NUC_91.L_CORE X_NUC_107.L_CORE 0.003318
K_6632 X_NUC_91.L_CORE X_NUC_108.L_CORE 0.002720
K_6633 X_NUC_91.L_CORE X_NUC_109.L_CORE 0.002523
K_6634 X_NUC_91.L_CORE X_NUC_110.L_CORE 0.004666
K_6635 X_NUC_91.L_CORE X_NUC_111.L_CORE 0.002532
K_6636 X_NUC_91.L_CORE X_NUC_112.L_CORE 0.003691
K_6637 X_NUC_91.L_CORE X_NUC_113.L_CORE 0.004264
K_6638 X_NUC_91.L_CORE X_NUC_114.L_CORE 0.002796
K_6639 X_NUC_91.L_CORE X_NUC_115.L_CORE 0.009069
K_6640 X_NUC_91.L_CORE X_NUC_116.L_CORE 0.003603
K_6641 X_NUC_91.L_CORE X_NUC_117.L_CORE 0.004167
K_6642 X_NUC_91.L_CORE X_NUC_118.L_CORE 0.012638
K_6643 X_NUC_91.L_CORE X_NUC_119.L_CORE 0.004590
K_6644 X_NUC_92.L_CORE X_NUC_93.L_CORE 0.004514
K_6645 X_NUC_92.L_CORE X_NUC_94.L_CORE 0.004613
K_6646 X_NUC_92.L_CORE X_NUC_95.L_CORE 0.004550
K_6647 X_NUC_92.L_CORE X_NUC_96.L_CORE 0.004566
K_6648 X_NUC_92.L_CORE X_NUC_97.L_CORE 0.006979
K_6649 X_NUC_92.L_CORE X_NUC_98.L_CORE 0.007171
K_6650 X_NUC_92.L_CORE X_NUC_99.L_CORE 0.007101
K_6651 X_NUC_92.L_CORE X_NUC_100.L_CORE 0.006968
K_6652 X_NUC_92.L_CORE X_NUC_101.L_CORE 0.002187
K_6653 X_NUC_92.L_CORE X_NUC_102.L_CORE 0.002596
K_6654 X_NUC_92.L_CORE X_NUC_103.L_CORE 0.002222
K_6655 X_NUC_92.L_CORE X_NUC_104.L_CORE 0.002454
K_6656 X_NUC_92.L_CORE X_NUC_105.L_CORE 0.002921
K_6657 X_NUC_92.L_CORE X_NUC_106.L_CORE 0.002210
K_6658 X_NUC_92.L_CORE X_NUC_107.L_CORE 0.003343
K_6659 X_NUC_92.L_CORE X_NUC_108.L_CORE 0.002700
K_6660 X_NUC_92.L_CORE X_NUC_109.L_CORE 0.002542
K_6661 X_NUC_92.L_CORE X_NUC_110.L_CORE 0.004631
K_6662 X_NUC_92.L_CORE X_NUC_111.L_CORE 0.002527
K_6663 X_NUC_92.L_CORE X_NUC_112.L_CORE 0.003750
K_6664 X_NUC_92.L_CORE X_NUC_113.L_CORE 0.004190
K_6665 X_NUC_92.L_CORE X_NUC_114.L_CORE 0.002811
K_6666 X_NUC_92.L_CORE X_NUC_115.L_CORE 0.009290
K_6667 X_NUC_92.L_CORE X_NUC_116.L_CORE 0.003574
K_6668 X_NUC_92.L_CORE X_NUC_117.L_CORE 0.004235
K_6669 X_NUC_92.L_CORE X_NUC_118.L_CORE 0.012029
K_6670 X_NUC_92.L_CORE X_NUC_119.L_CORE 0.004601
K_6671 X_NUC_93.L_CORE X_NUC_94.L_CORE 0.207973
K_6672 X_NUC_93.L_CORE X_NUC_95.L_CORE 0.207973
K_6673 X_NUC_93.L_CORE X_NUC_96.L_CORE 0.207973
K_6674 X_NUC_93.L_CORE X_NUC_97.L_CORE 0.006455
K_6675 X_NUC_93.L_CORE X_NUC_98.L_CORE 0.006322
K_6676 X_NUC_93.L_CORE X_NUC_99.L_CORE 0.006443
K_6677 X_NUC_93.L_CORE X_NUC_100.L_CORE 0.006301
K_6678 X_NUC_93.L_CORE X_NUC_101.L_CORE 0.002269
K_6679 X_NUC_93.L_CORE X_NUC_102.L_CORE 0.002174
K_6680 X_NUC_93.L_CORE X_NUC_103.L_CORE 0.002642
K_6681 X_NUC_93.L_CORE X_NUC_104.L_CORE 0.002270
K_6682 X_NUC_93.L_CORE X_NUC_105.L_CORE 0.002492
K_6683 X_NUC_93.L_CORE X_NUC_106.L_CORE 0.002956
K_6684 X_NUC_93.L_CORE X_NUC_107.L_CORE 0.002305
K_6685 X_NUC_93.L_CORE X_NUC_108.L_CORE 0.003335
K_6686 X_NUC_93.L_CORE X_NUC_109.L_CORE 0.002831
K_6687 X_NUC_93.L_CORE X_NUC_110.L_CORE 0.002678
K_6688 X_NUC_93.L_CORE X_NUC_111.L_CORE 0.004569
K_6689 X_NUC_93.L_CORE X_NUC_112.L_CORE 0.002743
K_6690 X_NUC_93.L_CORE X_NUC_113.L_CORE 0.003930
K_6691 X_NUC_93.L_CORE X_NUC_114.L_CORE 0.004543
K_6692 X_NUC_93.L_CORE X_NUC_115.L_CORE 0.003154
K_6693 X_NUC_93.L_CORE X_NUC_116.L_CORE 0.009404
K_6694 X_NUC_93.L_CORE X_NUC_117.L_CORE 0.004254
K_6695 X_NUC_93.L_CORE X_NUC_118.L_CORE 0.005193
K_6696 X_NUC_93.L_CORE X_NUC_119.L_CORE 0.013814
K_6697 X_NUC_94.L_CORE X_NUC_95.L_CORE 0.207973
K_6698 X_NUC_94.L_CORE X_NUC_96.L_CORE 0.207973
K_6699 X_NUC_94.L_CORE X_NUC_97.L_CORE 0.006589
K_6700 X_NUC_94.L_CORE X_NUC_98.L_CORE 0.006455
K_6701 X_NUC_94.L_CORE X_NUC_99.L_CORE 0.006580
K_6702 X_NUC_94.L_CORE X_NUC_100.L_CORE 0.006429
K_6703 X_NUC_94.L_CORE X_NUC_101.L_CORE 0.002271
K_6704 X_NUC_94.L_CORE X_NUC_102.L_CORE 0.002185
K_6705 X_NUC_94.L_CORE X_NUC_103.L_CORE 0.002638
K_6706 X_NUC_94.L_CORE X_NUC_104.L_CORE 0.002277
K_6707 X_NUC_94.L_CORE X_NUC_105.L_CORE 0.002508
K_6708 X_NUC_94.L_CORE X_NUC_106.L_CORE 0.002940
K_6709 X_NUC_94.L_CORE X_NUC_107.L_CORE 0.002322
K_6710 X_NUC_94.L_CORE X_NUC_108.L_CORE 0.003337
K_6711 X_NUC_94.L_CORE X_NUC_109.L_CORE 0.002829
K_6712 X_NUC_94.L_CORE X_NUC_110.L_CORE 0.002708
K_6713 X_NUC_94.L_CORE X_NUC_111.L_CORE 0.004504
K_6714 X_NUC_94.L_CORE X_NUC_112.L_CORE 0.002763
K_6715 X_NUC_94.L_CORE X_NUC_113.L_CORE 0.003974
K_6716 X_NUC_94.L_CORE X_NUC_114.L_CORE 0.004497
K_6717 X_NUC_94.L_CORE X_NUC_115.L_CORE 0.003199
K_6718 X_NUC_94.L_CORE X_NUC_116.L_CORE 0.009286
K_6719 X_NUC_94.L_CORE X_NUC_117.L_CORE 0.004281
K_6720 X_NUC_94.L_CORE X_NUC_118.L_CORE 0.005323
K_6721 X_NUC_94.L_CORE X_NUC_119.L_CORE 0.013915
K_6722 X_NUC_95.L_CORE X_NUC_96.L_CORE 0.207973
K_6723 X_NUC_95.L_CORE X_NUC_97.L_CORE 0.006460
K_6724 X_NUC_95.L_CORE X_NUC_98.L_CORE 0.006331
K_6725 X_NUC_95.L_CORE X_NUC_99.L_CORE 0.006455
K_6726 X_NUC_95.L_CORE X_NUC_100.L_CORE 0.006309
K_6727 X_NUC_95.L_CORE X_NUC_101.L_CORE 0.002250
K_6728 X_NUC_95.L_CORE X_NUC_102.L_CORE 0.002164
K_6729 X_NUC_95.L_CORE X_NUC_103.L_CORE 0.002619
K_6730 X_NUC_95.L_CORE X_NUC_104.L_CORE 0.002253
K_6731 X_NUC_95.L_CORE X_NUC_105.L_CORE 0.002487
K_6732 X_NUC_95.L_CORE X_NUC_106.L_CORE 0.002916
K_6733 X_NUC_95.L_CORE X_NUC_107.L_CORE 0.002297
K_6734 X_NUC_95.L_CORE X_NUC_108.L_CORE 0.003321
K_6735 X_NUC_95.L_CORE X_NUC_109.L_CORE 0.002798
K_6736 X_NUC_95.L_CORE X_NUC_110.L_CORE 0.002682
K_6737 X_NUC_95.L_CORE X_NUC_111.L_CORE 0.004491
K_6738 X_NUC_95.L_CORE X_NUC_112.L_CORE 0.002730
K_6739 X_NUC_95.L_CORE X_NUC_113.L_CORE 0.003954
K_6740 X_NUC_95.L_CORE X_NUC_114.L_CORE 0.004455
K_6741 X_NUC_95.L_CORE X_NUC_115.L_CORE 0.003163
K_6742 X_NUC_95.L_CORE X_NUC_116.L_CORE 0.009440
K_6743 X_NUC_95.L_CORE X_NUC_117.L_CORE 0.004224
K_6744 X_NUC_95.L_CORE X_NUC_118.L_CORE 0.005278
K_6745 X_NUC_95.L_CORE X_NUC_119.L_CORE 0.013904
K_6746 X_NUC_96.L_CORE X_NUC_97.L_CORE 0.006614
K_6747 X_NUC_96.L_CORE X_NUC_98.L_CORE 0.006474
K_6748 X_NUC_96.L_CORE X_NUC_99.L_CORE 0.006604
K_6749 X_NUC_96.L_CORE X_NUC_100.L_CORE 0.006455
K_6750 X_NUC_96.L_CORE X_NUC_101.L_CORE 0.002256
K_6751 X_NUC_96.L_CORE X_NUC_102.L_CORE 0.002167
K_6752 X_NUC_96.L_CORE X_NUC_103.L_CORE 0.002615
K_6753 X_NUC_96.L_CORE X_NUC_104.L_CORE 0.002267
K_6754 X_NUC_96.L_CORE X_NUC_105.L_CORE 0.002479
K_6755 X_NUC_96.L_CORE X_NUC_106.L_CORE 0.002929
K_6756 X_NUC_96.L_CORE X_NUC_107.L_CORE 0.002307
K_6757 X_NUC_96.L_CORE X_NUC_108.L_CORE 0.003290
K_6758 X_NUC_96.L_CORE X_NUC_109.L_CORE 0.002828
K_6759 X_NUC_96.L_CORE X_NUC_110.L_CORE 0.002678
K_6760 X_NUC_96.L_CORE X_NUC_111.L_CORE 0.004478
K_6761 X_NUC_96.L_CORE X_NUC_112.L_CORE 0.002756
K_6762 X_NUC_96.L_CORE X_NUC_113.L_CORE 0.003903
K_6763 X_NUC_96.L_CORE X_NUC_114.L_CORE 0.004532
K_6764 X_NUC_96.L_CORE X_NUC_115.L_CORE 0.003177
K_6765 X_NUC_96.L_CORE X_NUC_116.L_CORE 0.009070
K_6766 X_NUC_96.L_CORE X_NUC_117.L_CORE 0.004307
K_6767 X_NUC_96.L_CORE X_NUC_118.L_CORE 0.005253
K_6768 X_NUC_96.L_CORE X_NUC_119.L_CORE 0.014682
K_6769 X_NUC_97.L_CORE X_NUC_98.L_CORE 0.207973
K_6770 X_NUC_97.L_CORE X_NUC_99.L_CORE 0.207973
K_6771 X_NUC_97.L_CORE X_NUC_100.L_CORE 0.207973
K_6772 X_NUC_97.L_CORE X_NUC_101.L_CORE 0.002232
K_6773 X_NUC_97.L_CORE X_NUC_102.L_CORE 0.002282
K_6774 X_NUC_97.L_CORE X_NUC_103.L_CORE 0.002235
K_6775 X_NUC_97.L_CORE X_NUC_104.L_CORE 0.002581
K_6776 X_NUC_97.L_CORE X_NUC_105.L_CORE 0.002360
K_6777 X_NUC_97.L_CORE X_NUC_106.L_CORE 0.002567
K_6778 X_NUC_97.L_CORE X_NUC_107.L_CORE 0.002870
K_6779 X_NUC_97.L_CORE X_NUC_108.L_CORE 0.002507
K_6780 X_NUC_97.L_CORE X_NUC_109.L_CORE 0.003235
K_6781 X_NUC_97.L_CORE X_NUC_110.L_CORE 0.002972
K_6782 X_NUC_97.L_CORE X_NUC_111.L_CORE 0.002967
K_6783 X_NUC_97.L_CORE X_NUC_112.L_CORE 0.004144
K_6784 X_NUC_97.L_CORE X_NUC_113.L_CORE 0.003148
K_6785 X_NUC_97.L_CORE X_NUC_114.L_CORE 0.004234
K_6786 X_NUC_97.L_CORE X_NUC_115.L_CORE 0.004758
K_6787 X_NUC_97.L_CORE X_NUC_116.L_CORE 0.003941
K_6788 X_NUC_97.L_CORE X_NUC_117.L_CORE 0.008729
K_6789 X_NUC_97.L_CORE X_NUC_118.L_CORE 0.005815
K_6790 X_NUC_97.L_CORE X_NUC_119.L_CORE 0.008813
K_6791 X_NUC_98.L_CORE X_NUC_99.L_CORE 0.207973
K_6792 X_NUC_98.L_CORE X_NUC_100.L_CORE 0.207973
K_6793 X_NUC_98.L_CORE X_NUC_101.L_CORE 0.002228
K_6794 X_NUC_98.L_CORE X_NUC_102.L_CORE 0.002289
K_6795 X_NUC_98.L_CORE X_NUC_103.L_CORE 0.002227
K_6796 X_NUC_98.L_CORE X_NUC_104.L_CORE 0.002582
K_6797 X_NUC_98.L_CORE X_NUC_105.L_CORE 0.002367
K_6798 X_NUC_98.L_CORE X_NUC_106.L_CORE 0.002548
K_6799 X_NUC_98.L_CORE X_NUC_107.L_CORE 0.002892
K_6800 X_NUC_98.L_CORE X_NUC_108.L_CORE 0.002500
K_6801 X_NUC_98.L_CORE X_NUC_109.L_CORE 0.003215
K_6802 X_NUC_98.L_CORE X_NUC_110.L_CORE 0.002999
K_6803 X_NUC_98.L_CORE X_NUC_111.L_CORE 0.002936
K_6804 X_NUC_98.L_CORE X_NUC_112.L_CORE 0.004178
K_6805 X_NUC_98.L_CORE X_NUC_113.L_CORE 0.003155
K_6806 X_NUC_98.L_CORE X_NUC_114.L_CORE 0.004161
K_6807 X_NUC_98.L_CORE X_NUC_115.L_CORE 0.004861
K_6808 X_NUC_98.L_CORE X_NUC_116.L_CORE 0.003903
K_6809 X_NUC_98.L_CORE X_NUC_117.L_CORE 0.008634
K_6810 X_NUC_98.L_CORE X_NUC_118.L_CORE 0.005895
K_6811 X_NUC_98.L_CORE X_NUC_119.L_CORE 0.008514
K_6812 X_NUC_99.L_CORE X_NUC_100.L_CORE 0.207973
K_6813 X_NUC_99.L_CORE X_NUC_101.L_CORE 0.002214
K_6814 X_NUC_99.L_CORE X_NUC_102.L_CORE 0.002271
K_6815 X_NUC_99.L_CORE X_NUC_103.L_CORE 0.002220
K_6816 X_NUC_99.L_CORE X_NUC_104.L_CORE 0.002555
K_6817 X_NUC_99.L_CORE X_NUC_105.L_CORE 0.002356
K_6818 X_NUC_99.L_CORE X_NUC_106.L_CORE 0.002540
K_6819 X_NUC_99.L_CORE X_NUC_107.L_CORE 0.002855
K_6820 X_NUC_99.L_CORE X_NUC_108.L_CORE 0.002500
K_6821 X_NUC_99.L_CORE X_NUC_109.L_CORE 0.003186
K_6822 X_NUC_99.L_CORE X_NUC_110.L_CORE 0.002976
K_6823 X_NUC_99.L_CORE X_NUC_111.L_CORE 0.002944
K_6824 X_NUC_99.L_CORE X_NUC_112.L_CORE 0.004097
K_6825 X_NUC_99.L_CORE X_NUC_113.L_CORE 0.003159
K_6826 X_NUC_99.L_CORE X_NUC_114.L_CORE 0.004160
K_6827 X_NUC_99.L_CORE X_NUC_115.L_CORE 0.004785
K_6828 X_NUC_99.L_CORE X_NUC_116.L_CORE 0.003942
K_6829 X_NUC_99.L_CORE X_NUC_117.L_CORE 0.008462
K_6830 X_NUC_99.L_CORE X_NUC_118.L_CORE 0.005928
K_6831 X_NUC_99.L_CORE X_NUC_119.L_CORE 0.008813
K_6832 X_NUC_100.L_CORE X_NUC_101.L_CORE 0.002214
K_6833 X_NUC_100.L_CORE X_NUC_102.L_CORE 0.002267
K_6834 X_NUC_100.L_CORE X_NUC_103.L_CORE 0.002212
K_6835 X_NUC_100.L_CORE X_NUC_104.L_CORE 0.002566
K_6836 X_NUC_100.L_CORE X_NUC_105.L_CORE 0.002341
K_6837 X_NUC_100.L_CORE X_NUC_106.L_CORE 0.002539
K_6838 X_NUC_100.L_CORE X_NUC_107.L_CORE 0.002861
K_6839 X_NUC_100.L_CORE X_NUC_108.L_CORE 0.002479
K_6840 X_NUC_100.L_CORE X_NUC_109.L_CORE 0.003212
K_6841 X_NUC_100.L_CORE X_NUC_110.L_CORE 0.002957
K_6842 X_NUC_100.L_CORE X_NUC_111.L_CORE 0.002927
K_6843 X_NUC_100.L_CORE X_NUC_112.L_CORE 0.004150
K_6844 X_NUC_100.L_CORE X_NUC_113.L_CORE 0.003117
K_6845 X_NUC_100.L_CORE X_NUC_114.L_CORE 0.004182
K_6846 X_NUC_100.L_CORE X_NUC_115.L_CORE 0.004773
K_6847 X_NUC_100.L_CORE X_NUC_116.L_CORE 0.003881
K_6848 X_NUC_100.L_CORE X_NUC_117.L_CORE 0.008796
K_6849 X_NUC_100.L_CORE X_NUC_118.L_CORE 0.005784
K_6850 X_NUC_100.L_CORE X_NUC_119.L_CORE 0.008626
K_6851 X_NUC_101.L_CORE X_NUC_102.L_CORE 0.004961
K_6852 X_NUC_101.L_CORE X_NUC_103.L_CORE 0.005353
K_6853 X_NUC_101.L_CORE X_NUC_104.L_CORE 0.005689
K_6854 X_NUC_101.L_CORE X_NUC_105.L_CORE 0.003247
K_6855 X_NUC_101.L_CORE X_NUC_106.L_CORE 0.004773
K_6856 X_NUC_101.L_CORE X_NUC_107.L_CORE 0.003225
K_6857 X_NUC_101.L_CORE X_NUC_108.L_CORE 0.002930
K_6858 X_NUC_101.L_CORE X_NUC_109.L_CORE 0.003673
K_6859 X_NUC_101.L_CORE X_NUC_110.L_CORE 0.002502
K_6860 X_NUC_101.L_CORE X_NUC_111.L_CORE 0.002899
K_6861 X_NUC_101.L_CORE X_NUC_112.L_CORE 0.002708
K_6862 X_NUC_101.L_CORE X_NUC_113.L_CORE 0.002279
K_6863 X_NUC_101.L_CORE X_NUC_114.L_CORE 0.002697
K_6864 X_NUC_101.L_CORE X_NUC_115.L_CORE 0.002214
K_6865 X_NUC_101.L_CORE X_NUC_116.L_CORE 0.002231
K_6866 X_NUC_101.L_CORE X_NUC_117.L_CORE 0.002301
K_6867 X_NUC_101.L_CORE X_NUC_118.L_CORE 0.002029
K_6868 X_NUC_101.L_CORE X_NUC_119.L_CORE 0.002108
K_6869 X_NUC_102.L_CORE X_NUC_103.L_CORE 0.003537
K_6870 X_NUC_102.L_CORE X_NUC_104.L_CORE 0.004335
K_6871 X_NUC_102.L_CORE X_NUC_105.L_CORE 0.005404
K_6872 X_NUC_102.L_CORE X_NUC_106.L_CORE 0.002683
K_6873 X_NUC_102.L_CORE X_NUC_107.L_CORE 0.005180
K_6874 X_NUC_102.L_CORE X_NUC_108.L_CORE 0.002907
K_6875 X_NUC_102.L_CORE X_NUC_109.L_CORE 0.002646
K_6876 X_NUC_102.L_CORE X_NUC_110.L_CORE 0.004054
K_6877 X_NUC_102.L_CORE X_NUC_111.L_CORE 0.002263
K_6878 X_NUC_102.L_CORE X_NUC_112.L_CORE 0.002916
K_6879 X_NUC_102.L_CORE X_NUC_113.L_CORE 0.002700
K_6880 X_NUC_102.L_CORE X_NUC_114.L_CORE 0.002136
K_6881 X_NUC_102.L_CORE X_NUC_115.L_CORE 0.002855
K_6882 X_NUC_102.L_CORE X_NUC_116.L_CORE 0.002139
K_6883 X_NUC_102.L_CORE X_NUC_117.L_CORE 0.002206
K_6884 X_NUC_102.L_CORE X_NUC_118.L_CORE 0.002336
K_6885 X_NUC_102.L_CORE X_NUC_119.L_CORE 0.002029
K_6886 X_NUC_103.L_CORE X_NUC_104.L_CORE 0.002967
K_6887 X_NUC_103.L_CORE X_NUC_105.L_CORE 0.003799
K_6888 X_NUC_103.L_CORE X_NUC_106.L_CORE 0.005061
K_6889 X_NUC_103.L_CORE X_NUC_107.L_CORE 0.002408
K_6890 X_NUC_103.L_CORE X_NUC_108.L_CORE 0.005314
K_6891 X_NUC_103.L_CORE X_NUC_109.L_CORE 0.002719
K_6892 X_NUC_103.L_CORE X_NUC_110.L_CORE 0.002487
K_6893 X_NUC_103.L_CORE X_NUC_111.L_CORE 0.004264
K_6894 X_NUC_103.L_CORE X_NUC_112.L_CORE 0.002143
K_6895 X_NUC_103.L_CORE X_NUC_113.L_CORE 0.002905
K_6896 X_NUC_103.L_CORE X_NUC_114.L_CORE 0.002683
K_6897 X_NUC_103.L_CORE X_NUC_115.L_CORE 0.002074
K_6898 X_NUC_103.L_CORE X_NUC_116.L_CORE 0.002917
K_6899 X_NUC_103.L_CORE X_NUC_117.L_CORE 0.002119
K_6900 X_NUC_103.L_CORE X_NUC_118.L_CORE 0.002206
K_6901 X_NUC_103.L_CORE X_NUC_119.L_CORE 0.002301
K_6902 X_NUC_104.L_CORE X_NUC_105.L_CORE 0.002651
K_6903 X_NUC_104.L_CORE X_NUC_106.L_CORE 0.003473
K_6904 X_NUC_104.L_CORE X_NUC_107.L_CORE 0.004794
K_6905 X_NUC_104.L_CORE X_NUC_108.L_CORE 0.002242
K_6906 X_NUC_104.L_CORE X_NUC_109.L_CORE 0.005354
K_6907 X_NUC_104.L_CORE X_NUC_110.L_CORE 0.002598
K_6908 X_NUC_104.L_CORE X_NUC_111.L_CORE 0.002388
K_6909 X_NUC_104.L_CORE X_NUC_112.L_CORE 0.004389
K_6910 X_NUC_104.L_CORE X_NUC_113.L_CORE 0.002077
K_6911 X_NUC_104.L_CORE X_NUC_114.L_CORE 0.002895
K_6912 X_NUC_104.L_CORE X_NUC_115.L_CORE 0.002673
K_6913 X_NUC_104.L_CORE X_NUC_116.L_CORE 0.002056
K_6914 X_NUC_104.L_CORE X_NUC_117.L_CORE 0.002917
K_6915 X_NUC_104.L_CORE X_NUC_118.L_CORE 0.002139
K_6916 X_NUC_104.L_CORE X_NUC_119.L_CORE 0.002231
K_6917 X_NUC_105.L_CORE X_NUC_106.L_CORE 0.002454
K_6918 X_NUC_105.L_CORE X_NUC_107.L_CORE 0.003260
K_6919 X_NUC_105.L_CORE X_NUC_108.L_CORE 0.004599
K_6920 X_NUC_105.L_CORE X_NUC_109.L_CORE 0.002136
K_6921 X_NUC_105.L_CORE X_NUC_110.L_CORE 0.005358
K_6922 X_NUC_105.L_CORE X_NUC_111.L_CORE 0.002522
K_6923 X_NUC_105.L_CORE X_NUC_112.L_CORE 0.002330
K_6924 X_NUC_105.L_CORE X_NUC_113.L_CORE 0.004457
K_6925 X_NUC_105.L_CORE X_NUC_114.L_CORE 0.002048
K_6926 X_NUC_105.L_CORE X_NUC_115.L_CORE 0.002891
K_6927 X_NUC_105.L_CORE X_NUC_116.L_CORE 0.002673
K_6928 X_NUC_105.L_CORE X_NUC_117.L_CORE 0.002074
K_6929 X_NUC_105.L_CORE X_NUC_118.L_CORE 0.002855
K_6930 X_NUC_105.L_CORE X_NUC_119.L_CORE 0.002214
K_6931 X_NUC_106.L_CORE X_NUC_107.L_CORE 0.002324
K_6932 X_NUC_106.L_CORE X_NUC_108.L_CORE 0.003119
K_6933 X_NUC_106.L_CORE X_NUC_109.L_CORE 0.004465
K_6934 X_NUC_106.L_CORE X_NUC_110.L_CORE 0.002070
K_6935 X_NUC_106.L_CORE X_NUC_111.L_CORE 0.005351
K_6936 X_NUC_106.L_CORE X_NUC_112.L_CORE 0.002480
K_6937 X_NUC_106.L_CORE X_NUC_113.L_CORE 0.002303
K_6938 X_NUC_106.L_CORE X_NUC_114.L_CORE 0.004478
K_6939 X_NUC_106.L_CORE X_NUC_115.L_CORE 0.002048
K_6940 X_NUC_106.L_CORE X_NUC_116.L_CORE 0.002895
K_6941 X_NUC_106.L_CORE X_NUC_117.L_CORE 0.002683
K_6942 X_NUC_106.L_CORE X_NUC_118.L_CORE 0.002136
K_6943 X_NUC_106.L_CORE X_NUC_119.L_CORE 0.002697
K_6944 X_NUC_107.L_CORE X_NUC_108.L_CORE 0.002239
K_6945 X_NUC_107.L_CORE X_NUC_109.L_CORE 0.003029
K_6946 X_NUC_107.L_CORE X_NUC_110.L_CORE 0.004380
K_6947 X_NUC_107.L_CORE X_NUC_111.L_CORE 0.002033
K_6948 X_NUC_107.L_CORE X_NUC_112.L_CORE 0.005346
K_6949 X_NUC_107.L_CORE X_NUC_113.L_CORE 0.002466
K_6950 X_NUC_107.L_CORE X_NUC_114.L_CORE 0.002303
K_6951 X_NUC_107.L_CORE X_NUC_115.L_CORE 0.004457
K_6952 X_NUC_107.L_CORE X_NUC_116.L_CORE 0.002077
K_6953 X_NUC_107.L_CORE X_NUC_117.L_CORE 0.002905
K_6954 X_NUC_107.L_CORE X_NUC_118.L_CORE 0.002700
K_6955 X_NUC_107.L_CORE X_NUC_119.L_CORE 0.002279
K_6956 X_NUC_108.L_CORE X_NUC_109.L_CORE 0.002188
K_6957 X_NUC_108.L_CORE X_NUC_110.L_CORE 0.002978
K_6958 X_NUC_108.L_CORE X_NUC_111.L_CORE 0.004340
K_6959 X_NUC_108.L_CORE X_NUC_112.L_CORE 0.002021
K_6960 X_NUC_108.L_CORE X_NUC_113.L_CORE 0.005346
K_6961 X_NUC_108.L_CORE X_NUC_114.L_CORE 0.002480
K_6962 X_NUC_108.L_CORE X_NUC_115.L_CORE 0.002330
K_6963 X_NUC_108.L_CORE X_NUC_116.L_CORE 0.004389
K_6964 X_NUC_108.L_CORE X_NUC_117.L_CORE 0.002143
K_6965 X_NUC_108.L_CORE X_NUC_118.L_CORE 0.002916
K_6966 X_NUC_108.L_CORE X_NUC_119.L_CORE 0.002708
K_6967 X_NUC_109.L_CORE X_NUC_110.L_CORE 0.002163
K_6968 X_NUC_109.L_CORE X_NUC_111.L_CORE 0.002962
K_6969 X_NUC_109.L_CORE X_NUC_112.L_CORE 0.004340
K_6970 X_NUC_109.L_CORE X_NUC_113.L_CORE 0.002033
K_6971 X_NUC_109.L_CORE X_NUC_114.L_CORE 0.005351
K_6972 X_NUC_109.L_CORE X_NUC_115.L_CORE 0.002522
K_6973 X_NUC_109.L_CORE X_NUC_116.L_CORE 0.002388
K_6974 X_NUC_109.L_CORE X_NUC_117.L_CORE 0.004264
K_6975 X_NUC_109.L_CORE X_NUC_118.L_CORE 0.002263
K_6976 X_NUC_109.L_CORE X_NUC_119.L_CORE 0.002899
K_6977 X_NUC_110.L_CORE X_NUC_111.L_CORE 0.002163
K_6978 X_NUC_110.L_CORE X_NUC_112.L_CORE 0.002978
K_6979 X_NUC_110.L_CORE X_NUC_113.L_CORE 0.004380
K_6980 X_NUC_110.L_CORE X_NUC_114.L_CORE 0.002070
K_6981 X_NUC_110.L_CORE X_NUC_115.L_CORE 0.005358
K_6982 X_NUC_110.L_CORE X_NUC_116.L_CORE 0.002598
K_6983 X_NUC_110.L_CORE X_NUC_117.L_CORE 0.002487
K_6984 X_NUC_110.L_CORE X_NUC_118.L_CORE 0.004054
K_6985 X_NUC_110.L_CORE X_NUC_119.L_CORE 0.002502
K_6986 X_NUC_111.L_CORE X_NUC_112.L_CORE 0.002188
K_6987 X_NUC_111.L_CORE X_NUC_113.L_CORE 0.003029
K_6988 X_NUC_111.L_CORE X_NUC_114.L_CORE 0.004465
K_6989 X_NUC_111.L_CORE X_NUC_115.L_CORE 0.002136
K_6990 X_NUC_111.L_CORE X_NUC_116.L_CORE 0.005354
K_6991 X_NUC_111.L_CORE X_NUC_117.L_CORE 0.002719
K_6992 X_NUC_111.L_CORE X_NUC_118.L_CORE 0.002646
K_6993 X_NUC_111.L_CORE X_NUC_119.L_CORE 0.003673
K_6994 X_NUC_112.L_CORE X_NUC_113.L_CORE 0.002239
K_6995 X_NUC_112.L_CORE X_NUC_114.L_CORE 0.003119
K_6996 X_NUC_112.L_CORE X_NUC_115.L_CORE 0.004599
K_6997 X_NUC_112.L_CORE X_NUC_116.L_CORE 0.002242
K_6998 X_NUC_112.L_CORE X_NUC_117.L_CORE 0.005314
K_6999 X_NUC_112.L_CORE X_NUC_118.L_CORE 0.002907
K_7000 X_NUC_112.L_CORE X_NUC_119.L_CORE 0.002930
K_7001 X_NUC_113.L_CORE X_NUC_114.L_CORE 0.002324
K_7002 X_NUC_113.L_CORE X_NUC_115.L_CORE 0.003260
K_7003 X_NUC_113.L_CORE X_NUC_116.L_CORE 0.004794
K_7004 X_NUC_113.L_CORE X_NUC_117.L_CORE 0.002408
K_7005 X_NUC_113.L_CORE X_NUC_118.L_CORE 0.005180
K_7006 X_NUC_113.L_CORE X_NUC_119.L_CORE 0.003225
K_7007 X_NUC_114.L_CORE X_NUC_115.L_CORE 0.002454
K_7008 X_NUC_114.L_CORE X_NUC_116.L_CORE 0.003473
K_7009 X_NUC_114.L_CORE X_NUC_117.L_CORE 0.005061
K_7010 X_NUC_114.L_CORE X_NUC_118.L_CORE 0.002683
K_7011 X_NUC_114.L_CORE X_NUC_119.L_CORE 0.004773
K_7012 X_NUC_115.L_CORE X_NUC_116.L_CORE 0.002651
K_7013 X_NUC_115.L_CORE X_NUC_117.L_CORE 0.003799
K_7014 X_NUC_115.L_CORE X_NUC_118.L_CORE 0.005404
K_7015 X_NUC_115.L_CORE X_NUC_119.L_CORE 0.003247
K_7016 X_NUC_116.L_CORE X_NUC_117.L_CORE 0.002967
K_7017 X_NUC_116.L_CORE X_NUC_118.L_CORE 0.004335
K_7018 X_NUC_116.L_CORE X_NUC_119.L_CORE 0.005689
K_7019 X_NUC_117.L_CORE X_NUC_118.L_CORE 0.003537
K_7020 X_NUC_117.L_CORE X_NUC_119.L_CORE 0.005353
K_7021 X_NUC_118.L_CORE X_NUC_119.L_CORE 0.004961

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
