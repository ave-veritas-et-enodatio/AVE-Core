* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Gallium-70 (Z=31, A=70)
* Auto-generated topological mutual impedance array
* Nodes: 70

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON
X_NUC_65 NODE_65 0 NUCLEON
X_NUC_66 NODE_66 0 NUCLEON
X_NUC_67 NODE_67 0 NUCLEON
X_NUC_68 NODE_68 0 NUCLEON
X_NUC_69 NODE_69 0 NUCLEON
X_NUC_70 NODE_70 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.007950
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.007673
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.007732
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.007820
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.008573
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.008702
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.008405
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.008710
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.009058
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.008875
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.008966
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.008697
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.005234
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.005160
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005116
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.005208
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.007532
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.007730
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.007484
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.007497
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.005187
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.005086
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.005095
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.005074
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.004727
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.004730
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.004641
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.004724
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.005741
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.005760
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.005695
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.005618
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.004075
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.004023
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.003998
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.004025
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.004595
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.004633
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.004535
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.004571
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.004303
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.004268
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.004244
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.004219
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.003748
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.003732
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.003685
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.003718
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.004118
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.004129
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.004068
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.004065
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.003659
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.003639
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.003604
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.003610
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.032443
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.006104
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.006395
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.006267
K_64 X_NUC_1.L_CORE X_NUC_65.L_CORE 0.004051
K_65 X_NUC_1.L_CORE X_NUC_66.L_CORE 0.005134
K_66 X_NUC_1.L_CORE X_NUC_67.L_CORE 0.003876
K_67 X_NUC_1.L_CORE X_NUC_68.L_CORE 0.003602
K_68 X_NUC_1.L_CORE X_NUC_69.L_CORE 0.003837
K_69 X_NUC_1.L_CORE X_NUC_70.L_CORE 0.003237
K_70 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_71 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_72 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.008245
K_73 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.007950
K_74 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.008009
K_75 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.008106
K_76 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.008436
K_77 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.008573
K_78 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.008282
K_79 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.008574
K_80 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.009235
K_81 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.009058
K_82 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.009146
K_83 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.008862
K_84 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.005309
K_85 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.005234
K_86 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.005187
K_87 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.005283
K_88 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.007339
K_89 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.007532
K_90 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.007300
K_91 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.007311
K_92 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.005292
K_93 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.005187
K_94 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.005196
K_95 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.005174
K_96 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.004723
K_97 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.004727
K_98 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.004638
K_99 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.004721
K_100 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.005718
K_101 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.005741
K_102 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.005675
K_103 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.005598
K_104 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.004127
K_105 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.004075
K_106 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.004048
K_107 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.004076
K_108 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.004555
K_109 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.004595
K_110 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.004498
K_111 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.004532
K_112 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.004337
K_113 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.004303
K_114 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.004277
K_115 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.004252
K_116 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.003764
K_117 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.003748
K_118 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.003700
K_119 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.003733
K_120 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.004105
K_121 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.004118
K_122 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.004057
K_123 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.004054
K_124 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.003679
K_125 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.003659
K_126 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.003623
K_127 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.003629
K_128 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.029972
K_129 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.006282
K_130 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.006300
K_131 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.006334
K_132 X_NUC_2.L_CORE X_NUC_65.L_CORE 0.004093
K_133 X_NUC_2.L_CORE X_NUC_66.L_CORE 0.005052
K_134 X_NUC_2.L_CORE X_NUC_67.L_CORE 0.003926
K_135 X_NUC_2.L_CORE X_NUC_68.L_CORE 0.003600
K_136 X_NUC_2.L_CORE X_NUC_69.L_CORE 0.003833
K_137 X_NUC_2.L_CORE X_NUC_70.L_CORE 0.003254
K_138 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_139 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.008174
K_140 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.007880
K_141 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.007950
K_142 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.008039
K_143 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.008737
K_144 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.008881
K_145 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.008573
K_146 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.008890
K_147 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.009136
K_148 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.008956
K_149 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.009058
K_150 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.008774
K_151 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.005358
K_152 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.005280
K_153 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.005234
K_154 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.005331
K_155 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.007570
K_156 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.007777
K_157 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.007532
K_158 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.007540
K_159 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.005282
K_160 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.005176
K_161 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.005187
K_162 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.005164
K_163 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.004816
K_164 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.004819
K_165 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.004727
K_166 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.004814
K_167 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.005784
K_168 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.005805
K_169 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.005741
K_170 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.005659
K_171 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.004154
K_172 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.004101
K_173 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.004075
K_174 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.004102
K_175 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.004654
K_176 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.004696
K_177 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.004595
K_178 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.004630
K_179 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.004362
K_180 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.004327
K_181 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.004303
K_182 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.004276
K_183 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.003814
K_184 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.003798
K_185 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.003748
K_186 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.003782
K_187 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.004167
K_188 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.004179
K_189 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.004118
K_190 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.004114
K_191 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.003716
K_192 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.003696
K_193 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.003659
K_194 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.003665
K_195 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.028071
K_196 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.006223
K_197 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.006469
K_198 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.006292
K_199 X_NUC_3.L_CORE X_NUC_65.L_CORE 0.004127
K_200 X_NUC_3.L_CORE X_NUC_66.L_CORE 0.005159
K_201 X_NUC_3.L_CORE X_NUC_67.L_CORE 0.003931
K_202 X_NUC_3.L_CORE X_NUC_68.L_CORE 0.003655
K_203 X_NUC_3.L_CORE X_NUC_69.L_CORE 0.003873
K_204 X_NUC_3.L_CORE X_NUC_70.L_CORE 0.003284
K_205 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.008074
K_206 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.007791
K_207 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.007852
K_208 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.007950
K_209 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.008428
K_210 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.008558
K_211 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.008275
K_212 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.008573
K_213 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.009449
K_214 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.009250
K_215 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.009353
K_216 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.009058
K_217 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.005258
K_218 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.005184
K_219 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.005139
K_220 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.005234
K_221 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.007557
K_222 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.007763
K_223 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.007514
K_224 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.007532
K_225 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.005305
K_226 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.005198
K_227 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.005208
K_228 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.005187
K_229 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.004729
K_230 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.004732
K_231 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.004644
K_232 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.004727
K_233 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.005869
K_234 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.005891
K_235 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.005822
K_236 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.005741
K_237 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.004125
K_238 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.004072
K_239 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.004046
K_240 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.004075
K_241 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.004617
K_242 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.004657
K_243 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.004557
K_244 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.004595
K_245 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.004390
K_246 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.004354
K_247 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.004328
K_248 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.004303
K_249 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.003779
K_250 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.003763
K_251 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.003714
K_252 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.003748
K_253 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.004171
K_254 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.004183
K_255 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.004120
K_256 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.004118
K_257 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.003710
K_258 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.003689
K_259 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.003652
K_260 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.003659
K_261 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.030070
K_262 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.006177
K_263 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.006307
K_264 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.006447
K_265 X_NUC_4.L_CORE X_NUC_65.L_CORE 0.004070
K_266 X_NUC_4.L_CORE X_NUC_66.L_CORE 0.005160
K_267 X_NUC_4.L_CORE X_NUC_67.L_CORE 0.003944
K_268 X_NUC_4.L_CORE X_NUC_68.L_CORE 0.003615
K_269 X_NUC_4.L_CORE X_NUC_69.L_CORE 0.003894
K_270 X_NUC_4.L_CORE X_NUC_70.L_CORE 0.003274
K_271 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_272 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_273 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_274 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.005719
K_275 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.005868
K_276 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.005750
K_277 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.005808
K_278 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.007017
K_279 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.007128
K_280 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.007128
K_281 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.006928
K_282 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.008684
K_283 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.008709
K_284 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.008423
K_285 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.008727
K_286 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.004383
K_287 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.004471
K_288 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.004411
K_289 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.004397
K_290 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.008156
K_291 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.008057
K_292 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008029
K_293 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.007855
K_294 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.004747
K_295 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.004812
K_296 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.004705
K_297 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.004771
K_298 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.004343
K_299 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.004399
K_300 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.004359
K_301 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.004309
K_302 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006234
K_303 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.006185
K_304 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.006066
K_305 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.006117
K_306 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.003774
K_307 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.003827
K_308 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.003765
K_309 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.003775
K_310 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.004637
K_311 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.004649
K_312 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.004606
K_313 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.004556
K_314 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.004314
K_315 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.004335
K_316 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.004251
K_317 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.004287
K_318 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.003653
K_319 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.003689
K_320 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.003640
K_321 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.003629
K_322 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.004118
K_323 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.004128
K_324 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.004068
K_325 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.004064
K_326 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.006694
K_327 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.024694
K_328 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.004654
K_329 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.005413
K_330 X_NUC_5.L_CORE X_NUC_65.L_CORE 0.006038
K_331 X_NUC_5.L_CORE X_NUC_66.L_CORE 0.003572
K_332 X_NUC_5.L_CORE X_NUC_67.L_CORE 0.005181
K_333 X_NUC_5.L_CORE X_NUC_68.L_CORE 0.003703
K_334 X_NUC_5.L_CORE X_NUC_69.L_CORE 0.003462
K_335 X_NUC_5.L_CORE X_NUC_70.L_CORE 0.003756
K_336 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_337 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_338 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.005576
K_339 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.005719
K_340 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.005607
K_341 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.005661
K_342 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.006904
K_343 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.007017
K_344 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.007013
K_345 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.006822
K_346 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.008644
K_347 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.008684
K_348 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.008394
K_349 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.008695
K_350 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.004298
K_351 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.004383
K_352 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.004325
K_353 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.004312
K_354 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.008244
K_355 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.008156
K_356 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008120
K_357 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.007941
K_358 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.004683
K_359 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.004747
K_360 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.004644
K_361 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.004707
K_362 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.004288
K_363 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.004343
K_364 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.004304
K_365 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.004256
K_366 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006279
K_367 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006234
K_368 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.006109
K_369 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.006162
K_370 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.003723
K_371 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.003774
K_372 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.003714
K_373 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.003723
K_374 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.004622
K_375 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.004637
K_376 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.004592
K_377 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.004543
K_378 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.004292
K_379 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.004314
K_380 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.004231
K_381 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.004266
K_382 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.003617
K_383 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.003653
K_384 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.003605
K_385 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.003594
K_386 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.004105
K_387 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.004118
K_388 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.004057
K_389 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.004054
K_390 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.006507
K_391 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.027972
K_392 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.004562
K_393 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.005366
K_394 X_NUC_6.L_CORE X_NUC_65.L_CORE 0.006053
K_395 X_NUC_6.L_CORE X_NUC_66.L_CORE 0.003519
K_396 X_NUC_6.L_CORE X_NUC_67.L_CORE 0.005220
K_397 X_NUC_6.L_CORE X_NUC_68.L_CORE 0.003672
K_398 X_NUC_6.L_CORE X_NUC_69.L_CORE 0.003435
K_399 X_NUC_6.L_CORE X_NUC_70.L_CORE 0.003753
K_400 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_401 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.005684
K_402 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.005833
K_403 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.005719
K_404 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.005774
K_405 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.006904
K_406 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.007013
K_407 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.007017
K_408 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.006823
K_409 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.008954
K_410 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.008989
K_411 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.008684
K_412 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.009010
K_413 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.004353
K_414 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.004440
K_415 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.004383
K_416 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.004368
K_417 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.008275
K_418 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.008179
K_419 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.008156
K_420 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.007968
K_421 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.004788
K_422 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.004855
K_423 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.004747
K_424 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.004813
K_425 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.004326
K_426 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.004381
K_427 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.004343
K_428 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.004293
K_429 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006412
K_430 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006361
K_431 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006234
K_432 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006288
K_433 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.003783
K_434 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.003837
K_435 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.003774
K_436 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.003784
K_437 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.004666
K_438 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.004680
K_439 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.004637
K_440 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.004585
K_441 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.004378
K_442 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.004401
K_443 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.004314
K_444 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.004351
K_445 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.003666
K_446 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.003703
K_447 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.003653
K_448 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.003642
K_449 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.004167
K_450 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.004179
K_451 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.004118
K_452 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.004113
K_453 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.006521
K_454 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.025798
K_455 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.004637
K_456 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.005360
K_457 X_NUC_7.L_CORE X_NUC_65.L_CORE 0.006193
K_458 X_NUC_7.L_CORE X_NUC_66.L_CORE 0.003561
K_459 X_NUC_7.L_CORE X_NUC_67.L_CORE 0.005250
K_460 X_NUC_7.L_CORE X_NUC_68.L_CORE 0.003738
K_461 X_NUC_7.L_CORE X_NUC_69.L_CORE 0.003469
K_462 X_NUC_7.L_CORE X_NUC_70.L_CORE 0.003806
K_463 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.005629
K_464 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.005774
K_465 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.005661
K_466 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.005719
K_467 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.007101
K_468 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.007221
K_469 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.007221
K_470 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.007017
K_471 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.008626
K_472 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.008658
K_473 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.008377
K_474 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.008684
K_475 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.004366
K_476 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.004454
K_477 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.004395
K_478 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.004383
K_479 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.008479
K_480 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.008376
K_481 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.008344
K_482 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.008156
K_483 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.004721
K_484 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.004786
K_485 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.004681
K_486 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.004747
K_487 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.004376
K_488 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.004434
K_489 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.004394
K_490 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.004343
K_491 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006352
K_492 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006303
K_493 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.006177
K_494 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006234
K_495 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.003773
K_496 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.003826
K_497 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.003764
K_498 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.003774
K_499 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.004719
K_500 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.004734
K_501 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.004688
K_502 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.004637
K_503 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.004339
K_504 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.004362
K_505 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.004277
K_506 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.004314
K_507 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.003678
K_508 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.003715
K_509 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.003664
K_510 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.003653
K_511 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.004171
K_512 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.004183
K_513 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.004121
K_514 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.004118
K_515 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.006597
K_516 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.025663
K_517 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.004594
K_518 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.005486
K_519 X_NUC_8.L_CORE X_NUC_65.L_CORE 0.006045
K_520 X_NUC_8.L_CORE X_NUC_66.L_CORE 0.003569
K_521 X_NUC_8.L_CORE X_NUC_67.L_CORE 0.005309
K_522 X_NUC_8.L_CORE X_NUC_68.L_CORE 0.003704
K_523 X_NUC_8.L_CORE X_NUC_69.L_CORE 0.003492
K_524 X_NUC_8.L_CORE X_NUC_70.L_CORE 0.003799
K_525 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_526 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_527 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_528 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.004846
K_529 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.004793
K_530 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.004861
K_531 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.004763
K_532 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.006218
K_533 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.006047
K_534 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.006080
K_535 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.006122
K_536 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.008224
K_537 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.008357
K_538 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.008310
K_539 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.008059
K_540 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.003987
K_541 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.003927
K_542 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.003961
K_543 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.003921
K_544 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.008378
K_545 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.008268
K_546 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008060
K_547 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.008231
K_548 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.004510
K_549 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.004499
K_550 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.004512
K_551 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.004430
K_552 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.004155
K_553 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.004086
K_554 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.004092
K_555 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.004087
K_556 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006456
K_557 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006505
K_558 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006361
K_559 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006332
K_560 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.003666
K_561 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.003634
K_562 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.003642
K_563 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.003603
K_564 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.004642
K_565 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.004591
K_566 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.004547
K_567 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.004562
K_568 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.004314
K_569 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.004310
K_570 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.004278
K_571 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.004237
K_572 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.003748
K_573 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.003716
K_574 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.003702
K_575 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.003684
K_576 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.007395
K_577 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.004703
K_578 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.023541
K_579 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.003964
K_580 X_NUC_9.L_CORE X_NUC_65.L_CORE 0.004836
K_581 X_NUC_9.L_CORE X_NUC_66.L_CORE 0.005797
K_582 X_NUC_9.L_CORE X_NUC_67.L_CORE 0.003305
K_583 X_NUC_9.L_CORE X_NUC_68.L_CORE 0.005084
K_584 X_NUC_9.L_CORE X_NUC_69.L_CORE 0.003603
K_585 X_NUC_9.L_CORE X_NUC_70.L_CORE 0.003440
K_586 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_587 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_588 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.004897
K_589 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.004846
K_590 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.004914
K_591 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.004813
K_592 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.006399
K_593 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.006218
K_594 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.006252
K_595 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.006296
K_596 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.008084
K_597 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.008224
K_598 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.008172
K_599 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.007933
K_600 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.004048
K_601 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.003987
K_602 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.004022
K_603 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.003980
K_604 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.008478
K_605 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.008378
K_606 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.008155
K_607 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.008332
K_608 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.004518
K_609 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.004510
K_610 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.004521
K_611 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.004439
K_612 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.004226
K_613 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.004155
K_614 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.004160
K_615 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.004155
K_616 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006401
K_617 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006456
K_618 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006311
K_619 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.006284
K_620 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.003697
K_621 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.003666
K_622 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.003673
K_623 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.003633
K_624 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.004692
K_625 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.004642
K_626 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.004596
K_627 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.004611
K_628 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.004317
K_629 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.004314
K_630 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.004281
K_631 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.004240
K_632 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.003781
K_633 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.003748
K_634 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.003734
K_635 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.003715
K_636 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.007448
K_637 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.004806
K_638 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.021703
K_639 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.003994
K_640 X_NUC_10.L_CORE X_NUC_65.L_CORE 0.004935
K_641 X_NUC_10.L_CORE X_NUC_66.L_CORE 0.005719
K_642 X_NUC_10.L_CORE X_NUC_67.L_CORE 0.003344
K_643 X_NUC_10.L_CORE X_NUC_68.L_CORE 0.005107
K_644 X_NUC_10.L_CORE X_NUC_69.L_CORE 0.003610
K_645 X_NUC_10.L_CORE X_NUC_70.L_CORE 0.003469
K_646 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_647 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.004827
K_648 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.004777
K_649 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.004846
K_650 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.004747
K_651 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.006360
K_652 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.006180
K_653 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.006218
K_654 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.006260
K_655 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.008128
K_656 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.008263
K_657 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.008224
K_658 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.007974
K_659 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.004012
K_660 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.003952
K_661 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.003987
K_662 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.003946
K_663 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.008721
K_664 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.008605
K_665 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.008378
K_666 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.008563
K_667 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.004506
K_668 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.004497
K_669 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.004510
K_670 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.004427
K_671 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.004219
K_672 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.004148
K_673 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.004155
K_674 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.004149
K_675 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006549
K_676 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006604
K_677 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006456
K_678 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006423
K_679 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.003689
K_680 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.003657
K_681 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.003666
K_682 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.003626
K_683 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.004740
K_684 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.004687
K_685 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.004642
K_686 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.004657
K_687 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.004349
K_688 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.004346
K_689 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.004314
K_690 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.004271
K_691 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.003795
K_692 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.003762
K_693 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.003748
K_694 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.003729
K_695 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.007229
K_696 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.004729
K_697 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.023721
K_698 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.003954
K_699 X_NUC_11.L_CORE X_NUC_65.L_CORE 0.004936
K_700 X_NUC_11.L_CORE X_NUC_66.L_CORE 0.005782
K_701 X_NUC_11.L_CORE X_NUC_67.L_CORE 0.003329
K_702 X_NUC_11.L_CORE X_NUC_68.L_CORE 0.005202
K_703 X_NUC_11.L_CORE X_NUC_69.L_CORE 0.003620
K_704 X_NUC_11.L_CORE X_NUC_70.L_CORE 0.003486
K_705 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.004929
K_706 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.004876
K_707 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.004947
K_708 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.004846
K_709 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.006314
K_710 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.006138
K_711 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.006172
K_712 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.006218
K_713 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.008386
K_714 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.008535
K_715 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.008484
K_716 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.008224
K_717 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.004055
K_718 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.003993
K_719 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.004028
K_720 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.003987
K_721 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.008519
K_722 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.008410
K_723 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.008192
K_724 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.008378
K_725 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.004592
K_726 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.004582
K_727 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.004595
K_728 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.004510
K_729 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.004225
K_730 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.004153
K_731 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.004159
K_732 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.004155
K_733 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006580
K_734 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006636
K_735 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006483
K_736 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006456
K_737 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.003731
K_738 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.003698
K_739 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.003706
K_740 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.003666
K_741 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.004723
K_742 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.004670
K_743 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.004624
K_744 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.004642
K_745 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.004394
K_746 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.004390
K_747 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.004357
K_748 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.004314
K_749 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.003815
K_750 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.003781
K_751 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.003767
K_752 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.003748
K_753 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.007454
K_754 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.004760
K_755 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.022117
K_756 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.004023
K_757 X_NUC_12.L_CORE X_NUC_65.L_CORE 0.004895
K_758 X_NUC_12.L_CORE X_NUC_66.L_CORE 0.005880
K_759 X_NUC_12.L_CORE X_NUC_67.L_CORE 0.003355
K_760 X_NUC_12.L_CORE X_NUC_68.L_CORE 0.005153
K_761 X_NUC_12.L_CORE X_NUC_69.L_CORE 0.003661
K_762 X_NUC_12.L_CORE X_NUC_70.L_CORE 0.003493
K_763 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_764 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_765 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_766 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.004379
K_767 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.004355
K_768 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.004318
K_769 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.004406
K_770 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.005755
K_771 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.005891
K_772 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.005755
K_773 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.005837
K_774 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.007886
K_775 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.007648
K_776 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.007624
K_777 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.007727
K_778 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.003770
K_779 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.003784
K_780 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.003732
K_781 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.003795
K_782 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.008462
K_783 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.008676
K_784 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.008385
K_785 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.008361
K_786 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.004386
K_787 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.004342
K_788 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.004300
K_789 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.004366
K_790 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.004072
K_791 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.004116
K_792 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.004038
K_793 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.004090
K_794 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006522
K_795 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006468
K_796 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006352
K_797 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006368
K_798 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.003666
K_799 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.003663
K_800 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.003612
K_801 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.003662
K_802 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.004637
K_803 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.004677
K_804 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.004577
K_805 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.004611
K_806 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.004303
K_807 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.004289
K_808 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.004222
K_809 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.004262
K_810 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.008388
K_811 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.005955
K_812 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.004083
K_813 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.019608
K_814 X_NUC_13.L_CORE X_NUC_65.L_CORE 0.003652
K_815 X_NUC_13.L_CORE X_NUC_66.L_CORE 0.004647
K_816 X_NUC_13.L_CORE X_NUC_67.L_CORE 0.005478
K_817 X_NUC_13.L_CORE X_NUC_68.L_CORE 0.003255
K_818 X_NUC_13.L_CORE X_NUC_69.L_CORE 0.004894
K_819 X_NUC_13.L_CORE X_NUC_70.L_CORE 0.003632
K_820 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_821 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_822 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.004401
K_823 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.004379
K_824 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.004340
K_825 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.004430
K_826 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.005624
K_827 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.005755
K_828 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.005626
K_829 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.005703
K_830 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.008136
K_831 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.007886
K_832 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.007854
K_833 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.007968
K_834 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.003754
K_835 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.003770
K_836 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.003717
K_837 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.003780
K_838 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.008250
K_839 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.008462
K_840 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008185
K_841 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.008163
K_842 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.004430
K_843 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.004386
K_844 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.004342
K_845 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.004409
K_846 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.004028
K_847 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.004072
K_848 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.003996
K_849 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.004046
K_850 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006571
K_851 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006522
K_852 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006401
K_853 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006416
K_854 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.003668
K_855 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.003666
K_856 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.003614
K_857 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.003664
K_858 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.004595
K_859 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.004637
K_860 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.004539
K_861 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.004571
K_862 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.004315
K_863 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.004303
K_864 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.004234
K_865 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.004274
K_866 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.008203
K_867 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.006065
K_868 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.004042
K_869 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.019821
K_870 X_NUC_14.L_CORE X_NUC_65.L_CORE 0.003671
K_871 X_NUC_14.L_CORE X_NUC_66.L_CORE 0.004562
K_872 X_NUC_14.L_CORE X_NUC_67.L_CORE 0.005579
K_873 X_NUC_14.L_CORE X_NUC_68.L_CORE 0.003245
K_874 X_NUC_14.L_CORE X_NUC_69.L_CORE 0.004857
K_875 X_NUC_14.L_CORE X_NUC_70.L_CORE 0.003644
K_876 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_877 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.004441
K_878 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.004417
K_879 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.004379
K_880 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.004470
K_881 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.005750
K_882 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.005888
K_883 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.005755
K_884 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.005834
K_885 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.008166
K_886 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.007907
K_887 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.007886
K_888 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.007995
K_889 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.003808
K_890 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.003823
K_891 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.003770
K_892 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.003835
K_893 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.008527
K_894 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.008754
K_895 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.008462
K_896 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.008431
K_897 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.004476
K_898 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.004430
K_899 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.004386
K_900 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.004455
K_901 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.004106
K_902 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.004151
K_903 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.004072
K_904 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.004124
K_905 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006700
K_906 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006644
K_907 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006522
K_908 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.006535
K_909 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.003721
K_910 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.003718
K_911 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.003666
K_912 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.003717
K_913 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.004696
K_914 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.004739
K_915 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.004637
K_916 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.004670
K_917 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.004386
K_918 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.004373
K_919 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.004303
K_920 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.004344
K_921 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.008231
K_922 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.006040
K_923 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.004094
K_924 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.019513
K_925 X_NUC_15.L_CORE X_NUC_65.L_CORE 0.003701
K_926 X_NUC_15.L_CORE X_NUC_66.L_CORE 0.004654
K_927 X_NUC_15.L_CORE X_NUC_67.L_CORE 0.005616
K_928 X_NUC_15.L_CORE X_NUC_68.L_CORE 0.003290
K_929 X_NUC_15.L_CORE X_NUC_69.L_CORE 0.004954
K_930 X_NUC_15.L_CORE X_NUC_70.L_CORE 0.003693
K_931 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.004351
K_932 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.004328
K_933 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.004292
K_934 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.004379
K_935 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.005672
K_936 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.005804
K_937 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.005674
K_938 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.005755
K_939 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.008044
K_940 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.007796
K_941 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.007771
K_942 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.007886
K_943 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.003743
K_944 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.003758
K_945 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.003707
K_946 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.003770
K_947 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.008552
K_948 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.008781
K_949 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.008479
K_950 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.008462
K_951 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.004405
K_952 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.004361
K_953 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.004319
K_954 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.004386
K_955 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.004054
K_956 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.004097
K_957 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.004021
K_958 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.004072
K_959 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006682
K_960 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006627
K_961 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006503
K_962 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006522
K_963 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.003669
K_964 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.003666
K_965 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.003615
K_966 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.003666
K_967 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.004661
K_968 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.004703
K_969 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.004602
K_970 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.004637
K_971 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.004343
K_972 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.004330
K_973 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.004261
K_974 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.004303
K_975 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.008064
K_976 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.005915
K_977 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.004026
K_978 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.021294
K_979 X_NUC_16.L_CORE X_NUC_65.L_CORE 0.003641
K_980 X_NUC_16.L_CORE X_NUC_66.L_CORE 0.004616
K_981 X_NUC_16.L_CORE X_NUC_67.L_CORE 0.005586
K_982 X_NUC_16.L_CORE X_NUC_68.L_CORE 0.003248
K_983 X_NUC_16.L_CORE X_NUC_69.L_CORE 0.004951
K_984 X_NUC_16.L_CORE X_NUC_70.L_CORE 0.003658
K_985 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_986 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_987 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_988 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.004106
K_989 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.004175
K_990 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.004158
K_991 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.004113
K_992 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.005480
K_993 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.005442
K_994 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.005508
K_995 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.005374
K_996 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.007673
K_997 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.007929
K_998 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.007677
K_999 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.007739
K_1000 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.003657
K_1001 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.003687
K_1002 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.003687
K_1003 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.003633
K_1004 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.008490
K_1005 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.008338
K_1006 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.008301
K_1007 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.008159
K_1008 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.004348
K_1009 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.004425
K_1010 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.004366
K_1011 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.004342
K_1012 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.004072
K_1013 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.004078
K_1014 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.004079
K_1015 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.004012
K_1016 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006456
K_1017 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006513
K_1018 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.006353
K_1019 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.006347
K_1020 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.003774
K_1021 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.003811
K_1022 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.003781
K_1023 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.003743
K_1024 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.004595
K_1025 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.004605
K_1026 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.004565
K_1027 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.004514
K_1028 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.004543
K_1029 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.007895
K_1030 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.005407
K_1031 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.003722
K_1032 X_NUC_17.L_CORE X_NUC_65.L_CORE 0.017042
K_1033 X_NUC_17.L_CORE X_NUC_66.L_CORE 0.003529
K_1034 X_NUC_17.L_CORE X_NUC_67.L_CORE 0.004448
K_1035 X_NUC_17.L_CORE X_NUC_68.L_CORE 0.005386
K_1036 X_NUC_17.L_CORE X_NUC_69.L_CORE 0.003312
K_1037 X_NUC_17.L_CORE X_NUC_70.L_CORE 0.004491
K_1038 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_1039 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_1040 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.004040
K_1041 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.004106
K_1042 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.004090
K_1043 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.004047
K_1044 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.005515
K_1045 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.005480
K_1046 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.005545
K_1047 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.005409
K_1048 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.007431
K_1049 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.007673
K_1050 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.007439
K_1051 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.007496
K_1052 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.003626
K_1053 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.003657
K_1054 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.003656
K_1055 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.003603
K_1056 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.008635
K_1057 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.008490
K_1058 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.008443
K_1059 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.008294
K_1060 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.004273
K_1061 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.004348
K_1062 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.004291
K_1063 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.004268
K_1064 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.004065
K_1065 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.004072
K_1066 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.004073
K_1067 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.004007
K_1068 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.006394
K_1069 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006456
K_1070 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.006296
K_1071 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.006291
K_1072 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.003737
K_1073 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.003774
K_1074 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.003745
K_1075 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.003708
K_1076 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.004582
K_1077 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.004595
K_1078 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.004554
K_1079 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.004503
K_1080 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.004488
K_1081 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.008011
K_1082 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.005272
K_1083 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.003709
K_1084 X_NUC_18.L_CORE X_NUC_65.L_CORE 0.017635
K_1085 X_NUC_18.L_CORE X_NUC_66.L_CORE 0.003480
K_1086 X_NUC_18.L_CORE X_NUC_67.L_CORE 0.004477
K_1087 X_NUC_18.L_CORE X_NUC_68.L_CORE 0.005300
K_1088 X_NUC_18.L_CORE X_NUC_69.L_CORE 0.003291
K_1089 X_NUC_18.L_CORE X_NUC_70.L_CORE 0.004489
K_1090 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_1091 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.004055
K_1092 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.004122
K_1093 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.004106
K_1094 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.004062
K_1095 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.005449
K_1096 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.005414
K_1097 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.005480
K_1098 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.005347
K_1099 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.007659
K_1100 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.007920
K_1101 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.007673
K_1102 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.007730
K_1103 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.003627
K_1104 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.003657
K_1105 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.003657
K_1106 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.003604
K_1107 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.008678
K_1108 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.008523
K_1109 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.008490
K_1110 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.008332
K_1111 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.004328
K_1112 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.004405
K_1113 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.004348
K_1114 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.004323
K_1115 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.004064
K_1116 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.004070
K_1117 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.004072
K_1118 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.004006
K_1119 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006557
K_1120 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006621
K_1121 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006456
K_1122 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.006447
K_1123 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.003767
K_1124 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.003804
K_1125 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.003774
K_1126 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.003736
K_1127 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.004623
K_1128 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.004634
K_1129 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.004595
K_1130 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.004542
K_1131 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.004452
K_1132 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.007735
K_1133 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.005320
K_1134 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.003684
K_1135 X_NUC_19.L_CORE X_NUC_65.L_CORE 0.018554
K_1136 X_NUC_19.L_CORE X_NUC_66.L_CORE 0.003500
K_1137 X_NUC_19.L_CORE X_NUC_67.L_CORE 0.004455
K_1138 X_NUC_19.L_CORE X_NUC_68.L_CORE 0.005431
K_1139 X_NUC_19.L_CORE X_NUC_69.L_CORE 0.003304
K_1140 X_NUC_19.L_CORE X_NUC_70.L_CORE 0.004538
K_1141 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.004098
K_1142 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.004167
K_1143 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.004151
K_1144 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.004106
K_1145 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.005589
K_1146 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.005550
K_1147 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.005620
K_1148 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.005480
K_1149 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.007600
K_1150 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.007854
K_1151 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.007608
K_1152 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.007673
K_1153 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.003680
K_1154 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.003712
K_1155 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.003711
K_1156 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.003657
K_1157 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.008849
K_1158 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.008685
K_1159 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.008642
K_1160 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.008490
K_1161 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.004352
K_1162 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.004430
K_1163 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.004371
K_1164 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.004348
K_1165 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.004133
K_1166 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.004140
K_1167 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.004141
K_1168 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.004072
K_1169 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006563
K_1170 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.006627
K_1171 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006458
K_1172 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006456
K_1173 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.003805
K_1174 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.003844
K_1175 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.003813
K_1176 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.003774
K_1177 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.004677
K_1178 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.004689
K_1179 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.004647
K_1180 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.004595
K_1181 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.004519
K_1182 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.007964
K_1183 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.005327
K_1184 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.003750
K_1185 X_NUC_20.L_CORE X_NUC_65.L_CORE 0.017594
K_1186 X_NUC_20.L_CORE X_NUC_66.L_CORE 0.003529
K_1187 X_NUC_20.L_CORE X_NUC_67.L_CORE 0.004536
K_1188 X_NUC_20.L_CORE X_NUC_68.L_CORE 0.005403
K_1189 X_NUC_20.L_CORE X_NUC_69.L_CORE 0.003342
K_1190 X_NUC_20.L_CORE X_NUC_70.L_CORE 0.004573
K_1191 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_1192 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_1193 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_1194 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.003951
K_1195 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.003878
K_1196 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.003916
K_1197 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.003904
K_1198 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.005333
K_1199 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.005268
K_1200 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.005225
K_1201 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.005339
K_1202 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.007571
K_1203 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.007420
K_1204 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.007509
K_1205 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.007322
K_1206 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.003622
K_1207 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.003565
K_1208 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.003572
K_1209 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.003590
K_1210 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.008490
K_1211 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.008451
K_1212 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.008186
K_1213 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.008383
K_1214 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.004386
K_1215 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.004312
K_1216 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.004332
K_1217 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.004303
K_1218 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.004155
K_1219 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.004101
K_1220 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.004076
K_1221 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.004118
K_1222 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.006234
K_1223 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.006163
K_1224 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.006089
K_1225 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.006072
K_1226 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.004075
K_1227 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.004017
K_1228 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.004005
K_1229 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.004011
K_1230 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.007082
K_1231 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.003733
K_1232 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.007519
K_1233 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.004940
K_1234 X_NUC_21.L_CORE X_NUC_65.L_CORE 0.003517
K_1235 X_NUC_21.L_CORE X_NUC_66.L_CORE 0.015544
K_1236 X_NUC_21.L_CORE X_NUC_67.L_CORE 0.003431
K_1237 X_NUC_21.L_CORE X_NUC_68.L_CORE 0.004408
K_1238 X_NUC_21.L_CORE X_NUC_69.L_CORE 0.005140
K_1239 X_NUC_21.L_CORE X_NUC_70.L_CORE 0.003534
K_1240 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_1241 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_1242 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.004026
K_1243 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.003951
K_1244 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.003990
K_1245 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.003978
K_1246 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.005397
K_1247 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.005333
K_1248 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.005287
K_1249 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.005405
K_1250 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.007722
K_1251 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.007571
K_1252 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.007661
K_1253 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.007463
K_1254 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.003680
K_1255 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.003622
K_1256 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.003629
K_1257 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.003648
K_1258 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.008515
K_1259 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.008490
K_1260 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.008215
K_1261 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.008414
K_1262 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.004462
K_1263 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.004386
K_1264 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.004406
K_1265 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.004376
K_1266 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.004209
K_1267 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.004155
K_1268 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.004128
K_1269 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.004172
K_1270 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.006303
K_1271 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.006234
K_1272 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.006156
K_1273 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.006138
K_1274 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.004134
K_1275 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.004075
K_1276 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.004062
K_1277 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.004068
K_1278 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.007220
K_1279 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.003797
K_1280 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.007556
K_1281 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.005030
K_1282 X_NUC_22.L_CORE X_NUC_65.L_CORE 0.003565
K_1283 X_NUC_22.L_CORE X_NUC_66.L_CORE 0.014965
K_1284 X_NUC_22.L_CORE X_NUC_67.L_CORE 0.003485
K_1285 X_NUC_22.L_CORE X_NUC_68.L_CORE 0.004444
K_1286 X_NUC_22.L_CORE X_NUC_69.L_CORE 0.005193
K_1287 X_NUC_22.L_CORE X_NUC_70.L_CORE 0.003577
K_1288 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_1289 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.003985
K_1290 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.003912
K_1291 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.003951
K_1292 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.003938
K_1293 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.005445
K_1294 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.005378
K_1295 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.005333
K_1296 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.005453
K_1297 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.007624
K_1298 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.007475
K_1299 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.007571
K_1300 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.007375
K_1301 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.003672
K_1302 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.003613
K_1303 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.003622
K_1304 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.003640
K_1305 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.008815
K_1306 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.008780
K_1307 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.008490
K_1308 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.008703
K_1309 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.004440
K_1310 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.004365
K_1311 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.004386
K_1312 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.004355
K_1313 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.004237
K_1314 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.004181
K_1315 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.004155
K_1316 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.004199
K_1317 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.006385
K_1318 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.006310
K_1319 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.006234
K_1320 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.006213
K_1321 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.004147
K_1322 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.004086
K_1323 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.004075
K_1324 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.004081
K_1325 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.006992
K_1326 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.003754
K_1327 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.007595
K_1328 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.004940
K_1329 X_NUC_23.L_CORE X_NUC_65.L_CORE 0.003561
K_1330 X_NUC_23.L_CORE X_NUC_66.L_CORE 0.015867
K_1331 X_NUC_23.L_CORE X_NUC_67.L_CORE 0.003465
K_1332 X_NUC_23.L_CORE X_NUC_68.L_CORE 0.004498
K_1333 X_NUC_23.L_CORE X_NUC_69.L_CORE 0.005213
K_1334 X_NUC_23.L_CORE X_NUC_70.L_CORE 0.003591
K_1335 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.003998
K_1336 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.003923
K_1337 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.003962
K_1338 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.003951
K_1339 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.005324
K_1340 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.005261
K_1341 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.005218
K_1342 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.005333
K_1343 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.007837
K_1344 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.007674
K_1345 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.007773
K_1346 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.007571
K_1347 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.003653
K_1348 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.003595
K_1349 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.003603
K_1350 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.003622
K_1351 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.008587
K_1352 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.008553
K_1353 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.008279
K_1354 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.008490
K_1355 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.004472
K_1356 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.004395
K_1357 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.004416
K_1358 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.004386
K_1359 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.004191
K_1360 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.004136
K_1361 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.004110
K_1362 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.004155
K_1363 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.006404
K_1364 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.006330
K_1365 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.006250
K_1366 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.006234
K_1367 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.004140
K_1368 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.004080
K_1369 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.004067
K_1370 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.004075
K_1371 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.007030
K_1372 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.003746
K_1373 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.007349
K_1374 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.005018
K_1375 X_NUC_24.L_CORE X_NUC_65.L_CORE 0.003526
K_1376 X_NUC_24.L_CORE X_NUC_66.L_CORE 0.016014
K_1377 X_NUC_24.L_CORE X_NUC_67.L_CORE 0.003475
K_1378 X_NUC_24.L_CORE X_NUC_68.L_CORE 0.004426
K_1379 X_NUC_24.L_CORE X_NUC_69.L_CORE 0.005269
K_1380 X_NUC_24.L_CORE X_NUC_70.L_CORE 0.003579
K_1381 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_1382 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_1383 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_1384 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.003879
K_1385 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.003925
K_1386 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.003869
K_1387 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.003927
K_1388 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.005287
K_1389 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.005415
K_1390 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.005350
K_1391 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.005310
K_1392 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.007571
K_1393 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.007557
K_1394 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.007364
K_1395 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.007605
K_1396 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.003657
K_1397 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.003714
K_1398 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.003659
K_1399 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.003686
K_1400 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.008462
K_1401 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.008650
K_1402 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.008411
K_1403 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.008312
K_1404 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.004510
K_1405 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.004550
K_1406 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.004458
K_1407 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.004532
K_1408 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.004343
K_1409 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.004419
K_1410 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.004339
K_1411 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.004348
K_1412 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.005741
K_1413 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.005804
K_1414 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.005651
K_1415 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.005703
K_1416 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.004654
K_1417 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.008133
K_1418 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.003472
K_1419 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.007372
K_1420 X_NUC_25.L_CORE X_NUC_65.L_CORE 0.004820
K_1421 X_NUC_25.L_CORE X_NUC_66.L_CORE 0.003508
K_1422 X_NUC_25.L_CORE X_NUC_67.L_CORE 0.013230
K_1423 X_NUC_25.L_CORE X_NUC_68.L_CORE 0.003532
K_1424 X_NUC_25.L_CORE X_NUC_69.L_CORE 0.004520
K_1425 X_NUC_25.L_CORE X_NUC_70.L_CORE 0.004911
K_1426 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_1427 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_1428 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.003834
K_1429 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.003879
K_1430 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.003825
K_1431 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.003881
K_1432 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.005164
K_1433 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.005287
K_1434 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.005225
K_1435 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.005187
K_1436 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.007575
K_1437 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.007571
K_1438 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.007372
K_1439 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.007614
K_1440 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.003602
K_1441 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.003657
K_1442 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.003604
K_1443 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.003629
K_1444 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.008273
K_1445 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.008462
K_1446 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.008232
K_1447 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.008139
K_1448 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.004469
K_1449 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.004510
K_1450 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.004420
K_1451 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.004491
K_1452 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.004270
K_1453 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.004343
K_1454 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.004267
K_1455 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.004275
K_1456 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.005676
K_1457 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.005741
K_1458 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.005591
K_1459 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.005642
K_1460 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.004573
K_1461 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.008137
K_1462 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.003426
K_1463 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.007191
K_1464 X_NUC_26.L_CORE X_NUC_65.L_CORE 0.004808
K_1465 X_NUC_26.L_CORE X_NUC_66.L_CORE 0.003450
K_1466 X_NUC_26.L_CORE X_NUC_67.L_CORE 0.013468
K_1467 X_NUC_26.L_CORE X_NUC_68.L_CORE 0.003498
K_1468 X_NUC_26.L_CORE X_NUC_69.L_CORE 0.004447
K_1469 X_NUC_26.L_CORE X_NUC_70.L_CORE 0.004883
K_1470 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_1471 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.003888
K_1472 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.003934
K_1473 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.003879
K_1474 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.003936
K_1475 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.005222
K_1476 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.005348
K_1477 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.005287
K_1478 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.005246
K_1479 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.007786
K_1480 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.007777
K_1481 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.007571
K_1482 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.007829
K_1483 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.003654
K_1484 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.003711
K_1485 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.003657
K_1486 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.003683
K_1487 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.008500
K_1488 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.008698
K_1489 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.008462
K_1490 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.008354
K_1491 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.004561
K_1492 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.004604
K_1493 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.004510
K_1494 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.004585
K_1495 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.004346
K_1496 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.004422
K_1497 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.004343
K_1498 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.004352
K_1499 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.005832
K_1500 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.005900
K_1501 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.005741
K_1502 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.005794
K_1503 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.004573
K_1504 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.008049
K_1505 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.003456
K_1506 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.007156
K_1507 X_NUC_27.L_CORE X_NUC_65.L_CORE 0.004871
K_1508 X_NUC_27.L_CORE X_NUC_66.L_CORE 0.003487
K_1509 X_NUC_27.L_CORE X_NUC_67.L_CORE 0.013867
K_1510 X_NUC_27.L_CORE X_NUC_68.L_CORE 0.003552
K_1511 X_NUC_27.L_CORE X_NUC_69.L_CORE 0.004517
K_1512 X_NUC_27.L_CORE X_NUC_70.L_CORE 0.004995
K_1513 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.003832
K_1514 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.003877
K_1515 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.003824
K_1516 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.003879
K_1517 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.005261
K_1518 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.005389
K_1519 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.005325
K_1520 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.005287
K_1521 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.007528
K_1522 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.007519
K_1523 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.007328
K_1524 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.007571
K_1525 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.003628
K_1526 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.003684
K_1527 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.003630
K_1528 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.003657
K_1529 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.008606
K_1530 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.008812
K_1531 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.008560
K_1532 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.008462
K_1533 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.004486
K_1534 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.004527
K_1535 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.004436
K_1536 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.004510
K_1537 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.004337
K_1538 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.004413
K_1539 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.004333
K_1540 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.004343
K_1541 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.005775
K_1542 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.005841
K_1543 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.005685
K_1544 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.005741
K_1545 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.004565
K_1546 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.007870
K_1547 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.003424
K_1548 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.007323
K_1549 X_NUC_28.L_CORE X_NUC_65.L_CORE 0.004760
K_1550 X_NUC_28.L_CORE X_NUC_66.L_CORE 0.003480
K_1551 X_NUC_28.L_CORE X_NUC_67.L_CORE 0.014023
K_1552 X_NUC_28.L_CORE X_NUC_68.L_CORE 0.003508
K_1553 X_NUC_28.L_CORE X_NUC_69.L_CORE 0.004535
K_1554 X_NUC_28.L_CORE X_NUC_70.L_CORE 0.004938
K_1555 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_1556 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_1557 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_1558 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.003879
K_1559 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.003883
K_1560 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.003914
K_1561 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.003842
K_1562 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.005333
K_1563 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.005215
K_1564 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.005282
K_1565 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.005226
K_1566 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.007673
K_1567 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.007842
K_1568 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.007766
K_1569 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.007573
K_1570 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.003770
K_1571 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.003745
K_1572 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.003774
K_1573 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.003714
K_1574 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.008378
K_1575 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.008185
K_1576 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.008145
K_1577 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.008063
K_1578 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.004747
K_1579 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.004761
K_1580 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.004759
K_1581 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.004669
K_1582 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.004727
K_1583 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.004681
K_1584 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.004693
K_1585 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.004624
K_1586 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.004201
K_1587 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.004193
K_1588 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.008791
K_1589 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.003297
K_1590 X_NUC_29.L_CORE X_NUC_65.L_CORE 0.007063
K_1591 X_NUC_29.L_CORE X_NUC_66.L_CORE 0.004811
K_1592 X_NUC_29.L_CORE X_NUC_67.L_CORE 0.003496
K_1593 X_NUC_29.L_CORE X_NUC_68.L_CORE 0.011546
K_1594 X_NUC_29.L_CORE X_NUC_69.L_CORE 0.003705
K_1595 X_NUC_29.L_CORE X_NUC_70.L_CORE 0.004609
K_1596 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_1597 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_1598 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.003874
K_1599 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.003879
K_1600 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.003909
K_1601 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.003837
K_1602 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.005456
K_1603 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.005333
K_1604 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.005404
K_1605 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.005343
K_1606 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.007505
K_1607 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.007673
K_1608 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.007596
K_1609 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.007416
K_1610 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.003794
K_1611 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.003770
K_1612 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.003799
K_1613 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.003738
K_1614 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.008571
K_1615 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.008378
K_1616 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.008329
K_1617 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.008241
K_1618 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.004732
K_1619 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.004747
K_1620 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.004744
K_1621 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.004656
K_1622 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.004773
K_1623 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.004727
K_1624 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.004739
K_1625 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.004668
K_1626 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.004197
K_1627 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.004252
K_1628 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.008569
K_1629 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.003308
K_1630 X_NUC_30.L_CORE X_NUC_65.L_CORE 0.007309
K_1631 X_NUC_30.L_CORE X_NUC_66.L_CORE 0.004747
K_1632 X_NUC_30.L_CORE X_NUC_67.L_CORE 0.003534
K_1633 X_NUC_30.L_CORE X_NUC_68.L_CORE 0.011529
K_1634 X_NUC_30.L_CORE X_NUC_69.L_CORE 0.003703
K_1635 X_NUC_30.L_CORE X_NUC_70.L_CORE 0.004662
K_1636 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_1637 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.003845
K_1638 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.003849
K_1639 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.003879
K_1640 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.003809
K_1641 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.005382
K_1642 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.005262
K_1643 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.005333
K_1644 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.005274
K_1645 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.007575
K_1646 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.007742
K_1647 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.007673
K_1648 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.007483
K_1649 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.003764
K_1650 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.003740
K_1651 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.003770
K_1652 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.003710
K_1653 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.008616
K_1654 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.008414
K_1655 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.008378
K_1656 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.008281
K_1657 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.004734
K_1658 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.004748
K_1659 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.004747
K_1660 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.004658
K_1661 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.004760
K_1662 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.004714
K_1663 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.004727
K_1664 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.004656
K_1665 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.004130
K_1666 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.004170
K_1667 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.008440
K_1668 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.003272
K_1669 X_NUC_31.L_CORE X_NUC_65.L_CORE 0.007167
K_1670 X_NUC_31.L_CORE X_NUC_66.L_CORE 0.004741
K_1671 X_NUC_31.L_CORE X_NUC_67.L_CORE 0.003500
K_1672 X_NUC_31.L_CORE X_NUC_68.L_CORE 0.012038
K_1673 X_NUC_31.L_CORE X_NUC_69.L_CORE 0.003695
K_1674 X_NUC_31.L_CORE X_NUC_70.L_CORE 0.004662
K_1675 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.003917
K_1676 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.003921
K_1677 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.003953
K_1678 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.003879
K_1679 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.005444
K_1680 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.005320
K_1681 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.005391
K_1682 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.005333
K_1683 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.007767
K_1684 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.007948
K_1685 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.007868
K_1686 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.007673
K_1687 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.003827
K_1688 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.003801
K_1689 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.003831
K_1690 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.003770
K_1691 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.008718
K_1692 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.008508
K_1693 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.008464
K_1694 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.008378
K_1695 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.004827
K_1696 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.004842
K_1697 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.004840
K_1698 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.004747
K_1699 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.004835
K_1700 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.004786
K_1701 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.004799
K_1702 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.004727
K_1703 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.004194
K_1704 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.004215
K_1705 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.008552
K_1706 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.003322
K_1707 X_NUC_32.L_CORE X_NUC_65.L_CORE 0.007156
K_1708 X_NUC_32.L_CORE X_NUC_66.L_CORE 0.004830
K_1709 X_NUC_32.L_CORE X_NUC_67.L_CORE 0.003545
K_1710 X_NUC_32.L_CORE X_NUC_68.L_CORE 0.011975
K_1711 X_NUC_32.L_CORE X_NUC_69.L_CORE 0.003755
K_1712 X_NUC_32.L_CORE X_NUC_70.L_CORE 0.004713
K_1713 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_1714 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_1715 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_1716 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.003951
K_1717 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.003897
K_1718 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.003894
K_1719 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.003945
K_1720 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.005480
K_1721 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.005528
K_1722 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.005417
K_1723 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.005550
K_1724 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.007886
K_1725 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.007629
K_1726 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.007643
K_1727 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.007688
K_1728 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.003987
K_1729 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.003961
K_1730 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.003925
K_1731 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.003992
K_1732 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.008156
K_1733 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.008181
K_1734 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.007903
K_1735 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.008099
K_1736 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.005187
K_1737 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.005116
K_1738 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.005063
K_1739 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.005137
K_1740 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.005434
K_1741 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.003838
K_1742 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.004056
K_1743 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.008964
K_1744 X_NUC_33.L_CORE X_NUC_65.L_CORE 0.003252
K_1745 X_NUC_33.L_CORE X_NUC_66.L_CORE 0.007342
K_1746 X_NUC_33.L_CORE X_NUC_67.L_CORE 0.004815
K_1747 X_NUC_33.L_CORE X_NUC_68.L_CORE 0.003660
K_1748 X_NUC_33.L_CORE X_NUC_69.L_CORE 0.009694
K_1749 X_NUC_33.L_CORE X_NUC_70.L_CORE 0.004146
K_1750 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_1751 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_1752 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.004005
K_1753 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.003951
K_1754 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.003947
K_1755 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.004000
K_1756 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.005430
K_1757 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.005480
K_1758 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.005370
K_1759 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.005500
K_1760 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.008159
K_1761 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.007886
K_1762 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.007896
K_1763 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.007945
K_1764 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.004012
K_1765 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.003987
K_1766 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.003950
K_1767 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.004018
K_1768 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.008118
K_1769 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.008156
K_1770 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.007874
K_1771 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.008069
K_1772 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.005259
K_1773 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.005187
K_1774 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.005131
K_1775 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.005208
K_1776 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.005438
K_1777 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.003888
K_1778 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.004039
K_1779 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.009250
K_1780 X_NUC_34.L_CORE X_NUC_65.L_CORE 0.003277
K_1781 X_NUC_34.L_CORE X_NUC_66.L_CORE 0.007147
K_1782 X_NUC_34.L_CORE X_NUC_67.L_CORE 0.004925
K_1783 X_NUC_34.L_CORE X_NUC_68.L_CORE 0.003663
K_1784 X_NUC_34.L_CORE X_NUC_69.L_CORE 0.009725
K_1785 X_NUC_34.L_CORE X_NUC_70.L_CORE 0.004190
K_1786 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_1787 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.004008
K_1788 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.003953
K_1789 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.003951
K_1790 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.004003
K_1791 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.005542
K_1792 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.005593
K_1793 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.005480
K_1794 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.005616
K_1795 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.008142
K_1796 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.007865
K_1797 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.007886
K_1798 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.007930
K_1799 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.004051
K_1800 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.004024
K_1801 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.003987
K_1802 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.004056
K_1803 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.008420
K_1804 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.008455
K_1805 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.008156
K_1806 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.008365
K_1807 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.005318
K_1808 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.005242
K_1809 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.005187
K_1810 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.005265
K_1811 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.005372
K_1812 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.003854
K_1813 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.004059
K_1814 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.008871
K_1815 X_NUC_35.L_CORE X_NUC_65.L_CORE 0.003282
K_1816 X_NUC_35.L_CORE X_NUC_66.L_CORE 0.007322
K_1817 X_NUC_35.L_CORE X_NUC_67.L_CORE 0.004894
K_1818 X_NUC_35.L_CORE X_NUC_68.L_CORE 0.003705
K_1819 X_NUC_35.L_CORE X_NUC_69.L_CORE 0.010073
K_1820 X_NUC_35.L_CORE X_NUC_70.L_CORE 0.004228
K_1821 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.003955
K_1822 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.003902
K_1823 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.003899
K_1824 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.003951
K_1825 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.005410
K_1826 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.005457
K_1827 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.005350
K_1828 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.005480
K_1829 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.008089
K_1830 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.007817
K_1831 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.007833
K_1832 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.007886
K_1833 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.003981
K_1834 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.003956
K_1835 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.003920
K_1836 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.003987
K_1837 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.008200
K_1838 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.008233
K_1839 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.007949
K_1840 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.008156
K_1841 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.005236
K_1842 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.005164
K_1843 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.005110
K_1844 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.005187
K_1845 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.005319
K_1846 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.003819
K_1847 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.003991
K_1848 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.008992
K_1849 X_NUC_36.L_CORE X_NUC_65.L_CORE 0.003239
K_1850 X_NUC_36.L_CORE X_NUC_66.L_CORE 0.007162
K_1851 X_NUC_36.L_CORE X_NUC_67.L_CORE 0.004870
K_1852 X_NUC_36.L_CORE X_NUC_68.L_CORE 0.003642
K_1853 X_NUC_36.L_CORE X_NUC_69.L_CORE 0.010000
K_1854 X_NUC_36.L_CORE X_NUC_70.L_CORE 0.004174
K_1855 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_1856 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_1857 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_1858 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.004106
K_1859 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.004189
K_1860 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.004143
K_1861 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.004141
K_1862 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.005755
K_1863 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.005817
K_1864 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.005833
K_1865 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.005690
K_1866 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.008224
K_1867 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.008488
K_1868 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.008177
K_1869 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.008308
K_1870 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.004383
K_1871 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.004462
K_1872 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.004420
K_1873 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.004380
K_1874 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.007532
K_1875 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.007684
K_1876 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.007530
K_1877 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.007411
K_1878 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.003633
K_1879 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.006235
K_1880 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.003765
K_1881 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.004017
K_1882 X_NUC_37.L_CORE X_NUC_65.L_CORE 0.009609
K_1883 X_NUC_37.L_CORE X_NUC_66.L_CORE 0.003345
K_1884 X_NUC_37.L_CORE X_NUC_67.L_CORE 0.007459
K_1885 X_NUC_37.L_CORE X_NUC_68.L_CORE 0.005164
K_1886 X_NUC_37.L_CORE X_NUC_69.L_CORE 0.004007
K_1887 X_NUC_37.L_CORE X_NUC_70.L_CORE 0.007669
K_1888 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_1889 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_1890 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.004027
K_1891 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.004106
K_1892 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.004063
K_1893 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.004060
K_1894 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.005690
K_1895 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.005755
K_1896 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.005768
K_1897 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.005630
K_1898 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.007971
K_1899 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.008224
K_1900 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.007934
K_1901 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.008053
K_1902 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.004305
K_1903 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.004383
K_1904 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.004341
K_1905 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.004304
K_1906 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.007379
K_1907 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.007532
K_1908 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.007382
K_1909 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.007269
K_1910 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.003593
K_1911 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.006232
K_1912 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.003706
K_1913 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.003986
K_1914 X_NUC_38.L_CORE X_NUC_65.L_CORE 0.009497
K_1915 X_NUC_38.L_CORE X_NUC_66.L_CORE 0.003294
K_1916 X_NUC_38.L_CORE X_NUC_67.L_CORE 0.007492
K_1917 X_NUC_38.L_CORE X_NUC_68.L_CORE 0.005056
K_1918 X_NUC_38.L_CORE X_NUC_69.L_CORE 0.003954
K_1919 X_NUC_38.L_CORE X_NUC_70.L_CORE 0.007552
K_1920 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_1921 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.004069
K_1922 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.004150
K_1923 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.004106
K_1924 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.004103
K_1925 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.005675
K_1926 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.005737
K_1927 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.005755
K_1928 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.005616
K_1929 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.008258
K_1930 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.008533
K_1931 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.008224
K_1932 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.008350
K_1933 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.004345
K_1934 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.004423
K_1935 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.004383
K_1936 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.004343
K_1937 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.007523
K_1938 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.007680
K_1939 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.007532
K_1940 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.007407
K_1941 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.003571
K_1942 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.006084
K_1943 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.003719
K_1944 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.003951
K_1945 X_NUC_39.L_CORE X_NUC_65.L_CORE 0.009575
K_1946 X_NUC_39.L_CORE X_NUC_66.L_CORE 0.003309
K_1947 X_NUC_39.L_CORE X_NUC_67.L_CORE 0.007365
K_1948 X_NUC_39.L_CORE X_NUC_68.L_CORE 0.005160
K_1949 X_NUC_39.L_CORE X_NUC_69.L_CORE 0.003973
K_1950 X_NUC_39.L_CORE X_NUC_70.L_CORE 0.007763
K_1951 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.004071
K_1952 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.004152
K_1953 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.004108
K_1954 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.004106
K_1955 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.005817
K_1956 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.005883
K_1957 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.005900
K_1958 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.005755
K_1959 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.008129
K_1960 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.008392
K_1961 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.008091
K_1962 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.008224
K_1963 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.004383
K_1964 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.004464
K_1965 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.004421
K_1966 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.004383
K_1967 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.007649
K_1968 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.007814
K_1969 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.007652
K_1970 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.007532
K_1971 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.003594
K_1972 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.006135
K_1973 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.003708
K_1974 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.004015
K_1975 X_NUC_40.L_CORE X_NUC_65.L_CORE 0.009229
K_1976 X_NUC_40.L_CORE X_NUC_66.L_CORE 0.003325
K_1977 X_NUC_40.L_CORE X_NUC_67.L_CORE 0.007632
K_1978 X_NUC_40.L_CORE X_NUC_68.L_CORE 0.005102
K_1979 X_NUC_40.L_CORE X_NUC_69.L_CORE 0.004022
K_1980 X_NUC_40.L_CORE X_NUC_70.L_CORE 0.007815
K_1981 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_1982 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_1983 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_1984 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.004379
K_1985 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.004310
K_1986 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.004367
K_1987 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.004310
K_1988 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.006218
K_1989 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.006054
K_1990 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.006074
K_1991 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.006135
K_1992 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.008684
K_1993 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.008525
K_1994 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.008615
K_1995 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.008356
K_1996 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.005234
K_1997 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.005120
K_1998 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.005158
K_1999 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.005124
K_2000 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.004212
K_2001 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.003336
K_2002 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.006772
K_2003 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.003710
K_2004 X_NUC_41.L_CORE X_NUC_65.L_CORE 0.004030
K_2005 X_NUC_41.L_CORE X_NUC_66.L_CORE 0.010244
K_2006 X_NUC_41.L_CORE X_NUC_67.L_CORE 0.003455
K_2007 X_NUC_41.L_CORE X_NUC_68.L_CORE 0.007841
K_2008 X_NUC_41.L_CORE X_NUC_69.L_CORE 0.005542
K_2009 X_NUC_41.L_CORE X_NUC_70.L_CORE 0.004664
K_2010 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_2011 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_2012 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.004450
K_2013 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.004379
K_2014 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.004439
K_2015 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.004378
K_2016 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.006391
K_2017 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.006218
K_2018 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.006237
K_2019 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.006304
K_2020 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.008835
K_2021 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.008684
K_2022 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.008770
K_2023 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.008498
K_2024 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.005353
K_2025 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.005234
K_2026 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.005273
K_2027 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.005237
K_2028 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.004236
K_2029 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.003380
K_2030 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.006783
K_2031 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.003745
K_2032 X_NUC_42.L_CORE X_NUC_65.L_CORE 0.004099
K_2033 X_NUC_42.L_CORE X_NUC_66.L_CORE 0.010019
K_2034 X_NUC_42.L_CORE X_NUC_67.L_CORE 0.003508
K_2035 X_NUC_42.L_CORE X_NUC_68.L_CORE 0.008021
K_2036 X_NUC_42.L_CORE X_NUC_69.L_CORE 0.005599
K_2037 X_NUC_42.L_CORE X_NUC_70.L_CORE 0.004758
K_2038 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_2039 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.004389
K_2040 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.004320
K_2041 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.004379
K_2042 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.004320
K_2043 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.006368
K_2044 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.006194
K_2045 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.006218
K_2046 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.006282
K_2047 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.008739
K_2048 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.008585
K_2049 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.008684
K_2050 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.008412
K_2051 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.005311
K_2052 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.005193
K_2053 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.005234
K_2054 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.005197
K_2055 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.004155
K_2056 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.003332
K_2057 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.006670
K_2058 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.003684
K_2059 X_NUC_43.L_CORE X_NUC_65.L_CORE 0.004063
K_2060 X_NUC_43.L_CORE X_NUC_66.L_CORE 0.009810
K_2061 X_NUC_43.L_CORE X_NUC_67.L_CORE 0.003468
K_2062 X_NUC_43.L_CORE X_NUC_68.L_CORE 0.008099
K_2063 X_NUC_43.L_CORE X_NUC_69.L_CORE 0.005544
K_2064 X_NUC_43.L_CORE X_NUC_70.L_CORE 0.004741
K_2065 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.004450
K_2066 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.004378
K_2067 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.004439
K_2068 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.004379
K_2069 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.006299
K_2070 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.006131
K_2071 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.006151
K_2072 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.006218
K_2073 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.009036
K_2074 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.008866
K_2075 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.008967
K_2076 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.008684
K_2077 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.005348
K_2078 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.005229
K_2079 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.005269
K_2080 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.005234
K_2081 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.004189
K_2082 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.003339
K_2083 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.006599
K_2084 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.003734
K_2085 X_NUC_44.L_CORE X_NUC_65.L_CORE 0.004033
K_2086 X_NUC_44.L_CORE X_NUC_66.L_CORE 0.010193
K_2087 X_NUC_44.L_CORE X_NUC_67.L_CORE 0.003493
K_2088 X_NUC_44.L_CORE X_NUC_68.L_CORE 0.007864
K_2089 X_NUC_44.L_CORE X_NUC_69.L_CORE 0.005674
K_2090 X_NUC_44.L_CORE X_NUC_70.L_CORE 0.004749
K_2091 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_2092 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_2093 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_2094 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.004846
K_2095 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.004859
K_2096 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.004790
K_2097 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.004901
K_2098 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.007017
K_2099 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.007229
K_2100 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.007024
K_2101 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.007125
K_2102 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.009058
K_2103 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.009068
K_2104 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.008764
K_2105 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.009090
K_2106 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.003957
K_2107 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.004345
K_2108 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.003320
K_2109 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.007216
K_2110 X_NUC_45.L_CORE X_NUC_65.L_CORE 0.003824
K_2111 X_NUC_45.L_CORE X_NUC_66.L_CORE 0.004291
K_2112 X_NUC_45.L_CORE X_NUC_67.L_CORE 0.010699
K_2113 X_NUC_45.L_CORE X_NUC_68.L_CORE 0.003815
K_2114 X_NUC_45.L_CORE X_NUC_69.L_CORE 0.008861
K_2115 X_NUC_45.L_CORE X_NUC_70.L_CORE 0.006436
K_2116 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_2117 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_2118 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.004829
K_2119 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.004846
K_2120 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.004775
K_2121 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.004886
K_2122 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.006816
K_2123 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.007017
K_2124 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.006826
K_2125 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.006918
K_2126 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.009031
K_2127 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.009058
K_2128 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.008747
K_2129 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.009071
K_2130 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.003926
K_2131 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.004371
K_2132 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.003291
K_2133 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.007157
K_2134 X_NUC_46.L_CORE X_NUC_65.L_CORE 0.003835
K_2135 X_NUC_46.L_CORE X_NUC_66.L_CORE 0.004210
K_2136 X_NUC_46.L_CORE X_NUC_67.L_CORE 0.011241
K_2137 X_NUC_46.L_CORE X_NUC_68.L_CORE 0.003789
K_2138 X_NUC_46.L_CORE X_NUC_69.L_CORE 0.008529
K_2139 X_NUC_46.L_CORE X_NUC_70.L_CORE 0.006454
K_2140 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_2141 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.004900
K_2142 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.004916
K_2143 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.004846
K_2144 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.004960
K_2145 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.007003
K_2146 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.007217
K_2147 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.007017
K_2148 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.007113
K_2149 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.009366
K_2150 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.009386
K_2151 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.009058
K_2152 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.009410
K_2153 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.003902
K_2154 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.004326
K_2155 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.003303
K_2156 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.006987
K_2157 X_NUC_47.L_CORE X_NUC_65.L_CORE 0.003845
K_2158 X_NUC_47.L_CORE X_NUC_66.L_CORE 0.004248
K_2159 X_NUC_47.L_CORE X_NUC_67.L_CORE 0.010930
K_2160 X_NUC_47.L_CORE X_NUC_68.L_CORE 0.003837
K_2161 X_NUC_47.L_CORE X_NUC_69.L_CORE 0.008782
K_2162 X_NUC_47.L_CORE X_NUC_70.L_CORE 0.006607
K_2163 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.004789
K_2164 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.004804
K_2165 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.004737
K_2166 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.004846
K_2167 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.006907
K_2168 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.007113
K_2169 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.006917
K_2170 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.007017
K_2171 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.009010
K_2172 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.009029
K_2173 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.008728
K_2174 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.009058
K_2175 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.003888
K_2176 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.004284
K_2177 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.003270
K_2178 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.007081
K_2179 X_NUC_48.L_CORE X_NUC_65.L_CORE 0.003780
K_2180 X_NUC_48.L_CORE X_NUC_66.L_CORE 0.004223
K_2181 X_NUC_48.L_CORE X_NUC_67.L_CORE 0.010786
K_2182 X_NUC_48.L_CORE X_NUC_68.L_CORE 0.003773
K_2183 X_NUC_48.L_CORE X_NUC_69.L_CORE 0.008801
K_2184 X_NUC_48.L_CORE X_NUC_70.L_CORE 0.006431
K_2185 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_2186 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_2187 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_2188 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.005719
K_2189 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.005805
K_2190 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.005816
K_2191 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.005684
K_2192 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.008573
K_2193 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.008499
K_2194 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.008617
K_2195 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.008302
K_2196 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.003373
K_2197 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.004017
K_2198 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.004502
K_2199 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.003381
K_2200 X_NUC_49.L_CORE X_NUC_65.L_CORE 0.007401
K_2201 X_NUC_49.L_CORE X_NUC_66.L_CORE 0.004098
K_2202 X_NUC_49.L_CORE X_NUC_67.L_CORE 0.004588
K_2203 X_NUC_49.L_CORE X_NUC_68.L_CORE 0.012601
K_2204 X_NUC_49.L_CORE X_NUC_69.L_CORE 0.004462
K_2205 X_NUC_49.L_CORE X_NUC_70.L_CORE 0.009609
K_2206 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_2207 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_2208 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.005632
K_2209 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.005719
K_2210 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.005726
K_2211 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.005600
K_2212 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.008635
K_2213 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.008573
K_2214 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.008687
K_2215 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.008364
K_2216 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.003358
K_2217 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.004047
K_2218 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.004442
K_2219 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.003380
K_2220 X_NUC_50.L_CORE X_NUC_65.L_CORE 0.007542
K_2221 X_NUC_50.L_CORE X_NUC_66.L_CORE 0.004037
K_2222 X_NUC_50.L_CORE X_NUC_67.L_CORE 0.004642
K_2223 X_NUC_50.L_CORE X_NUC_68.L_CORE 0.011971
K_2224 X_NUC_50.L_CORE X_NUC_69.L_CORE 0.004429
K_2225 X_NUC_50.L_CORE X_NUC_70.L_CORE 0.009791
K_2226 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_2227 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.005622
K_2228 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.005707
K_2229 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.005719
K_2230 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.005591
K_2231 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.008515
K_2232 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.008450
K_2233 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.008573
K_2234 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.008256
K_2235 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.003321
K_2236 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.003972
K_2237 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.004417
K_2238 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.003338
K_2239 X_NUC_51.L_CORE X_NUC_65.L_CORE 0.007357
K_2240 X_NUC_51.L_CORE X_NUC_66.L_CORE 0.004028
K_2241 X_NUC_51.L_CORE X_NUC_67.L_CORE 0.004559
K_2242 X_NUC_51.L_CORE X_NUC_68.L_CORE 0.012404
K_2243 X_NUC_51.L_CORE X_NUC_69.L_CORE 0.004410
K_2244 X_NUC_51.L_CORE X_NUC_70.L_CORE 0.009727
K_2245 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.005750
K_2246 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.005841
K_2247 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.005851
K_2248 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.005719
K_2249 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.008857
K_2250 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.008783
K_2251 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.008913
K_2252 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.008573
K_2253 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.003348
K_2254 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.004000
K_2255 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.004420
K_2256 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.003386
K_2257 X_NUC_52.L_CORE X_NUC_65.L_CORE 0.007285
K_2258 X_NUC_52.L_CORE X_NUC_66.L_CORE 0.004072
K_2259 X_NUC_52.L_CORE X_NUC_67.L_CORE 0.004644
K_2260 X_NUC_52.L_CORE X_NUC_68.L_CORE 0.012054
K_2261 X_NUC_52.L_CORE X_NUC_69.L_CORE 0.004498
K_2262 X_NUC_52.L_CORE X_NUC_70.L_CORE 0.010060
K_2263 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_2264 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_2265 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_2266 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.007950
K_2267 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.007671
K_2268 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.007734
K_2269 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.007816
K_2270 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.003813
K_2271 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.003304
K_2272 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.004138
K_2273 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.004584
K_2274 X_NUC_53.L_CORE X_NUC_65.L_CORE 0.003585
K_2275 X_NUC_53.L_CORE X_NUC_66.L_CORE 0.007667
K_2276 X_NUC_53.L_CORE X_NUC_67.L_CORE 0.004484
K_2277 X_NUC_53.L_CORE X_NUC_68.L_CORE 0.005313
K_2278 X_NUC_53.L_CORE X_NUC_69.L_CORE 0.014524
K_2279 X_NUC_53.L_CORE X_NUC_70.L_CORE 0.006092
K_2280 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_2281 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_2282 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.008247
K_2283 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.007950
K_2284 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.008013
K_2285 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.008104
K_2286 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.003818
K_2287 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.003338
K_2288 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.004123
K_2289 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.004627
K_2290 X_NUC_54.L_CORE X_NUC_65.L_CORE 0.003623
K_2291 X_NUC_54.L_CORE X_NUC_66.L_CORE 0.007471
K_2292 X_NUC_54.L_CORE X_NUC_67.L_CORE 0.004578
K_2293 X_NUC_54.L_CORE X_NUC_68.L_CORE 0.005332
K_2294 X_NUC_54.L_CORE X_NUC_69.L_CORE 0.014814
K_2295 X_NUC_54.L_CORE X_NUC_70.L_CORE 0.006248
K_2296 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_2297 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.008172
K_2298 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.007876
K_2299 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.007950
K_2300 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.008033
K_2301 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.003766
K_2302 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.003297
K_2303 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.004107
K_2304 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.004527
K_2305 X_NUC_55.L_CORE X_NUC_65.L_CORE 0.003604
K_2306 X_NUC_55.L_CORE X_NUC_66.L_CORE 0.007441
K_2307 X_NUC_55.L_CORE X_NUC_67.L_CORE 0.004503
K_2308 X_NUC_55.L_CORE X_NUC_68.L_CORE 0.005377
K_2309 X_NUC_55.L_CORE X_NUC_69.L_CORE 0.014274
K_2310 X_NUC_55.L_CORE X_NUC_70.L_CORE 0.006244
K_2311 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.008078
K_2312 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.007793
K_2313 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.007858
K_2314 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.007950
K_2315 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.003768
K_2316 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.003289
K_2317 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.004062
K_2318 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.004579
K_2319 X_NUC_56.L_CORE X_NUC_65.L_CORE 0.003564
K_2320 X_NUC_56.L_CORE X_NUC_66.L_CORE 0.007424
K_2321 X_NUC_56.L_CORE X_NUC_67.L_CORE 0.004519
K_2322 X_NUC_56.L_CORE X_NUC_68.L_CORE 0.005244
K_2323 X_NUC_56.L_CORE X_NUC_69.L_CORE 0.015275
K_2324 X_NUC_56.L_CORE X_NUC_70.L_CORE 0.006160
K_2325 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.207973
K_2326 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.207973
K_2327 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.207973
K_2328 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.003334
K_2329 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.003886
K_2330 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.003518
K_2331 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.004249
K_2332 X_NUC_57.L_CORE X_NUC_65.L_CORE 0.004723
K_2333 X_NUC_57.L_CORE X_NUC_66.L_CORE 0.004170
K_2334 X_NUC_57.L_CORE X_NUC_67.L_CORE 0.007110
K_2335 X_NUC_57.L_CORE X_NUC_68.L_CORE 0.005585
K_2336 X_NUC_57.L_CORE X_NUC_69.L_CORE 0.007107
K_2337 X_NUC_57.L_CORE X_NUC_70.L_CORE 0.020306
K_2338 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.207973
K_2339 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.207973
K_2340 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.003316
K_2341 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.003907
K_2342 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.003485
K_2343 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.004239
K_2344 X_NUC_58.L_CORE X_NUC_65.L_CORE 0.004747
K_2345 X_NUC_58.L_CORE X_NUC_66.L_CORE 0.004097
K_2346 X_NUC_58.L_CORE X_NUC_67.L_CORE 0.007272
K_2347 X_NUC_58.L_CORE X_NUC_68.L_CORE 0.005509
K_2348 X_NUC_58.L_CORE X_NUC_69.L_CORE 0.006941
K_2349 X_NUC_58.L_CORE X_NUC_70.L_CORE 0.021120
K_2350 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.207973
K_2351 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.003287
K_2352 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.003850
K_2353 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.003481
K_2354 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.004171
K_2355 X_NUC_59.L_CORE X_NUC_65.L_CORE 0.004720
K_2356 X_NUC_59.L_CORE X_NUC_66.L_CORE 0.004102
K_2357 X_NUC_59.L_CORE X_NUC_67.L_CORE 0.007031
K_2358 X_NUC_59.L_CORE X_NUC_68.L_CORE 0.005582
K_2359 X_NUC_59.L_CORE X_NUC_69.L_CORE 0.006928
K_2360 X_NUC_59.L_CORE X_NUC_70.L_CORE 0.022358
K_2361 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.003294
K_2362 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.003846
K_2363 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.003460
K_2364 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.004225
K_2365 X_NUC_60.L_CORE X_NUC_65.L_CORE 0.004648
K_2366 X_NUC_60.L_CORE X_NUC_66.L_CORE 0.004111
K_2367 X_NUC_60.L_CORE X_NUC_67.L_CORE 0.007155
K_2368 X_NUC_60.L_CORE X_NUC_68.L_CORE 0.005462
K_2369 X_NUC_60.L_CORE X_NUC_69.L_CORE 0.007095
K_2370 X_NUC_60.L_CORE X_NUC_70.L_CORE 0.020607
K_2371 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.005399
K_2372 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.005814
K_2373 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.006053
K_2374 X_NUC_61.L_CORE X_NUC_65.L_CORE 0.003615
K_2375 X_NUC_61.L_CORE X_NUC_66.L_CORE 0.004913
K_2376 X_NUC_61.L_CORE X_NUC_67.L_CORE 0.003561
K_2377 X_NUC_61.L_CORE X_NUC_68.L_CORE 0.003280
K_2378 X_NUC_61.L_CORE X_NUC_69.L_CORE 0.003615
K_2379 X_NUC_61.L_CORE X_NUC_70.L_CORE 0.002967
K_2380 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.003975
K_2381 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.004891
K_2382 X_NUC_62.L_CORE X_NUC_65.L_CORE 0.005926
K_2383 X_NUC_62.L_CORE X_NUC_66.L_CORE 0.003142
K_2384 X_NUC_62.L_CORE X_NUC_67.L_CORE 0.005245
K_2385 X_NUC_62.L_CORE X_NUC_68.L_CORE 0.003401
K_2386 X_NUC_62.L_CORE X_NUC_69.L_CORE 0.003183
K_2387 X_NUC_62.L_CORE X_NUC_70.L_CORE 0.003615
K_2388 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.003461
K_2389 X_NUC_63.L_CORE X_NUC_65.L_CORE 0.004470
K_2390 X_NUC_63.L_CORE X_NUC_66.L_CORE 0.005765
K_2391 X_NUC_63.L_CORE X_NUC_67.L_CORE 0.002983
K_2392 X_NUC_63.L_CORE X_NUC_68.L_CORE 0.005321
K_2393 X_NUC_63.L_CORE X_NUC_69.L_CORE 0.003401
K_2394 X_NUC_63.L_CORE X_NUC_70.L_CORE 0.003280
K_2395 X_NUC_64.L_CORE X_NUC_65.L_CORE 0.003235
K_2396 X_NUC_64.L_CORE X_NUC_66.L_CORE 0.004296
K_2397 X_NUC_64.L_CORE X_NUC_67.L_CORE 0.005708
K_2398 X_NUC_64.L_CORE X_NUC_68.L_CORE 0.002983
K_2399 X_NUC_64.L_CORE X_NUC_69.L_CORE 0.005245
K_2400 X_NUC_64.L_CORE X_NUC_70.L_CORE 0.003561
K_2401 X_NUC_65.L_CORE X_NUC_66.L_CORE 0.003169
K_2402 X_NUC_65.L_CORE X_NUC_67.L_CORE 0.004296
K_2403 X_NUC_65.L_CORE X_NUC_68.L_CORE 0.005765
K_2404 X_NUC_65.L_CORE X_NUC_69.L_CORE 0.003142
K_2405 X_NUC_65.L_CORE X_NUC_70.L_CORE 0.004913
K_2406 X_NUC_66.L_CORE X_NUC_67.L_CORE 0.003235
K_2407 X_NUC_66.L_CORE X_NUC_68.L_CORE 0.004470
K_2408 X_NUC_66.L_CORE X_NUC_69.L_CORE 0.005926
K_2409 X_NUC_66.L_CORE X_NUC_70.L_CORE 0.003615
K_2410 X_NUC_67.L_CORE X_NUC_68.L_CORE 0.003461
K_2411 X_NUC_67.L_CORE X_NUC_69.L_CORE 0.004891
K_2412 X_NUC_67.L_CORE X_NUC_70.L_CORE 0.006053
K_2413 X_NUC_68.L_CORE X_NUC_69.L_CORE 0.003975
K_2414 X_NUC_68.L_CORE X_NUC_70.L_CORE 0.005814
K_2415 X_NUC_69.L_CORE X_NUC_70.L_CORE 0.005399

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
