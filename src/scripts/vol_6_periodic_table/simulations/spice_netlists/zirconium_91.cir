* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Zirconium-91 (Z=40, A=91)
* Auto-generated topological mutual impedance array
* Nodes: 91

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON
X_NUC_65 NODE_65 0 NUCLEON
X_NUC_66 NODE_66 0 NUCLEON
X_NUC_67 NODE_67 0 NUCLEON
X_NUC_68 NODE_68 0 NUCLEON
X_NUC_69 NODE_69 0 NUCLEON
X_NUC_70 NODE_70 0 NUCLEON
X_NUC_71 NODE_71 0 NUCLEON
X_NUC_72 NODE_72 0 NUCLEON
X_NUC_73 NODE_73 0 NUCLEON
X_NUC_74 NODE_74 0 NUCLEON
X_NUC_75 NODE_75 0 NUCLEON
X_NUC_76 NODE_76 0 NUCLEON
X_NUC_77 NODE_77 0 NUCLEON
X_NUC_78 NODE_78 0 NUCLEON
X_NUC_79 NODE_79 0 NUCLEON
X_NUC_80 NODE_80 0 NUCLEON
X_NUC_81 NODE_81 0 NUCLEON
X_NUC_82 NODE_82 0 NUCLEON
X_NUC_83 NODE_83 0 NUCLEON
X_NUC_84 NODE_84 0 NUCLEON
X_NUC_85 NODE_85 0 NUCLEON
X_NUC_86 NODE_86 0 NUCLEON
X_NUC_87 NODE_87 0 NUCLEON
X_NUC_88 NODE_88 0 NUCLEON
X_NUC_89 NODE_89 0 NUCLEON
X_NUC_90 NODE_90 0 NUCLEON
X_NUC_91 NODE_91 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.007319
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.007084
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.007138
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.007212
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.007899
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.008012
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.007765
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.008029
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.008402
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.008242
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.008344
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.008098
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.004785
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.004721
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.004688
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.004767
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.007060
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.007254
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.007044
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.007052
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.004755
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.004664
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.004683
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.004662
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.004317
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.004321
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.004249
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.004324
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.005442
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.005467
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.005423
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.005336
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.003681
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.003634
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.003619
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.003643
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.004285
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.004332
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.004244
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.004280
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.004001
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.003965
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.003959
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.003926
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.003349
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.003334
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.003298
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.003333
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.004007
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.004037
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.003980
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.003966
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.003254
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.003222
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.003209
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.003211
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.003287
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.003295
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.003247
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.003273
K_64 X_NUC_1.L_CORE X_NUC_65.L_CORE 0.003421
K_65 X_NUC_1.L_CORE X_NUC_66.L_CORE 0.003416
K_66 X_NUC_1.L_CORE X_NUC_67.L_CORE 0.003390
K_67 X_NUC_1.L_CORE X_NUC_68.L_CORE 0.003373
K_68 X_NUC_1.L_CORE X_NUC_69.L_CORE 0.002960
K_69 X_NUC_1.L_CORE X_NUC_70.L_CORE 0.002944
K_70 X_NUC_1.L_CORE X_NUC_71.L_CORE 0.002920
K_71 X_NUC_1.L_CORE X_NUC_72.L_CORE 0.002934
K_72 X_NUC_1.L_CORE X_NUC_73.L_CORE 0.003153
K_73 X_NUC_1.L_CORE X_NUC_74.L_CORE 0.003161
K_74 X_NUC_1.L_CORE X_NUC_75.L_CORE 0.003121
K_75 X_NUC_1.L_CORE X_NUC_76.L_CORE 0.003127
K_76 X_NUC_1.L_CORE X_NUC_77.L_CORE 0.002969
K_77 X_NUC_1.L_CORE X_NUC_78.L_CORE 0.002959
K_78 X_NUC_1.L_CORE X_NUC_79.L_CORE 0.002935
K_79 X_NUC_1.L_CORE X_NUC_80.L_CORE 0.002935
K_80 X_NUC_1.L_CORE X_NUC_81.L_CORE 0.028750
K_81 X_NUC_1.L_CORE X_NUC_82.L_CORE 0.005378
K_82 X_NUC_1.L_CORE X_NUC_83.L_CORE 0.005519
K_83 X_NUC_1.L_CORE X_NUC_84.L_CORE 0.005345
K_84 X_NUC_1.L_CORE X_NUC_85.L_CORE 0.003509
K_85 X_NUC_1.L_CORE X_NUC_86.L_CORE 0.004372
K_86 X_NUC_1.L_CORE X_NUC_87.L_CORE 0.003327
K_87 X_NUC_1.L_CORE X_NUC_88.L_CORE 0.003082
K_88 X_NUC_1.L_CORE X_NUC_89.L_CORE 0.003318
K_89 X_NUC_1.L_CORE X_NUC_90.L_CORE 0.002720
K_90 X_NUC_1.L_CORE X_NUC_91.L_CORE 0.002789
K_91 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_92 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_93 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.007570
K_94 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.007319
K_95 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.007374
K_96 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.007457
K_97 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.007779
K_98 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.007899
K_99 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.007656
K_100 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.007909
K_101 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.008557
K_102 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.008402
K_103 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.008502
K_104 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.008243
K_105 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.004848
K_106 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.004785
K_107 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.004749
K_108 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.004831
K_109 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.006874
K_110 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.007060
K_111 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.006863
K_112 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.006870
K_113 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.004849
K_114 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.004755
K_115 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.004773
K_116 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.004751
K_117 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.004312
K_118 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.004317
K_119 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.004245
K_120 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.004319
K_121 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.005415
K_122 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.005442
K_123 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.005398
K_124 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.005312
K_125 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.003728
K_126 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.003681
K_127 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.003665
K_128 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.003690
K_129 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.004238
K_130 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.004285
K_131 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.004199
K_132 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.004234
K_133 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.004037
K_134 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.004001
K_135 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.003994
K_136 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.003960
K_137 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.003363
K_138 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.003349
K_139 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.003312
K_140 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.003347
K_141 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.003977
K_142 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.004007
K_143 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.003951
K_144 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.003937
K_145 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.003285
K_146 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.003254
K_147 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.003240
K_148 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.003242
K_149 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.003278
K_150 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.003287
K_151 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.003239
K_152 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.003264
K_153 X_NUC_2.L_CORE X_NUC_65.L_CORE 0.003426
K_154 X_NUC_2.L_CORE X_NUC_66.L_CORE 0.003421
K_155 X_NUC_2.L_CORE X_NUC_67.L_CORE 0.003395
K_156 X_NUC_2.L_CORE X_NUC_68.L_CORE 0.003378
K_157 X_NUC_2.L_CORE X_NUC_69.L_CORE 0.002975
K_158 X_NUC_2.L_CORE X_NUC_70.L_CORE 0.002960
K_159 X_NUC_2.L_CORE X_NUC_71.L_CORE 0.002934
K_160 X_NUC_2.L_CORE X_NUC_72.L_CORE 0.002949
K_161 X_NUC_2.L_CORE X_NUC_73.L_CORE 0.003145
K_162 X_NUC_2.L_CORE X_NUC_74.L_CORE 0.003153
K_163 X_NUC_2.L_CORE X_NUC_75.L_CORE 0.003113
K_164 X_NUC_2.L_CORE X_NUC_76.L_CORE 0.003119
K_165 X_NUC_2.L_CORE X_NUC_77.L_CORE 0.002979
K_166 X_NUC_2.L_CORE X_NUC_78.L_CORE 0.002969
K_167 X_NUC_2.L_CORE X_NUC_79.L_CORE 0.002945
K_168 X_NUC_2.L_CORE X_NUC_80.L_CORE 0.002945
K_169 X_NUC_2.L_CORE X_NUC_81.L_CORE 0.026547
K_170 X_NUC_2.L_CORE X_NUC_82.L_CORE 0.005516
K_171 X_NUC_2.L_CORE X_NUC_83.L_CORE 0.005446
K_172 X_NUC_2.L_CORE X_NUC_84.L_CORE 0.005392
K_173 X_NUC_2.L_CORE X_NUC_85.L_CORE 0.003541
K_174 X_NUC_2.L_CORE X_NUC_86.L_CORE 0.004309
K_175 X_NUC_2.L_CORE X_NUC_87.L_CORE 0.003365
K_176 X_NUC_2.L_CORE X_NUC_88.L_CORE 0.003079
K_177 X_NUC_2.L_CORE X_NUC_89.L_CORE 0.003312
K_178 X_NUC_2.L_CORE X_NUC_90.L_CORE 0.002737
K_179 X_NUC_2.L_CORE X_NUC_91.L_CORE 0.002784
K_180 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_181 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.007506
K_182 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.007257
K_183 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.007319
K_184 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.007395
K_185 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.008027
K_186 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.008153
K_187 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.007899
K_188 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.008170
K_189 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.008448
K_190 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.008292
K_191 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.008402
K_192 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.008145
K_193 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.004885
K_194 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.004819
K_195 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.004785
K_196 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.004868
K_197 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.007068
K_198 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.007267
K_199 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.007060
K_200 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.007064
K_201 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.004828
K_202 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.004735
K_203 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.004755
K_204 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.004732
K_205 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.004387
K_206 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.004392
K_207 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.004317
K_208 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.004395
K_209 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.005458
K_210 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.005485
K_211 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.005442
K_212 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.005353
K_213 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.003744
K_214 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.003695
K_215 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.003681
K_216 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.003705
K_217 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.004326
K_218 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.004375
K_219 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.004285
K_220 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.004322
K_221 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.004043
K_222 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.004006
K_223 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.004001
K_224 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.003966
K_225 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.003401
K_226 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.003386
K_227 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.003349
K_228 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.003385
K_229 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.004033
K_230 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.004064
K_231 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.004007
K_232 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.003991
K_233 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.003299
K_234 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.003267
K_235 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.003254
K_236 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.003255
K_237 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.003327
K_238 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.003336
K_239 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.003287
K_240 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.003313
K_241 X_NUC_3.L_CORE X_NUC_65.L_CORE 0.003453
K_242 X_NUC_3.L_CORE X_NUC_66.L_CORE 0.003447
K_243 X_NUC_3.L_CORE X_NUC_67.L_CORE 0.003421
K_244 X_NUC_3.L_CORE X_NUC_68.L_CORE 0.003403
K_245 X_NUC_3.L_CORE X_NUC_69.L_CORE 0.003001
K_246 X_NUC_3.L_CORE X_NUC_70.L_CORE 0.002985
K_247 X_NUC_3.L_CORE X_NUC_71.L_CORE 0.002960
K_248 X_NUC_3.L_CORE X_NUC_72.L_CORE 0.002974
K_249 X_NUC_3.L_CORE X_NUC_73.L_CORE 0.003185
K_250 X_NUC_3.L_CORE X_NUC_74.L_CORE 0.003193
K_251 X_NUC_3.L_CORE X_NUC_75.L_CORE 0.003153
K_252 X_NUC_3.L_CORE X_NUC_76.L_CORE 0.003158
K_253 X_NUC_3.L_CORE X_NUC_77.L_CORE 0.003003
K_254 X_NUC_3.L_CORE X_NUC_78.L_CORE 0.002993
K_255 X_NUC_3.L_CORE X_NUC_79.L_CORE 0.002969
K_256 X_NUC_3.L_CORE X_NUC_80.L_CORE 0.002969
K_257 X_NUC_3.L_CORE X_NUC_81.L_CORE 0.025318
K_258 X_NUC_3.L_CORE X_NUC_82.L_CORE 0.005472
K_259 X_NUC_3.L_CORE X_NUC_83.L_CORE 0.005573
K_260 X_NUC_3.L_CORE X_NUC_84.L_CORE 0.005360
K_261 X_NUC_3.L_CORE X_NUC_85.L_CORE 0.003565
K_262 X_NUC_3.L_CORE X_NUC_86.L_CORE 0.004385
K_263 X_NUC_3.L_CORE X_NUC_87.L_CORE 0.003366
K_264 X_NUC_3.L_CORE X_NUC_88.L_CORE 0.003120
K_265 X_NUC_3.L_CORE X_NUC_89.L_CORE 0.003339
K_266 X_NUC_3.L_CORE X_NUC_90.L_CORE 0.002755
K_267 X_NUC_3.L_CORE X_NUC_91.L_CORE 0.002816
K_268 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.007422
K_269 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.007181
K_270 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.007237
K_271 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.007319
K_272 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.007764
K_273 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.007877
K_274 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.007642
K_275 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.007899
K_276 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.008727
K_277 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.008556
K_278 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.008669
K_279 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.008402
K_280 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.004800
K_281 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.004737
K_282 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.004703
K_283 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.004785
K_284 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.007061
K_285 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.007259
K_286 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.007048
K_287 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.007060
K_288 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.004852
K_289 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.004757
K_290 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.004776
K_291 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.004755
K_292 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.004309
K_293 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.004314
K_294 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.004242
K_295 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.004317
K_296 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.005551
K_297 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.005579
K_298 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.005533
K_299 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.005442
K_300 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.003718
K_301 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.003670
K_302 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.003655
K_303 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.003681
K_304 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.004289
K_305 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.004337
K_306 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.004248
K_307 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.004285
K_308 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.004079
K_309 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.004042
K_310 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.004036
K_311 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.004001
K_312 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.003364
K_313 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.003349
K_314 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.003313
K_315 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.003349
K_316 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.004049
K_317 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.004080
K_318 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.004022
K_319 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.004007
K_320 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.003297
K_321 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.003265
K_322 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.003251
K_323 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.003254
K_324 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.003300
K_325 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.003309
K_326 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.003261
K_327 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.003287
K_328 X_NUC_4.L_CORE X_NUC_65.L_CORE 0.003471
K_329 X_NUC_4.L_CORE X_NUC_66.L_CORE 0.003466
K_330 X_NUC_4.L_CORE X_NUC_67.L_CORE 0.003439
K_331 X_NUC_4.L_CORE X_NUC_68.L_CORE 0.003421
K_332 X_NUC_4.L_CORE X_NUC_69.L_CORE 0.002986
K_333 X_NUC_4.L_CORE X_NUC_70.L_CORE 0.002971
K_334 X_NUC_4.L_CORE X_NUC_71.L_CORE 0.002945
K_335 X_NUC_4.L_CORE X_NUC_72.L_CORE 0.002960
K_336 X_NUC_4.L_CORE X_NUC_73.L_CORE 0.003179
K_337 X_NUC_4.L_CORE X_NUC_74.L_CORE 0.003187
K_338 X_NUC_4.L_CORE X_NUC_75.L_CORE 0.003147
K_339 X_NUC_4.L_CORE X_NUC_76.L_CORE 0.003153
K_340 X_NUC_4.L_CORE X_NUC_77.L_CORE 0.003003
K_341 X_NUC_4.L_CORE X_NUC_78.L_CORE 0.002993
K_342 X_NUC_4.L_CORE X_NUC_79.L_CORE 0.002968
K_343 X_NUC_4.L_CORE X_NUC_80.L_CORE 0.002969
K_344 X_NUC_4.L_CORE X_NUC_81.L_CORE 0.027206
K_345 X_NUC_4.L_CORE X_NUC_82.L_CORE 0.005438
K_346 X_NUC_4.L_CORE X_NUC_83.L_CORE 0.005454
K_347 X_NUC_4.L_CORE X_NUC_84.L_CORE 0.005474
K_348 X_NUC_4.L_CORE X_NUC_85.L_CORE 0.003522
K_349 X_NUC_4.L_CORE X_NUC_86.L_CORE 0.004387
K_350 X_NUC_4.L_CORE X_NUC_87.L_CORE 0.003377
K_351 X_NUC_4.L_CORE X_NUC_88.L_CORE 0.003089
K_352 X_NUC_4.L_CORE X_NUC_89.L_CORE 0.003360
K_353 X_NUC_4.L_CORE X_NUC_90.L_CORE 0.002746
K_354 X_NUC_4.L_CORE X_NUC_91.L_CORE 0.002809
K_355 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_356 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_357 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_358 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.005209
K_359 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.005333
K_360 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.005237
K_361 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.005285
K_362 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.006384
K_363 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.006475
K_364 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.006482
K_365 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.006314
K_366 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.007967
K_367 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.007981
K_368 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.007753
K_369 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.008022
K_370 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.003944
K_371 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.004016
K_372 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.003970
K_373 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.003959
K_374 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.007665
K_375 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.007555
K_376 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.007568
K_377 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.007397
K_378 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.004275
K_379 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.004328
K_380 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.004244
K_381 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.004302
K_382 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.003887
K_383 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.003933
K_384 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.003908
K_385 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.003863
K_386 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006024
K_387 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.005951
K_388 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.005857
K_389 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.005918
K_390 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.003316
K_391 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.003361
K_392 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.003314
K_393 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.003323
K_394 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.004306
K_395 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.004309
K_396 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.004290
K_397 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.004232
K_398 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.003983
K_399 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.003996
K_400 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.003926
K_401 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.003972
K_402 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.003122
K_403 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.003156
K_404 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.003124
K_405 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.003110
K_406 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.004268
K_407 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.004244
K_408 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.004203
K_409 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.004192
K_410 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.003126
K_411 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.003152
K_412 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.003106
K_413 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.003122
K_414 X_NUC_5.L_CORE X_NUC_65.L_CORE 0.003237
K_415 X_NUC_5.L_CORE X_NUC_66.L_CORE 0.003254
K_416 X_NUC_5.L_CORE X_NUC_67.L_CORE 0.003226
K_417 X_NUC_5.L_CORE X_NUC_68.L_CORE 0.003205
K_418 X_NUC_5.L_CORE X_NUC_69.L_CORE 0.003502
K_419 X_NUC_5.L_CORE X_NUC_70.L_CORE 0.003502
K_420 X_NUC_5.L_CORE X_NUC_71.L_CORE 0.003455
K_421 X_NUC_5.L_CORE X_NUC_72.L_CORE 0.003469
K_422 X_NUC_5.L_CORE X_NUC_73.L_CORE 0.002899
K_423 X_NUC_5.L_CORE X_NUC_74.L_CORE 0.002921
K_424 X_NUC_5.L_CORE X_NUC_75.L_CORE 0.002886
K_425 X_NUC_5.L_CORE X_NUC_76.L_CORE 0.002885
K_426 X_NUC_5.L_CORE X_NUC_77.L_CORE 0.003153
K_427 X_NUC_5.L_CORE X_NUC_78.L_CORE 0.003160
K_428 X_NUC_5.L_CORE X_NUC_79.L_CORE 0.003127
K_429 X_NUC_5.L_CORE X_NUC_80.L_CORE 0.003121
K_430 X_NUC_5.L_CORE X_NUC_81.L_CORE 0.006047
K_431 X_NUC_5.L_CORE X_NUC_82.L_CORE 0.019636
K_432 X_NUC_5.L_CORE X_NUC_83.L_CORE 0.004070
K_433 X_NUC_5.L_CORE X_NUC_84.L_CORE 0.004649
K_434 X_NUC_5.L_CORE X_NUC_85.L_CORE 0.005092
K_435 X_NUC_5.L_CORE X_NUC_86.L_CORE 0.003065
K_436 X_NUC_5.L_CORE X_NUC_87.L_CORE 0.004376
K_437 X_NUC_5.L_CORE X_NUC_88.L_CORE 0.003137
K_438 X_NUC_5.L_CORE X_NUC_89.L_CORE 0.002913
K_439 X_NUC_5.L_CORE X_NUC_90.L_CORE 0.003303
K_440 X_NUC_5.L_CORE X_NUC_91.L_CORE 0.002676
K_441 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_442 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_443 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.005091
K_444 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.005209
K_445 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.005118
K_446 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.005163
K_447 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.006291
K_448 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.006384
K_449 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.006388
K_450 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.006226
K_451 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.007942
K_452 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.007967
K_453 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.007734
K_454 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.008001
K_455 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.003874
K_456 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.003944
K_457 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.003899
K_458 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.003889
K_459 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.007768
K_460 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.007665
K_461 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.007672
K_462 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.007495
K_463 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.004222
K_464 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.004275
K_465 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.004193
K_466 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.004249
K_467 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.003841
K_468 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.003887
K_469 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.003862
K_470 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.003819
K_471 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006094
K_472 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006024
K_473 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.005924
K_474 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.005987
K_475 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.003272
K_476 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.003316
K_477 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.003270
K_478 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.003280
K_479 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.004300
K_480 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.004306
K_481 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.004286
K_482 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.004228
K_483 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.003967
K_484 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.003983
K_485 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.003912
K_486 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.003958
K_487 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.003089
K_488 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.003122
K_489 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.003091
K_490 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.003078
K_491 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.004290
K_492 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.004268
K_493 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.004225
K_494 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.004214
K_495 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.003099
K_496 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.003126
K_497 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.003080
K_498 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.003096
K_499 X_NUC_6.L_CORE X_NUC_65.L_CORE 0.003220
K_500 X_NUC_6.L_CORE X_NUC_66.L_CORE 0.003237
K_501 X_NUC_6.L_CORE X_NUC_67.L_CORE 0.003210
K_502 X_NUC_6.L_CORE X_NUC_68.L_CORE 0.003189
K_503 X_NUC_6.L_CORE X_NUC_69.L_CORE 0.003500
K_504 X_NUC_6.L_CORE X_NUC_70.L_CORE 0.003502
K_505 X_NUC_6.L_CORE X_NUC_71.L_CORE 0.003453
K_506 X_NUC_6.L_CORE X_NUC_72.L_CORE 0.003468
K_507 X_NUC_6.L_CORE X_NUC_73.L_CORE 0.002878
K_508 X_NUC_6.L_CORE X_NUC_74.L_CORE 0.002899
K_509 X_NUC_6.L_CORE X_NUC_75.L_CORE 0.002865
K_510 X_NUC_6.L_CORE X_NUC_76.L_CORE 0.002864
K_511 X_NUC_6.L_CORE X_NUC_77.L_CORE 0.003145
K_512 X_NUC_6.L_CORE X_NUC_78.L_CORE 0.003153
K_513 X_NUC_6.L_CORE X_NUC_79.L_CORE 0.003119
K_514 X_NUC_6.L_CORE X_NUC_80.L_CORE 0.003113
K_515 X_NUC_6.L_CORE X_NUC_81.L_CORE 0.005893
K_516 X_NUC_6.L_CORE X_NUC_82.L_CORE 0.021681
K_517 X_NUC_6.L_CORE X_NUC_83.L_CORE 0.004000
K_518 X_NUC_6.L_CORE X_NUC_84.L_CORE 0.004618
K_519 X_NUC_6.L_CORE X_NUC_85.L_CORE 0.005107
K_520 X_NUC_6.L_CORE X_NUC_86.L_CORE 0.003026
K_521 X_NUC_6.L_CORE X_NUC_87.L_CORE 0.004410
K_522 X_NUC_6.L_CORE X_NUC_88.L_CORE 0.003116
K_523 X_NUC_6.L_CORE X_NUC_89.L_CORE 0.002894
K_524 X_NUC_6.L_CORE X_NUC_90.L_CORE 0.003309
K_525 X_NUC_6.L_CORE X_NUC_91.L_CORE 0.002661
K_526 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_527 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.005179
K_528 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.005303
K_529 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.005209
K_530 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.005256
K_531 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.006284
K_532 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.006373
K_533 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.006384
K_534 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.006220
K_535 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.008188
K_536 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.008210
K_537 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.007967
K_538 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.008254
K_539 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.003917
K_540 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.003988
K_541 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.003944
K_542 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.003932
K_543 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.007755
K_544 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.007647
K_545 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.007665
K_546 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.007483
K_547 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.004304
K_548 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.004359
K_549 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.004275
K_550 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.004333
K_551 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.003865
K_552 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.003911
K_553 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.003887
K_554 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.003842
K_555 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006199
K_556 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006123
K_557 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006024
K_558 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006087
K_559 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.003317
K_560 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.003363
K_561 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.003316
K_562 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.003325
K_563 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.004320
K_564 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.004324
K_565 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.004306
K_566 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.004246
K_567 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.004040
K_568 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.004056
K_569 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.003983
K_570 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.004030
K_571 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.003120
K_572 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.003154
K_573 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.003122
K_574 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.003109
K_575 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.004333
K_576 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.004309
K_577 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.004268
K_578 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.004255
K_579 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.003146
K_580 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.003173
K_581 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.003126
K_582 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.003142
K_583 X_NUC_7.L_CORE X_NUC_65.L_CORE 0.003248
K_584 X_NUC_7.L_CORE X_NUC_66.L_CORE 0.003264
K_585 X_NUC_7.L_CORE X_NUC_67.L_CORE 0.003237
K_586 X_NUC_7.L_CORE X_NUC_68.L_CORE 0.003215
K_587 X_NUC_7.L_CORE X_NUC_69.L_CORE 0.003549
K_588 X_NUC_7.L_CORE X_NUC_70.L_CORE 0.003551
K_589 X_NUC_7.L_CORE X_NUC_71.L_CORE 0.003502
K_590 X_NUC_7.L_CORE X_NUC_72.L_CORE 0.003516
K_591 X_NUC_7.L_CORE X_NUC_73.L_CORE 0.002913
K_592 X_NUC_7.L_CORE X_NUC_74.L_CORE 0.002934
K_593 X_NUC_7.L_CORE X_NUC_75.L_CORE 0.002899
K_594 X_NUC_7.L_CORE X_NUC_76.L_CORE 0.002899
K_595 X_NUC_7.L_CORE X_NUC_77.L_CORE 0.003179
K_596 X_NUC_7.L_CORE X_NUC_78.L_CORE 0.003187
K_597 X_NUC_7.L_CORE X_NUC_79.L_CORE 0.003153
K_598 X_NUC_7.L_CORE X_NUC_80.L_CORE 0.003147
K_599 X_NUC_7.L_CORE X_NUC_81.L_CORE 0.005910
K_600 X_NUC_7.L_CORE X_NUC_82.L_CORE 0.020595
K_601 X_NUC_7.L_CORE X_NUC_83.L_CORE 0.004059
K_602 X_NUC_7.L_CORE X_NUC_84.L_CORE 0.004612
K_603 X_NUC_7.L_CORE X_NUC_85.L_CORE 0.005202
K_604 X_NUC_7.L_CORE X_NUC_86.L_CORE 0.003056
K_605 X_NUC_7.L_CORE X_NUC_87.L_CORE 0.004425
K_606 X_NUC_7.L_CORE X_NUC_88.L_CORE 0.003163
K_607 X_NUC_7.L_CORE X_NUC_89.L_CORE 0.002916
K_608 X_NUC_7.L_CORE X_NUC_90.L_CORE 0.003347
K_609 X_NUC_7.L_CORE X_NUC_91.L_CORE 0.002691
K_610 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.005134
K_611 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.005254
K_612 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.005161
K_613 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.005209
K_614 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.006450
K_615 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.006547
K_616 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.006555
K_617 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.006384
K_618 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.007903
K_619 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.007922
K_620 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.007698
K_621 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.007967
K_622 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.003928
K_623 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.004000
K_624 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.003954
K_625 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.003944
K_626 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.007952
K_627 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.007835
K_628 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.007849
K_629 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.007665
K_630 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.004246
K_631 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.004299
K_632 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.004217
K_633 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.004275
K_634 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.003910
K_635 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.003958
K_636 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.003932
K_637 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.003887
K_638 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006130
K_639 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006055
K_640 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.005957
K_641 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006024
K_642 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.003308
K_643 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.003353
K_644 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.003306
K_645 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.003316
K_646 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.004381
K_647 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.004386
K_648 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.004365
K_649 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.004306
K_650 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.003991
K_651 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.004006
K_652 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.003935
K_653 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.003983
K_654 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.003133
K_655 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.003167
K_656 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.003135
K_657 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.003122
K_658 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.004345
K_659 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.004321
K_660 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.004278
K_661 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.004268
K_662 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.003129
K_663 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.003156
K_664 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.003109
K_665 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.003126
K_666 X_NUC_8.L_CORE X_NUC_65.L_CORE 0.003270
K_667 X_NUC_8.L_CORE X_NUC_66.L_CORE 0.003287
K_668 X_NUC_8.L_CORE X_NUC_67.L_CORE 0.003259
K_669 X_NUC_8.L_CORE X_NUC_68.L_CORE 0.003237
K_670 X_NUC_8.L_CORE X_NUC_69.L_CORE 0.003533
K_671 X_NUC_8.L_CORE X_NUC_70.L_CORE 0.003535
K_672 X_NUC_8.L_CORE X_NUC_71.L_CORE 0.003486
K_673 X_NUC_8.L_CORE X_NUC_72.L_CORE 0.003502
K_674 X_NUC_8.L_CORE X_NUC_73.L_CORE 0.002913
K_675 X_NUC_8.L_CORE X_NUC_74.L_CORE 0.002935
K_676 X_NUC_8.L_CORE X_NUC_75.L_CORE 0.002900
K_677 X_NUC_8.L_CORE X_NUC_76.L_CORE 0.002899
K_678 X_NUC_8.L_CORE X_NUC_77.L_CORE 0.003185
K_679 X_NUC_8.L_CORE X_NUC_78.L_CORE 0.003193
K_680 X_NUC_8.L_CORE X_NUC_79.L_CORE 0.003159
K_681 X_NUC_8.L_CORE X_NUC_80.L_CORE 0.003153
K_682 X_NUC_8.L_CORE X_NUC_81.L_CORE 0.005974
K_683 X_NUC_8.L_CORE X_NUC_82.L_CORE 0.020506
K_684 X_NUC_8.L_CORE X_NUC_83.L_CORE 0.004026
K_685 X_NUC_8.L_CORE X_NUC_84.L_CORE 0.004705
K_686 X_NUC_8.L_CORE X_NUC_85.L_CORE 0.005098
K_687 X_NUC_8.L_CORE X_NUC_86.L_CORE 0.003063
K_688 X_NUC_8.L_CORE X_NUC_87.L_CORE 0.004469
K_689 X_NUC_8.L_CORE X_NUC_88.L_CORE 0.003136
K_690 X_NUC_8.L_CORE X_NUC_89.L_CORE 0.002935
K_691 X_NUC_8.L_CORE X_NUC_90.L_CORE 0.003338
K_692 X_NUC_8.L_CORE X_NUC_91.L_CORE 0.002689
K_693 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_694 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_695 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_696 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.004363
K_697 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.004321
K_698 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.004377
K_699 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.004297
K_700 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.005584
K_701 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.005445
K_702 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.005475
K_703 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.005510
K_704 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.007447
K_705 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.007570
K_706 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.007540
K_707 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.007329
K_708 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.003532
K_709 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.003484
K_710 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.003513
K_711 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.003482
K_712 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.007860
K_713 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.007769
K_714 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.007583
K_715 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.007770
K_716 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.003987
K_717 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.003982
K_718 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.003997
K_719 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.003929
K_720 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.003642
K_721 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.003586
K_722 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.003595
K_723 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.003594
K_724 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006349
K_725 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006440
K_726 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006282
K_727 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006265
K_728 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.003129
K_729 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.003104
K_730 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.003117
K_731 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.003085
K_732 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.004284
K_733 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.004234
K_734 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.004198
K_735 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.004230
K_736 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.003951
K_737 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.003964
K_738 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.003941
K_739 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.003895
K_740 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.003016
K_741 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.002984
K_742 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.002987
K_743 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.002974
K_744 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.004388
K_745 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.004387
K_746 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.004316
K_747 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.004332
K_748 X_NUC_9.L_CORE X_NUC_65.L_CORE 0.003076
K_749 X_NUC_9.L_CORE X_NUC_66.L_CORE 0.003065
K_750 X_NUC_9.L_CORE X_NUC_67.L_CORE 0.003061
K_751 X_NUC_9.L_CORE X_NUC_68.L_CORE 0.003033
K_752 X_NUC_9.L_CORE X_NUC_69.L_CORE 0.003223
K_753 X_NUC_9.L_CORE X_NUC_70.L_CORE 0.003195
K_754 X_NUC_9.L_CORE X_NUC_71.L_CORE 0.003179
K_755 X_NUC_9.L_CORE X_NUC_72.L_CORE 0.003180
K_756 X_NUC_9.L_CORE X_NUC_73.L_CORE 0.003502
K_757 X_NUC_9.L_CORE X_NUC_74.L_CORE 0.003502
K_758 X_NUC_9.L_CORE X_NUC_75.L_CORE 0.003469
K_759 X_NUC_9.L_CORE X_NUC_76.L_CORE 0.003454
K_760 X_NUC_9.L_CORE X_NUC_77.L_CORE 0.002960
K_761 X_NUC_9.L_CORE X_NUC_78.L_CORE 0.002944
K_762 X_NUC_9.L_CORE X_NUC_79.L_CORE 0.002933
K_763 X_NUC_9.L_CORE X_NUC_80.L_CORE 0.002920
K_764 X_NUC_9.L_CORE X_NUC_81.L_CORE 0.006822
K_765 X_NUC_9.L_CORE X_NUC_82.L_CORE 0.004179
K_766 X_NUC_9.L_CORE X_NUC_83.L_CORE 0.017251
K_767 X_NUC_9.L_CORE X_NUC_84.L_CORE 0.003441
K_768 X_NUC_9.L_CORE X_NUC_85.L_CORE 0.004126
K_769 X_NUC_9.L_CORE X_NUC_86.L_CORE 0.004839
K_770 X_NUC_9.L_CORE X_NUC_87.L_CORE 0.002804
K_771 X_NUC_9.L_CORE X_NUC_88.L_CORE 0.004283
K_772 X_NUC_9.L_CORE X_NUC_89.L_CORE 0.003007
K_773 X_NUC_9.L_CORE X_NUC_90.L_CORE 0.002819
K_774 X_NUC_9.L_CORE X_NUC_91.L_CORE 0.003135
K_775 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_776 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_777 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.004404
K_778 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.004363
K_779 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.004420
K_780 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.004338
K_781 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.005729
K_782 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.005584
K_783 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.005614
K_784 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.005652
K_785 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.007321
K_786 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.007447
K_787 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.007413
K_788 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.007213
K_789 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.003580
K_790 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.003532
K_791 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.003562
K_792 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.003529
K_793 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.007942
K_794 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.007860
K_795 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.007662
K_796 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.007855
K_797 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.003991
K_798 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.003987
K_799 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.004002
K_800 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.003933
K_801 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.003701
K_802 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.003642
K_803 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.003652
K_804 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.003650
K_805 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006257
K_806 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006349
K_807 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006195
K_808 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.006179
K_809 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.003153
K_810 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.003129
K_811 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.003141
K_812 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.003108
K_813 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.004333
K_814 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.004284
K_815 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.004245
K_816 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.004278
K_817 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.003936
K_818 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.003951
K_819 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.003927
K_820 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.003881
K_821 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.003047
K_822 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.003016
K_823 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.003018
K_824 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.003005
K_825 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.004387
K_826 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.004388
K_827 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.004316
K_828 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.004332
K_829 X_NUC_10.L_CORE X_NUC_65.L_CORE 0.003086
K_830 X_NUC_10.L_CORE X_NUC_66.L_CORE 0.003076
K_831 X_NUC_10.L_CORE X_NUC_67.L_CORE 0.003071
K_832 X_NUC_10.L_CORE X_NUC_68.L_CORE 0.003043
K_833 X_NUC_10.L_CORE X_NUC_69.L_CORE 0.003250
K_834 X_NUC_10.L_CORE X_NUC_70.L_CORE 0.003223
K_835 X_NUC_10.L_CORE X_NUC_71.L_CORE 0.003206
K_836 X_NUC_10.L_CORE X_NUC_72.L_CORE 0.003207
K_837 X_NUC_10.L_CORE X_NUC_73.L_CORE 0.003500
K_838 X_NUC_10.L_CORE X_NUC_74.L_CORE 0.003502
K_839 X_NUC_10.L_CORE X_NUC_75.L_CORE 0.003468
K_840 X_NUC_10.L_CORE X_NUC_76.L_CORE 0.003454
K_841 X_NUC_10.L_CORE X_NUC_77.L_CORE 0.002975
K_842 X_NUC_10.L_CORE X_NUC_78.L_CORE 0.002960
K_843 X_NUC_10.L_CORE X_NUC_79.L_CORE 0.002948
K_844 X_NUC_10.L_CORE X_NUC_80.L_CORE 0.002935
K_845 X_NUC_10.L_CORE X_NUC_81.L_CORE 0.006864
K_846 X_NUC_10.L_CORE X_NUC_82.L_CORE 0.004261
K_847 X_NUC_10.L_CORE X_NUC_83.L_CORE 0.016278
K_848 X_NUC_10.L_CORE X_NUC_84.L_CORE 0.003464
K_849 X_NUC_10.L_CORE X_NUC_85.L_CORE 0.004196
K_850 X_NUC_10.L_CORE X_NUC_86.L_CORE 0.004780
K_851 X_NUC_10.L_CORE X_NUC_87.L_CORE 0.002832
K_852 X_NUC_10.L_CORE X_NUC_88.L_CORE 0.004295
K_853 X_NUC_10.L_CORE X_NUC_89.L_CORE 0.003009
K_854 X_NUC_10.L_CORE X_NUC_90.L_CORE 0.002843
K_855 X_NUC_10.L_CORE X_NUC_91.L_CORE 0.003137
K_856 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_857 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.004347
K_858 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.004306
K_859 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.004363
K_860 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.004283
K_861 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.005695
K_862 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.005550
K_863 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.005584
K_864 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.005619
K_865 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.007348
K_866 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.007472
K_867 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.007447
K_868 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.007239
K_869 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.003550
K_870 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.003502
K_871 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.003532
K_872 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.003499
K_873 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.008156
K_874 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.008061
K_875 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.007860
K_876 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.008062
K_877 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.003977
K_878 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.003972
K_879 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.003987
K_880 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.003919
K_881 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.003691
K_882 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.003632
K_883 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.003642
K_884 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.003640
K_885 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006413
K_886 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006509
K_887 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006349
K_888 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006329
K_889 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.003141
K_890 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.003116
K_891 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.003129
K_892 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.003096
K_893 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.004373
K_894 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.004321
K_895 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.004284
K_896 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.004316
K_897 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.003959
K_898 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.003973
K_899 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.003951
K_900 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.003903
K_901 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.003044
K_902 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.003012
K_903 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.003016
K_904 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.003002
K_905 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.004462
K_906 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.004462
K_907 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.004388
K_908 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.004404
K_909 X_NUC_11.L_CORE X_NUC_65.L_CORE 0.003091
K_910 X_NUC_11.L_CORE X_NUC_66.L_CORE 0.003080
K_911 X_NUC_11.L_CORE X_NUC_67.L_CORE 0.003076
K_912 X_NUC_11.L_CORE X_NUC_68.L_CORE 0.003048
K_913 X_NUC_11.L_CORE X_NUC_69.L_CORE 0.003267
K_914 X_NUC_11.L_CORE X_NUC_70.L_CORE 0.003238
K_915 X_NUC_11.L_CORE X_NUC_71.L_CORE 0.003223
K_916 X_NUC_11.L_CORE X_NUC_72.L_CORE 0.003223
K_917 X_NUC_11.L_CORE X_NUC_73.L_CORE 0.003534
K_918 X_NUC_11.L_CORE X_NUC_74.L_CORE 0.003535
K_919 X_NUC_11.L_CORE X_NUC_75.L_CORE 0.003502
K_920 X_NUC_11.L_CORE X_NUC_76.L_CORE 0.003486
K_921 X_NUC_11.L_CORE X_NUC_77.L_CORE 0.002987
K_922 X_NUC_11.L_CORE X_NUC_78.L_CORE 0.002971
K_923 X_NUC_11.L_CORE X_NUC_79.L_CORE 0.002960
K_924 X_NUC_11.L_CORE X_NUC_80.L_CORE 0.002946
K_925 X_NUC_11.L_CORE X_NUC_81.L_CORE 0.006686
K_926 X_NUC_11.L_CORE X_NUC_82.L_CORE 0.004203
K_927 X_NUC_11.L_CORE X_NUC_83.L_CORE 0.017495
K_928 X_NUC_11.L_CORE X_NUC_84.L_CORE 0.003435
K_929 X_NUC_11.L_CORE X_NUC_85.L_CORE 0.004199
K_930 X_NUC_11.L_CORE X_NUC_86.L_CORE 0.004827
K_931 X_NUC_11.L_CORE X_NUC_87.L_CORE 0.002821
K_932 X_NUC_11.L_CORE X_NUC_88.L_CORE 0.004366
K_933 X_NUC_11.L_CORE X_NUC_89.L_CORE 0.003015
K_934 X_NUC_11.L_CORE X_NUC_90.L_CORE 0.002851
K_935 X_NUC_11.L_CORE X_NUC_91.L_CORE 0.003166
K_936 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.004430
K_937 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.004387
K_938 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.004445
K_939 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.004363
K_940 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.005656
K_941 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.005513
K_942 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.005544
K_943 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.005584
K_944 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.007561
K_945 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.007695
K_946 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.007663
K_947 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.007447
K_948 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.003583
K_949 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.003534
K_950 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.003564
K_951 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.003532
K_952 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.007940
K_953 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.007853
K_954 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.007661
K_955 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.007860
K_956 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.004047
K_957 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.004042
K_958 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.004058
K_959 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.003987
K_960 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.003692
K_961 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.003634
K_962 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.003644
K_963 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.003642
K_964 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006431
K_965 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006529
K_966 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006364
K_967 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006349
K_968 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.003175
K_969 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.003149
K_970 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.003162
K_971 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.003129
K_972 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.004338
K_973 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.004288
K_974 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.004250
K_975 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.004284
K_976 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.004007
K_977 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.004023
K_978 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.003998
K_979 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.003951
K_980 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.003058
K_981 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.003025
K_982 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.003028
K_983 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.003016
K_984 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.004444
K_985 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.004444
K_986 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.004371
K_987 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.004388
K_988 X_NUC_12.L_CORE X_NUC_65.L_CORE 0.003120
K_989 X_NUC_12.L_CORE X_NUC_66.L_CORE 0.003109
K_990 X_NUC_12.L_CORE X_NUC_67.L_CORE 0.003105
K_991 X_NUC_12.L_CORE X_NUC_68.L_CORE 0.003076
K_992 X_NUC_12.L_CORE X_NUC_69.L_CORE 0.003266
K_993 X_NUC_12.L_CORE X_NUC_70.L_CORE 0.003238
K_994 X_NUC_12.L_CORE X_NUC_71.L_CORE 0.003222
K_995 X_NUC_12.L_CORE X_NUC_72.L_CORE 0.003223
K_996 X_NUC_12.L_CORE X_NUC_73.L_CORE 0.003549
K_997 X_NUC_12.L_CORE X_NUC_74.L_CORE 0.003550
K_998 X_NUC_12.L_CORE X_NUC_75.L_CORE 0.003516
K_999 X_NUC_12.L_CORE X_NUC_76.L_CORE 0.003502
K_1000 X_NUC_12.L_CORE X_NUC_77.L_CORE 0.003001
K_1001 X_NUC_12.L_CORE X_NUC_78.L_CORE 0.002985
K_1002 X_NUC_12.L_CORE X_NUC_79.L_CORE 0.002973
K_1003 X_NUC_12.L_CORE X_NUC_80.L_CORE 0.002960
K_1004 X_NUC_12.L_CORE X_NUC_81.L_CORE 0.006886
K_1005 X_NUC_12.L_CORE X_NUC_82.L_CORE 0.004227
K_1006 X_NUC_12.L_CORE X_NUC_83.L_CORE 0.016634
K_1007 X_NUC_12.L_CORE X_NUC_84.L_CORE 0.003487
K_1008 X_NUC_12.L_CORE X_NUC_85.L_CORE 0.004168
K_1009 X_NUC_12.L_CORE X_NUC_86.L_CORE 0.004891
K_1010 X_NUC_12.L_CORE X_NUC_87.L_CORE 0.002840
K_1011 X_NUC_12.L_CORE X_NUC_88.L_CORE 0.004323
K_1012 X_NUC_12.L_CORE X_NUC_89.L_CORE 0.003046
K_1013 X_NUC_12.L_CORE X_NUC_90.L_CORE 0.002854
K_1014 X_NUC_12.L_CORE X_NUC_91.L_CORE 0.003173
K_1015 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_1016 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_1017 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_1018 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.003891
K_1019 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.003872
K_1020 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.003843
K_1021 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.003913
K_1022 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.005093
K_1023 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.005201
K_1024 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.005098
K_1025 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.005161
K_1026 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.007038
K_1027 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.006837
K_1028 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.006837
K_1029 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.006914
K_1030 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.003280
K_1031 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.003292
K_1032 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.003253
K_1033 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.003302
K_1034 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.007912
K_1035 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.008126
K_1036 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.007896
K_1037 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.007838
K_1038 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.003799
K_1039 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.003762
K_1040 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.003736
K_1041 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.003787
K_1042 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.003487
K_1043 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.003524
K_1044 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.003469
K_1045 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.003507
K_1046 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006551
K_1047 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006465
K_1048 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006394
K_1049 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006367
K_1050 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.003020
K_1051 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.003017
K_1052 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.002985
K_1053 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.003023
K_1054 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.004261
K_1055 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.004318
K_1056 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.004236
K_1057 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.004251
K_1058 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.003928
K_1059 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.003889
K_1060 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.003856
K_1061 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.003885
K_1062 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.002969
K_1063 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.002982
K_1064 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.002942
K_1065 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.002973
K_1066 X_NUC_13.L_CORE X_NUC_65.L_CORE 0.004425
K_1067 X_NUC_13.L_CORE X_NUC_66.L_CORE 0.004436
K_1068 X_NUC_13.L_CORE X_NUC_67.L_CORE 0.004365
K_1069 X_NUC_13.L_CORE X_NUC_68.L_CORE 0.004365
K_1070 X_NUC_13.L_CORE X_NUC_69.L_CORE 0.003076
K_1071 X_NUC_13.L_CORE X_NUC_70.L_CORE 0.003066
K_1072 X_NUC_13.L_CORE X_NUC_71.L_CORE 0.003034
K_1073 X_NUC_13.L_CORE X_NUC_72.L_CORE 0.003062
K_1074 X_NUC_13.L_CORE X_NUC_73.L_CORE 0.003237
K_1075 X_NUC_13.L_CORE X_NUC_74.L_CORE 0.003255
K_1076 X_NUC_13.L_CORE X_NUC_75.L_CORE 0.003206
K_1077 X_NUC_13.L_CORE X_NUC_76.L_CORE 0.003227
K_1078 X_NUC_13.L_CORE X_NUC_77.L_CORE 0.003421
K_1079 X_NUC_13.L_CORE X_NUC_78.L_CORE 0.003417
K_1080 X_NUC_13.L_CORE X_NUC_79.L_CORE 0.003373
K_1081 X_NUC_13.L_CORE X_NUC_80.L_CORE 0.003391
K_1082 X_NUC_13.L_CORE X_NUC_81.L_CORE 0.008035
K_1083 X_NUC_13.L_CORE X_NUC_82.L_CORE 0.005334
K_1084 X_NUC_13.L_CORE X_NUC_83.L_CORE 0.003573
K_1085 X_NUC_13.L_CORE X_NUC_84.L_CORE 0.014121
K_1086 X_NUC_13.L_CORE X_NUC_85.L_CORE 0.003131
K_1087 X_NUC_13.L_CORE X_NUC_86.L_CORE 0.003902
K_1088 X_NUC_13.L_CORE X_NUC_87.L_CORE 0.004533
K_1089 X_NUC_13.L_CORE X_NUC_88.L_CORE 0.002705
K_1090 X_NUC_13.L_CORE X_NUC_89.L_CORE 0.004134
K_1091 X_NUC_13.L_CORE X_NUC_90.L_CORE 0.002949
K_1092 X_NUC_13.L_CORE X_NUC_91.L_CORE 0.002850
K_1093 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_1094 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_1095 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.003909
K_1096 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.003891
K_1097 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.003861
K_1098 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.003932
K_1099 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.004988
K_1100 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.005093
K_1101 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.004995
K_1102 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.005053
K_1103 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.007249
K_1104 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.007038
K_1105 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.007034
K_1106 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.007118
K_1107 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.003269
K_1108 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.003280
K_1109 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.003242
K_1110 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.003291
K_1111 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.007702
K_1112 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.007912
K_1113 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.007693
K_1114 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.007640
K_1115 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.003837
K_1116 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.003799
K_1117 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.003773
K_1118 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.003824
K_1119 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.003451
K_1120 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.003487
K_1121 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.003433
K_1122 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.003470
K_1123 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006632
K_1124 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006551
K_1125 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006473
K_1126 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006445
K_1127 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.003024
K_1128 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.003020
K_1129 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.002988
K_1130 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.003027
K_1131 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.004204
K_1132 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.004261
K_1133 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.004181
K_1134 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.004196
K_1135 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.003967
K_1136 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.003928
K_1137 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.003893
K_1138 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.003923
K_1139 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.002956
K_1140 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.002969
K_1141 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.002929
K_1142 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.002959
K_1143 X_NUC_14.L_CORE X_NUC_65.L_CORE 0.004412
K_1144 X_NUC_14.L_CORE X_NUC_66.L_CORE 0.004425
K_1145 X_NUC_14.L_CORE X_NUC_67.L_CORE 0.004354
K_1146 X_NUC_14.L_CORE X_NUC_68.L_CORE 0.004354
K_1147 X_NUC_14.L_CORE X_NUC_69.L_CORE 0.003085
K_1148 X_NUC_14.L_CORE X_NUC_70.L_CORE 0.003076
K_1149 X_NUC_14.L_CORE X_NUC_71.L_CORE 0.003043
K_1150 X_NUC_14.L_CORE X_NUC_72.L_CORE 0.003071
K_1151 X_NUC_14.L_CORE X_NUC_73.L_CORE 0.003219
K_1152 X_NUC_14.L_CORE X_NUC_74.L_CORE 0.003237
K_1153 X_NUC_14.L_CORE X_NUC_75.L_CORE 0.003189
K_1154 X_NUC_14.L_CORE X_NUC_76.L_CORE 0.003209
K_1155 X_NUC_14.L_CORE X_NUC_77.L_CORE 0.003425
K_1156 X_NUC_14.L_CORE X_NUC_78.L_CORE 0.003421
K_1157 X_NUC_14.L_CORE X_NUC_79.L_CORE 0.003377
K_1158 X_NUC_14.L_CORE X_NUC_80.L_CORE 0.003395
K_1159 X_NUC_14.L_CORE X_NUC_81.L_CORE 0.007849
K_1160 X_NUC_14.L_CORE X_NUC_82.L_CORE 0.005425
K_1161 X_NUC_14.L_CORE X_NUC_83.L_CORE 0.003541
K_1162 X_NUC_14.L_CORE X_NUC_84.L_CORE 0.014225
K_1163 X_NUC_14.L_CORE X_NUC_85.L_CORE 0.003145
K_1164 X_NUC_14.L_CORE X_NUC_86.L_CORE 0.003842
K_1165 X_NUC_14.L_CORE X_NUC_87.L_CORE 0.004604
K_1166 X_NUC_14.L_CORE X_NUC_88.L_CORE 0.002698
K_1167 X_NUC_14.L_CORE X_NUC_89.L_CORE 0.004104
K_1168 X_NUC_14.L_CORE X_NUC_90.L_CORE 0.002963
K_1169 X_NUC_14.L_CORE X_NUC_91.L_CORE 0.002839
K_1170 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_1171 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.003939
K_1172 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.003920
K_1173 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.003891
K_1174 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.003962
K_1175 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.005084
K_1176 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.005193
K_1177 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.005093
K_1178 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.005153
K_1179 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.007249
K_1180 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.007034
K_1181 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.007038
K_1182 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.007118
K_1183 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.003307
K_1184 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.003319
K_1185 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.003280
K_1186 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.003330
K_1187 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.007916
K_1188 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.008137
K_1189 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.007912
K_1190 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.007848
K_1191 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.003864
K_1192 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.003825
K_1193 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.003799
K_1194 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.003851
K_1195 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.003505
K_1196 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.003543
K_1197 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.003487
K_1198 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.003526
K_1199 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006712
K_1200 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006624
K_1201 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006551
K_1202 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.006519
K_1203 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.003056
K_1204 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.003053
K_1205 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.003020
K_1206 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.003059
K_1207 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.004285
K_1208 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.004345
K_1209 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.004261
K_1210 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.004276
K_1211 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.004003
K_1212 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.003962
K_1213 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.003928
K_1214 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.003958
K_1215 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.002997
K_1216 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.003010
K_1217 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.002969
K_1218 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.003000
K_1219 X_NUC_15.L_CORE X_NUC_65.L_CORE 0.004485
K_1220 X_NUC_15.L_CORE X_NUC_66.L_CORE 0.004498
K_1221 X_NUC_15.L_CORE X_NUC_67.L_CORE 0.004425
K_1222 X_NUC_15.L_CORE X_NUC_68.L_CORE 0.004424
K_1223 X_NUC_15.L_CORE X_NUC_69.L_CORE 0.003120
K_1224 X_NUC_15.L_CORE X_NUC_70.L_CORE 0.003110
K_1225 X_NUC_15.L_CORE X_NUC_71.L_CORE 0.003076
K_1226 X_NUC_15.L_CORE X_NUC_72.L_CORE 0.003105
K_1227 X_NUC_15.L_CORE X_NUC_73.L_CORE 0.003269
K_1228 X_NUC_15.L_CORE X_NUC_74.L_CORE 0.003287
K_1229 X_NUC_15.L_CORE X_NUC_75.L_CORE 0.003237
K_1230 X_NUC_15.L_CORE X_NUC_76.L_CORE 0.003258
K_1231 X_NUC_15.L_CORE X_NUC_77.L_CORE 0.003471
K_1232 X_NUC_15.L_CORE X_NUC_78.L_CORE 0.003466
K_1233 X_NUC_15.L_CORE X_NUC_79.L_CORE 0.003421
K_1234 X_NUC_15.L_CORE X_NUC_80.L_CORE 0.003439
K_1235 X_NUC_15.L_CORE X_NUC_81.L_CORE 0.007902
K_1236 X_NUC_15.L_CORE X_NUC_82.L_CORE 0.005411
K_1237 X_NUC_15.L_CORE X_NUC_83.L_CORE 0.003583
K_1238 X_NUC_15.L_CORE X_NUC_84.L_CORE 0.014149
K_1239 X_NUC_15.L_CORE X_NUC_85.L_CORE 0.003168
K_1240 X_NUC_15.L_CORE X_NUC_86.L_CORE 0.003906
K_1241 X_NUC_15.L_CORE X_NUC_87.L_CORE 0.004624
K_1242 X_NUC_15.L_CORE X_NUC_88.L_CORE 0.002729
K_1243 X_NUC_15.L_CORE X_NUC_89.L_CORE 0.004169
K_1244 X_NUC_15.L_CORE X_NUC_90.L_CORE 0.002990
K_1245 X_NUC_15.L_CORE X_NUC_91.L_CORE 0.002877
K_1246 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.003868
K_1247 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.003850
K_1248 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.003822
K_1249 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.003891
K_1250 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.005024
K_1251 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.005130
K_1252 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.005031
K_1253 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.005093
K_1254 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.007160
K_1255 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.006953
K_1256 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.006953
K_1257 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.007038
K_1258 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.003258
K_1259 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.003270
K_1260 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.003232
K_1261 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.003280
K_1262 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.007975
K_1263 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.008202
K_1264 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.007965
K_1265 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.007912
K_1266 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.003811
K_1267 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.003774
K_1268 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.003748
K_1269 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.003799
K_1270 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.003467
K_1271 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.003503
K_1272 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.003449
K_1273 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.003487
K_1274 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006743
K_1275 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006654
K_1276 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006576
K_1277 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006551
K_1278 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.003017
K_1279 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.003014
K_1280 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.002982
K_1281 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.003020
K_1282 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.004269
K_1283 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.004328
K_1284 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.004244
K_1285 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.004261
K_1286 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.003972
K_1287 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.003932
K_1288 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.003898
K_1289 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.003928
K_1290 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.002965
K_1291 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.002979
K_1292 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.002939
K_1293 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.002969
K_1294 X_NUC_16.L_CORE X_NUC_65.L_CORE 0.004486
K_1295 X_NUC_16.L_CORE X_NUC_66.L_CORE 0.004498
K_1296 X_NUC_16.L_CORE X_NUC_67.L_CORE 0.004424
K_1297 X_NUC_16.L_CORE X_NUC_68.L_CORE 0.004425
K_1298 X_NUC_16.L_CORE X_NUC_69.L_CORE 0.003090
K_1299 X_NUC_16.L_CORE X_NUC_70.L_CORE 0.003080
K_1300 X_NUC_16.L_CORE X_NUC_71.L_CORE 0.003047
K_1301 X_NUC_16.L_CORE X_NUC_72.L_CORE 0.003076
K_1302 X_NUC_16.L_CORE X_NUC_73.L_CORE 0.003247
K_1303 X_NUC_16.L_CORE X_NUC_74.L_CORE 0.003265
K_1304 X_NUC_16.L_CORE X_NUC_75.L_CORE 0.003216
K_1305 X_NUC_16.L_CORE X_NUC_76.L_CORE 0.003237
K_1306 X_NUC_16.L_CORE X_NUC_77.L_CORE 0.003452
K_1307 X_NUC_16.L_CORE X_NUC_78.L_CORE 0.003448
K_1308 X_NUC_16.L_CORE X_NUC_79.L_CORE 0.003403
K_1309 X_NUC_16.L_CORE X_NUC_80.L_CORE 0.003421
K_1310 X_NUC_16.L_CORE X_NUC_81.L_CORE 0.007740
K_1311 X_NUC_16.L_CORE X_NUC_82.L_CORE 0.005311
K_1312 X_NUC_16.L_CORE X_NUC_83.L_CORE 0.003531
K_1313 X_NUC_16.L_CORE X_NUC_84.L_CORE 0.015005
K_1314 X_NUC_16.L_CORE X_NUC_85.L_CORE 0.003124
K_1315 X_NUC_16.L_CORE X_NUC_86.L_CORE 0.003882
K_1316 X_NUC_16.L_CORE X_NUC_87.L_CORE 0.004610
K_1317 X_NUC_16.L_CORE X_NUC_88.L_CORE 0.002699
K_1318 X_NUC_16.L_CORE X_NUC_89.L_CORE 0.004177
K_1319 X_NUC_16.L_CORE X_NUC_90.L_CORE 0.002967
K_1320 X_NUC_16.L_CORE X_NUC_91.L_CORE 0.002859
K_1321 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_1322 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_1323 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_1324 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.003593
K_1325 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.003645
K_1326 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.003633
K_1327 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.003598
K_1328 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.004769
K_1329 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.004738
K_1330 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.004792
K_1331 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.004690
K_1332 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.006736
K_1333 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.006936
K_1334 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.006746
K_1335 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.006808
K_1336 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.003117
K_1337 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.003139
K_1338 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.003141
K_1339 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.003101
K_1340 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.007909
K_1341 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.007728
K_1342 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.007735
K_1343 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.007622
K_1344 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.003676
K_1345 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.003735
K_1346 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.003694
K_1347 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.003680
K_1348 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.003390
K_1349 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.003390
K_1350 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.003399
K_1351 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.003349
K_1352 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006669
K_1353 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006723
K_1354 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.006529
K_1355 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.006587
K_1356 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.002962
K_1357 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.002990
K_1358 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.002975
K_1359 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.002949
K_1360 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.004248
K_1361 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.004222
K_1362 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.004217
K_1363 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.004166
K_1364 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.003920
K_1365 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.003970
K_1366 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.003906
K_1367 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.003905
K_1368 X_NUC_17.L_CORE X_NUC_65.L_CORE 0.002969
K_1369 X_NUC_17.L_CORE X_NUC_66.L_CORE 0.002981
K_1370 X_NUC_17.L_CORE X_NUC_67.L_CORE 0.002972
K_1371 X_NUC_17.L_CORE X_NUC_68.L_CORE 0.002941
K_1372 X_NUC_17.L_CORE X_NUC_69.L_CORE 0.004388
K_1373 X_NUC_17.L_CORE X_NUC_70.L_CORE 0.004387
K_1374 X_NUC_17.L_CORE X_NUC_71.L_CORE 0.004332
K_1375 X_NUC_17.L_CORE X_NUC_72.L_CORE 0.004316
K_1376 X_NUC_17.L_CORE X_NUC_73.L_CORE 0.003126
K_1377 X_NUC_17.L_CORE X_NUC_74.L_CORE 0.003151
K_1378 X_NUC_17.L_CORE X_NUC_75.L_CORE 0.003122
K_1379 X_NUC_17.L_CORE X_NUC_76.L_CORE 0.003105
K_1380 X_NUC_17.L_CORE X_NUC_77.L_CORE 0.003287
K_1381 X_NUC_17.L_CORE X_NUC_78.L_CORE 0.003294
K_1382 X_NUC_17.L_CORE X_NUC_79.L_CORE 0.003272
K_1383 X_NUC_17.L_CORE X_NUC_80.L_CORE 0.003246
K_1384 X_NUC_17.L_CORE X_NUC_81.L_CORE 0.004118
K_1385 X_NUC_17.L_CORE X_NUC_82.L_CORE 0.007325
K_1386 X_NUC_17.L_CORE X_NUC_83.L_CORE 0.004735
K_1387 X_NUC_17.L_CORE X_NUC_84.L_CORE 0.003212
K_1388 X_NUC_17.L_CORE X_NUC_85.L_CORE 0.012116
K_1389 X_NUC_17.L_CORE X_NUC_86.L_CORE 0.002974
K_1390 X_NUC_17.L_CORE X_NUC_87.L_CORE 0.003680
K_1391 X_NUC_17.L_CORE X_NUC_88.L_CORE 0.004396
K_1392 X_NUC_17.L_CORE X_NUC_89.L_CORE 0.002670
K_1393 X_NUC_17.L_CORE X_NUC_90.L_CORE 0.003887
K_1394 X_NUC_17.L_CORE X_NUC_91.L_CORE 0.002981
K_1395 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_1396 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_1397 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.003541
K_1398 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.003593
K_1399 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.003580
K_1400 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.003547
K_1401 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.004798
K_1402 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.004769
K_1403 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.004823
K_1404 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.004719
K_1405 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.006545
K_1406 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.006736
K_1407 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.006558
K_1408 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.006615
K_1409 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.003094
K_1410 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.003117
K_1411 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.003118
K_1412 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.003079
K_1413 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.008092
K_1414 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.007909
K_1415 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.007911
K_1416 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.007791
K_1417 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.003618
K_1418 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.003676
K_1419 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.003636
K_1420 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.003623
K_1421 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.003388
K_1422 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.003390
K_1423 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.003398
K_1424 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.003348
K_1425 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.006610
K_1426 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006669
K_1427 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.006476
K_1428 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.006534
K_1429 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.002935
K_1430 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.002962
K_1431 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.002948
K_1432 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.002923
K_1433 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.004273
K_1434 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.004248
K_1435 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.004242
K_1436 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.004190
K_1437 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.003871
K_1438 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.003920
K_1439 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.003858
K_1440 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.003857
K_1441 X_NUC_18.L_CORE X_NUC_65.L_CORE 0.002957
K_1442 X_NUC_18.L_CORE X_NUC_66.L_CORE 0.002969
K_1443 X_NUC_18.L_CORE X_NUC_67.L_CORE 0.002960
K_1444 X_NUC_18.L_CORE X_NUC_68.L_CORE 0.002930
K_1445 X_NUC_18.L_CORE X_NUC_69.L_CORE 0.004388
K_1446 X_NUC_18.L_CORE X_NUC_70.L_CORE 0.004388
K_1447 X_NUC_18.L_CORE X_NUC_71.L_CORE 0.004332
K_1448 X_NUC_18.L_CORE X_NUC_72.L_CORE 0.004317
K_1449 X_NUC_18.L_CORE X_NUC_73.L_CORE 0.003100
K_1450 X_NUC_18.L_CORE X_NUC_74.L_CORE 0.003126
K_1451 X_NUC_18.L_CORE X_NUC_75.L_CORE 0.003097
K_1452 X_NUC_18.L_CORE X_NUC_76.L_CORE 0.003080
K_1453 X_NUC_18.L_CORE X_NUC_77.L_CORE 0.003279
K_1454 X_NUC_18.L_CORE X_NUC_78.L_CORE 0.003287
K_1455 X_NUC_18.L_CORE X_NUC_79.L_CORE 0.003265
K_1456 X_NUC_18.L_CORE X_NUC_80.L_CORE 0.003239
K_1457 X_NUC_18.L_CORE X_NUC_81.L_CORE 0.004071
K_1458 X_NUC_18.L_CORE X_NUC_82.L_CORE 0.007435
K_1459 X_NUC_18.L_CORE X_NUC_83.L_CORE 0.004629
K_1460 X_NUC_18.L_CORE X_NUC_84.L_CORE 0.003202
K_1461 X_NUC_18.L_CORE X_NUC_85.L_CORE 0.012399
K_1462 X_NUC_18.L_CORE X_NUC_86.L_CORE 0.002939
K_1463 X_NUC_18.L_CORE X_NUC_87.L_CORE 0.003702
K_1464 X_NUC_18.L_CORE X_NUC_88.L_CORE 0.004340
K_1465 X_NUC_18.L_CORE X_NUC_89.L_CORE 0.002656
K_1466 X_NUC_18.L_CORE X_NUC_90.L_CORE 0.003900
K_1467 X_NUC_18.L_CORE X_NUC_91.L_CORE 0.002961
K_1468 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_1469 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.003553
K_1470 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.003604
K_1471 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.003593
K_1472 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.003559
K_1473 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.004744
K_1474 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.004715
K_1475 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.004769
K_1476 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.004668
K_1477 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.006719
K_1478 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.006921
K_1479 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.006736
K_1480 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.006794
K_1481 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.003093
K_1482 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.003115
K_1483 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.003117
K_1484 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.003077
K_1485 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.008084
K_1486 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.007896
K_1487 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.007909
K_1488 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.007783
K_1489 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.003657
K_1490 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.003716
K_1491 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.003676
K_1492 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.003661
K_1493 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.003380
K_1494 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.003380
K_1495 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.003390
K_1496 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.003340
K_1497 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006812
K_1498 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006873
K_1499 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006669
K_1500 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.006728
K_1501 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.002949
K_1502 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.002977
K_1503 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.002962
K_1504 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.002937
K_1505 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.004279
K_1506 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.004253
K_1507 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.004248
K_1508 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.004195
K_1509 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.003933
K_1510 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.003984
K_1511 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.003920
K_1512 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.003919
K_1513 X_NUC_19.L_CORE X_NUC_65.L_CORE 0.002966
K_1514 X_NUC_19.L_CORE X_NUC_66.L_CORE 0.002978
K_1515 X_NUC_19.L_CORE X_NUC_67.L_CORE 0.002969
K_1516 X_NUC_19.L_CORE X_NUC_68.L_CORE 0.002938
K_1517 X_NUC_19.L_CORE X_NUC_69.L_CORE 0.004445
K_1518 X_NUC_19.L_CORE X_NUC_70.L_CORE 0.004444
K_1519 X_NUC_19.L_CORE X_NUC_71.L_CORE 0.004388
K_1520 X_NUC_19.L_CORE X_NUC_72.L_CORE 0.004371
K_1521 X_NUC_19.L_CORE X_NUC_73.L_CORE 0.003129
K_1522 X_NUC_19.L_CORE X_NUC_74.L_CORE 0.003155
K_1523 X_NUC_19.L_CORE X_NUC_75.L_CORE 0.003126
K_1524 X_NUC_19.L_CORE X_NUC_76.L_CORE 0.003108
K_1525 X_NUC_19.L_CORE X_NUC_77.L_CORE 0.003301
K_1526 X_NUC_19.L_CORE X_NUC_78.L_CORE 0.003308
K_1527 X_NUC_19.L_CORE X_NUC_79.L_CORE 0.003287
K_1528 X_NUC_19.L_CORE X_NUC_80.L_CORE 0.003260
K_1529 X_NUC_19.L_CORE X_NUC_81.L_CORE 0.004045
K_1530 X_NUC_19.L_CORE X_NUC_82.L_CORE 0.007206
K_1531 X_NUC_19.L_CORE X_NUC_83.L_CORE 0.004673
K_1532 X_NUC_19.L_CORE X_NUC_84.L_CORE 0.003185
K_1533 X_NUC_19.L_CORE X_NUC_85.L_CORE 0.012862
K_1534 X_NUC_19.L_CORE X_NUC_86.L_CORE 0.002954
K_1535 X_NUC_19.L_CORE X_NUC_87.L_CORE 0.003687
K_1536 X_NUC_19.L_CORE X_NUC_88.L_CORE 0.004429
K_1537 X_NUC_19.L_CORE X_NUC_89.L_CORE 0.002664
K_1538 X_NUC_19.L_CORE X_NUC_90.L_CORE 0.003934
K_1539 X_NUC_19.L_CORE X_NUC_91.L_CORE 0.002991
K_1540 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.003586
K_1541 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.003638
K_1542 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.003626
K_1543 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.003593
K_1544 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.004849
K_1545 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.004818
K_1546 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.004875
K_1547 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.004769
K_1548 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.006660
K_1549 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.006857
K_1550 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.006673
K_1551 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.006736
K_1552 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.003132
K_1553 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.003155
K_1554 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.003157
K_1555 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.003117
K_1556 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.008219
K_1557 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.008022
K_1558 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.008030
K_1559 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.007909
K_1560 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.003671
K_1561 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.003730
K_1562 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.003690
K_1563 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.003676
K_1564 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.003431
K_1565 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.003431
K_1566 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.003441
K_1567 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.003390
K_1568 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006747
K_1569 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.006807
K_1570 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006605
K_1571 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006669
K_1572 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.002975
K_1573 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.003003
K_1574 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.002988
K_1575 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.002962
K_1576 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.004334
K_1577 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.004308
K_1578 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.004302
K_1579 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.004248
K_1580 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.003934
K_1581 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.003985
K_1582 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.003921
K_1583 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.003920
K_1584 X_NUC_20.L_CORE X_NUC_65.L_CORE 0.002998
K_1585 X_NUC_20.L_CORE X_NUC_66.L_CORE 0.003010
K_1586 X_NUC_20.L_CORE X_NUC_67.L_CORE 0.003001
K_1587 X_NUC_20.L_CORE X_NUC_68.L_CORE 0.002969
K_1588 X_NUC_20.L_CORE X_NUC_69.L_CORE 0.004462
K_1589 X_NUC_20.L_CORE X_NUC_70.L_CORE 0.004461
K_1590 X_NUC_20.L_CORE X_NUC_71.L_CORE 0.004404
K_1591 X_NUC_20.L_CORE X_NUC_72.L_CORE 0.004388
K_1592 X_NUC_20.L_CORE X_NUC_73.L_CORE 0.003147
K_1593 X_NUC_20.L_CORE X_NUC_74.L_CORE 0.003173
K_1594 X_NUC_20.L_CORE X_NUC_75.L_CORE 0.003143
K_1595 X_NUC_20.L_CORE X_NUC_76.L_CORE 0.003126
K_1596 X_NUC_20.L_CORE X_NUC_77.L_CORE 0.003328
K_1597 X_NUC_20.L_CORE X_NUC_78.L_CORE 0.003336
K_1598 X_NUC_20.L_CORE X_NUC_79.L_CORE 0.003313
K_1599 X_NUC_20.L_CORE X_NUC_80.L_CORE 0.003287
K_1600 X_NUC_20.L_CORE X_NUC_81.L_CORE 0.004103
K_1601 X_NUC_20.L_CORE X_NUC_82.L_CORE 0.007416
K_1602 X_NUC_20.L_CORE X_NUC_83.L_CORE 0.004678
K_1603 X_NUC_20.L_CORE X_NUC_84.L_CORE 0.003234
K_1604 X_NUC_20.L_CORE X_NUC_85.L_CORE 0.012419
K_1605 X_NUC_20.L_CORE X_NUC_86.L_CORE 0.002975
K_1606 X_NUC_20.L_CORE X_NUC_87.L_CORE 0.003741
K_1607 X_NUC_20.L_CORE X_NUC_88.L_CORE 0.004404
K_1608 X_NUC_20.L_CORE X_NUC_89.L_CORE 0.002689
K_1609 X_NUC_20.L_CORE X_NUC_90.L_CORE 0.003953
K_1610 X_NUC_20.L_CORE X_NUC_91.L_CORE 0.003002
K_1611 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_1612 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_1613 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_1614 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.003394
K_1615 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.003340
K_1616 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.003369
K_1617 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.003360
K_1618 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.004550
K_1619 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.004505
K_1620 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.004474
K_1621 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.004559
K_1622 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.006521
K_1623 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.006416
K_1624 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.006498
K_1625 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.006344
K_1626 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.003010
K_1627 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.002970
K_1628 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.002977
K_1629 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.002989
K_1630 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.007891
K_1631 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.007913
K_1632 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.007657
K_1633 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.007864
K_1634 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.003600
K_1635 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.003550
K_1636 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.003571
K_1637 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.003546
K_1638 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.003335
K_1639 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.003301
K_1640 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.003286
K_1641 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.003320
K_1642 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.006725
K_1643 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.006701
K_1644 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.006610
K_1645 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.006537
K_1646 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.002944
K_1647 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.002907
K_1648 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.002912
K_1649 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.002913
K_1650 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.004248
K_1651 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.004225
K_1652 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.004166
K_1653 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.004219
K_1654 X_NUC_21.L_CORE X_NUC_65.L_CORE 0.003928
K_1655 X_NUC_21.L_CORE X_NUC_66.L_CORE 0.003888
K_1656 X_NUC_21.L_CORE X_NUC_67.L_CORE 0.003883
K_1657 X_NUC_21.L_CORE X_NUC_68.L_CORE 0.003856
K_1658 X_NUC_21.L_CORE X_NUC_69.L_CORE 0.003016
K_1659 X_NUC_21.L_CORE X_NUC_70.L_CORE 0.002985
K_1660 X_NUC_21.L_CORE X_NUC_71.L_CORE 0.002974
K_1661 X_NUC_21.L_CORE X_NUC_72.L_CORE 0.002988
K_1662 X_NUC_21.L_CORE X_NUC_73.L_CORE 0.004268
K_1663 X_NUC_21.L_CORE X_NUC_74.L_CORE 0.004245
K_1664 X_NUC_21.L_CORE X_NUC_75.L_CORE 0.004192
K_1665 X_NUC_21.L_CORE X_NUC_76.L_CORE 0.004204
K_1666 X_NUC_21.L_CORE X_NUC_77.L_CORE 0.003254
K_1667 X_NUC_21.L_CORE X_NUC_78.L_CORE 0.003222
K_1668 X_NUC_21.L_CORE X_NUC_79.L_CORE 0.003210
K_1669 X_NUC_21.L_CORE X_NUC_80.L_CORE 0.003210
K_1670 X_NUC_21.L_CORE X_NUC_81.L_CORE 0.006998
K_1671 X_NUC_21.L_CORE X_NUC_82.L_CORE 0.003306
K_1672 X_NUC_21.L_CORE X_NUC_83.L_CORE 0.006760
K_1673 X_NUC_21.L_CORE X_NUC_84.L_CORE 0.004253
K_1674 X_NUC_21.L_CORE X_NUC_85.L_CORE 0.002988
K_1675 X_NUC_21.L_CORE X_NUC_86.L_CORE 0.010865
K_1676 X_NUC_21.L_CORE X_NUC_87.L_CORE 0.002840
K_1677 X_NUC_21.L_CORE X_NUC_88.L_CORE 0.003573
K_1678 X_NUC_21.L_CORE X_NUC_89.L_CORE 0.004178
K_1679 X_NUC_21.L_CORE X_NUC_90.L_CORE 0.002689
K_1680 X_NUC_21.L_CORE X_NUC_91.L_CORE 0.003560
K_1681 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_1682 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_1683 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.003449
K_1684 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.003394
K_1685 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.003423
K_1686 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.003414
K_1687 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.004595
K_1688 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.004550
K_1689 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.004517
K_1690 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.004605
K_1691 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.006625
K_1692 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.006521
K_1693 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.006604
K_1694 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.006442
K_1695 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.003051
K_1696 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.003010
K_1697 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.003017
K_1698 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.003030
K_1699 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.007858
K_1700 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.007891
K_1701 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.007632
K_1702 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.007837
K_1703 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.003653
K_1704 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.003600
K_1705 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.003623
K_1706 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.003596
K_1707 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.003370
K_1708 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.003335
K_1709 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.003320
K_1710 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.003355
K_1711 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.006742
K_1712 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.006725
K_1713 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.006630
K_1714 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.006556
K_1715 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.002981
K_1716 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.002944
K_1717 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.002948
K_1718 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.002949
K_1719 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.004271
K_1720 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.004248
K_1721 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.004188
K_1722 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.004241
K_1723 X_NUC_22.L_CORE X_NUC_65.L_CORE 0.003969
K_1724 X_NUC_22.L_CORE X_NUC_66.L_CORE 0.003928
K_1725 X_NUC_22.L_CORE X_NUC_67.L_CORE 0.003923
K_1726 X_NUC_22.L_CORE X_NUC_68.L_CORE 0.003895
K_1727 X_NUC_22.L_CORE X_NUC_69.L_CORE 0.003047
K_1728 X_NUC_22.L_CORE X_NUC_70.L_CORE 0.003016
K_1729 X_NUC_22.L_CORE X_NUC_71.L_CORE 0.003004
K_1730 X_NUC_22.L_CORE X_NUC_72.L_CORE 0.003019
K_1731 X_NUC_22.L_CORE X_NUC_73.L_CORE 0.004289
K_1732 X_NUC_22.L_CORE X_NUC_74.L_CORE 0.004268
K_1733 X_NUC_22.L_CORE X_NUC_75.L_CORE 0.004213
K_1734 X_NUC_22.L_CORE X_NUC_76.L_CORE 0.004225
K_1735 X_NUC_22.L_CORE X_NUC_77.L_CORE 0.003285
K_1736 X_NUC_22.L_CORE X_NUC_78.L_CORE 0.003254
K_1737 X_NUC_22.L_CORE X_NUC_79.L_CORE 0.003241
K_1738 X_NUC_22.L_CORE X_NUC_80.L_CORE 0.003241
K_1739 X_NUC_22.L_CORE X_NUC_81.L_CORE 0.007152
K_1740 X_NUC_22.L_CORE X_NUC_82.L_CORE 0.003357
K_1741 X_NUC_22.L_CORE X_NUC_83.L_CORE 0.006790
K_1742 X_NUC_22.L_CORE X_NUC_84.L_CORE 0.004319
K_1743 X_NUC_22.L_CORE X_NUC_85.L_CORE 0.003022
K_1744 X_NUC_22.L_CORE X_NUC_86.L_CORE 0.010581
K_1745 X_NUC_22.L_CORE X_NUC_87.L_CORE 0.002876
K_1746 X_NUC_22.L_CORE X_NUC_88.L_CORE 0.003594
K_1747 X_NUC_22.L_CORE X_NUC_89.L_CORE 0.004205
K_1748 X_NUC_22.L_CORE X_NUC_90.L_CORE 0.002716
K_1749 X_NUC_22.L_CORE X_NUC_91.L_CORE 0.003576
K_1750 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_1751 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.003419
K_1752 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.003364
K_1753 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.003394
K_1754 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.003385
K_1755 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.004628
K_1756 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.004581
K_1757 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.004550
K_1758 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.004639
K_1759 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.006538
K_1760 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.006435
K_1761 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.006521
K_1762 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.006362
K_1763 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.003043
K_1764 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.003002
K_1765 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.003010
K_1766 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.003023
K_1767 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.008136
K_1768 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.008166
K_1769 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.007891
K_1770 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.008112
K_1771 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.003629
K_1772 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.003578
K_1773 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.003600
K_1774 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.003574
K_1775 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.003386
K_1776 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.003350
K_1777 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.003335
K_1778 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.003370
K_1779 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.006838
K_1780 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.006816
K_1781 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.006725
K_1782 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.006644
K_1783 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.002977
K_1784 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.002939
K_1785 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.002944
K_1786 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.002944
K_1787 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.004334
K_1788 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.004309
K_1789 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.004248
K_1790 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.004303
K_1791 X_NUC_23.L_CORE X_NUC_65.L_CORE 0.003973
K_1792 X_NUC_23.L_CORE X_NUC_66.L_CORE 0.003932
K_1793 X_NUC_23.L_CORE X_NUC_67.L_CORE 0.003928
K_1794 X_NUC_23.L_CORE X_NUC_68.L_CORE 0.003899
K_1795 X_NUC_23.L_CORE X_NUC_69.L_CORE 0.003058
K_1796 X_NUC_23.L_CORE X_NUC_70.L_CORE 0.003026
K_1797 X_NUC_23.L_CORE X_NUC_71.L_CORE 0.003016
K_1798 X_NUC_23.L_CORE X_NUC_72.L_CORE 0.003030
K_1799 X_NUC_23.L_CORE X_NUC_73.L_CORE 0.004345
K_1800 X_NUC_23.L_CORE X_NUC_74.L_CORE 0.004322
K_1801 X_NUC_23.L_CORE X_NUC_75.L_CORE 0.004268
K_1802 X_NUC_23.L_CORE X_NUC_76.L_CORE 0.004279
K_1803 X_NUC_23.L_CORE X_NUC_77.L_CORE 0.003298
K_1804 X_NUC_23.L_CORE X_NUC_78.L_CORE 0.003266
K_1805 X_NUC_23.L_CORE X_NUC_79.L_CORE 0.003254
K_1806 X_NUC_23.L_CORE X_NUC_80.L_CORE 0.003253
K_1807 X_NUC_23.L_CORE X_NUC_81.L_CORE 0.006927
K_1808 X_NUC_23.L_CORE X_NUC_82.L_CORE 0.003326
K_1809 X_NUC_23.L_CORE X_NUC_83.L_CORE 0.006848
K_1810 X_NUC_23.L_CORE X_NUC_84.L_CORE 0.004258
K_1811 X_NUC_23.L_CORE X_NUC_85.L_CORE 0.003022
K_1812 X_NUC_23.L_CORE X_NUC_86.L_CORE 0.011026
K_1813 X_NUC_23.L_CORE X_NUC_87.L_CORE 0.002863
K_1814 X_NUC_23.L_CORE X_NUC_88.L_CORE 0.003632
K_1815 X_NUC_23.L_CORE X_NUC_89.L_CORE 0.004217
K_1816 X_NUC_23.L_CORE X_NUC_90.L_CORE 0.002722
K_1817 X_NUC_23.L_CORE X_NUC_91.L_CORE 0.003616
K_1818 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.003428
K_1819 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.003373
K_1820 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.003402
K_1821 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.003394
K_1822 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.004539
K_1823 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.004495
K_1824 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.004464
K_1825 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.004550
K_1826 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.006708
K_1827 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.006596
K_1828 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.006686
K_1829 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.006521
K_1830 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.003030
K_1831 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.002989
K_1832 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.002996
K_1833 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.003010
K_1834 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.007907
K_1835 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.007935
K_1836 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.007677
K_1837 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.007891
K_1838 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.003657
K_1839 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.003604
K_1840 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.003627
K_1841 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.003600
K_1842 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.003350
K_1843 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.003316
K_1844 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.003301
K_1845 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.003335
K_1846 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.006922
K_1847 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.006899
K_1848 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.006801
K_1849 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.006725
K_1850 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.002976
K_1851 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.002938
K_1852 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.002943
K_1853 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.002944
K_1854 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.004277
K_1855 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.004254
K_1856 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.004194
K_1857 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.004248
K_1858 X_NUC_24.L_CORE X_NUC_65.L_CORE 0.004003
K_1859 X_NUC_24.L_CORE X_NUC_66.L_CORE 0.003961
K_1860 X_NUC_24.L_CORE X_NUC_67.L_CORE 0.003956
K_1861 X_NUC_24.L_CORE X_NUC_68.L_CORE 0.003928
K_1862 X_NUC_24.L_CORE X_NUC_69.L_CORE 0.003043
K_1863 X_NUC_24.L_CORE X_NUC_70.L_CORE 0.003012
K_1864 X_NUC_24.L_CORE X_NUC_71.L_CORE 0.003001
K_1865 X_NUC_24.L_CORE X_NUC_72.L_CORE 0.003016
K_1866 X_NUC_24.L_CORE X_NUC_73.L_CORE 0.004332
K_1867 X_NUC_24.L_CORE X_NUC_74.L_CORE 0.004309
K_1868 X_NUC_24.L_CORE X_NUC_75.L_CORE 0.004254
K_1869 X_NUC_24.L_CORE X_NUC_76.L_CORE 0.004268
K_1870 X_NUC_24.L_CORE X_NUC_77.L_CORE 0.003298
K_1871 X_NUC_24.L_CORE X_NUC_78.L_CORE 0.003266
K_1872 X_NUC_24.L_CORE X_NUC_79.L_CORE 0.003254
K_1873 X_NUC_24.L_CORE X_NUC_80.L_CORE 0.003254
K_1874 X_NUC_24.L_CORE X_NUC_81.L_CORE 0.006970
K_1875 X_NUC_24.L_CORE X_NUC_82.L_CORE 0.003319
K_1876 X_NUC_24.L_CORE X_NUC_83.L_CORE 0.006638
K_1877 X_NUC_24.L_CORE X_NUC_84.L_CORE 0.004316
K_1878 X_NUC_24.L_CORE X_NUC_85.L_CORE 0.002996
K_1879 X_NUC_24.L_CORE X_NUC_86.L_CORE 0.011096
K_1880 X_NUC_24.L_CORE X_NUC_87.L_CORE 0.002870
K_1881 X_NUC_24.L_CORE X_NUC_88.L_CORE 0.003584
K_1882 X_NUC_24.L_CORE X_NUC_89.L_CORE 0.004262
K_1883 X_NUC_24.L_CORE X_NUC_90.L_CORE 0.002713
K_1884 X_NUC_24.L_CORE X_NUC_91.L_CORE 0.003602
K_1885 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_1886 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_1887 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_1888 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.003260
K_1889 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.003292
K_1890 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.003254
K_1891 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.003294
K_1892 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.004404
K_1893 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.004493
K_1894 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.004453
K_1895 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.004422
K_1896 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.006378
K_1897 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.006351
K_1898 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.006231
K_1899 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.006409
K_1900 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.002945
K_1901 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.002982
K_1902 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.002948
K_1903 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.002966
K_1904 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.007875
K_1905 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.008016
K_1906 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.007881
K_1907 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.007720
K_1908 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.003565
K_1909 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.003585
K_1910 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.003533
K_1911 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.003585
K_1912 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.003318
K_1913 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.003367
K_1914 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.003327
K_1915 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.003326
K_1916 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.006725
K_1917 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.006704
K_1918 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.006538
K_1919 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.006613
K_1920 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.002962
K_1921 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.002991
K_1922 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.002950
K_1923 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.002975
K_1924 X_NUC_25.L_CORE X_NUC_65.L_CORE 0.004261
K_1925 X_NUC_25.L_CORE X_NUC_66.L_CORE 0.004318
K_1926 X_NUC_25.L_CORE X_NUC_67.L_CORE 0.004252
K_1927 X_NUC_25.L_CORE X_NUC_68.L_CORE 0.004234
K_1928 X_NUC_25.L_CORE X_NUC_69.L_CORE 0.003951
K_1929 X_NUC_25.L_CORE X_NUC_70.L_CORE 0.003967
K_1930 X_NUC_25.L_CORE X_NUC_71.L_CORE 0.003896
K_1931 X_NUC_25.L_CORE X_NUC_72.L_CORE 0.003942
K_1932 X_NUC_25.L_CORE X_NUC_73.L_CORE 0.003122
K_1933 X_NUC_25.L_CORE X_NUC_74.L_CORE 0.003156
K_1934 X_NUC_25.L_CORE X_NUC_75.L_CORE 0.003111
K_1935 X_NUC_25.L_CORE X_NUC_76.L_CORE 0.003123
K_1936 X_NUC_25.L_CORE X_NUC_77.L_CORE 0.004007
K_1937 X_NUC_25.L_CORE X_NUC_78.L_CORE 0.004038
K_1938 X_NUC_25.L_CORE X_NUC_79.L_CORE 0.003967
K_1939 X_NUC_25.L_CORE X_NUC_80.L_CORE 0.003980
K_1940 X_NUC_25.L_CORE X_NUC_81.L_CORE 0.004287
K_1941 X_NUC_25.L_CORE X_NUC_82.L_CORE 0.008203
K_1942 X_NUC_25.L_CORE X_NUC_83.L_CORE 0.003011
K_1943 X_NUC_25.L_CORE X_NUC_84.L_CORE 0.006417
K_1944 X_NUC_25.L_CORE X_NUC_85.L_CORE 0.004054
K_1945 X_NUC_25.L_CORE X_NUC_86.L_CORE 0.002912
K_1946 X_NUC_25.L_CORE X_NUC_87.L_CORE 0.009359
K_1947 X_NUC_25.L_CORE X_NUC_88.L_CORE 0.002834
K_1948 X_NUC_25.L_CORE X_NUC_89.L_CORE 0.003555
K_1949 X_NUC_25.L_CORE X_NUC_90.L_CORE 0.004014
K_1950 X_NUC_25.L_CORE X_NUC_91.L_CORE 0.002887
K_1951 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_1952 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_1953 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.003229
K_1954 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.003260
K_1955 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.003223
K_1956 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.003262
K_1957 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.004319
K_1958 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.004404
K_1959 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.004366
K_1960 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.004336
K_1961 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.006399
K_1962 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.006378
K_1963 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.006253
K_1964 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.006433
K_1965 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.002908
K_1966 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.002945
K_1967 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.002912
K_1968 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.002928
K_1969 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.007730
K_1970 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.007875
K_1971 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.007741
K_1972 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.007588
K_1973 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.003543
K_1974 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.003565
K_1975 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.003512
K_1976 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.003564
K_1977 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.003270
K_1978 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.003318
K_1979 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.003280
K_1980 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.003278
K_1981 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.006738
K_1982 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.006725
K_1983 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.006554
K_1984 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.006629
K_1985 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.002934
K_1986 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.002962
K_1987 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.002923
K_1988 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.002946
K_1989 X_NUC_26.L_CORE X_NUC_65.L_CORE 0.004205
K_1990 X_NUC_26.L_CORE X_NUC_66.L_CORE 0.004261
K_1991 X_NUC_26.L_CORE X_NUC_67.L_CORE 0.004198
K_1992 X_NUC_26.L_CORE X_NUC_68.L_CORE 0.004180
K_1993 X_NUC_26.L_CORE X_NUC_69.L_CORE 0.003933
K_1994 X_NUC_26.L_CORE X_NUC_70.L_CORE 0.003951
K_1995 X_NUC_26.L_CORE X_NUC_71.L_CORE 0.003880
K_1996 X_NUC_26.L_CORE X_NUC_72.L_CORE 0.003925
K_1997 X_NUC_26.L_CORE X_NUC_73.L_CORE 0.003089
K_1998 X_NUC_26.L_CORE X_NUC_74.L_CORE 0.003122
K_1999 X_NUC_26.L_CORE X_NUC_75.L_CORE 0.003079
K_2000 X_NUC_26.L_CORE X_NUC_76.L_CORE 0.003090
K_2001 X_NUC_26.L_CORE X_NUC_77.L_CORE 0.003976
K_2002 X_NUC_26.L_CORE X_NUC_78.L_CORE 0.004007
K_2003 X_NUC_26.L_CORE X_NUC_79.L_CORE 0.003937
K_2004 X_NUC_26.L_CORE X_NUC_80.L_CORE 0.003950
K_2005 X_NUC_26.L_CORE X_NUC_81.L_CORE 0.004213
K_2006 X_NUC_26.L_CORE X_NUC_82.L_CORE 0.008201
K_2007 X_NUC_26.L_CORE X_NUC_83.L_CORE 0.002976
K_2008 X_NUC_26.L_CORE X_NUC_84.L_CORE 0.006275
K_2009 X_NUC_26.L_CORE X_NUC_85.L_CORE 0.004046
K_2010 X_NUC_26.L_CORE X_NUC_86.L_CORE 0.002872
K_2011 X_NUC_26.L_CORE X_NUC_87.L_CORE 0.009492
K_2012 X_NUC_26.L_CORE X_NUC_88.L_CORE 0.002813
K_2013 X_NUC_26.L_CORE X_NUC_89.L_CORE 0.003510
K_2014 X_NUC_26.L_CORE X_NUC_90.L_CORE 0.004010
K_2015 X_NUC_26.L_CORE X_NUC_91.L_CORE 0.002862
K_2016 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_2017 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.003266
K_2018 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.003299
K_2019 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.003260
K_2020 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.003301
K_2021 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.004356
K_2022 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.004442
K_2023 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.004404
K_2024 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.004373
K_2025 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.006529
K_2026 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.006504
K_2027 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.006378
K_2028 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.006566
K_2029 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.002940
K_2030 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.002978
K_2031 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.002945
K_2032 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.002962
K_2033 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.007858
K_2034 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.008005
K_2035 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.007875
K_2036 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.007709
K_2037 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.003596
K_2038 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.003618
K_2039 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.003565
K_2040 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.003618
K_2041 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.003308
K_2042 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.003357
K_2043 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.003318
K_2044 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.003316
K_2045 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.006920
K_2046 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.006902
K_2047 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.006725
K_2048 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.006802
K_2049 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.002974
K_2050 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.003003
K_2051 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.002962
K_2052 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.002987
K_2053 X_NUC_27.L_CORE X_NUC_65.L_CORE 0.004268
K_2054 X_NUC_27.L_CORE X_NUC_66.L_CORE 0.004326
K_2055 X_NUC_27.L_CORE X_NUC_67.L_CORE 0.004261
K_2056 X_NUC_27.L_CORE X_NUC_68.L_CORE 0.004242
K_2057 X_NUC_27.L_CORE X_NUC_69.L_CORE 0.004006
K_2058 X_NUC_27.L_CORE X_NUC_70.L_CORE 0.004023
K_2059 X_NUC_27.L_CORE X_NUC_71.L_CORE 0.003951
K_2060 X_NUC_27.L_CORE X_NUC_72.L_CORE 0.003998
K_2061 X_NUC_27.L_CORE X_NUC_73.L_CORE 0.003132
K_2062 X_NUC_27.L_CORE X_NUC_74.L_CORE 0.003167
K_2063 X_NUC_27.L_CORE X_NUC_75.L_CORE 0.003122
K_2064 X_NUC_27.L_CORE X_NUC_76.L_CORE 0.003134
K_2065 X_NUC_27.L_CORE X_NUC_77.L_CORE 0.004048
K_2066 X_NUC_27.L_CORE X_NUC_78.L_CORE 0.004080
K_2067 X_NUC_27.L_CORE X_NUC_79.L_CORE 0.004007
K_2068 X_NUC_27.L_CORE X_NUC_80.L_CORE 0.004020
K_2069 X_NUC_27.L_CORE X_NUC_81.L_CORE 0.004221
K_2070 X_NUC_27.L_CORE X_NUC_82.L_CORE 0.008154
K_2071 X_NUC_27.L_CORE X_NUC_83.L_CORE 0.003001
K_2072 X_NUC_27.L_CORE X_NUC_84.L_CORE 0.006269
K_2073 X_NUC_27.L_CORE X_NUC_85.L_CORE 0.004095
K_2074 X_NUC_27.L_CORE X_NUC_86.L_CORE 0.002899
K_2075 X_NUC_27.L_CORE X_NUC_87.L_CORE 0.009673
K_2076 X_NUC_27.L_CORE X_NUC_88.L_CORE 0.002848
K_2077 X_NUC_27.L_CORE X_NUC_89.L_CORE 0.003551
K_2078 X_NUC_27.L_CORE X_NUC_90.L_CORE 0.004080
K_2079 X_NUC_27.L_CORE X_NUC_91.L_CORE 0.002901
K_2080 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.003227
K_2081 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.003258
K_2082 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.003221
K_2083 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.003260
K_2084 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.004385
K_2085 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.004474
K_2086 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.004434
K_2087 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.004404
K_2088 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.006341
K_2089 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.006318
K_2090 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.006200
K_2091 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.006378
K_2092 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.002923
K_2093 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.002960
K_2094 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.002927
K_2095 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.002945
K_2096 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.008028
K_2097 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.008184
K_2098 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.008040
K_2099 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.007875
K_2100 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.003543
K_2101 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.003564
K_2102 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.003513
K_2103 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.003565
K_2104 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.003309
K_2105 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.003358
K_2106 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.003319
K_2107 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.003318
K_2108 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.006836
K_2109 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.006818
K_2110 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.006643
K_2111 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.006725
K_2112 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.002949
K_2113 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.002978
K_2114 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.002938
K_2115 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.002962
K_2116 X_NUC_28.L_CORE X_NUC_65.L_CORE 0.004287
K_2117 X_NUC_28.L_CORE X_NUC_66.L_CORE 0.004345
K_2118 X_NUC_28.L_CORE X_NUC_67.L_CORE 0.004279
K_2119 X_NUC_28.L_CORE X_NUC_68.L_CORE 0.004261
K_2120 X_NUC_28.L_CORE X_NUC_69.L_CORE 0.003958
K_2121 X_NUC_28.L_CORE X_NUC_70.L_CORE 0.003975
K_2122 X_NUC_28.L_CORE X_NUC_71.L_CORE 0.003904
K_2123 X_NUC_28.L_CORE X_NUC_72.L_CORE 0.003951
K_2124 X_NUC_28.L_CORE X_NUC_73.L_CORE 0.003120
K_2125 X_NUC_28.L_CORE X_NUC_74.L_CORE 0.003155
K_2126 X_NUC_28.L_CORE X_NUC_75.L_CORE 0.003110
K_2127 X_NUC_28.L_CORE X_NUC_76.L_CORE 0.003122
K_2128 X_NUC_28.L_CORE X_NUC_77.L_CORE 0.004033
K_2129 X_NUC_28.L_CORE X_NUC_78.L_CORE 0.004065
K_2130 X_NUC_28.L_CORE X_NUC_79.L_CORE 0.003993
K_2131 X_NUC_28.L_CORE X_NUC_80.L_CORE 0.004007
K_2132 X_NUC_28.L_CORE X_NUC_81.L_CORE 0.004214
K_2133 X_NUC_28.L_CORE X_NUC_82.L_CORE 0.007937
K_2134 X_NUC_28.L_CORE X_NUC_83.L_CORE 0.002977
K_2135 X_NUC_28.L_CORE X_NUC_84.L_CORE 0.006400
K_2136 X_NUC_28.L_CORE X_NUC_85.L_CORE 0.004017
K_2137 X_NUC_28.L_CORE X_NUC_86.L_CORE 0.002895
K_2138 X_NUC_28.L_CORE X_NUC_87.L_CORE 0.009757
K_2139 X_NUC_28.L_CORE X_NUC_88.L_CORE 0.002820
K_2140 X_NUC_28.L_CORE X_NUC_89.L_CORE 0.003567
K_2141 X_NUC_28.L_CORE X_NUC_90.L_CORE 0.004037
K_2142 X_NUC_28.L_CORE X_NUC_91.L_CORE 0.002888
K_2143 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_2144 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_2145 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_2146 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.003174
K_2147 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.003177
K_2148 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.003198
K_2149 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.003150
K_2150 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.004315
K_2151 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.004235
K_2152 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.004282
K_2153 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.004248
K_2154 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.006296
K_2155 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.006431
K_2156 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.006378
K_2157 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.006256
K_2158 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.002914
K_2159 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.002898
K_2160 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.002918
K_2161 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.002882
K_2162 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.007869
K_2163 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.007654
K_2164 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.007621
K_2165 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.007625
K_2166 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.003565
K_2167 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.003583
K_2168 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.003584
K_2169 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.003531
K_2170 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.003335
K_2171 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.003299
K_2172 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.003318
K_2173 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.003286
K_2174 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.006669
K_2175 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.006720
K_2176 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.006587
K_2177 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.006526
K_2178 X_NUC_29.L_CORE X_NUC_65.L_CORE 0.003020
K_2179 X_NUC_29.L_CORE X_NUC_66.L_CORE 0.003015
K_2180 X_NUC_29.L_CORE X_NUC_67.L_CORE 0.003022
K_2181 X_NUC_29.L_CORE X_NUC_68.L_CORE 0.002984
K_2182 X_NUC_29.L_CORE X_NUC_69.L_CORE 0.004284
K_2183 X_NUC_29.L_CORE X_NUC_70.L_CORE 0.004233
K_2184 X_NUC_29.L_CORE X_NUC_71.L_CORE 0.004228
K_2185 X_NUC_29.L_CORE X_NUC_72.L_CORE 0.004198
K_2186 X_NUC_29.L_CORE X_NUC_73.L_CORE 0.003983
K_2187 X_NUC_29.L_CORE X_NUC_74.L_CORE 0.003994
K_2188 X_NUC_29.L_CORE X_NUC_75.L_CORE 0.003971
K_2189 X_NUC_29.L_CORE X_NUC_76.L_CORE 0.003924
K_2190 X_NUC_29.L_CORE X_NUC_77.L_CORE 0.003349
K_2191 X_NUC_29.L_CORE X_NUC_78.L_CORE 0.003332
K_2192 X_NUC_29.L_CORE X_NUC_79.L_CORE 0.003331
K_2193 X_NUC_29.L_CORE X_NUC_80.L_CORE 0.003297
K_2194 X_NUC_29.L_CORE X_NUC_81.L_CORE 0.003847
K_2195 X_NUC_29.L_CORE X_NUC_82.L_CORE 0.003756
K_2196 X_NUC_29.L_CORE X_NUC_83.L_CORE 0.008818
K_2197 X_NUC_29.L_CORE X_NUC_84.L_CORE 0.002805
K_2198 X_NUC_29.L_CORE X_NUC_85.L_CORE 0.005972
K_2199 X_NUC_29.L_CORE X_NUC_86.L_CORE 0.003938
K_2200 X_NUC_29.L_CORE X_NUC_87.L_CORE 0.002832
K_2201 X_NUC_29.L_CORE X_NUC_88.L_CORE 0.008292
K_2202 X_NUC_29.L_CORE X_NUC_89.L_CORE 0.002853
K_2203 X_NUC_29.L_CORE X_NUC_90.L_CORE 0.003510
K_2204 X_NUC_29.L_CORE X_NUC_91.L_CORE 0.003770
K_2205 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_2206 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_2207 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.003171
K_2208 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.003174
K_2209 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.003195
K_2210 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.003147
K_2211 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.004397
K_2212 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.004315
K_2213 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.004364
K_2214 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.004327
K_2215 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.006163
K_2216 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.006296
K_2217 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.006243
K_2218 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.006129
K_2219 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.002929
K_2220 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.002914
K_2221 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.002934
K_2222 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.002897
K_2223 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.008091
K_2224 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.007869
K_2225 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.007828
K_2226 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.007833
K_2227 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.003546
K_2228 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.003565
K_2229 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.003566
K_2230 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.003513
K_2231 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.003372
K_2232 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.003335
K_2233 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.003354
K_2234 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.003321
K_2235 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.006613
K_2236 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.006669
K_2237 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.006536
K_2238 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.006476
K_2239 X_NUC_30.L_CORE X_NUC_65.L_CORE 0.003025
K_2240 X_NUC_30.L_CORE X_NUC_66.L_CORE 0.003020
K_2241 X_NUC_30.L_CORE X_NUC_67.L_CORE 0.003027
K_2242 X_NUC_30.L_CORE X_NUC_68.L_CORE 0.002989
K_2243 X_NUC_30.L_CORE X_NUC_69.L_CORE 0.004334
K_2244 X_NUC_30.L_CORE X_NUC_70.L_CORE 0.004284
K_2245 X_NUC_30.L_CORE X_NUC_71.L_CORE 0.004278
K_2246 X_NUC_30.L_CORE X_NUC_72.L_CORE 0.004247
K_2247 X_NUC_30.L_CORE X_NUC_73.L_CORE 0.003970
K_2248 X_NUC_30.L_CORE X_NUC_74.L_CORE 0.003983
K_2249 X_NUC_30.L_CORE X_NUC_75.L_CORE 0.003959
K_2250 X_NUC_30.L_CORE X_NUC_76.L_CORE 0.003913
K_2251 X_NUC_30.L_CORE X_NUC_77.L_CORE 0.003365
K_2252 X_NUC_30.L_CORE X_NUC_78.L_CORE 0.003349
K_2253 X_NUC_30.L_CORE X_NUC_79.L_CORE 0.003348
K_2254 X_NUC_30.L_CORE X_NUC_80.L_CORE 0.003313
K_2255 X_NUC_30.L_CORE X_NUC_81.L_CORE 0.003845
K_2256 X_NUC_30.L_CORE X_NUC_82.L_CORE 0.003805
K_2257 X_NUC_30.L_CORE X_NUC_83.L_CORE 0.008565
K_2258 X_NUC_30.L_CORE X_NUC_84.L_CORE 0.002813
K_2259 X_NUC_30.L_CORE X_NUC_85.L_CORE 0.006148
K_2260 X_NUC_30.L_CORE X_NUC_86.L_CORE 0.003895
K_2261 X_NUC_30.L_CORE X_NUC_87.L_CORE 0.002857
K_2262 X_NUC_30.L_CORE X_NUC_88.L_CORE 0.008273
K_2263 X_NUC_30.L_CORE X_NUC_89.L_CORE 0.002850
K_2264 X_NUC_30.L_CORE X_NUC_90.L_CORE 0.003548
K_2265 X_NUC_30.L_CORE X_NUC_91.L_CORE 0.003763
K_2266 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_2267 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.003150
K_2268 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.003153
K_2269 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.003174
K_2270 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.003127
K_2271 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.004346
K_2272 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.004266
K_2273 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.004315
K_2274 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.004278
K_2275 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.006211
K_2276 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.006344
K_2277 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.006296
K_2278 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.006176
K_2279 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.002908
K_2280 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.002893
K_2281 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.002914
K_2282 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.002877
K_2283 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.008130
K_2284 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.007900
K_2285 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.007869
K_2286 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.007868
K_2287 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.003544
K_2288 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.003563
K_2289 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.003565
K_2290 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.003512
K_2291 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.003352
K_2292 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.003316
K_2293 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.003335
K_2294 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.003302
K_2295 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.006747
K_2296 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.006804
K_2297 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.006669
K_2298 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.006603
K_2299 X_NUC_31.L_CORE X_NUC_65.L_CORE 0.003018
K_2300 X_NUC_31.L_CORE X_NUC_66.L_CORE 0.003013
K_2301 X_NUC_31.L_CORE X_NUC_67.L_CORE 0.003020
K_2302 X_NUC_31.L_CORE X_NUC_68.L_CORE 0.002982
K_2303 X_NUC_31.L_CORE X_NUC_69.L_CORE 0.004340
K_2304 X_NUC_31.L_CORE X_NUC_70.L_CORE 0.004288
K_2305 X_NUC_31.L_CORE X_NUC_71.L_CORE 0.004284
K_2306 X_NUC_31.L_CORE X_NUC_72.L_CORE 0.004252
K_2307 X_NUC_31.L_CORE X_NUC_73.L_CORE 0.003992
K_2308 X_NUC_31.L_CORE X_NUC_74.L_CORE 0.004005
K_2309 X_NUC_31.L_CORE X_NUC_75.L_CORE 0.003983
K_2310 X_NUC_31.L_CORE X_NUC_76.L_CORE 0.003934
K_2311 X_NUC_31.L_CORE X_NUC_77.L_CORE 0.003365
K_2312 X_NUC_31.L_CORE X_NUC_78.L_CORE 0.003349
K_2313 X_NUC_31.L_CORE X_NUC_79.L_CORE 0.003349
K_2314 X_NUC_31.L_CORE X_NUC_80.L_CORE 0.003313
K_2315 X_NUC_31.L_CORE X_NUC_81.L_CORE 0.003790
K_2316 X_NUC_31.L_CORE X_NUC_82.L_CORE 0.003742
K_2317 X_NUC_31.L_CORE X_NUC_83.L_CORE 0.008468
K_2318 X_NUC_31.L_CORE X_NUC_84.L_CORE 0.002789
K_2319 X_NUC_31.L_CORE X_NUC_85.L_CORE 0.006065
K_2320 X_NUC_31.L_CORE X_NUC_86.L_CORE 0.003896
K_2321 X_NUC_31.L_CORE X_NUC_87.L_CORE 0.002836
K_2322 X_NUC_31.L_CORE X_NUC_88.L_CORE 0.008550
K_2323 X_NUC_31.L_CORE X_NUC_89.L_CORE 0.002846
K_2324 X_NUC_31.L_CORE X_NUC_90.L_CORE 0.003546
K_2325 X_NUC_31.L_CORE X_NUC_91.L_CORE 0.003791
K_2326 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.003198
K_2327 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.003202
K_2328 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.003223
K_2329 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.003174
K_2330 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.004383
K_2331 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.004301
K_2332 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.004350
K_2333 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.004315
K_2334 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.006330
K_2335 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.006471
K_2336 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.006417
K_2337 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.006296
K_2338 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.002946
K_2339 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.002930
K_2340 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.002951
K_2341 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.002914
K_2342 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.008125
K_2343 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.007894
K_2344 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.007858
K_2345 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.007869
K_2346 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.003598
K_2347 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.003617
K_2348 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.003619
K_2349 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.003565
K_2350 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.003386
K_2351 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.003349
K_2352 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.003369
K_2353 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.003335
K_2354 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.006815
K_2355 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.006873
K_2356 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.006731
K_2357 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.006669
K_2358 X_NUC_32.L_CORE X_NUC_65.L_CORE 0.003057
K_2359 X_NUC_32.L_CORE X_NUC_66.L_CORE 0.003052
K_2360 X_NUC_32.L_CORE X_NUC_67.L_CORE 0.003059
K_2361 X_NUC_32.L_CORE X_NUC_68.L_CORE 0.003020
K_2362 X_NUC_32.L_CORE X_NUC_69.L_CORE 0.004372
K_2363 X_NUC_32.L_CORE X_NUC_70.L_CORE 0.004319
K_2364 X_NUC_32.L_CORE X_NUC_71.L_CORE 0.004314
K_2365 X_NUC_32.L_CORE X_NUC_72.L_CORE 0.004284
K_2366 X_NUC_32.L_CORE X_NUC_73.L_CORE 0.004042
K_2367 X_NUC_32.L_CORE X_NUC_74.L_CORE 0.004055
K_2368 X_NUC_32.L_CORE X_NUC_75.L_CORE 0.004031
K_2369 X_NUC_32.L_CORE X_NUC_76.L_CORE 0.003983
K_2370 X_NUC_32.L_CORE X_NUC_77.L_CORE 0.003402
K_2371 X_NUC_32.L_CORE X_NUC_78.L_CORE 0.003385
K_2372 X_NUC_32.L_CORE X_NUC_79.L_CORE 0.003384
K_2373 X_NUC_32.L_CORE X_NUC_80.L_CORE 0.003349
K_2374 X_NUC_32.L_CORE X_NUC_81.L_CORE 0.003848
K_2375 X_NUC_32.L_CORE X_NUC_82.L_CORE 0.003781
K_2376 X_NUC_32.L_CORE X_NUC_83.L_CORE 0.008617
K_2377 X_NUC_32.L_CORE X_NUC_84.L_CORE 0.002825
K_2378 X_NUC_32.L_CORE X_NUC_85.L_CORE 0.006060
K_2379 X_NUC_32.L_CORE X_NUC_86.L_CORE 0.003955
K_2380 X_NUC_32.L_CORE X_NUC_87.L_CORE 0.002865
K_2381 X_NUC_32.L_CORE X_NUC_88.L_CORE 0.008487
K_2382 X_NUC_32.L_CORE X_NUC_89.L_CORE 0.002882
K_2383 X_NUC_32.L_CORE X_NUC_90.L_CORE 0.003569
K_2384 X_NUC_32.L_CORE X_NUC_91.L_CORE 0.003826
K_2385 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_2386 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_2387 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_2388 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.003126
K_2389 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.003092
K_2390 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.003091
K_2391 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.003123
K_2392 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.004272
K_2393 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.004305
K_2394 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.004239
K_2395 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.004319
K_2396 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.006269
K_2397 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.006095
K_2398 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.006136
K_2399 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.006140
K_2400 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.002914
K_2401 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.002900
K_2402 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.002882
K_2403 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.002920
K_2404 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.007875
K_2405 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.008024
K_2406 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.007727
K_2407 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.007881
K_2408 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.003600
K_2409 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.003551
K_2410 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.003545
K_2411 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.003573
K_2412 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.003390
K_2413 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.003392
K_2414 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.003350
K_2415 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.003400
K_2416 X_NUC_33.L_CORE X_NUC_65.L_CORE 0.006551
K_2417 X_NUC_33.L_CORE X_NUC_66.L_CORE 0.006467
K_2418 X_NUC_33.L_CORE X_NUC_67.L_CORE 0.006366
K_2419 X_NUC_33.L_CORE X_NUC_68.L_CORE 0.006396
K_2420 X_NUC_33.L_CORE X_NUC_69.L_CORE 0.003129
K_2421 X_NUC_33.L_CORE X_NUC_70.L_CORE 0.003106
K_2422 X_NUC_33.L_CORE X_NUC_71.L_CORE 0.003085
K_2423 X_NUC_33.L_CORE X_NUC_72.L_CORE 0.003118
K_2424 X_NUC_33.L_CORE X_NUC_73.L_CORE 0.004306
K_2425 X_NUC_33.L_CORE X_NUC_74.L_CORE 0.004312
K_2426 X_NUC_33.L_CORE X_NUC_75.L_CORE 0.004234
K_2427 X_NUC_33.L_CORE X_NUC_76.L_CORE 0.004291
K_2428 X_NUC_33.L_CORE X_NUC_77.L_CORE 0.004001
K_2429 X_NUC_33.L_CORE X_NUC_78.L_CORE 0.003966
K_2430 X_NUC_33.L_CORE X_NUC_79.L_CORE 0.003926
K_2431 X_NUC_33.L_CORE X_NUC_80.L_CORE 0.003961
K_2432 X_NUC_33.L_CORE X_NUC_81.L_CORE 0.005435
K_2433 X_NUC_33.L_CORE X_NUC_82.L_CORE 0.003413
K_2434 X_NUC_33.L_CORE X_NUC_83.L_CORE 0.003541
K_2435 X_NUC_33.L_CORE X_NUC_84.L_CORE 0.008758
K_2436 X_NUC_33.L_CORE X_NUC_85.L_CORE 0.002702
K_2437 X_NUC_33.L_CORE X_NUC_86.L_CORE 0.005941
K_2438 X_NUC_33.L_CORE X_NUC_87.L_CORE 0.003825
K_2439 X_NUC_33.L_CORE X_NUC_88.L_CORE 0.002854
K_2440 X_NUC_33.L_CORE X_NUC_89.L_CORE 0.007228
K_2441 X_NUC_33.L_CORE X_NUC_90.L_CORE 0.002946
K_2442 X_NUC_33.L_CORE X_NUC_91.L_CORE 0.003565
K_2443 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_2444 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_2445 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.003160
K_2446 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.003126
K_2447 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.003124
K_2448 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.003157
K_2449 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.004238
K_2450 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.004272
K_2451 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.004206
K_2452 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.004285
K_2453 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.006452
K_2454 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.006269
K_2455 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.006310
K_2456 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.006315
K_2457 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.002927
K_2458 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.002914
K_2459 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.002896
K_2460 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.002933
K_2461 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.007723
K_2462 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.007875
K_2463 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.007588
K_2464 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.007734
K_2465 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.003651
K_2466 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.003600
K_2467 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.003594
K_2468 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.003623
K_2469 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.003386
K_2470 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.003390
K_2471 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.003347
K_2472 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.003397
K_2473 X_NUC_34.L_CORE X_NUC_65.L_CORE 0.006631
K_2474 X_NUC_34.L_CORE X_NUC_66.L_CORE 0.006551
K_2475 X_NUC_34.L_CORE X_NUC_67.L_CORE 0.006443
K_2476 X_NUC_34.L_CORE X_NUC_68.L_CORE 0.006474
K_2477 X_NUC_34.L_CORE X_NUC_69.L_CORE 0.003152
K_2478 X_NUC_34.L_CORE X_NUC_70.L_CORE 0.003129
K_2479 X_NUC_34.L_CORE X_NUC_71.L_CORE 0.003107
K_2480 X_NUC_34.L_CORE X_NUC_72.L_CORE 0.003141
K_2481 X_NUC_34.L_CORE X_NUC_73.L_CORE 0.004297
K_2482 X_NUC_34.L_CORE X_NUC_74.L_CORE 0.004306
K_2483 X_NUC_34.L_CORE X_NUC_75.L_CORE 0.004227
K_2484 X_NUC_34.L_CORE X_NUC_76.L_CORE 0.004284
K_2485 X_NUC_34.L_CORE X_NUC_77.L_CORE 0.004035
K_2486 X_NUC_34.L_CORE X_NUC_78.L_CORE 0.004001
K_2487 X_NUC_34.L_CORE X_NUC_79.L_CORE 0.003959
K_2488 X_NUC_34.L_CORE X_NUC_80.L_CORE 0.003994
K_2489 X_NUC_34.L_CORE X_NUC_81.L_CORE 0.005444
K_2490 X_NUC_34.L_CORE X_NUC_82.L_CORE 0.003454
K_2491 X_NUC_34.L_CORE X_NUC_83.L_CORE 0.003529
K_2492 X_NUC_34.L_CORE X_NUC_84.L_CORE 0.009087
K_2493 X_NUC_34.L_CORE X_NUC_85.L_CORE 0.002720
K_2494 X_NUC_34.L_CORE X_NUC_86.L_CORE 0.005817
K_2495 X_NUC_34.L_CORE X_NUC_87.L_CORE 0.003893
K_2496 X_NUC_34.L_CORE X_NUC_88.L_CORE 0.002855
K_2497 X_NUC_34.L_CORE X_NUC_89.L_CORE 0.007228
K_2498 X_NUC_34.L_CORE X_NUC_90.L_CORE 0.002971
K_2499 X_NUC_34.L_CORE X_NUC_91.L_CORE 0.003563
K_2500 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_2501 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.003161
K_2502 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.003126
K_2503 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.003126
K_2504 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.003158
K_2505 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.004304
K_2506 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.004338
K_2507 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.004272
K_2508 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.004353
K_2509 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.006405
K_2510 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.006223
K_2511 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.006269
K_2512 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.006270
K_2513 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.002945
K_2514 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.002931
K_2515 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.002914
K_2516 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.002952
K_2517 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.008021
K_2518 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.008185
K_2519 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.007875
K_2520 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.008033
K_2521 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.003657
K_2522 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.003606
K_2523 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.003600
K_2524 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.003629
K_2525 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.003430
K_2526 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.003433
K_2527 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.003390
K_2528 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.003441
K_2529 X_NUC_35.L_CORE X_NUC_65.L_CORE 0.006745
K_2530 X_NUC_35.L_CORE X_NUC_66.L_CORE 0.006657
K_2531 X_NUC_35.L_CORE X_NUC_67.L_CORE 0.006551
K_2532 X_NUC_35.L_CORE X_NUC_68.L_CORE 0.006580
K_2533 X_NUC_35.L_CORE X_NUC_69.L_CORE 0.003174
K_2534 X_NUC_35.L_CORE X_NUC_70.L_CORE 0.003151
K_2535 X_NUC_35.L_CORE X_NUC_71.L_CORE 0.003129
K_2536 X_NUC_35.L_CORE X_NUC_72.L_CORE 0.003163
K_2537 X_NUC_35.L_CORE X_NUC_73.L_CORE 0.004379
K_2538 X_NUC_35.L_CORE X_NUC_74.L_CORE 0.004387
K_2539 X_NUC_35.L_CORE X_NUC_75.L_CORE 0.004306
K_2540 X_NUC_35.L_CORE X_NUC_76.L_CORE 0.004365
K_2541 X_NUC_35.L_CORE X_NUC_77.L_CORE 0.004079
K_2542 X_NUC_35.L_CORE X_NUC_78.L_CORE 0.004043
K_2543 X_NUC_35.L_CORE X_NUC_79.L_CORE 0.004001
K_2544 X_NUC_35.L_CORE X_NUC_80.L_CORE 0.004037
K_2545 X_NUC_35.L_CORE X_NUC_81.L_CORE 0.005390
K_2546 X_NUC_35.L_CORE X_NUC_82.L_CORE 0.003432
K_2547 X_NUC_35.L_CORE X_NUC_83.L_CORE 0.003550
K_2548 X_NUC_35.L_CORE X_NUC_84.L_CORE 0.008751
K_2549 X_NUC_35.L_CORE X_NUC_85.L_CORE 0.002725
K_2550 X_NUC_35.L_CORE X_NUC_86.L_CORE 0.005951
K_2551 X_NUC_35.L_CORE X_NUC_87.L_CORE 0.003879
K_2552 X_NUC_35.L_CORE X_NUC_88.L_CORE 0.002882
K_2553 X_NUC_35.L_CORE X_NUC_89.L_CORE 0.007410
K_2554 X_NUC_35.L_CORE X_NUC_90.L_CORE 0.002987
K_2555 X_NUC_35.L_CORE X_NUC_91.L_CORE 0.003617
K_2556 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.003128
K_2557 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.003094
K_2558 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.003093
K_2559 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.003126
K_2560 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.004224
K_2561 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.004257
K_2562 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.004193
K_2563 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.004272
K_2564 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.006401
K_2565 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.006219
K_2566 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.006262
K_2567 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.006269
K_2568 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.002907
K_2569 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.002894
K_2570 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.002876
K_2571 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.002914
K_2572 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.007858
K_2573 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.008012
K_2574 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.007716
K_2575 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.007875
K_2576 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.003627
K_2577 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.003577
K_2578 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.003572
K_2579 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.003600
K_2580 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.003379
K_2581 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.003382
K_2582 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.003340
K_2583 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.003390
K_2584 X_NUC_36.L_CORE X_NUC_65.L_CORE 0.006710
K_2585 X_NUC_36.L_CORE X_NUC_66.L_CORE 0.006623
K_2586 X_NUC_36.L_CORE X_NUC_67.L_CORE 0.006515
K_2587 X_NUC_36.L_CORE X_NUC_68.L_CORE 0.006551
K_2588 X_NUC_36.L_CORE X_NUC_69.L_CORE 0.003139
K_2589 X_NUC_36.L_CORE X_NUC_70.L_CORE 0.003116
K_2590 X_NUC_36.L_CORE X_NUC_71.L_CORE 0.003095
K_2591 X_NUC_36.L_CORE X_NUC_72.L_CORE 0.003129
K_2592 X_NUC_36.L_CORE X_NUC_73.L_CORE 0.004318
K_2593 X_NUC_36.L_CORE X_NUC_74.L_CORE 0.004326
K_2594 X_NUC_36.L_CORE X_NUC_75.L_CORE 0.004247
K_2595 X_NUC_36.L_CORE X_NUC_76.L_CORE 0.004306
K_2596 X_NUC_36.L_CORE X_NUC_77.L_CORE 0.004041
K_2597 X_NUC_36.L_CORE X_NUC_78.L_CORE 0.004006
K_2598 X_NUC_36.L_CORE X_NUC_79.L_CORE 0.003964
K_2599 X_NUC_36.L_CORE X_NUC_80.L_CORE 0.004001
K_2600 X_NUC_36.L_CORE X_NUC_81.L_CORE 0.005320
K_2601 X_NUC_36.L_CORE X_NUC_82.L_CORE 0.003401
K_2602 X_NUC_36.L_CORE X_NUC_83.L_CORE 0.003495
K_2603 X_NUC_36.L_CORE X_NUC_84.L_CORE 0.008859
K_2604 X_NUC_36.L_CORE X_NUC_85.L_CORE 0.002695
K_2605 X_NUC_36.L_CORE X_NUC_86.L_CORE 0.005842
K_2606 X_NUC_36.L_CORE X_NUC_87.L_CORE 0.003863
K_2607 X_NUC_36.L_CORE X_NUC_88.L_CORE 0.002844
K_2608 X_NUC_36.L_CORE X_NUC_89.L_CORE 0.007410
K_2609 X_NUC_36.L_CORE X_NUC_90.L_CORE 0.002961
K_2610 X_NUC_36.L_CORE X_NUC_91.L_CORE 0.003576
K_2611 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_2612 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_2613 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_2614 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.003110
K_2615 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.003157
K_2616 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.003132
K_2617 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.003131
K_2618 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.004272
K_2619 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.004301
K_2620 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.004318
K_2621 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.004237
K_2622 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.006296
K_2623 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.006437
K_2624 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.006262
K_2625 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.006377
K_2626 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.002945
K_2627 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.002981
K_2628 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.002966
K_2629 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.002947
K_2630 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.007891
K_2631 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.007903
K_2632 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.007860
K_2633 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.007652
K_2634 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.003676
K_2635 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.003736
K_2636 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.003682
K_2637 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.003693
K_2638 X_NUC_37.L_CORE X_NUC_65.L_CORE 0.003487
K_2639 X_NUC_37.L_CORE X_NUC_66.L_CORE 0.003522
K_2640 X_NUC_37.L_CORE X_NUC_67.L_CORE 0.003507
K_2641 X_NUC_37.L_CORE X_NUC_68.L_CORE 0.003467
K_2642 X_NUC_37.L_CORE X_NUC_69.L_CORE 0.006349
K_2643 X_NUC_37.L_CORE X_NUC_70.L_CORE 0.006441
K_2644 X_NUC_37.L_CORE X_NUC_71.L_CORE 0.006267
K_2645 X_NUC_37.L_CORE X_NUC_72.L_CORE 0.006281
K_2646 X_NUC_37.L_CORE X_NUC_73.L_CORE 0.003316
K_2647 X_NUC_37.L_CORE X_NUC_74.L_CORE 0.003360
K_2648 X_NUC_37.L_CORE X_NUC_75.L_CORE 0.003324
K_2649 X_NUC_37.L_CORE X_NUC_76.L_CORE 0.003312
K_2650 X_NUC_37.L_CORE X_NUC_77.L_CORE 0.004285
K_2651 X_NUC_37.L_CORE X_NUC_78.L_CORE 0.004330
K_2652 X_NUC_37.L_CORE X_NUC_79.L_CORE 0.004280
K_2653 X_NUC_37.L_CORE X_NUC_80.L_CORE 0.004242
K_2654 X_NUC_37.L_CORE X_NUC_81.L_CORE 0.003278
K_2655 X_NUC_37.L_CORE X_NUC_82.L_CORE 0.006627
K_2656 X_NUC_37.L_CORE X_NUC_83.L_CORE 0.003255
K_2657 X_NUC_37.L_CORE X_NUC_84.L_CORE 0.003415
K_2658 X_NUC_37.L_CORE X_NUC_85.L_CORE 0.009129
K_2659 X_NUC_37.L_CORE X_NUC_86.L_CORE 0.002690
K_2660 X_NUC_37.L_CORE X_NUC_87.L_CORE 0.005774
K_2661 X_NUC_37.L_CORE X_NUC_88.L_CORE 0.003898
K_2662 X_NUC_37.L_CORE X_NUC_89.L_CORE 0.002943
K_2663 X_NUC_37.L_CORE X_NUC_90.L_CORE 0.006213
K_2664 X_NUC_37.L_CORE X_NUC_91.L_CORE 0.003242
K_2665 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_2666 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_2667 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.003064
K_2668 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.003110
K_2669 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.003085
K_2670 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.003084
K_2671 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.004241
K_2672 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.004272
K_2673 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.004288
K_2674 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.004208
K_2675 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.006158
K_2676 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.006296
K_2677 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.006129
K_2678 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.006237
K_2679 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.002909
K_2680 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.002945
K_2681 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.002930
K_2682 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.002911
K_2683 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.007868
K_2684 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.007891
K_2685 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.007843
K_2686 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.007636
K_2687 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.003618
K_2688 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.003676
K_2689 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.003624
K_2690 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.003635
K_2691 X_NUC_38.L_CORE X_NUC_65.L_CORE 0.003453
K_2692 X_NUC_38.L_CORE X_NUC_66.L_CORE 0.003487
K_2693 X_NUC_38.L_CORE X_NUC_67.L_CORE 0.003472
K_2694 X_NUC_38.L_CORE X_NUC_68.L_CORE 0.003433
K_2695 X_NUC_38.L_CORE X_NUC_69.L_CORE 0.006256
K_2696 X_NUC_38.L_CORE X_NUC_70.L_CORE 0.006349
K_2697 X_NUC_38.L_CORE X_NUC_71.L_CORE 0.006180
K_2698 X_NUC_38.L_CORE X_NUC_72.L_CORE 0.006193
K_2699 X_NUC_38.L_CORE X_NUC_73.L_CORE 0.003273
K_2700 X_NUC_38.L_CORE X_NUC_74.L_CORE 0.003316
K_2701 X_NUC_38.L_CORE X_NUC_75.L_CORE 0.003281
K_2702 X_NUC_38.L_CORE X_NUC_76.L_CORE 0.003270
K_2703 X_NUC_38.L_CORE X_NUC_77.L_CORE 0.004240
K_2704 X_NUC_38.L_CORE X_NUC_78.L_CORE 0.004285
K_2705 X_NUC_38.L_CORE X_NUC_79.L_CORE 0.004236
K_2706 X_NUC_38.L_CORE X_NUC_80.L_CORE 0.004199
K_2707 X_NUC_38.L_CORE X_NUC_81.L_CORE 0.003241
K_2708 X_NUC_38.L_CORE X_NUC_82.L_CORE 0.006599
K_2709 X_NUC_38.L_CORE X_NUC_83.L_CORE 0.003208
K_2710 X_NUC_38.L_CORE X_NUC_84.L_CORE 0.003389
K_2711 X_NUC_38.L_CORE X_NUC_85.L_CORE 0.008970
K_2712 X_NUC_38.L_CORE X_NUC_86.L_CORE 0.002657
K_2713 X_NUC_38.L_CORE X_NUC_87.L_CORE 0.005787
K_2714 X_NUC_38.L_CORE X_NUC_88.L_CORE 0.003838
K_2715 X_NUC_38.L_CORE X_NUC_89.L_CORE 0.002915
K_2716 X_NUC_38.L_CORE X_NUC_90.L_CORE 0.006178
K_2717 X_NUC_38.L_CORE X_NUC_91.L_CORE 0.003203
K_2718 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_2719 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.003088
K_2720 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.003134
K_2721 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.003110
K_2722 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.003109
K_2723 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.004225
K_2724 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.004254
K_2725 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.004272
K_2726 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.004192
K_2727 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.006324
K_2728 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.006470
K_2729 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.006296
K_2730 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.006410
K_2731 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.002923
K_2732 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.002959
K_2733 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.002945
K_2734 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.002926
K_2735 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.007912
K_2736 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.007929
K_2737 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.007891
K_2738 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.007676
K_2739 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.003669
K_2740 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.003729
K_2741 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.003676
K_2742 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.003687
K_2743 X_NUC_39.L_CORE X_NUC_65.L_CORE 0.003467
K_2744 X_NUC_39.L_CORE X_NUC_66.L_CORE 0.003502
K_2745 X_NUC_39.L_CORE X_NUC_67.L_CORE 0.003487
K_2746 X_NUC_39.L_CORE X_NUC_68.L_CORE 0.003447
K_2747 X_NUC_39.L_CORE X_NUC_69.L_CORE 0.006429
K_2748 X_NUC_39.L_CORE X_NUC_70.L_CORE 0.006527
K_2749 X_NUC_39.L_CORE X_NUC_71.L_CORE 0.006349
K_2750 X_NUC_39.L_CORE X_NUC_72.L_CORE 0.006360
K_2751 X_NUC_39.L_CORE X_NUC_73.L_CORE 0.003307
K_2752 X_NUC_39.L_CORE X_NUC_74.L_CORE 0.003351
K_2753 X_NUC_39.L_CORE X_NUC_75.L_CORE 0.003316
K_2754 X_NUC_39.L_CORE X_NUC_76.L_CORE 0.003304
K_2755 X_NUC_39.L_CORE X_NUC_77.L_CORE 0.004289
K_2756 X_NUC_39.L_CORE X_NUC_78.L_CORE 0.004335
K_2757 X_NUC_39.L_CORE X_NUC_79.L_CORE 0.004285
K_2758 X_NUC_39.L_CORE X_NUC_80.L_CORE 0.004246
K_2759 X_NUC_39.L_CORE X_NUC_81.L_CORE 0.003228
K_2760 X_NUC_39.L_CORE X_NUC_82.L_CORE 0.006441
K_2761 X_NUC_39.L_CORE X_NUC_83.L_CORE 0.003223
K_2762 X_NUC_39.L_CORE X_NUC_84.L_CORE 0.003370
K_2763 X_NUC_39.L_CORE X_NUC_85.L_CORE 0.009153
K_2764 X_NUC_39.L_CORE X_NUC_86.L_CORE 0.002669
K_2765 X_NUC_39.L_CORE X_NUC_87.L_CORE 0.005734
K_2766 X_NUC_39.L_CORE X_NUC_88.L_CORE 0.003900
K_2767 X_NUC_39.L_CORE X_NUC_89.L_CORE 0.002926
K_2768 X_NUC_39.L_CORE X_NUC_90.L_CORE 0.006318
K_2769 X_NUC_39.L_CORE X_NUC_91.L_CORE 0.003241
K_2770 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.003089
K_2771 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.003135
K_2772 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.003111
K_2773 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.003110
K_2774 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.004306
K_2775 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.004337
K_2776 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.004355
K_2777 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.004272
K_2778 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.006212
K_2779 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.006350
K_2780 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.006182
K_2781 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.006296
K_2782 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.002942
K_2783 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.002978
K_2784 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.002963
K_2785 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.002945
K_2786 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.008142
K_2787 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.008161
K_2788 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.008113
K_2789 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.007891
K_2790 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.003658
K_2791 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.003717
K_2792 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.003664
K_2793 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.003676
K_2794 X_NUC_40.L_CORE X_NUC_65.L_CORE 0.003507
K_2795 X_NUC_40.L_CORE X_NUC_66.L_CORE 0.003543
K_2796 X_NUC_40.L_CORE X_NUC_67.L_CORE 0.003528
K_2797 X_NUC_40.L_CORE X_NUC_68.L_CORE 0.003487
K_2798 X_NUC_40.L_CORE X_NUC_69.L_CORE 0.006414
K_2799 X_NUC_40.L_CORE X_NUC_70.L_CORE 0.006512
K_2800 X_NUC_40.L_CORE X_NUC_71.L_CORE 0.006333
K_2801 X_NUC_40.L_CORE X_NUC_72.L_CORE 0.006349
K_2802 X_NUC_40.L_CORE X_NUC_73.L_CORE 0.003319
K_2803 X_NUC_40.L_CORE X_NUC_74.L_CORE 0.003363
K_2804 X_NUC_40.L_CORE X_NUC_75.L_CORE 0.003327
K_2805 X_NUC_40.L_CORE X_NUC_76.L_CORE 0.003316
K_2806 X_NUC_40.L_CORE X_NUC_77.L_CORE 0.004328
K_2807 X_NUC_40.L_CORE X_NUC_78.L_CORE 0.004375
K_2808 X_NUC_40.L_CORE X_NUC_79.L_CORE 0.004324
K_2809 X_NUC_40.L_CORE X_NUC_80.L_CORE 0.004285
K_2810 X_NUC_40.L_CORE X_NUC_81.L_CORE 0.003249
K_2811 X_NUC_40.L_CORE X_NUC_82.L_CORE 0.006520
K_2812 X_NUC_40.L_CORE X_NUC_83.L_CORE 0.003216
K_2813 X_NUC_40.L_CORE X_NUC_84.L_CORE 0.003417
K_2814 X_NUC_40.L_CORE X_NUC_85.L_CORE 0.008813
K_2815 X_NUC_40.L_CORE X_NUC_86.L_CORE 0.002679
K_2816 X_NUC_40.L_CORE X_NUC_87.L_CORE 0.005891
K_2817 X_NUC_40.L_CORE X_NUC_88.L_CORE 0.003868
K_2818 X_NUC_40.L_CORE X_NUC_89.L_CORE 0.002953
K_2819 X_NUC_40.L_CORE X_NUC_90.L_CORE 0.006334
K_2820 X_NUC_40.L_CORE X_NUC_91.L_CORE 0.003247
K_2821 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_2822 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_2823 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_2824 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.003126
K_2825 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.003091
K_2826 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.003121
K_2827 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.003091
K_2828 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.004315
K_2829 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.004237
K_2830 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.004247
K_2831 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.004285
K_2832 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.006378
K_2833 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.006343
K_2834 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.006404
K_2835 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.006228
K_2836 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.003010
K_2837 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.002969
K_2838 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.002988
K_2839 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.002977
K_2840 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.007909
K_2841 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.007734
K_2842 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.007621
K_2843 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.007742
K_2844 X_NUC_41.L_CORE X_NUC_65.L_CORE 0.003799
K_2845 X_NUC_41.L_CORE X_NUC_66.L_CORE 0.003760
K_2846 X_NUC_41.L_CORE X_NUC_67.L_CORE 0.003785
K_2847 X_NUC_41.L_CORE X_NUC_68.L_CORE 0.003736
K_2848 X_NUC_41.L_CORE X_NUC_69.L_CORE 0.003642
K_2849 X_NUC_41.L_CORE X_NUC_70.L_CORE 0.003586
K_2850 X_NUC_41.L_CORE X_NUC_71.L_CORE 0.003592
K_2851 X_NUC_41.L_CORE X_NUC_72.L_CORE 0.003597
K_2852 X_NUC_41.L_CORE X_NUC_73.L_CORE 0.006024
K_2853 X_NUC_41.L_CORE X_NUC_74.L_CORE 0.005948
K_2854 X_NUC_41.L_CORE X_NUC_75.L_CORE 0.005915
K_2855 X_NUC_41.L_CORE X_NUC_76.L_CORE 0.005857
K_2856 X_NUC_41.L_CORE X_NUC_77.L_CORE 0.003681
K_2857 X_NUC_41.L_CORE X_NUC_78.L_CORE 0.003633
K_2858 X_NUC_41.L_CORE X_NUC_79.L_CORE 0.003642
K_2859 X_NUC_41.L_CORE X_NUC_80.L_CORE 0.003620
K_2860 X_NUC_41.L_CORE X_NUC_81.L_CORE 0.004027
K_2861 X_NUC_41.L_CORE X_NUC_82.L_CORE 0.002901
K_2862 X_NUC_41.L_CORE X_NUC_83.L_CORE 0.007544
K_2863 X_NUC_41.L_CORE X_NUC_84.L_CORE 0.003117
K_2864 X_NUC_41.L_CORE X_NUC_85.L_CORE 0.003321
K_2865 X_NUC_41.L_CORE X_NUC_86.L_CORE 0.009222
K_2866 X_NUC_41.L_CORE X_NUC_87.L_CORE 0.002675
K_2867 X_NUC_41.L_CORE X_NUC_88.L_CORE 0.005699
K_2868 X_NUC_41.L_CORE X_NUC_89.L_CORE 0.003930
K_2869 X_NUC_41.L_CORE X_NUC_90.L_CORE 0.003076
K_2870 X_NUC_41.L_CORE X_NUC_91.L_CORE 0.005022
K_2871 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_2872 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_2873 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.003161
K_2874 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.003126
K_2875 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.003157
K_2876 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.003126
K_2877 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.004395
K_2878 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.004315
K_2879 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.004324
K_2880 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.004365
K_2881 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.006407
K_2882 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.006378
K_2883 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.006437
K_2884 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.006258
K_2885 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.003051
K_2886 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.003010
K_2887 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.003029
K_2888 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.003018
K_2889 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.008086
K_2890 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.007909
K_2891 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.007784
K_2892 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.007913
K_2893 X_NUC_42.L_CORE X_NUC_65.L_CORE 0.003839
K_2894 X_NUC_42.L_CORE X_NUC_66.L_CORE 0.003799
K_2895 X_NUC_42.L_CORE X_NUC_67.L_CORE 0.003824
K_2896 X_NUC_42.L_CORE X_NUC_68.L_CORE 0.003775
K_2897 X_NUC_42.L_CORE X_NUC_69.L_CORE 0.003700
K_2898 X_NUC_42.L_CORE X_NUC_70.L_CORE 0.003642
K_2899 X_NUC_42.L_CORE X_NUC_71.L_CORE 0.003649
K_2900 X_NUC_42.L_CORE X_NUC_72.L_CORE 0.003653
K_2901 X_NUC_42.L_CORE X_NUC_73.L_CORE 0.006097
K_2902 X_NUC_42.L_CORE X_NUC_74.L_CORE 0.006024
K_2903 X_NUC_42.L_CORE X_NUC_75.L_CORE 0.005987
K_2904 X_NUC_42.L_CORE X_NUC_76.L_CORE 0.005927
K_2905 X_NUC_42.L_CORE X_NUC_77.L_CORE 0.003730
K_2906 X_NUC_42.L_CORE X_NUC_78.L_CORE 0.003681
K_2907 X_NUC_42.L_CORE X_NUC_79.L_CORE 0.003689
K_2908 X_NUC_42.L_CORE X_NUC_80.L_CORE 0.003667
K_2909 X_NUC_42.L_CORE X_NUC_81.L_CORE 0.004060
K_2910 X_NUC_42.L_CORE X_NUC_82.L_CORE 0.002937
K_2911 X_NUC_42.L_CORE X_NUC_83.L_CORE 0.007610
K_2912 X_NUC_42.L_CORE X_NUC_84.L_CORE 0.003145
K_2913 X_NUC_42.L_CORE X_NUC_85.L_CORE 0.003371
K_2914 X_NUC_42.L_CORE X_NUC_86.L_CORE 0.009088
K_2915 X_NUC_42.L_CORE X_NUC_87.L_CORE 0.002706
K_2916 X_NUC_42.L_CORE X_NUC_88.L_CORE 0.005795
K_2917 X_NUC_42.L_CORE X_NUC_89.L_CORE 0.003957
K_2918 X_NUC_42.L_CORE X_NUC_90.L_CORE 0.003117
K_2919 X_NUC_42.L_CORE X_NUC_91.L_CORE 0.005073
K_2920 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_2921 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.003129
K_2922 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.003094
K_2923 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.003126
K_2924 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.003095
K_2925 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.004384
K_2926 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.004303
K_2927 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.004315
K_2928 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.004354
K_2929 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.006346
K_2930 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.006314
K_2931 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.006378
K_2932 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.006201
K_2933 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.003031
K_2934 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.002990
K_2935 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.003010
K_2936 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.002998
K_2937 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.008220
K_2938 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.008029
K_2939 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.007909
K_2940 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.008039
K_2941 X_NUC_43.L_CORE X_NUC_65.L_CORE 0.003813
K_2942 X_NUC_43.L_CORE X_NUC_66.L_CORE 0.003773
K_2943 X_NUC_43.L_CORE X_NUC_67.L_CORE 0.003799
K_2944 X_NUC_43.L_CORE X_NUC_68.L_CORE 0.003750
K_2945 X_NUC_43.L_CORE X_NUC_69.L_CORE 0.003694
K_2946 X_NUC_43.L_CORE X_NUC_70.L_CORE 0.003635
K_2947 X_NUC_43.L_CORE X_NUC_71.L_CORE 0.003642
K_2948 X_NUC_43.L_CORE X_NUC_72.L_CORE 0.003646
K_2949 X_NUC_43.L_CORE X_NUC_73.L_CORE 0.006133
K_2950 X_NUC_43.L_CORE X_NUC_74.L_CORE 0.006055
K_2951 X_NUC_43.L_CORE X_NUC_75.L_CORE 0.006024
K_2952 X_NUC_43.L_CORE X_NUC_76.L_CORE 0.005960
K_2953 X_NUC_43.L_CORE X_NUC_77.L_CORE 0.003720
K_2954 X_NUC_43.L_CORE X_NUC_78.L_CORE 0.003671
K_2955 X_NUC_43.L_CORE X_NUC_79.L_CORE 0.003681
K_2956 X_NUC_43.L_CORE X_NUC_80.L_CORE 0.003658
K_2957 X_NUC_43.L_CORE X_NUC_81.L_CORE 0.003983
K_2958 X_NUC_43.L_CORE X_NUC_82.L_CORE 0.002903
K_2959 X_NUC_43.L_CORE X_NUC_83.L_CORE 0.007456
K_2960 X_NUC_43.L_CORE X_NUC_84.L_CORE 0.003104
K_2961 X_NUC_43.L_CORE X_NUC_85.L_CORE 0.003349
K_2962 X_NUC_43.L_CORE X_NUC_86.L_CORE 0.008949
K_2963 X_NUC_43.L_CORE X_NUC_87.L_CORE 0.002685
K_2964 X_NUC_43.L_CORE X_NUC_88.L_CORE 0.005846
K_2965 X_NUC_43.L_CORE X_NUC_89.L_CORE 0.003934
K_2966 X_NUC_43.L_CORE X_NUC_90.L_CORE 0.003110
K_2967 X_NUC_43.L_CORE X_NUC_91.L_CORE 0.005116
K_2968 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.003161
K_2969 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.003125
K_2970 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.003157
K_2971 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.003126
K_2972 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.004343
K_2973 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.004265
K_2974 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.004275
K_2975 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.004315
K_2976 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.006533
K_2977 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.006499
K_2978 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.006565
K_2979 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.006378
K_2980 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.003042
K_2981 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.003001
K_2982 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.003021
K_2983 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.003010
K_2984 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.008076
K_2985 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.007895
K_2986 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.007775
K_2987 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.007909
K_2988 X_NUC_44.L_CORE X_NUC_65.L_CORE 0.003864
K_2989 X_NUC_44.L_CORE X_NUC_66.L_CORE 0.003823
K_2990 X_NUC_44.L_CORE X_NUC_67.L_CORE 0.003850
K_2991 X_NUC_44.L_CORE X_NUC_68.L_CORE 0.003799
K_2992 X_NUC_44.L_CORE X_NUC_69.L_CORE 0.003689
K_2993 X_NUC_44.L_CORE X_NUC_70.L_CORE 0.003631
K_2994 X_NUC_44.L_CORE X_NUC_71.L_CORE 0.003638
K_2995 X_NUC_44.L_CORE X_NUC_72.L_CORE 0.003642
K_2996 X_NUC_44.L_CORE X_NUC_73.L_CORE 0.006199
K_2997 X_NUC_44.L_CORE X_NUC_74.L_CORE 0.006119
K_2998 X_NUC_44.L_CORE X_NUC_75.L_CORE 0.006084
K_2999 X_NUC_44.L_CORE X_NUC_76.L_CORE 0.006024
K_3000 X_NUC_44.L_CORE X_NUC_77.L_CORE 0.003744
K_3001 X_NUC_44.L_CORE X_NUC_78.L_CORE 0.003694
K_3002 X_NUC_44.L_CORE X_NUC_79.L_CORE 0.003703
K_3003 X_NUC_44.L_CORE X_NUC_80.L_CORE 0.003681
K_3004 X_NUC_44.L_CORE X_NUC_81.L_CORE 0.004019
K_3005 X_NUC_44.L_CORE X_NUC_82.L_CORE 0.002909
K_3006 X_NUC_44.L_CORE X_NUC_83.L_CORE 0.007357
K_3007 X_NUC_44.L_CORE X_NUC_84.L_CORE 0.003140
K_3008 X_NUC_44.L_CORE X_NUC_85.L_CORE 0.003331
K_3009 X_NUC_44.L_CORE X_NUC_86.L_CORE 0.009326
K_3010 X_NUC_44.L_CORE X_NUC_87.L_CORE 0.002699
K_3011 X_NUC_44.L_CORE X_NUC_88.L_CORE 0.005733
K_3012 X_NUC_44.L_CORE X_NUC_89.L_CORE 0.003997
K_3013 X_NUC_44.L_CORE X_NUC_90.L_CORE 0.003111
K_3014 X_NUC_44.L_CORE X_NUC_91.L_CORE 0.005135
K_3015 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_3016 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_3017 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_3018 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.003174
K_3019 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.003179
K_3020 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.003151
K_3021 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.003199
K_3022 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.004404
K_3023 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.004495
K_3024 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.004425
K_3025 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.004452
K_3026 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.006521
K_3027 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.006423
K_3028 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.006345
K_3029 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.006504
K_3030 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.003117
K_3031 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.003141
K_3032 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.003102
K_3033 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.003141
K_3034 X_NUC_45.L_CORE X_NUC_65.L_CORE 0.007912
K_3035 X_NUC_45.L_CORE X_NUC_66.L_CORE 0.008129
K_3036 X_NUC_45.L_CORE X_NUC_67.L_CORE 0.007844
K_3037 X_NUC_45.L_CORE X_NUC_68.L_CORE 0.007893
K_3038 X_NUC_45.L_CORE X_NUC_69.L_CORE 0.003987
K_3039 X_NUC_45.L_CORE X_NUC_70.L_CORE 0.003985
K_3040 X_NUC_45.L_CORE X_NUC_71.L_CORE 0.003930
K_3041 X_NUC_45.L_CORE X_NUC_72.L_CORE 0.003998
K_3042 X_NUC_45.L_CORE X_NUC_73.L_CORE 0.003887
K_3043 X_NUC_45.L_CORE X_NUC_74.L_CORE 0.003935
K_3044 X_NUC_45.L_CORE X_NUC_75.L_CORE 0.003865
K_3045 X_NUC_45.L_CORE X_NUC_76.L_CORE 0.003908
K_3046 X_NUC_45.L_CORE X_NUC_77.L_CORE 0.005442
K_3047 X_NUC_45.L_CORE X_NUC_78.L_CORE 0.005471
K_3048 X_NUC_45.L_CORE X_NUC_79.L_CORE 0.005339
K_3049 X_NUC_45.L_CORE X_NUC_80.L_CORE 0.005425
K_3050 X_NUC_45.L_CORE X_NUC_81.L_CORE 0.003766
K_3051 X_NUC_45.L_CORE X_NUC_82.L_CORE 0.004146
K_3052 X_NUC_45.L_CORE X_NUC_83.L_CORE 0.002785
K_3053 X_NUC_45.L_CORE X_NUC_84.L_CORE 0.008571
K_3054 X_NUC_45.L_CORE X_NUC_85.L_CORE 0.003097
K_3055 X_NUC_45.L_CORE X_NUC_86.L_CORE 0.003380
K_3056 X_NUC_45.L_CORE X_NUC_87.L_CORE 0.009087
K_3057 X_NUC_45.L_CORE X_NUC_88.L_CORE 0.002771
K_3058 X_NUC_45.L_CORE X_NUC_89.L_CORE 0.005822
K_3059 X_NUC_45.L_CORE X_NUC_90.L_CORE 0.004088
K_3060 X_NUC_45.L_CORE X_NUC_91.L_CORE 0.003482
K_3061 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_3062 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_3063 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.003168
K_3064 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.003174
K_3065 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.003146
K_3066 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.003193
K_3067 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.004318
K_3068 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.004404
K_3069 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.004338
K_3070 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.004363
K_3071 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.006617
K_3072 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.006521
K_3073 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.006436
K_3074 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.006602
K_3075 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.003092
K_3076 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.003117
K_3077 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.003078
K_3078 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.003116
K_3079 X_NUC_46.L_CORE X_NUC_65.L_CORE 0.007700
K_3080 X_NUC_46.L_CORE X_NUC_66.L_CORE 0.007912
K_3081 X_NUC_46.L_CORE X_NUC_67.L_CORE 0.007643
K_3082 X_NUC_46.L_CORE X_NUC_68.L_CORE 0.007688
K_3083 X_NUC_46.L_CORE X_NUC_69.L_CORE 0.003988
K_3084 X_NUC_46.L_CORE X_NUC_70.L_CORE 0.003987
K_3085 X_NUC_46.L_CORE X_NUC_71.L_CORE 0.003932
K_3086 X_NUC_46.L_CORE X_NUC_72.L_CORE 0.004000
K_3087 X_NUC_46.L_CORE X_NUC_73.L_CORE 0.003839
K_3088 X_NUC_46.L_CORE X_NUC_74.L_CORE 0.003887
K_3089 X_NUC_46.L_CORE X_NUC_75.L_CORE 0.003819
K_3090 X_NUC_46.L_CORE X_NUC_76.L_CORE 0.003860
K_3091 X_NUC_46.L_CORE X_NUC_77.L_CORE 0.005411
K_3092 X_NUC_46.L_CORE X_NUC_78.L_CORE 0.005442
K_3093 X_NUC_46.L_CORE X_NUC_79.L_CORE 0.005310
K_3094 X_NUC_46.L_CORE X_NUC_80.L_CORE 0.005395
K_3095 X_NUC_46.L_CORE X_NUC_81.L_CORE 0.003730
K_3096 X_NUC_46.L_CORE X_NUC_82.L_CORE 0.004167
K_3097 X_NUC_46.L_CORE X_NUC_83.L_CORE 0.002764
K_3098 X_NUC_46.L_CORE X_NUC_84.L_CORE 0.008411
K_3099 X_NUC_46.L_CORE X_NUC_85.L_CORE 0.003102
K_3100 X_NUC_46.L_CORE X_NUC_86.L_CORE 0.003329
K_3101 X_NUC_46.L_CORE X_NUC_87.L_CORE 0.009446
K_3102 X_NUC_46.L_CORE X_NUC_88.L_CORE 0.002758
K_3103 X_NUC_46.L_CORE X_NUC_89.L_CORE 0.005684
K_3104 X_NUC_46.L_CORE X_NUC_90.L_CORE 0.004104
K_3105 X_NUC_46.L_CORE X_NUC_91.L_CORE 0.003450
K_3106 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_3107 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.003197
K_3108 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.003203
K_3109 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.003174
K_3110 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.003223
K_3111 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.004383
K_3112 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.004472
K_3113 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.004404
K_3114 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.004430
K_3115 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.006706
K_3116 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.006603
K_3117 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.006521
K_3118 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.006691
K_3119 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.003131
K_3120 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.003156
K_3121 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.003117
K_3122 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.003156
K_3123 X_NUC_47.L_CORE X_NUC_65.L_CORE 0.007969
K_3124 X_NUC_47.L_CORE X_NUC_66.L_CORE 0.008198
K_3125 X_NUC_47.L_CORE X_NUC_67.L_CORE 0.007912
K_3126 X_NUC_47.L_CORE X_NUC_68.L_CORE 0.007955
K_3127 X_NUC_47.L_CORE X_NUC_69.L_CORE 0.004046
K_3128 X_NUC_47.L_CORE X_NUC_70.L_CORE 0.004044
K_3129 X_NUC_47.L_CORE X_NUC_71.L_CORE 0.003987
K_3130 X_NUC_47.L_CORE X_NUC_72.L_CORE 0.004058
K_3131 X_NUC_47.L_CORE X_NUC_73.L_CORE 0.003908
K_3132 X_NUC_47.L_CORE X_NUC_74.L_CORE 0.003958
K_3133 X_NUC_47.L_CORE X_NUC_75.L_CORE 0.003887
K_3134 X_NUC_47.L_CORE X_NUC_76.L_CORE 0.003930
K_3135 X_NUC_47.L_CORE X_NUC_77.L_CORE 0.005549
K_3136 X_NUC_47.L_CORE X_NUC_78.L_CORE 0.005581
K_3137 X_NUC_47.L_CORE X_NUC_79.L_CORE 0.005442
K_3138 X_NUC_47.L_CORE X_NUC_80.L_CORE 0.005532
K_3139 X_NUC_47.L_CORE X_NUC_81.L_CORE 0.003722
K_3140 X_NUC_47.L_CORE X_NUC_82.L_CORE 0.004141
K_3141 X_NUC_47.L_CORE X_NUC_83.L_CORE 0.002778
K_3142 X_NUC_47.L_CORE X_NUC_84.L_CORE 0.008240
K_3143 X_NUC_47.L_CORE X_NUC_85.L_CORE 0.003116
K_3144 X_NUC_47.L_CORE X_NUC_86.L_CORE 0.003361
K_3145 X_NUC_47.L_CORE X_NUC_87.L_CORE 0.009392
K_3146 X_NUC_47.L_CORE X_NUC_88.L_CORE 0.002785
K_3147 X_NUC_47.L_CORE X_NUC_89.L_CORE 0.005806
K_3148 X_NUC_47.L_CORE X_NUC_90.L_CORE 0.004160
K_3149 X_NUC_47.L_CORE X_NUC_91.L_CORE 0.003507
K_3150 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.003149
K_3151 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.003155
K_3152 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.003127
K_3153 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.003174
K_3154 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.004357
K_3155 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.004445
K_3156 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.004377
K_3157 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.004404
K_3158 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.006532
K_3159 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.006437
K_3160 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.006358
K_3161 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.006521
K_3162 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.003092
K_3163 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.003116
K_3164 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.003078
K_3165 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.003117
K_3166 X_NUC_48.L_CORE X_NUC_65.L_CORE 0.007919
K_3167 X_NUC_48.L_CORE X_NUC_66.L_CORE 0.008144
K_3168 X_NUC_48.L_CORE X_NUC_67.L_CORE 0.007858
K_3169 X_NUC_48.L_CORE X_NUC_68.L_CORE 0.007912
K_3170 X_NUC_48.L_CORE X_NUC_69.L_CORE 0.003975
K_3171 X_NUC_48.L_CORE X_NUC_70.L_CORE 0.003973
K_3172 X_NUC_48.L_CORE X_NUC_71.L_CORE 0.003919
K_3173 X_NUC_48.L_CORE X_NUC_72.L_CORE 0.003987
K_3174 X_NUC_48.L_CORE X_NUC_73.L_CORE 0.003865
K_3175 X_NUC_48.L_CORE X_NUC_74.L_CORE 0.003913
K_3176 X_NUC_48.L_CORE X_NUC_75.L_CORE 0.003845
K_3177 X_NUC_48.L_CORE X_NUC_76.L_CORE 0.003887
K_3178 X_NUC_48.L_CORE X_NUC_77.L_CORE 0.005457
K_3179 X_NUC_48.L_CORE X_NUC_78.L_CORE 0.005487
K_3180 X_NUC_48.L_CORE X_NUC_79.L_CORE 0.005354
K_3181 X_NUC_48.L_CORE X_NUC_80.L_CORE 0.005442
K_3182 X_NUC_48.L_CORE X_NUC_81.L_CORE 0.003700
K_3183 X_NUC_48.L_CORE X_NUC_82.L_CORE 0.004088
K_3184 X_NUC_48.L_CORE X_NUC_83.L_CORE 0.002752
K_3185 X_NUC_48.L_CORE X_NUC_84.L_CORE 0.008340
K_3186 X_NUC_48.L_CORE X_NUC_85.L_CORE 0.003071
K_3187 X_NUC_48.L_CORE X_NUC_86.L_CORE 0.003341
K_3188 X_NUC_48.L_CORE X_NUC_87.L_CORE 0.009194
K_3189 X_NUC_48.L_CORE X_NUC_88.L_CORE 0.002751
K_3190 X_NUC_48.L_CORE X_NUC_89.L_CORE 0.005809
K_3191 X_NUC_48.L_CORE X_NUC_90.L_CORE 0.004091
K_3192 X_NUC_48.L_CORE X_NUC_91.L_CORE 0.003470
K_3193 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_3194 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_3195 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_3196 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.003260
K_3197 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.003290
K_3198 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.003294
K_3199 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.003252
K_3200 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.004550
K_3201 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.004501
K_3202 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.004556
K_3203 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.004473
K_3204 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.006736
K_3205 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.006933
K_3206 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.006811
K_3207 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.006740
K_3208 X_NUC_49.L_CORE X_NUC_65.L_CORE 0.003280
K_3209 X_NUC_49.L_CORE X_NUC_66.L_CORE 0.003289
K_3210 X_NUC_49.L_CORE X_NUC_67.L_CORE 0.003301
K_3211 X_NUC_49.L_CORE X_NUC_68.L_CORE 0.003252
K_3212 X_NUC_49.L_CORE X_NUC_69.L_CORE 0.007860
K_3213 X_NUC_49.L_CORE X_NUC_70.L_CORE 0.007760
K_3214 X_NUC_49.L_CORE X_NUC_71.L_CORE 0.007764
K_3215 X_NUC_49.L_CORE X_NUC_72.L_CORE 0.007581
K_3216 X_NUC_49.L_CORE X_NUC_73.L_CORE 0.004275
K_3217 X_NUC_49.L_CORE X_NUC_74.L_CORE 0.004325
K_3218 X_NUC_49.L_CORE X_NUC_75.L_CORE 0.004302
K_3219 X_NUC_49.L_CORE X_NUC_76.L_CORE 0.004242
K_3220 X_NUC_49.L_CORE X_NUC_77.L_CORE 0.004317
K_3221 X_NUC_49.L_CORE X_NUC_78.L_CORE 0.004318
K_3222 X_NUC_49.L_CORE X_NUC_79.L_CORE 0.004322
K_3223 X_NUC_49.L_CORE X_NUC_80.L_CORE 0.004247
K_3224 X_NUC_49.L_CORE X_NUC_81.L_CORE 0.003014
K_3225 X_NUC_49.L_CORE X_NUC_82.L_CORE 0.003790
K_3226 X_NUC_49.L_CORE X_NUC_83.L_CORE 0.004261
K_3227 X_NUC_49.L_CORE X_NUC_84.L_CORE 0.002719
K_3228 X_NUC_49.L_CORE X_NUC_85.L_CORE 0.009284
K_3229 X_NUC_49.L_CORE X_NUC_86.L_CORE 0.003148
K_3230 X_NUC_49.L_CORE X_NUC_87.L_CORE 0.003416
K_3231 X_NUC_49.L_CORE X_NUC_88.L_CORE 0.009561
K_3232 X_NUC_49.L_CORE X_NUC_89.L_CORE 0.002922
K_3233 X_NUC_49.L_CORE X_NUC_90.L_CORE 0.005707
K_3234 X_NUC_49.L_CORE X_NUC_91.L_CORE 0.004365
K_3235 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_3236 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_3237 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.003231
K_3238 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.003260
K_3239 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.003264
K_3240 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.003223
K_3241 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.004599
K_3242 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.004550
K_3243 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.004606
K_3244 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.004520
K_3245 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.006548
K_3246 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.006736
K_3247 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.006620
K_3248 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.006555
K_3249 X_NUC_50.L_CORE X_NUC_65.L_CORE 0.003271
K_3250 X_NUC_50.L_CORE X_NUC_66.L_CORE 0.003280
K_3251 X_NUC_50.L_CORE X_NUC_67.L_CORE 0.003292
K_3252 X_NUC_50.L_CORE X_NUC_68.L_CORE 0.003243
K_3253 X_NUC_50.L_CORE X_NUC_69.L_CORE 0.007951
K_3254 X_NUC_50.L_CORE X_NUC_70.L_CORE 0.007860
K_3255 X_NUC_50.L_CORE X_NUC_71.L_CORE 0.007858
K_3256 X_NUC_50.L_CORE X_NUC_72.L_CORE 0.007668
K_3257 X_NUC_50.L_CORE X_NUC_73.L_CORE 0.004224
K_3258 X_NUC_50.L_CORE X_NUC_74.L_CORE 0.004275
K_3259 X_NUC_50.L_CORE X_NUC_75.L_CORE 0.004252
K_3260 X_NUC_50.L_CORE X_NUC_76.L_CORE 0.004193
K_3261 X_NUC_50.L_CORE X_NUC_77.L_CORE 0.004315
K_3262 X_NUC_50.L_CORE X_NUC_78.L_CORE 0.004317
K_3263 X_NUC_50.L_CORE X_NUC_79.L_CORE 0.004321
K_3264 X_NUC_50.L_CORE X_NUC_80.L_CORE 0.004246
K_3265 X_NUC_50.L_CORE X_NUC_81.L_CORE 0.003001
K_3266 X_NUC_50.L_CORE X_NUC_82.L_CORE 0.003816
K_3267 X_NUC_50.L_CORE X_NUC_83.L_CORE 0.004197
K_3268 X_NUC_50.L_CORE X_NUC_84.L_CORE 0.002717
K_3269 X_NUC_50.L_CORE X_NUC_85.L_CORE 0.009572
K_3270 X_NUC_50.L_CORE X_NUC_86.L_CORE 0.003112
K_3271 X_NUC_50.L_CORE X_NUC_87.L_CORE 0.003441
K_3272 X_NUC_50.L_CORE X_NUC_88.L_CORE 0.009167
K_3273 X_NUC_50.L_CORE X_NUC_89.L_CORE 0.002909
K_3274 X_NUC_50.L_CORE X_NUC_90.L_CORE 0.005786
K_3275 X_NUC_50.L_CORE X_NUC_91.L_CORE 0.004317
K_3276 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_3277 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.003227
K_3278 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.003256
K_3279 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.003260
K_3280 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.003219
K_3281 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.004542
K_3282 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.004494
K_3283 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.004550
K_3284 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.004466
K_3285 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.006657
K_3286 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.006850
K_3287 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.006736
K_3288 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.006664
K_3289 X_NUC_51.L_CORE X_NUC_65.L_CORE 0.003259
K_3290 X_NUC_51.L_CORE X_NUC_66.L_CORE 0.003268
K_3291 X_NUC_51.L_CORE X_NUC_67.L_CORE 0.003280
K_3292 X_NUC_51.L_CORE X_NUC_68.L_CORE 0.003232
K_3293 X_NUC_51.L_CORE X_NUC_69.L_CORE 0.007947
K_3294 X_NUC_51.L_CORE X_NUC_70.L_CORE 0.007850
K_3295 X_NUC_51.L_CORE X_NUC_71.L_CORE 0.007860
K_3296 X_NUC_51.L_CORE X_NUC_72.L_CORE 0.007665
K_3297 X_NUC_51.L_CORE X_NUC_73.L_CORE 0.004246
K_3298 X_NUC_51.L_CORE X_NUC_74.L_CORE 0.004296
K_3299 X_NUC_51.L_CORE X_NUC_75.L_CORE 0.004275
K_3300 X_NUC_51.L_CORE X_NUC_76.L_CORE 0.004214
K_3301 X_NUC_51.L_CORE X_NUC_77.L_CORE 0.004311
K_3302 X_NUC_51.L_CORE X_NUC_78.L_CORE 0.004312
K_3303 X_NUC_51.L_CORE X_NUC_79.L_CORE 0.004317
K_3304 X_NUC_51.L_CORE X_NUC_80.L_CORE 0.004242
K_3305 X_NUC_51.L_CORE X_NUC_81.L_CORE 0.002972
K_3306 X_NUC_51.L_CORE X_NUC_82.L_CORE 0.003748
K_3307 X_NUC_51.L_CORE X_NUC_83.L_CORE 0.004180
K_3308 X_NUC_51.L_CORE X_NUC_84.L_CORE 0.002694
K_3309 X_NUC_51.L_CORE X_NUC_85.L_CORE 0.009209
K_3310 X_NUC_51.L_CORE X_NUC_86.L_CORE 0.003110
K_3311 X_NUC_51.L_CORE X_NUC_87.L_CORE 0.003402
K_3312 X_NUC_51.L_CORE X_NUC_88.L_CORE 0.009483
K_3313 X_NUC_51.L_CORE X_NUC_89.L_CORE 0.002903
K_3314 X_NUC_51.L_CORE X_NUC_90.L_CORE 0.005764
K_3315 X_NUC_51.L_CORE X_NUC_91.L_CORE 0.004354
K_3316 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.003268
K_3317 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.003298
K_3318 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.003302
K_3319 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.003260
K_3320 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.004629
K_3321 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.004578
K_3322 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.004637
K_3323 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.004550
K_3324 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.006725
K_3325 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.006925
K_3326 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.006803
K_3327 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.006736
K_3328 X_NUC_52.L_CORE X_NUC_65.L_CORE 0.003309
K_3329 X_NUC_52.L_CORE X_NUC_66.L_CORE 0.003318
K_3330 X_NUC_52.L_CORE X_NUC_67.L_CORE 0.003331
K_3331 X_NUC_52.L_CORE X_NUC_68.L_CORE 0.003280
K_3332 X_NUC_52.L_CORE X_NUC_69.L_CORE 0.008158
K_3333 X_NUC_52.L_CORE X_NUC_70.L_CORE 0.008054
K_3334 X_NUC_52.L_CORE X_NUC_71.L_CORE 0.008057
K_3335 X_NUC_52.L_CORE X_NUC_72.L_CORE 0.007860
K_3336 X_NUC_52.L_CORE X_NUC_73.L_CORE 0.004307
K_3337 X_NUC_52.L_CORE X_NUC_74.L_CORE 0.004359
K_3338 X_NUC_52.L_CORE X_NUC_75.L_CORE 0.004336
K_3339 X_NUC_52.L_CORE X_NUC_76.L_CORE 0.004275
K_3340 X_NUC_52.L_CORE X_NUC_77.L_CORE 0.004389
K_3341 X_NUC_52.L_CORE X_NUC_78.L_CORE 0.004390
K_3342 X_NUC_52.L_CORE X_NUC_79.L_CORE 0.004395
K_3343 X_NUC_52.L_CORE X_NUC_80.L_CORE 0.004317
K_3344 X_NUC_52.L_CORE X_NUC_81.L_CORE 0.003001
K_3345 X_NUC_52.L_CORE X_NUC_82.L_CORE 0.003788
K_3346 X_NUC_52.L_CORE X_NUC_83.L_CORE 0.004199
K_3347 X_NUC_52.L_CORE X_NUC_84.L_CORE 0.002727
K_3348 X_NUC_52.L_CORE X_NUC_85.L_CORE 0.009201
K_3349 X_NUC_52.L_CORE X_NUC_86.L_CORE 0.003140
K_3350 X_NUC_52.L_CORE X_NUC_87.L_CORE 0.003453
K_3351 X_NUC_52.L_CORE X_NUC_88.L_CORE 0.009406
K_3352 X_NUC_52.L_CORE X_NUC_89.L_CORE 0.002940
K_3353 X_NUC_52.L_CORE X_NUC_90.L_CORE 0.005866
K_3354 X_NUC_52.L_CORE X_NUC_91.L_CORE 0.004407
K_3355 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_3356 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_3357 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_3358 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.003394
K_3359 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.003341
K_3360 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.003359
K_3361 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.003370
K_3362 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.004769
K_3363 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.004743
K_3364 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.004692
K_3365 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.004795
K_3366 X_NUC_53.L_CORE X_NUC_65.L_CORE 0.007038
K_3367 X_NUC_53.L_CORE X_NUC_66.L_CORE 0.006834
K_3368 X_NUC_53.L_CORE X_NUC_67.L_CORE 0.006908
K_3369 X_NUC_53.L_CORE X_NUC_68.L_CORE 0.006840
K_3370 X_NUC_53.L_CORE X_NUC_69.L_CORE 0.003532
K_3371 X_NUC_53.L_CORE X_NUC_70.L_CORE 0.003486
K_3372 X_NUC_53.L_CORE X_NUC_71.L_CORE 0.003481
K_3373 X_NUC_53.L_CORE X_NUC_72.L_CORE 0.003515
K_3374 X_NUC_53.L_CORE X_NUC_73.L_CORE 0.007665
K_3375 X_NUC_53.L_CORE X_NUC_74.L_CORE 0.007564
K_3376 X_NUC_53.L_CORE X_NUC_75.L_CORE 0.007399
K_3377 X_NUC_53.L_CORE X_NUC_76.L_CORE 0.007574
K_3378 X_NUC_53.L_CORE X_NUC_77.L_CORE 0.004755
K_3379 X_NUC_53.L_CORE X_NUC_78.L_CORE 0.004666
K_3380 X_NUC_53.L_CORE X_NUC_79.L_CORE 0.004660
K_3381 X_NUC_53.L_CORE X_NUC_80.L_CORE 0.004685
K_3382 X_NUC_53.L_CORE X_NUC_81.L_CORE 0.003889
K_3383 X_NUC_53.L_CORE X_NUC_82.L_CORE 0.002791
K_3384 X_NUC_53.L_CORE X_NUC_83.L_CORE 0.003853
K_3385 X_NUC_53.L_CORE X_NUC_84.L_CORE 0.004291
K_3386 X_NUC_53.L_CORE X_NUC_85.L_CORE 0.002712
K_3387 X_NUC_53.L_CORE X_NUC_86.L_CORE 0.010628
K_3388 X_NUC_53.L_CORE X_NUC_87.L_CORE 0.003200
K_3389 X_NUC_53.L_CORE X_NUC_88.L_CORE 0.003572
K_3390 X_NUC_53.L_CORE X_NUC_89.L_CORE 0.009246
K_3391 X_NUC_53.L_CORE X_NUC_90.L_CORE 0.003177
K_3392 X_NUC_53.L_CORE X_NUC_91.L_CORE 0.005525
K_3393 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_3394 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_3395 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.003449
K_3396 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.003394
K_3397 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.003413
K_3398 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.003424
K_3399 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.004793
K_3400 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.004769
K_3401 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.004716
K_3402 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.004821
K_3403 X_NUC_54.L_CORE X_NUC_65.L_CORE 0.007253
K_3404 X_NUC_54.L_CORE X_NUC_66.L_CORE 0.007038
K_3405 X_NUC_54.L_CORE X_NUC_67.L_CORE 0.007115
K_3406 X_NUC_54.L_CORE X_NUC_68.L_CORE 0.007041
K_3407 X_NUC_54.L_CORE X_NUC_69.L_CORE 0.003579
K_3408 X_NUC_54.L_CORE X_NUC_70.L_CORE 0.003532
K_3409 X_NUC_54.L_CORE X_NUC_71.L_CORE 0.003527
K_3410 X_NUC_54.L_CORE X_NUC_72.L_CORE 0.003562
K_3411 X_NUC_54.L_CORE X_NUC_73.L_CORE 0.007759
K_3412 X_NUC_54.L_CORE X_NUC_74.L_CORE 0.007665
K_3413 X_NUC_54.L_CORE X_NUC_75.L_CORE 0.007489
K_3414 X_NUC_54.L_CORE X_NUC_76.L_CORE 0.007670
K_3415 X_NUC_54.L_CORE X_NUC_77.L_CORE 0.004847
K_3416 X_NUC_54.L_CORE X_NUC_78.L_CORE 0.004755
K_3417 X_NUC_54.L_CORE X_NUC_79.L_CORE 0.004748
K_3418 X_NUC_54.L_CORE X_NUC_80.L_CORE 0.004775
K_3419 X_NUC_54.L_CORE X_NUC_81.L_CORE 0.003911
K_3420 X_NUC_54.L_CORE X_NUC_82.L_CORE 0.002820
K_3421 X_NUC_54.L_CORE X_NUC_83.L_CORE 0.003855
K_3422 X_NUC_54.L_CORE X_NUC_84.L_CORE 0.004353
K_3423 X_NUC_54.L_CORE X_NUC_85.L_CORE 0.002736
K_3424 X_NUC_54.L_CORE X_NUC_86.L_CORE 0.010287
K_3425 X_NUC_54.L_CORE X_NUC_87.L_CORE 0.003250
K_3426 X_NUC_54.L_CORE X_NUC_88.L_CORE 0.003590
K_3427 X_NUC_54.L_CORE X_NUC_89.L_CORE 0.009501
K_3428 X_NUC_54.L_CORE X_NUC_90.L_CORE 0.003219
K_3429 X_NUC_54.L_CORE X_NUC_91.L_CORE 0.005571
K_3430 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_3431 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.003429
K_3432 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.003375
K_3433 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.003394
K_3434 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.003405
K_3435 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.004847
K_3436 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.004821
K_3437 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.004769
K_3438 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.004876
K_3439 X_NUC_55.L_CORE X_NUC_65.L_CORE 0.007167
K_3440 X_NUC_55.L_CORE X_NUC_66.L_CORE 0.006955
K_3441 X_NUC_55.L_CORE X_NUC_67.L_CORE 0.007038
K_3442 X_NUC_55.L_CORE X_NUC_68.L_CORE 0.006962
K_3443 X_NUC_55.L_CORE X_NUC_69.L_CORE 0.003583
K_3444 X_NUC_55.L_CORE X_NUC_70.L_CORE 0.003536
K_3445 X_NUC_55.L_CORE X_NUC_71.L_CORE 0.003532
K_3446 X_NUC_55.L_CORE X_NUC_72.L_CORE 0.003567
K_3447 X_NUC_55.L_CORE X_NUC_73.L_CORE 0.007950
K_3448 X_NUC_55.L_CORE X_NUC_74.L_CORE 0.007843
K_3449 X_NUC_55.L_CORE X_NUC_75.L_CORE 0.007665
K_3450 X_NUC_55.L_CORE X_NUC_76.L_CORE 0.007854
K_3451 X_NUC_55.L_CORE X_NUC_77.L_CORE 0.004853
K_3452 X_NUC_55.L_CORE X_NUC_78.L_CORE 0.004759
K_3453 X_NUC_55.L_CORE X_NUC_79.L_CORE 0.004755
K_3454 X_NUC_55.L_CORE X_NUC_80.L_CORE 0.004780
K_3455 X_NUC_55.L_CORE X_NUC_81.L_CORE 0.003855
K_3456 X_NUC_55.L_CORE X_NUC_82.L_CORE 0.002795
K_3457 X_NUC_55.L_CORE X_NUC_83.L_CORE 0.003848
K_3458 X_NUC_55.L_CORE X_NUC_84.L_CORE 0.004266
K_3459 X_NUC_55.L_CORE X_NUC_85.L_CORE 0.002730
K_3460 X_NUC_55.L_CORE X_NUC_86.L_CORE 0.010339
K_3461 X_NUC_55.L_CORE X_NUC_87.L_CORE 0.003221
K_3462 X_NUC_55.L_CORE X_NUC_88.L_CORE 0.003613
K_3463 X_NUC_55.L_CORE X_NUC_89.L_CORE 0.009379
K_3464 X_NUC_55.L_CORE X_NUC_90.L_CORE 0.003219
K_3465 X_NUC_55.L_CORE X_NUC_91.L_CORE 0.005671
K_3466 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.003417
K_3467 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.003363
K_3468 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.003382
K_3469 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.003394
K_3470 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.004741
K_3471 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.004716
K_3472 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.004666
K_3473 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.004769
K_3474 X_NUC_56.L_CORE X_NUC_65.L_CORE 0.007245
K_3475 X_NUC_56.L_CORE X_NUC_66.L_CORE 0.007027
K_3476 X_NUC_56.L_CORE X_NUC_67.L_CORE 0.007108
K_3477 X_NUC_56.L_CORE X_NUC_68.L_CORE 0.007038
K_3478 X_NUC_56.L_CORE X_NUC_69.L_CORE 0.003548
K_3479 X_NUC_56.L_CORE X_NUC_70.L_CORE 0.003501
K_3480 X_NUC_56.L_CORE X_NUC_71.L_CORE 0.003497
K_3481 X_NUC_56.L_CORE X_NUC_72.L_CORE 0.003532
K_3482 X_NUC_56.L_CORE X_NUC_73.L_CORE 0.007748
K_3483 X_NUC_56.L_CORE X_NUC_74.L_CORE 0.007649
K_3484 X_NUC_56.L_CORE X_NUC_75.L_CORE 0.007479
K_3485 X_NUC_56.L_CORE X_NUC_76.L_CORE 0.007665
K_3486 X_NUC_56.L_CORE X_NUC_77.L_CORE 0.004826
K_3487 X_NUC_56.L_CORE X_NUC_78.L_CORE 0.004733
K_3488 X_NUC_56.L_CORE X_NUC_79.L_CORE 0.004728
K_3489 X_NUC_56.L_CORE X_NUC_80.L_CORE 0.004755
K_3490 X_NUC_56.L_CORE X_NUC_81.L_CORE 0.003848
K_3491 X_NUC_56.L_CORE X_NUC_82.L_CORE 0.002785
K_3492 X_NUC_56.L_CORE X_NUC_83.L_CORE 0.003795
K_3493 X_NUC_56.L_CORE X_NUC_84.L_CORE 0.004305
K_3494 X_NUC_56.L_CORE X_NUC_85.L_CORE 0.002705
K_3495 X_NUC_56.L_CORE X_NUC_86.L_CORE 0.010118
K_3496 X_NUC_56.L_CORE X_NUC_87.L_CORE 0.003223
K_3497 X_NUC_56.L_CORE X_NUC_88.L_CORE 0.003554
K_3498 X_NUC_56.L_CORE X_NUC_89.L_CORE 0.009658
K_3499 X_NUC_56.L_CORE X_NUC_90.L_CORE 0.003196
K_3500 X_NUC_56.L_CORE X_NUC_91.L_CORE 0.005572
K_3501 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.207973
K_3502 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.207973
K_3503 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.207973
K_3504 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.003593
K_3505 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.003647
K_3506 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.003600
K_3507 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.003632
K_3508 X_NUC_57.L_CORE X_NUC_65.L_CORE 0.005093
K_3509 X_NUC_57.L_CORE X_NUC_66.L_CORE 0.005198
K_3510 X_NUC_57.L_CORE X_NUC_67.L_CORE 0.005162
K_3511 X_NUC_57.L_CORE X_NUC_68.L_CORE 0.005094
K_3512 X_NUC_57.L_CORE X_NUC_69.L_CORE 0.007447
K_3513 X_NUC_57.L_CORE X_NUC_70.L_CORE 0.007580
K_3514 X_NUC_57.L_CORE X_NUC_71.L_CORE 0.007337
K_3515 X_NUC_57.L_CORE X_NUC_72.L_CORE 0.007542
K_3516 X_NUC_57.L_CORE X_NUC_73.L_CORE 0.003944
K_3517 X_NUC_57.L_CORE X_NUC_74.L_CORE 0.004017
K_3518 X_NUC_57.L_CORE X_NUC_75.L_CORE 0.003961
K_3519 X_NUC_57.L_CORE X_NUC_76.L_CORE 0.003969
K_3520 X_NUC_57.L_CORE X_NUC_77.L_CORE 0.007060
K_3521 X_NUC_57.L_CORE X_NUC_78.L_CORE 0.007253
K_3522 X_NUC_57.L_CORE X_NUC_79.L_CORE 0.007056
K_3523 X_NUC_57.L_CORE X_NUC_80.L_CORE 0.007040
K_3524 X_NUC_57.L_CORE X_NUC_81.L_CORE 0.002979
K_3525 X_NUC_57.L_CORE X_NUC_82.L_CORE 0.004421
K_3526 X_NUC_57.L_CORE X_NUC_83.L_CORE 0.002757
K_3527 X_NUC_57.L_CORE X_NUC_84.L_CORE 0.003956
K_3528 X_NUC_57.L_CORE X_NUC_85.L_CORE 0.004469
K_3529 X_NUC_57.L_CORE X_NUC_86.L_CORE 0.002808
K_3530 X_NUC_57.L_CORE X_NUC_87.L_CORE 0.011589
K_3531 X_NUC_57.L_CORE X_NUC_88.L_CORE 0.003423
K_3532 X_NUC_57.L_CORE X_NUC_89.L_CORE 0.003879
K_3533 X_NUC_57.L_CORE X_NUC_90.L_CORE 0.009141
K_3534 X_NUC_57.L_CORE X_NUC_91.L_CORE 0.003856
K_3535 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.207973
K_3536 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.207973
K_3537 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.003540
K_3538 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.003593
K_3539 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.003548
K_3540 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.003578
K_3541 X_NUC_58.L_CORE X_NUC_65.L_CORE 0.004991
K_3542 X_NUC_58.L_CORE X_NUC_66.L_CORE 0.005093
K_3543 X_NUC_58.L_CORE X_NUC_67.L_CORE 0.005057
K_3544 X_NUC_58.L_CORE X_NUC_68.L_CORE 0.004994
K_3545 X_NUC_58.L_CORE X_NUC_69.L_CORE 0.007311
K_3546 X_NUC_58.L_CORE X_NUC_70.L_CORE 0.007447
K_3547 X_NUC_58.L_CORE X_NUC_71.L_CORE 0.007211
K_3548 X_NUC_58.L_CORE X_NUC_72.L_CORE 0.007406
K_3549 X_NUC_58.L_CORE X_NUC_73.L_CORE 0.003874
K_3550 X_NUC_58.L_CORE X_NUC_74.L_CORE 0.003944
K_3551 X_NUC_58.L_CORE X_NUC_75.L_CORE 0.003890
K_3552 X_NUC_58.L_CORE X_NUC_76.L_CORE 0.003898
K_3553 X_NUC_58.L_CORE X_NUC_77.L_CORE 0.006874
K_3554 X_NUC_58.L_CORE X_NUC_78.L_CORE 0.007060
K_3555 X_NUC_58.L_CORE X_NUC_79.L_CORE 0.006874
K_3556 X_NUC_58.L_CORE X_NUC_80.L_CORE 0.006859
K_3557 X_NUC_58.L_CORE X_NUC_81.L_CORE 0.002952
K_3558 X_NUC_58.L_CORE X_NUC_82.L_CORE 0.004416
K_3559 X_NUC_58.L_CORE X_NUC_83.L_CORE 0.002729
K_3560 X_NUC_58.L_CORE X_NUC_84.L_CORE 0.003919
K_3561 X_NUC_58.L_CORE X_NUC_85.L_CORE 0.004453
K_3562 X_NUC_58.L_CORE X_NUC_86.L_CORE 0.002771
K_3563 X_NUC_58.L_CORE X_NUC_87.L_CORE 0.011752
K_3564 X_NUC_58.L_CORE X_NUC_88.L_CORE 0.003383
K_3565 X_NUC_58.L_CORE X_NUC_89.L_CORE 0.003818
K_3566 X_NUC_58.L_CORE X_NUC_90.L_CORE 0.009057
K_3567 X_NUC_58.L_CORE X_NUC_91.L_CORE 0.003794
K_3568 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.207973
K_3569 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.003584
K_3570 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.003638
K_3571 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.003593
K_3572 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.003624
K_3573 X_NUC_59.L_CORE X_NUC_65.L_CORE 0.005023
K_3574 X_NUC_59.L_CORE X_NUC_66.L_CORE 0.005126
K_3575 X_NUC_59.L_CORE X_NUC_67.L_CORE 0.005093
K_3576 X_NUC_59.L_CORE X_NUC_68.L_CORE 0.005026
K_3577 X_NUC_59.L_CORE X_NUC_69.L_CORE 0.007553
K_3578 X_NUC_59.L_CORE X_NUC_70.L_CORE 0.007697
K_3579 X_NUC_59.L_CORE X_NUC_71.L_CORE 0.007447
K_3580 X_NUC_59.L_CORE X_NUC_72.L_CORE 0.007657
K_3581 X_NUC_59.L_CORE X_NUC_73.L_CORE 0.003926
K_3582 X_NUC_59.L_CORE X_NUC_74.L_CORE 0.003998
K_3583 X_NUC_59.L_CORE X_NUC_75.L_CORE 0.003944
K_3584 X_NUC_59.L_CORE X_NUC_76.L_CORE 0.003951
K_3585 X_NUC_59.L_CORE X_NUC_77.L_CORE 0.007056
K_3586 X_NUC_59.L_CORE X_NUC_78.L_CORE 0.007254
K_3587 X_NUC_59.L_CORE X_NUC_79.L_CORE 0.007060
K_3588 X_NUC_59.L_CORE X_NUC_80.L_CORE 0.007040
K_3589 X_NUC_59.L_CORE X_NUC_81.L_CORE 0.002940
K_3590 X_NUC_59.L_CORE X_NUC_82.L_CORE 0.004361
K_3591 X_NUC_59.L_CORE X_NUC_83.L_CORE 0.002737
K_3592 X_NUC_59.L_CORE X_NUC_84.L_CORE 0.003884
K_3593 X_NUC_59.L_CORE X_NUC_85.L_CORE 0.004467
K_3594 X_NUC_59.L_CORE X_NUC_86.L_CORE 0.002783
K_3595 X_NUC_59.L_CORE X_NUC_87.L_CORE 0.011200
K_3596 X_NUC_59.L_CORE X_NUC_88.L_CORE 0.003422
K_3597 X_NUC_59.L_CORE X_NUC_89.L_CORE 0.003837
K_3598 X_NUC_59.L_CORE X_NUC_90.L_CORE 0.009441
K_3599 X_NUC_59.L_CORE X_NUC_91.L_CORE 0.003853
K_3600 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.003553
K_3601 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.003606
K_3602 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.003561
K_3603 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.003593
K_3604 X_NUC_60.L_CORE X_NUC_65.L_CORE 0.005088
K_3605 X_NUC_60.L_CORE X_NUC_66.L_CORE 0.005194
K_3606 X_NUC_60.L_CORE X_NUC_67.L_CORE 0.005158
K_3607 X_NUC_60.L_CORE X_NUC_68.L_CORE 0.005093
K_3608 X_NUC_60.L_CORE X_NUC_69.L_CORE 0.007347
K_3609 X_NUC_60.L_CORE X_NUC_70.L_CORE 0.007480
K_3610 X_NUC_60.L_CORE X_NUC_71.L_CORE 0.007245
K_3611 X_NUC_60.L_CORE X_NUC_72.L_CORE 0.007447
K_3612 X_NUC_60.L_CORE X_NUC_73.L_CORE 0.003918
K_3613 X_NUC_60.L_CORE X_NUC_74.L_CORE 0.003990
K_3614 X_NUC_60.L_CORE X_NUC_75.L_CORE 0.003935
K_3615 X_NUC_60.L_CORE X_NUC_76.L_CORE 0.003944
K_3616 X_NUC_60.L_CORE X_NUC_77.L_CORE 0.007073
K_3617 X_NUC_60.L_CORE X_NUC_78.L_CORE 0.007272
K_3618 X_NUC_60.L_CORE X_NUC_79.L_CORE 0.007073
K_3619 X_NUC_60.L_CORE X_NUC_80.L_CORE 0.007060
K_3620 X_NUC_60.L_CORE X_NUC_81.L_CORE 0.002944
K_3621 X_NUC_60.L_CORE X_NUC_82.L_CORE 0.004348
K_3622 X_NUC_60.L_CORE X_NUC_83.L_CORE 0.002723
K_3623 X_NUC_60.L_CORE X_NUC_84.L_CORE 0.003930
K_3624 X_NUC_60.L_CORE X_NUC_85.L_CORE 0.004387
K_3625 X_NUC_60.L_CORE X_NUC_86.L_CORE 0.002784
K_3626 X_NUC_60.L_CORE X_NUC_87.L_CORE 0.011730
K_3627 X_NUC_60.L_CORE X_NUC_88.L_CORE 0.003383
K_3628 X_NUC_60.L_CORE X_NUC_89.L_CORE 0.003873
K_3629 X_NUC_60.L_CORE X_NUC_90.L_CORE 0.009133
K_3630 X_NUC_60.L_CORE X_NUC_91.L_CORE 0.003838
K_3631 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.207973
K_3632 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.207973
K_3633 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.207973
K_3634 X_NUC_61.L_CORE X_NUC_65.L_CORE 0.003891
K_3635 X_NUC_61.L_CORE X_NUC_66.L_CORE 0.003868
K_3636 X_NUC_61.L_CORE X_NUC_67.L_CORE 0.003910
K_3637 X_NUC_61.L_CORE X_NUC_68.L_CORE 0.003842
K_3638 X_NUC_61.L_CORE X_NUC_69.L_CORE 0.005584
K_3639 X_NUC_61.L_CORE X_NUC_70.L_CORE 0.005443
K_3640 X_NUC_61.L_CORE X_NUC_71.L_CORE 0.005506
K_3641 X_NUC_61.L_CORE X_NUC_72.L_CORE 0.005477
K_3642 X_NUC_61.L_CORE X_NUC_73.L_CORE 0.007967
K_3643 X_NUC_61.L_CORE X_NUC_74.L_CORE 0.007969
K_3644 X_NUC_61.L_CORE X_NUC_75.L_CORE 0.008015
K_3645 X_NUC_61.L_CORE X_NUC_76.L_CORE 0.007747
K_3646 X_NUC_61.L_CORE X_NUC_77.L_CORE 0.004785
K_3647 X_NUC_61.L_CORE X_NUC_78.L_CORE 0.004718
K_3648 X_NUC_61.L_CORE X_NUC_79.L_CORE 0.004764
K_3649 X_NUC_61.L_CORE X_NUC_80.L_CORE 0.004687
K_3650 X_NUC_61.L_CORE X_NUC_81.L_CORE 0.003038
K_3651 X_NUC_61.L_CORE X_NUC_82.L_CORE 0.002859
K_3652 X_NUC_61.L_CORE X_NUC_83.L_CORE 0.004811
K_3653 X_NUC_61.L_CORE X_NUC_84.L_CORE 0.002751
K_3654 X_NUC_61.L_CORE X_NUC_85.L_CORE 0.004039
K_3655 X_NUC_61.L_CORE X_NUC_86.L_CORE 0.004696
K_3656 X_NUC_61.L_CORE X_NUC_87.L_CORE 0.002908
K_3657 X_NUC_61.L_CORE X_NUC_88.L_CORE 0.013052
K_3658 X_NUC_61.L_CORE X_NUC_89.L_CORE 0.003709
K_3659 X_NUC_61.L_CORE X_NUC_90.L_CORE 0.004279
K_3660 X_NUC_61.L_CORE X_NUC_91.L_CORE 0.007968
K_3661 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.207973
K_3662 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.207973
K_3663 X_NUC_62.L_CORE X_NUC_65.L_CORE 0.003912
K_3664 X_NUC_62.L_CORE X_NUC_66.L_CORE 0.003891
K_3665 X_NUC_62.L_CORE X_NUC_67.L_CORE 0.003933
K_3666 X_NUC_62.L_CORE X_NUC_68.L_CORE 0.003863
K_3667 X_NUC_62.L_CORE X_NUC_69.L_CORE 0.005731
K_3668 X_NUC_62.L_CORE X_NUC_70.L_CORE 0.005584
K_3669 X_NUC_62.L_CORE X_NUC_71.L_CORE 0.005650
K_3670 X_NUC_62.L_CORE X_NUC_72.L_CORE 0.005618
K_3671 X_NUC_62.L_CORE X_NUC_73.L_CORE 0.007954
K_3672 X_NUC_62.L_CORE X_NUC_74.L_CORE 0.007967
K_3673 X_NUC_62.L_CORE X_NUC_75.L_CORE 0.008008
K_3674 X_NUC_62.L_CORE X_NUC_76.L_CORE 0.007740
K_3675 X_NUC_62.L_CORE X_NUC_77.L_CORE 0.004852
K_3676 X_NUC_62.L_CORE X_NUC_78.L_CORE 0.004785
K_3677 X_NUC_62.L_CORE X_NUC_79.L_CORE 0.004832
K_3678 X_NUC_62.L_CORE X_NUC_80.L_CORE 0.004752
K_3679 X_NUC_62.L_CORE X_NUC_81.L_CORE 0.003042
K_3680 X_NUC_62.L_CORE X_NUC_82.L_CORE 0.002885
K_3681 X_NUC_62.L_CORE X_NUC_83.L_CORE 0.004788
K_3682 X_NUC_62.L_CORE X_NUC_84.L_CORE 0.002763
K_3683 X_NUC_62.L_CORE X_NUC_85.L_CORE 0.004105
K_3684 X_NUC_62.L_CORE X_NUC_86.L_CORE 0.004642
K_3685 X_NUC_62.L_CORE X_NUC_87.L_CORE 0.002940
K_3686 X_NUC_62.L_CORE X_NUC_88.L_CORE 0.013395
K_3687 X_NUC_62.L_CORE X_NUC_89.L_CORE 0.003713
K_3688 X_NUC_62.L_CORE X_NUC_90.L_CORE 0.004363
K_3689 X_NUC_62.L_CORE X_NUC_91.L_CORE 0.007989
K_3690 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.207973
K_3691 X_NUC_63.L_CORE X_NUC_65.L_CORE 0.003870
K_3692 X_NUC_63.L_CORE X_NUC_66.L_CORE 0.003849
K_3693 X_NUC_63.L_CORE X_NUC_67.L_CORE 0.003891
K_3694 X_NUC_63.L_CORE X_NUC_68.L_CORE 0.003823
K_3695 X_NUC_63.L_CORE X_NUC_69.L_CORE 0.005660
K_3696 X_NUC_63.L_CORE X_NUC_70.L_CORE 0.005516
K_3697 X_NUC_63.L_CORE X_NUC_71.L_CORE 0.005584
K_3698 X_NUC_63.L_CORE X_NUC_72.L_CORE 0.005551
K_3699 X_NUC_63.L_CORE X_NUC_73.L_CORE 0.007909
K_3700 X_NUC_63.L_CORE X_NUC_74.L_CORE 0.007916
K_3701 X_NUC_63.L_CORE X_NUC_75.L_CORE 0.007967
K_3702 X_NUC_63.L_CORE X_NUC_76.L_CORE 0.007698
K_3703 X_NUC_63.L_CORE X_NUC_77.L_CORE 0.004803
K_3704 X_NUC_63.L_CORE X_NUC_78.L_CORE 0.004737
K_3705 X_NUC_63.L_CORE X_NUC_79.L_CORE 0.004785
K_3706 X_NUC_63.L_CORE X_NUC_80.L_CORE 0.004706
K_3707 X_NUC_63.L_CORE X_NUC_81.L_CORE 0.003002
K_3708 X_NUC_63.L_CORE X_NUC_82.L_CORE 0.002846
K_3709 X_NUC_63.L_CORE X_NUC_83.L_CORE 0.004723
K_3710 X_NUC_63.L_CORE X_NUC_84.L_CORE 0.002730
K_3711 X_NUC_63.L_CORE X_NUC_85.L_CORE 0.004049
K_3712 X_NUC_63.L_CORE X_NUC_86.L_CORE 0.004599
K_3713 X_NUC_63.L_CORE X_NUC_87.L_CORE 0.002906
K_3714 X_NUC_63.L_CORE X_NUC_88.L_CORE 0.013428
K_3715 X_NUC_63.L_CORE X_NUC_89.L_CORE 0.003681
K_3716 X_NUC_63.L_CORE X_NUC_90.L_CORE 0.004323
K_3717 X_NUC_63.L_CORE X_NUC_91.L_CORE 0.008030
K_3718 X_NUC_64.L_CORE X_NUC_65.L_CORE 0.003940
K_3719 X_NUC_64.L_CORE X_NUC_66.L_CORE 0.003918
K_3720 X_NUC_64.L_CORE X_NUC_67.L_CORE 0.003961
K_3721 X_NUC_64.L_CORE X_NUC_68.L_CORE 0.003891
K_3722 X_NUC_64.L_CORE X_NUC_69.L_CORE 0.005692
K_3723 X_NUC_64.L_CORE X_NUC_70.L_CORE 0.005546
K_3724 X_NUC_64.L_CORE X_NUC_71.L_CORE 0.005613
K_3725 X_NUC_64.L_CORE X_NUC_72.L_CORE 0.005584
K_3726 X_NUC_64.L_CORE X_NUC_73.L_CORE 0.008195
K_3727 X_NUC_64.L_CORE X_NUC_74.L_CORE 0.008203
K_3728 X_NUC_64.L_CORE X_NUC_75.L_CORE 0.008254
K_3729 X_NUC_64.L_CORE X_NUC_76.L_CORE 0.007967
K_3730 X_NUC_64.L_CORE X_NUC_77.L_CORE 0.004885
K_3731 X_NUC_64.L_CORE X_NUC_78.L_CORE 0.004815
K_3732 X_NUC_64.L_CORE X_NUC_79.L_CORE 0.004865
K_3733 X_NUC_64.L_CORE X_NUC_80.L_CORE 0.004785
K_3734 X_NUC_64.L_CORE X_NUC_81.L_CORE 0.003025
K_3735 X_NUC_64.L_CORE X_NUC_82.L_CORE 0.002858
K_3736 X_NUC_64.L_CORE X_NUC_83.L_CORE 0.004725
K_3737 X_NUC_64.L_CORE X_NUC_84.L_CORE 0.002760
K_3738 X_NUC_64.L_CORE X_NUC_85.L_CORE 0.004034
K_3739 X_NUC_64.L_CORE X_NUC_86.L_CORE 0.004675
K_3740 X_NUC_64.L_CORE X_NUC_87.L_CORE 0.002932
K_3741 X_NUC_64.L_CORE X_NUC_88.L_CORE 0.012717
K_3742 X_NUC_64.L_CORE X_NUC_89.L_CORE 0.003747
K_3743 X_NUC_64.L_CORE X_NUC_90.L_CORE 0.004347
K_3744 X_NUC_64.L_CORE X_NUC_91.L_CORE 0.008251
K_3745 X_NUC_65.L_CORE X_NUC_66.L_CORE 0.207973
K_3746 X_NUC_65.L_CORE X_NUC_67.L_CORE 0.207973
K_3747 X_NUC_65.L_CORE X_NUC_68.L_CORE 0.207973
K_3748 X_NUC_65.L_CORE X_NUC_69.L_CORE 0.004363
K_3749 X_NUC_65.L_CORE X_NUC_70.L_CORE 0.004324
K_3750 X_NUC_65.L_CORE X_NUC_71.L_CORE 0.004298
K_3751 X_NUC_65.L_CORE X_NUC_72.L_CORE 0.004380
K_3752 X_NUC_65.L_CORE X_NUC_73.L_CORE 0.006384
K_3753 X_NUC_65.L_CORE X_NUC_74.L_CORE 0.006483
K_3754 X_NUC_65.L_CORE X_NUC_75.L_CORE 0.006319
K_3755 X_NUC_65.L_CORE X_NUC_76.L_CORE 0.006484
K_3756 X_NUC_65.L_CORE X_NUC_77.L_CORE 0.008402
K_3757 X_NUC_65.L_CORE X_NUC_78.L_CORE 0.008254
K_3758 X_NUC_65.L_CORE X_NUC_79.L_CORE 0.008101
K_3759 X_NUC_65.L_CORE X_NUC_80.L_CORE 0.008353
K_3760 X_NUC_65.L_CORE X_NUC_81.L_CORE 0.003259
K_3761 X_NUC_65.L_CORE X_NUC_82.L_CORE 0.003034
K_3762 X_NUC_65.L_CORE X_NUC_83.L_CORE 0.002885
K_3763 X_NUC_65.L_CORE X_NUC_84.L_CORE 0.005086
K_3764 X_NUC_65.L_CORE X_NUC_85.L_CORE 0.002832
K_3765 X_NUC_65.L_CORE X_NUC_86.L_CORE 0.004312
K_3766 X_NUC_65.L_CORE X_NUC_87.L_CORE 0.004929
K_3767 X_NUC_65.L_CORE X_NUC_88.L_CORE 0.003164
K_3768 X_NUC_65.L_CORE X_NUC_89.L_CORE 0.015905
K_3769 X_NUC_65.L_CORE X_NUC_90.L_CORE 0.004244
K_3770 X_NUC_65.L_CORE X_NUC_91.L_CORE 0.005324
K_3771 X_NUC_66.L_CORE X_NUC_67.L_CORE 0.207973
K_3772 X_NUC_66.L_CORE X_NUC_68.L_CORE 0.207973
K_3773 X_NUC_66.L_CORE X_NUC_69.L_CORE 0.004400
K_3774 X_NUC_66.L_CORE X_NUC_70.L_CORE 0.004363
K_3775 X_NUC_66.L_CORE X_NUC_71.L_CORE 0.004335
K_3776 X_NUC_66.L_CORE X_NUC_72.L_CORE 0.004419
K_3777 X_NUC_66.L_CORE X_NUC_73.L_CORE 0.006283
K_3778 X_NUC_66.L_CORE X_NUC_74.L_CORE 0.006384
K_3779 X_NUC_66.L_CORE X_NUC_75.L_CORE 0.006225
K_3780 X_NUC_66.L_CORE X_NUC_76.L_CORE 0.006382
K_3781 X_NUC_66.L_CORE X_NUC_77.L_CORE 0.008544
K_3782 X_NUC_66.L_CORE X_NUC_78.L_CORE 0.008402
K_3783 X_NUC_66.L_CORE X_NUC_79.L_CORE 0.008234
K_3784 X_NUC_66.L_CORE X_NUC_80.L_CORE 0.008500
K_3785 X_NUC_66.L_CORE X_NUC_81.L_CORE 0.003250
K_3786 X_NUC_66.L_CORE X_NUC_82.L_CORE 0.003054
K_3787 X_NUC_66.L_CORE X_NUC_83.L_CORE 0.002871
K_3788 X_NUC_66.L_CORE X_NUC_84.L_CORE 0.005109
K_3789 X_NUC_66.L_CORE X_NUC_85.L_CORE 0.002846
K_3790 X_NUC_66.L_CORE X_NUC_86.L_CORE 0.004242
K_3791 X_NUC_66.L_CORE X_NUC_87.L_CORE 0.005039
K_3792 X_NUC_66.L_CORE X_NUC_88.L_CORE 0.003157
K_3793 X_NUC_66.L_CORE X_NUC_89.L_CORE 0.014848
K_3794 X_NUC_66.L_CORE X_NUC_90.L_CORE 0.004297
K_3795 X_NUC_66.L_CORE X_NUC_91.L_CORE 0.005276
K_3796 X_NUC_67.L_CORE X_NUC_68.L_CORE 0.207973
K_3797 X_NUC_67.L_CORE X_NUC_69.L_CORE 0.004429
K_3798 X_NUC_67.L_CORE X_NUC_70.L_CORE 0.004390
K_3799 X_NUC_67.L_CORE X_NUC_71.L_CORE 0.004363
K_3800 X_NUC_67.L_CORE X_NUC_72.L_CORE 0.004447
K_3801 X_NUC_67.L_CORE X_NUC_73.L_CORE 0.006444
K_3802 X_NUC_67.L_CORE X_NUC_74.L_CORE 0.006549
K_3803 X_NUC_67.L_CORE X_NUC_75.L_CORE 0.006384
K_3804 X_NUC_67.L_CORE X_NUC_76.L_CORE 0.006550
K_3805 X_NUC_67.L_CORE X_NUC_77.L_CORE 0.008724
K_3806 X_NUC_67.L_CORE X_NUC_78.L_CORE 0.008566
K_3807 X_NUC_67.L_CORE X_NUC_79.L_CORE 0.008402
K_3808 X_NUC_67.L_CORE X_NUC_80.L_CORE 0.008677
K_3809 X_NUC_67.L_CORE X_NUC_81.L_CORE 0.003226
K_3810 X_NUC_67.L_CORE X_NUC_82.L_CORE 0.003029
K_3811 X_NUC_67.L_CORE X_NUC_83.L_CORE 0.002874
K_3812 X_NUC_67.L_CORE X_NUC_84.L_CORE 0.004999
K_3813 X_NUC_67.L_CORE X_NUC_85.L_CORE 0.002844
K_3814 X_NUC_67.L_CORE X_NUC_86.L_CORE 0.004263
K_3815 X_NUC_67.L_CORE X_NUC_87.L_CORE 0.004961
K_3816 X_NUC_67.L_CORE X_NUC_88.L_CORE 0.003180
K_3817 X_NUC_67.L_CORE X_NUC_89.L_CORE 0.015131
K_3818 X_NUC_67.L_CORE X_NUC_90.L_CORE 0.004315
K_3819 X_NUC_67.L_CORE X_NUC_91.L_CORE 0.005396
K_3820 X_NUC_68.L_CORE X_NUC_69.L_CORE 0.004344
K_3821 X_NUC_68.L_CORE X_NUC_70.L_CORE 0.004307
K_3822 X_NUC_68.L_CORE X_NUC_71.L_CORE 0.004281
K_3823 X_NUC_68.L_CORE X_NUC_72.L_CORE 0.004363
K_3824 X_NUC_68.L_CORE X_NUC_73.L_CORE 0.006282
K_3825 X_NUC_68.L_CORE X_NUC_74.L_CORE 0.006380
K_3826 X_NUC_68.L_CORE X_NUC_75.L_CORE 0.006224
K_3827 X_NUC_68.L_CORE X_NUC_76.L_CORE 0.006384
K_3828 X_NUC_68.L_CORE X_NUC_77.L_CORE 0.008438
K_3829 X_NUC_68.L_CORE X_NUC_78.L_CORE 0.008294
K_3830 X_NUC_68.L_CORE X_NUC_79.L_CORE 0.008139
K_3831 X_NUC_68.L_CORE X_NUC_80.L_CORE 0.008402
K_3832 X_NUC_68.L_CORE X_NUC_81.L_CORE 0.003215
K_3833 X_NUC_68.L_CORE X_NUC_82.L_CORE 0.003011
K_3834 X_NUC_68.L_CORE X_NUC_83.L_CORE 0.002847
K_3835 X_NUC_68.L_CORE X_NUC_84.L_CORE 0.005033
K_3836 X_NUC_68.L_CORE X_NUC_85.L_CORE 0.002812
K_3837 X_NUC_68.L_CORE X_NUC_86.L_CORE 0.004231
K_3838 X_NUC_68.L_CORE X_NUC_87.L_CORE 0.004943
K_3839 X_NUC_68.L_CORE X_NUC_88.L_CORE 0.003133
K_3840 X_NUC_68.L_CORE X_NUC_89.L_CORE 0.015543
K_3841 X_NUC_68.L_CORE X_NUC_90.L_CORE 0.004246
K_3842 X_NUC_68.L_CORE X_NUC_91.L_CORE 0.005280
K_3843 X_NUC_69.L_CORE X_NUC_70.L_CORE 0.207973
K_3844 X_NUC_69.L_CORE X_NUC_71.L_CORE 0.207973
K_3845 X_NUC_69.L_CORE X_NUC_72.L_CORE 0.207973
K_3846 X_NUC_69.L_CORE X_NUC_73.L_CORE 0.005209
K_3847 X_NUC_69.L_CORE X_NUC_74.L_CORE 0.005331
K_3848 X_NUC_69.L_CORE X_NUC_75.L_CORE 0.005287
K_3849 X_NUC_69.L_CORE X_NUC_76.L_CORE 0.005233
K_3850 X_NUC_69.L_CORE X_NUC_77.L_CORE 0.007899
K_3851 X_NUC_69.L_CORE X_NUC_78.L_CORE 0.007999
K_3852 X_NUC_69.L_CORE X_NUC_79.L_CORE 0.008025
K_3853 X_NUC_69.L_CORE X_NUC_80.L_CORE 0.007757
K_3854 X_NUC_69.L_CORE X_NUC_81.L_CORE 0.002709
K_3855 X_NUC_69.L_CORE X_NUC_82.L_CORE 0.003446
K_3856 X_NUC_69.L_CORE X_NUC_83.L_CORE 0.003119
K_3857 X_NUC_69.L_CORE X_NUC_84.L_CORE 0.002963
K_3858 X_NUC_69.L_CORE X_NUC_85.L_CORE 0.005298
K_3859 X_NUC_69.L_CORE X_NUC_86.L_CORE 0.003025
K_3860 X_NUC_69.L_CORE X_NUC_87.L_CORE 0.004568
K_3861 X_NUC_69.L_CORE X_NUC_88.L_CORE 0.005528
K_3862 X_NUC_69.L_CORE X_NUC_89.L_CORE 0.003594
K_3863 X_NUC_69.L_CORE X_NUC_90.L_CORE 0.017700
K_3864 X_NUC_69.L_CORE X_NUC_91.L_CORE 0.005632
K_3865 X_NUC_70.L_CORE X_NUC_71.L_CORE 0.207973
K_3866 X_NUC_70.L_CORE X_NUC_72.L_CORE 0.207973
K_3867 X_NUC_70.L_CORE X_NUC_73.L_CORE 0.005093
K_3868 X_NUC_70.L_CORE X_NUC_74.L_CORE 0.005209
K_3869 X_NUC_70.L_CORE X_NUC_75.L_CORE 0.005167
K_3870 X_NUC_70.L_CORE X_NUC_76.L_CORE 0.005116
K_3871 X_NUC_70.L_CORE X_NUC_77.L_CORE 0.007791
K_3872 X_NUC_70.L_CORE X_NUC_78.L_CORE 0.007899
K_3873 X_NUC_70.L_CORE X_NUC_79.L_CORE 0.007917
K_3874 X_NUC_70.L_CORE X_NUC_80.L_CORE 0.007660
K_3875 X_NUC_70.L_CORE X_NUC_81.L_CORE 0.002695
K_3876 X_NUC_70.L_CORE X_NUC_82.L_CORE 0.003457
K_3877 X_NUC_70.L_CORE X_NUC_83.L_CORE 0.003088
K_3878 X_NUC_70.L_CORE X_NUC_84.L_CORE 0.002955
K_3879 X_NUC_70.L_CORE X_NUC_85.L_CORE 0.005320
K_3880 X_NUC_70.L_CORE X_NUC_86.L_CORE 0.002988
K_3881 X_NUC_70.L_CORE X_NUC_87.L_CORE 0.004610
K_3882 X_NUC_70.L_CORE X_NUC_88.L_CORE 0.005417
K_3883 X_NUC_70.L_CORE X_NUC_89.L_CORE 0.003560
K_3884 X_NUC_70.L_CORE X_NUC_90.L_CORE 0.019030
K_3885 X_NUC_70.L_CORE X_NUC_91.L_CORE 0.005496
K_3886 X_NUC_71.L_CORE X_NUC_72.L_CORE 0.207973
K_3887 X_NUC_71.L_CORE X_NUC_73.L_CORE 0.005132
K_3888 X_NUC_71.L_CORE X_NUC_74.L_CORE 0.005250
K_3889 X_NUC_71.L_CORE X_NUC_75.L_CORE 0.005209
K_3890 X_NUC_71.L_CORE X_NUC_76.L_CORE 0.005156
K_3891 X_NUC_71.L_CORE X_NUC_77.L_CORE 0.007767
K_3892 X_NUC_71.L_CORE X_NUC_78.L_CORE 0.007869
K_3893 X_NUC_71.L_CORE X_NUC_79.L_CORE 0.007899
K_3894 X_NUC_71.L_CORE X_NUC_80.L_CORE 0.007637
K_3895 X_NUC_71.L_CORE X_NUC_81.L_CORE 0.002675
K_3896 X_NUC_71.L_CORE X_NUC_82.L_CORE 0.003407
K_3897 X_NUC_71.L_CORE X_NUC_83.L_CORE 0.003082
K_3898 X_NUC_71.L_CORE X_NUC_84.L_CORE 0.002925
K_3899 X_NUC_71.L_CORE X_NUC_85.L_CORE 0.005256
K_3900 X_NUC_71.L_CORE X_NUC_86.L_CORE 0.002987
K_3901 X_NUC_71.L_CORE X_NUC_87.L_CORE 0.004519
K_3902 X_NUC_71.L_CORE X_NUC_88.L_CORE 0.005481
K_3903 X_NUC_71.L_CORE X_NUC_89.L_CORE 0.003549
K_3904 X_NUC_71.L_CORE X_NUC_90.L_CORE 0.018361
K_3905 X_NUC_71.L_CORE X_NUC_91.L_CORE 0.005575
K_3906 X_NUC_72.L_CORE X_NUC_73.L_CORE 0.005183
K_3907 X_NUC_72.L_CORE X_NUC_74.L_CORE 0.005304
K_3908 X_NUC_72.L_CORE X_NUC_75.L_CORE 0.005261
K_3909 X_NUC_72.L_CORE X_NUC_76.L_CORE 0.005209
K_3910 X_NUC_72.L_CORE X_NUC_77.L_CORE 0.008036
K_3911 X_NUC_72.L_CORE X_NUC_78.L_CORE 0.008149
K_3912 X_NUC_72.L_CORE X_NUC_79.L_CORE 0.008176
K_3913 X_NUC_72.L_CORE X_NUC_80.L_CORE 0.007899
K_3914 X_NUC_72.L_CORE X_NUC_81.L_CORE 0.002688
K_3915 X_NUC_72.L_CORE X_NUC_82.L_CORE 0.003420
K_3916 X_NUC_72.L_CORE X_NUC_83.L_CORE 0.003077
K_3917 X_NUC_72.L_CORE X_NUC_84.L_CORE 0.002957
K_3918 X_NUC_72.L_CORE X_NUC_85.L_CORE 0.005197
K_3919 X_NUC_72.L_CORE X_NUC_86.L_CORE 0.003002
K_3920 X_NUC_72.L_CORE X_NUC_87.L_CORE 0.004600
K_3921 X_NUC_72.L_CORE X_NUC_88.L_CORE 0.005401
K_3922 X_NUC_72.L_CORE X_NUC_89.L_CORE 0.003600
K_3923 X_NUC_72.L_CORE X_NUC_90.L_CORE 0.019112
K_3924 X_NUC_72.L_CORE X_NUC_91.L_CORE 0.005616
K_3925 X_NUC_73.L_CORE X_NUC_74.L_CORE 0.207973
K_3926 X_NUC_73.L_CORE X_NUC_75.L_CORE 0.207973
K_3927 X_NUC_73.L_CORE X_NUC_76.L_CORE 0.207973
K_3928 X_NUC_73.L_CORE X_NUC_77.L_CORE 0.007319
K_3929 X_NUC_73.L_CORE X_NUC_78.L_CORE 0.007081
K_3930 X_NUC_73.L_CORE X_NUC_79.L_CORE 0.007205
K_3931 X_NUC_73.L_CORE X_NUC_80.L_CORE 0.007141
K_3932 X_NUC_73.L_CORE X_NUC_81.L_CORE 0.002972
K_3933 X_NUC_73.L_CORE X_NUC_82.L_CORE 0.002676
K_3934 X_NUC_73.L_CORE X_NUC_83.L_CORE 0.003563
K_3935 X_NUC_73.L_CORE X_NUC_84.L_CORE 0.003213
K_3936 X_NUC_73.L_CORE X_NUC_85.L_CORE 0.003115
K_3937 X_NUC_73.L_CORE X_NUC_86.L_CORE 0.005428
K_3938 X_NUC_73.L_CORE X_NUC_87.L_CORE 0.003289
K_3939 X_NUC_73.L_CORE X_NUC_88.L_CORE 0.005066
K_3940 X_NUC_73.L_CORE X_NUC_89.L_CORE 0.006278
K_3941 X_NUC_73.L_CORE X_NUC_90.L_CORE 0.004379
K_3942 X_NUC_73.L_CORE X_NUC_91.L_CORE 0.019578
K_3943 X_NUC_74.L_CORE X_NUC_75.L_CORE 0.207973
K_3944 X_NUC_74.L_CORE X_NUC_76.L_CORE 0.207973
K_3945 X_NUC_74.L_CORE X_NUC_77.L_CORE 0.007574
K_3946 X_NUC_74.L_CORE X_NUC_78.L_CORE 0.007319
K_3947 X_NUC_74.L_CORE X_NUC_79.L_CORE 0.007452
K_3948 X_NUC_74.L_CORE X_NUC_80.L_CORE 0.007382
K_3949 X_NUC_74.L_CORE X_NUC_81.L_CORE 0.002976
K_3950 X_NUC_74.L_CORE X_NUC_82.L_CORE 0.002697
K_3951 X_NUC_74.L_CORE X_NUC_83.L_CORE 0.003555
K_3952 X_NUC_74.L_CORE X_NUC_84.L_CORE 0.003232
K_3953 X_NUC_74.L_CORE X_NUC_85.L_CORE 0.003146
K_3954 X_NUC_74.L_CORE X_NUC_86.L_CORE 0.005348
K_3955 X_NUC_74.L_CORE X_NUC_87.L_CORE 0.003335
K_3956 X_NUC_74.L_CORE X_NUC_88.L_CORE 0.005087
K_3957 X_NUC_74.L_CORE X_NUC_89.L_CORE 0.006300
K_3958 X_NUC_74.L_CORE X_NUC_90.L_CORE 0.004470
K_3959 X_NUC_74.L_CORE X_NUC_91.L_CORE 0.020000
K_3960 X_NUC_75.L_CORE X_NUC_76.L_CORE 0.207973
K_3961 X_NUC_75.L_CORE X_NUC_77.L_CORE 0.007429
K_3962 X_NUC_75.L_CORE X_NUC_78.L_CORE 0.007184
K_3963 X_NUC_75.L_CORE X_NUC_79.L_CORE 0.007319
K_3964 X_NUC_75.L_CORE X_NUC_80.L_CORE 0.007248
K_3965 X_NUC_75.L_CORE X_NUC_81.L_CORE 0.002941
K_3966 X_NUC_75.L_CORE X_NUC_82.L_CORE 0.002667
K_3967 X_NUC_75.L_CORE X_NUC_83.L_CORE 0.003532
K_3968 X_NUC_75.L_CORE X_NUC_84.L_CORE 0.003183
K_3969 X_NUC_75.L_CORE X_NUC_85.L_CORE 0.003123
K_3970 X_NUC_75.L_CORE X_NUC_86.L_CORE 0.005295
K_3971 X_NUC_75.L_CORE X_NUC_87.L_CORE 0.003290
K_3972 X_NUC_75.L_CORE X_NUC_88.L_CORE 0.005101
K_3973 X_NUC_75.L_CORE X_NUC_89.L_CORE 0.006170
K_3974 X_NUC_75.L_CORE X_NUC_90.L_CORE 0.004435
K_3975 X_NUC_75.L_CORE X_NUC_91.L_CORE 0.021535
K_3976 X_NUC_76.L_CORE X_NUC_77.L_CORE 0.007501
K_3977 X_NUC_76.L_CORE X_NUC_78.L_CORE 0.007250
K_3978 X_NUC_76.L_CORE X_NUC_79.L_CORE 0.007384
K_3979 X_NUC_76.L_CORE X_NUC_80.L_CORE 0.007319
K_3980 X_NUC_76.L_CORE X_NUC_81.L_CORE 0.002948
K_3981 X_NUC_76.L_CORE X_NUC_82.L_CORE 0.002667
K_3982 X_NUC_76.L_CORE X_NUC_83.L_CORE 0.003509
K_3983 X_NUC_76.L_CORE X_NUC_84.L_CORE 0.003212
K_3984 X_NUC_76.L_CORE X_NUC_85.L_CORE 0.003099
K_3985 X_NUC_76.L_CORE X_NUC_86.L_CORE 0.005327
K_3986 X_NUC_76.L_CORE X_NUC_87.L_CORE 0.003307
K_3987 X_NUC_76.L_CORE X_NUC_88.L_CORE 0.004990
K_3988 X_NUC_76.L_CORE X_NUC_89.L_CORE 0.006352
K_3989 X_NUC_76.L_CORE X_NUC_90.L_CORE 0.004413
K_3990 X_NUC_76.L_CORE X_NUC_91.L_CORE 0.020262
K_3991 X_NUC_77.L_CORE X_NUC_78.L_CORE 0.207973
K_3992 X_NUC_77.L_CORE X_NUC_79.L_CORE 0.207973
K_3993 X_NUC_77.L_CORE X_NUC_80.L_CORE 0.207973
K_3994 X_NUC_77.L_CORE X_NUC_81.L_CORE 0.002771
K_3995 X_NUC_77.L_CORE X_NUC_82.L_CORE 0.003041
K_3996 X_NUC_77.L_CORE X_NUC_83.L_CORE 0.002842
K_3997 X_NUC_77.L_CORE X_NUC_84.L_CORE 0.003564
K_3998 X_NUC_77.L_CORE X_NUC_85.L_CORE 0.003419
K_3999 X_NUC_77.L_CORE X_NUC_86.L_CORE 0.003495
K_4000 X_NUC_77.L_CORE X_NUC_87.L_CORE 0.005124
K_4001 X_NUC_77.L_CORE X_NUC_88.L_CORE 0.003964
K_4002 X_NUC_77.L_CORE X_NUC_89.L_CORE 0.005925
K_4003 X_NUC_77.L_CORE X_NUC_90.L_CORE 0.007760
K_4004 X_NUC_77.L_CORE X_NUC_91.L_CORE 0.007369
K_4005 X_NUC_78.L_CORE X_NUC_79.L_CORE 0.207973
K_4006 X_NUC_78.L_CORE X_NUC_80.L_CORE 0.207973
K_4007 X_NUC_78.L_CORE X_NUC_81.L_CORE 0.002761
K_4008 X_NUC_78.L_CORE X_NUC_82.L_CORE 0.003054
K_4009 X_NUC_78.L_CORE X_NUC_83.L_CORE 0.002823
K_4010 X_NUC_78.L_CORE X_NUC_84.L_CORE 0.003561
K_4011 X_NUC_78.L_CORE X_NUC_85.L_CORE 0.003434
K_4012 X_NUC_78.L_CORE X_NUC_86.L_CORE 0.003447
K_4013 X_NUC_78.L_CORE X_NUC_87.L_CORE 0.005212
K_4014 X_NUC_78.L_CORE X_NUC_88.L_CORE 0.003935
K_4015 X_NUC_78.L_CORE X_NUC_89.L_CORE 0.005816
K_4016 X_NUC_78.L_CORE X_NUC_90.L_CORE 0.007968
K_4017 X_NUC_78.L_CORE X_NUC_91.L_CORE 0.007150
K_4018 X_NUC_79.L_CORE X_NUC_80.L_CORE 0.207973
K_4019 X_NUC_79.L_CORE X_NUC_81.L_CORE 0.002740
K_4020 X_NUC_79.L_CORE X_NUC_82.L_CORE 0.003021
K_4021 X_NUC_79.L_CORE X_NUC_83.L_CORE 0.002819
K_4022 X_NUC_79.L_CORE X_NUC_84.L_CORE 0.003511
K_4023 X_NUC_79.L_CORE X_NUC_85.L_CORE 0.003418
K_4024 X_NUC_79.L_CORE X_NUC_86.L_CORE 0.003447
K_4025 X_NUC_79.L_CORE X_NUC_87.L_CORE 0.005088
K_4026 X_NUC_79.L_CORE X_NUC_88.L_CORE 0.003963
K_4027 X_NUC_79.L_CORE X_NUC_89.L_CORE 0.005778
K_4028 X_NUC_79.L_CORE X_NUC_90.L_CORE 0.007942
K_4029 X_NUC_79.L_CORE X_NUC_91.L_CORE 0.007345
K_4030 X_NUC_80.L_CORE X_NUC_81.L_CORE 0.002742
K_4031 X_NUC_80.L_CORE X_NUC_82.L_CORE 0.003015
K_4032 X_NUC_80.L_CORE X_NUC_83.L_CORE 0.002804
K_4033 X_NUC_80.L_CORE X_NUC_84.L_CORE 0.003542
K_4034 X_NUC_80.L_CORE X_NUC_85.L_CORE 0.003381
K_4035 X_NUC_80.L_CORE X_NUC_86.L_CORE 0.003449
K_4036 X_NUC_80.L_CORE X_NUC_87.L_CORE 0.005129
K_4037 X_NUC_80.L_CORE X_NUC_88.L_CORE 0.003899
K_4038 X_NUC_80.L_CORE X_NUC_89.L_CORE 0.005891
K_4039 X_NUC_80.L_CORE X_NUC_90.L_CORE 0.007734
K_4040 X_NUC_80.L_CORE X_NUC_91.L_CORE 0.007224
K_4041 X_NUC_81.L_CORE X_NUC_82.L_CORE 0.004697
K_4042 X_NUC_81.L_CORE X_NUC_83.L_CORE 0.005060
K_4043 X_NUC_81.L_CORE X_NUC_84.L_CORE 0.005290
K_4044 X_NUC_81.L_CORE X_NUC_85.L_CORE 0.003129
K_4045 X_NUC_81.L_CORE X_NUC_86.L_CORE 0.004324
K_4046 X_NUC_81.L_CORE X_NUC_87.L_CORE 0.003088
K_4047 X_NUC_81.L_CORE X_NUC_88.L_CORE 0.002834
K_4048 X_NUC_81.L_CORE X_NUC_89.L_CORE 0.003222
K_4049 X_NUC_81.L_CORE X_NUC_90.L_CORE 0.002509
K_4050 X_NUC_81.L_CORE X_NUC_91.L_CORE 0.002630
K_4051 X_NUC_82.L_CORE X_NUC_83.L_CORE 0.003435
K_4052 X_NUC_82.L_CORE X_NUC_84.L_CORE 0.004224
K_4053 X_NUC_82.L_CORE X_NUC_85.L_CORE 0.005150
K_4054 X_NUC_82.L_CORE X_NUC_86.L_CORE 0.002690
K_4055 X_NUC_82.L_CORE X_NUC_87.L_CORE 0.004642
K_4056 X_NUC_82.L_CORE X_NUC_88.L_CORE 0.002911
K_4057 X_NUC_82.L_CORE X_NUC_89.L_CORE 0.002701
K_4058 X_NUC_82.L_CORE X_NUC_90.L_CORE 0.003341
K_4059 X_NUC_82.L_CORE X_NUC_91.L_CORE 0.002509
K_4060 X_NUC_83.L_CORE X_NUC_84.L_CORE 0.002967
K_4061 X_NUC_83.L_CORE X_NUC_85.L_CORE 0.003825
K_4062 X_NUC_83.L_CORE X_NUC_86.L_CORE 0.004974
K_4063 X_NUC_83.L_CORE X_NUC_87.L_CORE 0.002519
K_4064 X_NUC_83.L_CORE X_NUC_88.L_CORE 0.004740
K_4065 X_NUC_83.L_CORE X_NUC_89.L_CORE 0.002862
K_4066 X_NUC_83.L_CORE X_NUC_90.L_CORE 0.002701
K_4067 X_NUC_83.L_CORE X_NUC_91.L_CORE 0.003222
K_4068 X_NUC_84.L_CORE X_NUC_85.L_CORE 0.002745
K_4069 X_NUC_84.L_CORE X_NUC_86.L_CORE 0.003633
K_4070 X_NUC_84.L_CORE X_NUC_87.L_CORE 0.004882
K_4071 X_NUC_84.L_CORE X_NUC_88.L_CORE 0.002470
K_4072 X_NUC_84.L_CORE X_NUC_89.L_CORE 0.004740
K_4073 X_NUC_84.L_CORE X_NUC_90.L_CORE 0.002911
K_4074 X_NUC_84.L_CORE X_NUC_91.L_CORE 0.002834
K_4075 X_NUC_85.L_CORE X_NUC_86.L_CORE 0.002651
K_4076 X_NUC_85.L_CORE X_NUC_87.L_CORE 0.003575
K_4077 X_NUC_85.L_CORE X_NUC_88.L_CORE 0.004882
K_4078 X_NUC_85.L_CORE X_NUC_89.L_CORE 0.002519
K_4079 X_NUC_85.L_CORE X_NUC_90.L_CORE 0.004642
K_4080 X_NUC_85.L_CORE X_NUC_91.L_CORE 0.003088
K_4081 X_NUC_86.L_CORE X_NUC_87.L_CORE 0.002651
K_4082 X_NUC_86.L_CORE X_NUC_88.L_CORE 0.003633
K_4083 X_NUC_86.L_CORE X_NUC_89.L_CORE 0.004974
K_4084 X_NUC_86.L_CORE X_NUC_90.L_CORE 0.002690
K_4085 X_NUC_86.L_CORE X_NUC_91.L_CORE 0.004324
K_4086 X_NUC_87.L_CORE X_NUC_88.L_CORE 0.002745
K_4087 X_NUC_87.L_CORE X_NUC_89.L_CORE 0.003825
K_4088 X_NUC_87.L_CORE X_NUC_90.L_CORE 0.005150
K_4089 X_NUC_87.L_CORE X_NUC_91.L_CORE 0.003129
K_4090 X_NUC_88.L_CORE X_NUC_89.L_CORE 0.002967
K_4091 X_NUC_88.L_CORE X_NUC_90.L_CORE 0.004224
K_4092 X_NUC_88.L_CORE X_NUC_91.L_CORE 0.005290
K_4093 X_NUC_89.L_CORE X_NUC_90.L_CORE 0.003435
K_4094 X_NUC_89.L_CORE X_NUC_91.L_CORE 0.005060
K_4095 X_NUC_90.L_CORE X_NUC_91.L_CORE 0.004697

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
