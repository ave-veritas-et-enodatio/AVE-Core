* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Nitrogen-14 (Z=7, A=14)
* Auto-generated topological mutual impedance array
* Nodes: 14

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.036163
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.168646
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.037529
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.029338
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.073808
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.089478
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.042888
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.047769
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.030829
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.018530
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.037534
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.038060
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.041467
K_14 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.039557
K_15 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.085895
K_16 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.035613
K_17 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.056188
K_18 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.050740
K_19 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.029515
K_20 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.028844
K_21 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.027941
K_22 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.017756
K_23 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.042028
K_24 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.163821
K_25 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.093619
K_26 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.043759
K_27 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.031981
K_28 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.074663
K_29 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.138822
K_30 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.038757
K_31 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.050145
K_32 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.032186
K_33 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.018395
K_34 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.047147
K_35 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.040311
K_36 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.043630
K_37 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.055313
K_38 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.060158
K_39 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.062921
K_40 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.032468
K_41 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.037114
K_42 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.037253
K_43 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.020200
K_44 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.072559
K_45 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.081402
K_46 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.084612
K_47 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.041524
K_48 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.040147
K_49 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.037256
K_50 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.046542
K_51 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.080784
K_52 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.029814
K_53 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.049550
K_54 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.039282
K_55 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.046245
K_56 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.112701
K_57 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.055498
K_58 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.050470
K_59 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.039680
K_60 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.021632
K_61 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.044375
K_62 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.069103
K_63 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.090595
K_64 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.041959
K_65 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.054418
K_66 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.037615
K_67 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.019843
K_68 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.061030
K_69 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.052818
K_70 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.059863
K_71 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.056712
K_72 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.049746
K_73 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.030406
K_74 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.028813
K_75 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.034755
K_76 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.041917
K_77 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.069240
K_78 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.027093
K_79 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.042887
K_80 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.031441
K_81 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.036736
K_82 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.038961
K_83 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.037741
K_84 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.031172
K_85 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.036860
K_86 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.019307
K_87 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.019503
K_88 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.021572
K_89 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.039778
K_90 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.042130
K_91 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.188699

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
