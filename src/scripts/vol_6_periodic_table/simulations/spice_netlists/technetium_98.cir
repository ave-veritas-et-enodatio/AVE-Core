* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Technetium-98 (Z=43, A=98)
* Auto-generated topological mutual impedance array
* Nodes: 98

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON
X_NUC_65 NODE_65 0 NUCLEON
X_NUC_66 NODE_66 0 NUCLEON
X_NUC_67 NODE_67 0 NUCLEON
X_NUC_68 NODE_68 0 NUCLEON
X_NUC_69 NODE_69 0 NUCLEON
X_NUC_70 NODE_70 0 NUCLEON
X_NUC_71 NODE_71 0 NUCLEON
X_NUC_72 NODE_72 0 NUCLEON
X_NUC_73 NODE_73 0 NUCLEON
X_NUC_74 NODE_74 0 NUCLEON
X_NUC_75 NODE_75 0 NUCLEON
X_NUC_76 NODE_76 0 NUCLEON
X_NUC_77 NODE_77 0 NUCLEON
X_NUC_78 NODE_78 0 NUCLEON
X_NUC_79 NODE_79 0 NUCLEON
X_NUC_80 NODE_80 0 NUCLEON
X_NUC_81 NODE_81 0 NUCLEON
X_NUC_82 NODE_82 0 NUCLEON
X_NUC_83 NODE_83 0 NUCLEON
X_NUC_84 NODE_84 0 NUCLEON
X_NUC_85 NODE_85 0 NUCLEON
X_NUC_86 NODE_86 0 NUCLEON
X_NUC_87 NODE_87 0 NUCLEON
X_NUC_88 NODE_88 0 NUCLEON
X_NUC_89 NODE_89 0 NUCLEON
X_NUC_90 NODE_90 0 NUCLEON
X_NUC_91 NODE_91 0 NUCLEON
X_NUC_92 NODE_92 0 NUCLEON
X_NUC_93 NODE_93 0 NUCLEON
X_NUC_94 NODE_94 0 NUCLEON
X_NUC_95 NODE_95 0 NUCLEON
X_NUC_96 NODE_96 0 NUCLEON
X_NUC_97 NODE_97 0 NUCLEON
X_NUC_98 NODE_98 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.007031
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.006813
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.006864
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.006933
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.007588
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.007694
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.007467
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.007710
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.008080
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.007932
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.008029
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.007800
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.004592
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.004533
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.004503
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.004576
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.006799
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.006981
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.006788
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.006795
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.004565
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.004481
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.004499
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.004480
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.004143
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.004147
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.004081
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.004150
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.005249
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.005273
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.005234
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.005151
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.003527
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.003484
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.003471
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.003494
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.004123
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.004168
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.004087
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.004121
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.003848
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.003814
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.003810
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.003778
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.003206
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.003192
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.003159
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.003192
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.003874
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.003904
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.003851
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.003836
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.003116
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.003086
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.003075
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.003077
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.003154
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.003163
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.003118
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.003143
K_64 X_NUC_1.L_CORE X_NUC_65.L_CORE 0.003308
K_65 X_NUC_1.L_CORE X_NUC_66.L_CORE 0.003303
K_66 X_NUC_1.L_CORE X_NUC_67.L_CORE 0.003281
K_67 X_NUC_1.L_CORE X_NUC_68.L_CORE 0.003262
K_68 X_NUC_1.L_CORE X_NUC_69.L_CORE 0.002820
K_69 X_NUC_1.L_CORE X_NUC_70.L_CORE 0.002805
K_70 X_NUC_1.L_CORE X_NUC_71.L_CORE 0.002783
K_71 X_NUC_1.L_CORE X_NUC_72.L_CORE 0.002797
K_72 X_NUC_1.L_CORE X_NUC_73.L_CORE 0.003056
K_73 X_NUC_1.L_CORE X_NUC_74.L_CORE 0.003066
K_74 X_NUC_1.L_CORE X_NUC_75.L_CORE 0.003028
K_75 X_NUC_1.L_CORE X_NUC_76.L_CORE 0.003033
K_76 X_NUC_1.L_CORE X_NUC_77.L_CORE 0.002849
K_77 X_NUC_1.L_CORE X_NUC_78.L_CORE 0.002837
K_78 X_NUC_1.L_CORE X_NUC_79.L_CORE 0.002819
K_79 X_NUC_1.L_CORE X_NUC_80.L_CORE 0.002816
K_80 X_NUC_1.L_CORE X_NUC_81.L_CORE 0.002744
K_81 X_NUC_1.L_CORE X_NUC_82.L_CORE 0.002740
K_82 X_NUC_1.L_CORE X_NUC_83.L_CORE 0.002713
K_83 X_NUC_1.L_CORE X_NUC_84.L_CORE 0.002722
K_84 X_NUC_1.L_CORE X_NUC_85.L_CORE 0.031968
K_85 X_NUC_1.L_CORE X_NUC_86.L_CORE 0.005540
K_86 X_NUC_1.L_CORE X_NUC_87.L_CORE 0.005812
K_87 X_NUC_1.L_CORE X_NUC_88.L_CORE 0.005764
K_88 X_NUC_1.L_CORE X_NUC_89.L_CORE 0.003625
K_89 X_NUC_1.L_CORE X_NUC_90.L_CORE 0.004795
K_90 X_NUC_1.L_CORE X_NUC_91.L_CORE 0.003487
K_91 X_NUC_1.L_CORE X_NUC_92.L_CORE 0.003216
K_92 X_NUC_1.L_CORE X_NUC_93.L_CORE 0.003669
K_93 X_NUC_1.L_CORE X_NUC_94.L_CORE 0.002782
K_94 X_NUC_1.L_CORE X_NUC_95.L_CORE 0.003032
K_95 X_NUC_1.L_CORE X_NUC_96.L_CORE 0.002839
K_96 X_NUC_1.L_CORE X_NUC_97.L_CORE 0.002556
K_97 X_NUC_1.L_CORE X_NUC_98.L_CORE 0.002655
K_98 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_99 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_100 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.007262
K_101 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.007031
K_102 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.007083
K_103 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.007159
K_104 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.007477
K_105 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.007588
K_106 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.007365
K_107 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.007599
K_108 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.008223
K_109 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.008080
K_110 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.008176
K_111 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.007934
K_112 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.004650
K_113 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.004592
K_114 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.004559
K_115 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.004636
K_116 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.006624
K_117 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.006799
K_118 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.006617
K_119 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.006623
K_120 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.004652
K_121 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.004565
K_122 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.004583
K_123 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.004563
K_124 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.004138
K_125 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.004143
K_126 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.004076
K_127 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.004146
K_128 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.005222
K_129 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.005249
K_130 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.005209
K_131 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.005127
K_132 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.003572
K_133 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.003527
K_134 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.003514
K_135 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.003537
K_136 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.004078
K_137 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.004123
K_138 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.004044
K_139 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.004077
K_140 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.003882
K_141 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.003848
K_142 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.003844
K_143 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.003811
K_144 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.003219
K_145 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.003206
K_146 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.003173
K_147 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.003206
K_148 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.003843
K_149 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.003874
K_150 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.003822
K_151 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.003807
K_152 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.003146
K_153 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.003116
K_154 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.003105
K_155 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.003106
K_156 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.003145
K_157 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.003154
K_158 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.003110
K_159 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.003134
K_160 X_NUC_2.L_CORE X_NUC_65.L_CORE 0.003312
K_161 X_NUC_2.L_CORE X_NUC_66.L_CORE 0.003308
K_162 X_NUC_2.L_CORE X_NUC_67.L_CORE 0.003285
K_163 X_NUC_2.L_CORE X_NUC_68.L_CORE 0.003267
K_164 X_NUC_2.L_CORE X_NUC_69.L_CORE 0.002835
K_165 X_NUC_2.L_CORE X_NUC_70.L_CORE 0.002820
K_166 X_NUC_2.L_CORE X_NUC_71.L_CORE 0.002798
K_167 X_NUC_2.L_CORE X_NUC_72.L_CORE 0.002812
K_168 X_NUC_2.L_CORE X_NUC_73.L_CORE 0.003045
K_169 X_NUC_2.L_CORE X_NUC_74.L_CORE 0.003056
K_170 X_NUC_2.L_CORE X_NUC_75.L_CORE 0.003017
K_171 X_NUC_2.L_CORE X_NUC_76.L_CORE 0.003023
K_172 X_NUC_2.L_CORE X_NUC_77.L_CORE 0.002861
K_173 X_NUC_2.L_CORE X_NUC_78.L_CORE 0.002849
K_174 X_NUC_2.L_CORE X_NUC_79.L_CORE 0.002831
K_175 X_NUC_2.L_CORE X_NUC_80.L_CORE 0.002828
K_176 X_NUC_2.L_CORE X_NUC_81.L_CORE 0.002747
K_177 X_NUC_2.L_CORE X_NUC_82.L_CORE 0.002744
K_178 X_NUC_2.L_CORE X_NUC_83.L_CORE 0.002716
K_179 X_NUC_2.L_CORE X_NUC_84.L_CORE 0.002726
K_180 X_NUC_2.L_CORE X_NUC_85.L_CORE 0.029637
K_181 X_NUC_2.L_CORE X_NUC_86.L_CORE 0.005686
K_182 X_NUC_2.L_CORE X_NUC_87.L_CORE 0.005733
K_183 X_NUC_2.L_CORE X_NUC_88.L_CORE 0.005824
K_184 X_NUC_2.L_CORE X_NUC_89.L_CORE 0.003661
K_185 X_NUC_2.L_CORE X_NUC_90.L_CORE 0.004709
K_186 X_NUC_2.L_CORE X_NUC_91.L_CORE 0.003534
K_187 X_NUC_2.L_CORE X_NUC_92.L_CORE 0.003212
K_188 X_NUC_2.L_CORE X_NUC_93.L_CORE 0.003657
K_189 X_NUC_2.L_CORE X_NUC_94.L_CORE 0.002806
K_190 X_NUC_2.L_CORE X_NUC_95.L_CORE 0.003015
K_191 X_NUC_2.L_CORE X_NUC_96.L_CORE 0.002852
K_192 X_NUC_2.L_CORE X_NUC_97.L_CORE 0.002562
K_193 X_NUC_2.L_CORE X_NUC_98.L_CORE 0.002653
K_194 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_195 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.007203
K_196 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.006973
K_197 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.007031
K_198 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.007101
K_199 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.007706
K_200 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.007822
K_201 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.007588
K_202 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.007839
K_203 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.008119
K_204 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.007975
K_205 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.008080
K_206 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.007841
K_207 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.004684
K_208 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.004623
K_209 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.004592
K_210 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.004669
K_211 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.006803
K_212 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.006990
K_213 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.006799
K_214 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.006802
K_215 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.004632
K_216 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.004545
K_217 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.004565
K_218 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.004544
K_219 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.004206
K_220 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.004211
K_221 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.004143
K_222 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.004215
K_223 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.005260
K_224 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.005286
K_225 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.005249
K_226 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.005163
K_227 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.003585
K_228 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.003540
K_229 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.003527
K_230 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.003550
K_231 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.004160
K_232 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.004206
K_233 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.004123
K_234 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.004158
K_235 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.003885
K_236 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.003851
K_237 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.003848
K_238 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.003814
K_239 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.003254
K_240 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.003240
K_241 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.003206
K_242 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.003240
K_243 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.003895
K_244 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.003926
K_245 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.003874
K_246 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.003858
K_247 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.003157
K_248 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.003127
K_249 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.003116
K_250 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.003117
K_251 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.003191
K_252 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.003200
K_253 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.003154
K_254 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.003180
K_255 X_NUC_3.L_CORE X_NUC_65.L_CORE 0.003335
K_256 X_NUC_3.L_CORE X_NUC_66.L_CORE 0.003330
K_257 X_NUC_3.L_CORE X_NUC_67.L_CORE 0.003308
K_258 X_NUC_3.L_CORE X_NUC_68.L_CORE 0.003289
K_259 X_NUC_3.L_CORE X_NUC_69.L_CORE 0.002858
K_260 X_NUC_3.L_CORE X_NUC_70.L_CORE 0.002842
K_261 X_NUC_3.L_CORE X_NUC_71.L_CORE 0.002820
K_262 X_NUC_3.L_CORE X_NUC_72.L_CORE 0.002834
K_263 X_NUC_3.L_CORE X_NUC_73.L_CORE 0.003084
K_264 X_NUC_3.L_CORE X_NUC_74.L_CORE 0.003095
K_265 X_NUC_3.L_CORE X_NUC_75.L_CORE 0.003056
K_266 X_NUC_3.L_CORE X_NUC_76.L_CORE 0.003061
K_267 X_NUC_3.L_CORE X_NUC_77.L_CORE 0.002881
K_268 X_NUC_3.L_CORE X_NUC_78.L_CORE 0.002868
K_269 X_NUC_3.L_CORE X_NUC_79.L_CORE 0.002849
K_270 X_NUC_3.L_CORE X_NUC_80.L_CORE 0.002846
K_271 X_NUC_3.L_CORE X_NUC_81.L_CORE 0.002775
K_272 X_NUC_3.L_CORE X_NUC_82.L_CORE 0.002772
K_273 X_NUC_3.L_CORE X_NUC_83.L_CORE 0.002744
K_274 X_NUC_3.L_CORE X_NUC_84.L_CORE 0.002753
K_275 X_NUC_3.L_CORE X_NUC_85.L_CORE 0.027714
K_276 X_NUC_3.L_CORE X_NUC_86.L_CORE 0.005635
K_277 X_NUC_3.L_CORE X_NUC_87.L_CORE 0.005866
K_278 X_NUC_3.L_CORE X_NUC_88.L_CORE 0.005771
K_279 X_NUC_3.L_CORE X_NUC_89.L_CORE 0.003683
K_280 X_NUC_3.L_CORE X_NUC_90.L_CORE 0.004798
K_281 X_NUC_3.L_CORE X_NUC_91.L_CORE 0.003527
K_282 X_NUC_3.L_CORE X_NUC_92.L_CORE 0.003256
K_283 X_NUC_3.L_CORE X_NUC_93.L_CORE 0.003682
K_284 X_NUC_3.L_CORE X_NUC_94.L_CORE 0.002819
K_285 X_NUC_3.L_CORE X_NUC_95.L_CORE 0.003057
K_286 X_NUC_3.L_CORE X_NUC_96.L_CORE 0.002864
K_287 X_NUC_3.L_CORE X_NUC_97.L_CORE 0.002586
K_288 X_NUC_3.L_CORE X_NUC_98.L_CORE 0.002678
K_289 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.007125
K_290 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.006903
K_291 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.006955
K_292 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.007031
K_293 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.007462
K_294 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.007568
K_295 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.007351
K_296 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.007588
K_297 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.008378
K_298 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.008220
K_299 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.008328
K_300 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.008080
K_301 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.004605
K_302 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.004547
K_303 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.004517
K_304 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.004592
K_305 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.006796
K_306 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.006982
K_307 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.006789
K_308 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.006799
K_309 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.004654
K_310 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.004566
K_311 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.004585
K_312 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.004565
K_313 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.004134
K_314 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.004139
K_315 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.004073
K_316 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.004143
K_317 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.005349
K_318 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.005376
K_319 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.005335
K_320 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.005249
K_321 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.003561
K_322 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.003517
K_323 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.003504
K_324 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.003527
K_325 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.004125
K_326 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.004170
K_327 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.004089
K_328 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.004123
K_329 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.003920
K_330 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.003885
K_331 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.003881
K_332 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.003848
K_333 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.003219
K_334 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.003205
K_335 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.003172
K_336 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.003206
K_337 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.003911
K_338 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.003943
K_339 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.003888
K_340 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.003874
K_341 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.003156
K_342 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.003125
K_343 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.003114
K_344 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.003116
K_345 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.003165
K_346 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.003174
K_347 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.003129
K_348 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.003154
K_349 X_NUC_4.L_CORE X_NUC_65.L_CORE 0.003355
K_350 X_NUC_4.L_CORE X_NUC_66.L_CORE 0.003350
K_351 X_NUC_4.L_CORE X_NUC_67.L_CORE 0.003327
K_352 X_NUC_4.L_CORE X_NUC_68.L_CORE 0.003308
K_353 X_NUC_4.L_CORE X_NUC_69.L_CORE 0.002843
K_354 X_NUC_4.L_CORE X_NUC_70.L_CORE 0.002828
K_355 X_NUC_4.L_CORE X_NUC_71.L_CORE 0.002805
K_356 X_NUC_4.L_CORE X_NUC_72.L_CORE 0.002820
K_357 X_NUC_4.L_CORE X_NUC_73.L_CORE 0.003078
K_358 X_NUC_4.L_CORE X_NUC_74.L_CORE 0.003089
K_359 X_NUC_4.L_CORE X_NUC_75.L_CORE 0.003050
K_360 X_NUC_4.L_CORE X_NUC_76.L_CORE 0.003056
K_361 X_NUC_4.L_CORE X_NUC_77.L_CORE 0.002883
K_362 X_NUC_4.L_CORE X_NUC_78.L_CORE 0.002871
K_363 X_NUC_4.L_CORE X_NUC_79.L_CORE 0.002852
K_364 X_NUC_4.L_CORE X_NUC_80.L_CORE 0.002849
K_365 X_NUC_4.L_CORE X_NUC_81.L_CORE 0.002765
K_366 X_NUC_4.L_CORE X_NUC_82.L_CORE 0.002762
K_367 X_NUC_4.L_CORE X_NUC_83.L_CORE 0.002734
K_368 X_NUC_4.L_CORE X_NUC_84.L_CORE 0.002744
K_369 X_NUC_4.L_CORE X_NUC_85.L_CORE 0.029592
K_370 X_NUC_4.L_CORE X_NUC_86.L_CORE 0.005596
K_371 X_NUC_4.L_CORE X_NUC_87.L_CORE 0.005730
K_372 X_NUC_4.L_CORE X_NUC_88.L_CORE 0.005910
K_373 X_NUC_4.L_CORE X_NUC_89.L_CORE 0.003635
K_374 X_NUC_4.L_CORE X_NUC_90.L_CORE 0.004801
K_375 X_NUC_4.L_CORE X_NUC_91.L_CORE 0.003542
K_376 X_NUC_4.L_CORE X_NUC_92.L_CORE 0.003216
K_377 X_NUC_4.L_CORE X_NUC_93.L_CORE 0.003719
K_378 X_NUC_4.L_CORE X_NUC_94.L_CORE 0.002806
K_379 X_NUC_4.L_CORE X_NUC_95.L_CORE 0.003043
K_380 X_NUC_4.L_CORE X_NUC_96.L_CORE 0.002876
K_381 X_NUC_4.L_CORE X_NUC_97.L_CORE 0.002572
K_382 X_NUC_4.L_CORE X_NUC_98.L_CORE 0.002678
K_383 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_384 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_385 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_386 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.004997
K_387 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.005111
K_388 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.005022
K_389 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.005067
K_390 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.006122
K_391 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.006206
K_392 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.006214
K_393 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.006058
K_394 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.007650
K_395 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.007662
K_396 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.007453
K_397 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.007702
K_398 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.003777
K_399 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.003843
K_400 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.003802
K_401 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.003791
K_402 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.007383
K_403 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.007278
K_404 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.007295
K_405 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.007134
K_406 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.004094
K_407 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.004143
K_408 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.004067
K_409 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.004121
K_410 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.003720
K_411 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.003763
K_412 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.003740
K_413 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.003699
K_414 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.005822
K_415 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.005751
K_416 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.005666
K_417 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.005725
K_418 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.003167
K_419 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.003208
K_420 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.003166
K_421 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.003175
K_422 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.004139
K_423 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.004141
K_424 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.004126
K_425 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.004071
K_426 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.003825
K_427 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.003837
K_428 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.003772
K_429 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.003817
K_430 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.002976
K_431 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.003007
K_432 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.002978
K_433 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.002966
K_434 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.004146
K_435 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.004120
K_436 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.004084
K_437 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.004074
K_438 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.002979
K_439 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.003003
K_440 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.002961
K_441 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.002977
K_442 X_NUC_5.L_CORE X_NUC_65.L_CORE 0.003096
K_443 X_NUC_5.L_CORE X_NUC_66.L_CORE 0.003112
K_444 X_NUC_5.L_CORE X_NUC_67.L_CORE 0.003088
K_445 X_NUC_5.L_CORE X_NUC_68.L_CORE 0.003067
K_446 X_NUC_5.L_CORE X_NUC_69.L_CORE 0.003404
K_447 X_NUC_5.L_CORE X_NUC_70.L_CORE 0.003402
K_448 X_NUC_5.L_CORE X_NUC_71.L_CORE 0.003358
K_449 X_NUC_5.L_CORE X_NUC_72.L_CORE 0.003374
K_450 X_NUC_5.L_CORE X_NUC_73.L_CORE 0.002730
K_451 X_NUC_5.L_CORE X_NUC_74.L_CORE 0.002751
K_452 X_NUC_5.L_CORE X_NUC_75.L_CORE 0.002720
K_453 X_NUC_5.L_CORE X_NUC_76.L_CORE 0.002720
K_454 X_NUC_5.L_CORE X_NUC_77.L_CORE 0.003094
K_455 X_NUC_5.L_CORE X_NUC_78.L_CORE 0.003097
K_456 X_NUC_5.L_CORE X_NUC_79.L_CORE 0.003069
K_457 X_NUC_5.L_CORE X_NUC_80.L_CORE 0.003059
K_458 X_NUC_5.L_CORE X_NUC_81.L_CORE 0.002849
K_459 X_NUC_5.L_CORE X_NUC_82.L_CORE 0.002860
K_460 X_NUC_5.L_CORE X_NUC_83.L_CORE 0.002826
K_461 X_NUC_5.L_CORE X_NUC_84.L_CORE 0.002832
K_462 X_NUC_5.L_CORE X_NUC_85.L_CORE 0.006056
K_463 X_NUC_5.L_CORE X_NUC_86.L_CORE 0.024159
K_464 X_NUC_5.L_CORE X_NUC_87.L_CORE 0.004143
K_465 X_NUC_5.L_CORE X_NUC_88.L_CORE 0.004838
K_466 X_NUC_5.L_CORE X_NUC_89.L_CORE 0.005511
K_467 X_NUC_5.L_CORE X_NUC_90.L_CORE 0.003112
K_468 X_NUC_5.L_CORE X_NUC_91.L_CORE 0.004898
K_469 X_NUC_5.L_CORE X_NUC_92.L_CORE 0.003246
K_470 X_NUC_5.L_CORE X_NUC_93.L_CORE 0.002984
K_471 X_NUC_5.L_CORE X_NUC_94.L_CORE 0.003794
K_472 X_NUC_5.L_CORE X_NUC_95.L_CORE 0.002621
K_473 X_NUC_5.L_CORE X_NUC_96.L_CORE 0.003003
K_474 X_NUC_5.L_CORE X_NUC_97.L_CORE 0.002816
K_475 X_NUC_5.L_CORE X_NUC_98.L_CORE 0.002533
K_476 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_477 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_478 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.004888
K_479 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.004997
K_480 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.004913
K_481 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.004955
K_482 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.006037
K_483 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.006122
K_484 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.006127
K_485 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.005978
K_486 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.007627
K_487 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.007650
K_488 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.007436
K_489 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.007684
K_490 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.003713
K_491 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.003777
K_492 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.003737
K_493 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.003727
K_494 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.007482
K_495 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.007383
K_496 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.007395
K_497 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.007228
K_498 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.004046
K_499 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.004094
K_500 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.004020
K_501 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.004072
K_502 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.003678
K_503 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.003720
K_504 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.003698
K_505 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.003658
K_506 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.005892
K_507 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.005822
K_508 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.005732
K_509 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.005793
K_510 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.003127
K_511 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.003167
K_512 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.003126
K_513 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.003134
K_514 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.004135
K_515 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.004139
K_516 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.004123
K_517 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.004068
K_518 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.003811
K_519 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.003825
K_520 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.003760
K_521 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.003804
K_522 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.002945
K_523 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.002976
K_524 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.002948
K_525 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.002936
K_526 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.004170
K_527 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.004146
K_528 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.004109
K_529 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.004097
K_530 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.002954
K_531 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.002979
K_532 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.002937
K_533 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.002952
K_534 X_NUC_6.L_CORE X_NUC_65.L_CORE 0.003081
K_535 X_NUC_6.L_CORE X_NUC_66.L_CORE 0.003096
K_536 X_NUC_6.L_CORE X_NUC_67.L_CORE 0.003073
K_537 X_NUC_6.L_CORE X_NUC_68.L_CORE 0.003052
K_538 X_NUC_6.L_CORE X_NUC_69.L_CORE 0.003405
K_539 X_NUC_6.L_CORE X_NUC_70.L_CORE 0.003404
K_540 X_NUC_6.L_CORE X_NUC_71.L_CORE 0.003359
K_541 X_NUC_6.L_CORE X_NUC_72.L_CORE 0.003375
K_542 X_NUC_6.L_CORE X_NUC_73.L_CORE 0.002709
K_543 X_NUC_6.L_CORE X_NUC_74.L_CORE 0.002730
K_544 X_NUC_6.L_CORE X_NUC_75.L_CORE 0.002700
K_545 X_NUC_6.L_CORE X_NUC_76.L_CORE 0.002699
K_546 X_NUC_6.L_CORE X_NUC_77.L_CORE 0.003090
K_547 X_NUC_6.L_CORE X_NUC_78.L_CORE 0.003094
K_548 X_NUC_6.L_CORE X_NUC_79.L_CORE 0.003065
K_549 X_NUC_6.L_CORE X_NUC_80.L_CORE 0.003056
K_550 X_NUC_6.L_CORE X_NUC_81.L_CORE 0.002838
K_551 X_NUC_6.L_CORE X_NUC_82.L_CORE 0.002849
K_552 X_NUC_6.L_CORE X_NUC_83.L_CORE 0.002815
K_553 X_NUC_6.L_CORE X_NUC_84.L_CORE 0.002821
K_554 X_NUC_6.L_CORE X_NUC_85.L_CORE 0.005901
K_555 X_NUC_6.L_CORE X_NUC_86.L_CORE 0.027230
K_556 X_NUC_6.L_CORE X_NUC_87.L_CORE 0.004070
K_557 X_NUC_6.L_CORE X_NUC_88.L_CORE 0.004800
K_558 X_NUC_6.L_CORE X_NUC_89.L_CORE 0.005527
K_559 X_NUC_6.L_CORE X_NUC_90.L_CORE 0.003070
K_560 X_NUC_6.L_CORE X_NUC_91.L_CORE 0.004951
K_561 X_NUC_6.L_CORE X_NUC_92.L_CORE 0.003220
K_562 X_NUC_6.L_CORE X_NUC_93.L_CORE 0.002961
K_563 X_NUC_6.L_CORE X_NUC_94.L_CORE 0.003818
K_564 X_NUC_6.L_CORE X_NUC_95.L_CORE 0.002598
K_565 X_NUC_6.L_CORE X_NUC_96.L_CORE 0.003001
K_566 X_NUC_6.L_CORE X_NUC_97.L_CORE 0.002810
K_567 X_NUC_6.L_CORE X_NUC_98.L_CORE 0.002520
K_568 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_569 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.004969
K_570 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.005083
K_571 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.004997
K_572 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.005039
K_573 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.006030
K_574 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.006112
K_575 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.006122
K_576 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.005971
K_577 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.007852
K_578 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.007871
K_579 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.007650
K_580 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.007915
K_581 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.003752
K_582 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.003817
K_583 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.003777
K_584 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.003766
K_585 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.007464
K_586 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.007361
K_587 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.007383
K_588 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.007212
K_589 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.004121
K_590 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.004171
K_591 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.004094
K_592 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.004149
K_593 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.003699
K_594 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.003742
K_595 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.003720
K_596 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.003679
K_597 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.005987
K_598 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.005912
K_599 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.005822
K_600 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.005884
K_601 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.003168
K_602 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.003209
K_603 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.003167
K_604 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.003176
K_605 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.004150
K_606 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.004154
K_607 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.004139
K_608 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.004082
K_609 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.003879
K_610 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.003892
K_611 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.003825
K_612 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.003871
K_613 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.002973
K_614 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.003004
K_615 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.002976
K_616 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.002963
K_617 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.004208
K_618 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.004182
K_619 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.004146
K_620 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.004134
K_621 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.002996
K_622 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.003021
K_623 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.002979
K_624 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.002994
K_625 X_NUC_7.L_CORE X_NUC_65.L_CORE 0.003104
K_626 X_NUC_7.L_CORE X_NUC_66.L_CORE 0.003120
K_627 X_NUC_7.L_CORE X_NUC_67.L_CORE 0.003096
K_628 X_NUC_7.L_CORE X_NUC_68.L_CORE 0.003074
K_629 X_NUC_7.L_CORE X_NUC_69.L_CORE 0.003451
K_630 X_NUC_7.L_CORE X_NUC_70.L_CORE 0.003450
K_631 X_NUC_7.L_CORE X_NUC_71.L_CORE 0.003404
K_632 X_NUC_7.L_CORE X_NUC_72.L_CORE 0.003420
K_633 X_NUC_7.L_CORE X_NUC_73.L_CORE 0.002740
K_634 X_NUC_7.L_CORE X_NUC_74.L_CORE 0.002761
K_635 X_NUC_7.L_CORE X_NUC_75.L_CORE 0.002730
K_636 X_NUC_7.L_CORE X_NUC_76.L_CORE 0.002729
K_637 X_NUC_7.L_CORE X_NUC_77.L_CORE 0.003119
K_638 X_NUC_7.L_CORE X_NUC_78.L_CORE 0.003123
K_639 X_NUC_7.L_CORE X_NUC_79.L_CORE 0.003094
K_640 X_NUC_7.L_CORE X_NUC_80.L_CORE 0.003084
K_641 X_NUC_7.L_CORE X_NUC_81.L_CORE 0.002873
K_642 X_NUC_7.L_CORE X_NUC_82.L_CORE 0.002884
K_643 X_NUC_7.L_CORE X_NUC_83.L_CORE 0.002849
K_644 X_NUC_7.L_CORE X_NUC_84.L_CORE 0.002855
K_645 X_NUC_7.L_CORE X_NUC_85.L_CORE 0.005917
K_646 X_NUC_7.L_CORE X_NUC_86.L_CORE 0.025022
K_647 X_NUC_7.L_CORE X_NUC_87.L_CORE 0.004128
K_648 X_NUC_7.L_CORE X_NUC_88.L_CORE 0.004788
K_649 X_NUC_7.L_CORE X_NUC_89.L_CORE 0.005634
K_650 X_NUC_7.L_CORE X_NUC_90.L_CORE 0.003099
K_651 X_NUC_7.L_CORE X_NUC_91.L_CORE 0.004950
K_652 X_NUC_7.L_CORE X_NUC_92.L_CORE 0.003270
K_653 X_NUC_7.L_CORE X_NUC_93.L_CORE 0.002979
K_654 X_NUC_7.L_CORE X_NUC_94.L_CORE 0.003860
K_655 X_NUC_7.L_CORE X_NUC_95.L_CORE 0.002628
K_656 X_NUC_7.L_CORE X_NUC_96.L_CORE 0.003019
K_657 X_NUC_7.L_CORE X_NUC_97.L_CORE 0.002845
K_658 X_NUC_7.L_CORE X_NUC_98.L_CORE 0.002544
K_659 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.004927
K_660 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.005037
K_661 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.004953
K_662 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.004997
K_663 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.006183
K_664 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.006272
K_665 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.006280
K_666 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.006122
K_667 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.007588
K_668 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.007605
K_669 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.007400
K_670 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.007650
K_671 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.003762
K_672 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.003828
K_673 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.003787
K_674 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.003777
K_675 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.007648
K_676 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.007538
K_677 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.007556
K_678 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.007383
K_679 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.004067
K_680 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.004115
K_681 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.004040
K_682 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.004094
K_683 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.003741
K_684 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.003785
K_685 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.003762
K_686 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.003720
K_687 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.005920
K_688 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.005848
K_689 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.005758
K_690 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.005822
K_691 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.003159
K_692 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.003200
K_693 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.003158
K_694 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.003167
K_695 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.004209
K_696 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.004212
K_697 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.004196
K_698 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.004139
K_699 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.003832
K_700 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.003845
K_701 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.003779
K_702 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.003825
K_703 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.002985
K_704 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.003017
K_705 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.002988
K_706 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.002976
K_707 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.004220
K_708 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.004194
K_709 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.004156
K_710 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.004146
K_711 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.002980
K_712 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.003005
K_713 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.002963
K_714 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.002979
K_715 X_NUC_8.L_CORE X_NUC_65.L_CORE 0.003126
K_716 X_NUC_8.L_CORE X_NUC_66.L_CORE 0.003142
K_717 X_NUC_8.L_CORE X_NUC_67.L_CORE 0.003118
K_718 X_NUC_8.L_CORE X_NUC_68.L_CORE 0.003096
K_719 X_NUC_8.L_CORE X_NUC_69.L_CORE 0.003433
K_720 X_NUC_8.L_CORE X_NUC_70.L_CORE 0.003432
K_721 X_NUC_8.L_CORE X_NUC_71.L_CORE 0.003387
K_722 X_NUC_8.L_CORE X_NUC_72.L_CORE 0.003404
K_723 X_NUC_8.L_CORE X_NUC_73.L_CORE 0.002740
K_724 X_NUC_8.L_CORE X_NUC_74.L_CORE 0.002762
K_725 X_NUC_8.L_CORE X_NUC_75.L_CORE 0.002730
K_726 X_NUC_8.L_CORE X_NUC_76.L_CORE 0.002730
K_727 X_NUC_8.L_CORE X_NUC_77.L_CORE 0.003129
K_728 X_NUC_8.L_CORE X_NUC_78.L_CORE 0.003133
K_729 X_NUC_8.L_CORE X_NUC_79.L_CORE 0.003103
K_730 X_NUC_8.L_CORE X_NUC_80.L_CORE 0.003094
K_731 X_NUC_8.L_CORE X_NUC_81.L_CORE 0.002867
K_732 X_NUC_8.L_CORE X_NUC_82.L_CORE 0.002878
K_733 X_NUC_8.L_CORE X_NUC_83.L_CORE 0.002843
K_734 X_NUC_8.L_CORE X_NUC_84.L_CORE 0.002849
K_735 X_NUC_8.L_CORE X_NUC_85.L_CORE 0.005978
K_736 X_NUC_8.L_CORE X_NUC_86.L_CORE 0.024897
K_737 X_NUC_8.L_CORE X_NUC_87.L_CORE 0.004094
K_738 X_NUC_8.L_CORE X_NUC_88.L_CORE 0.004890
K_739 X_NUC_8.L_CORE X_NUC_89.L_CORE 0.005501
K_740 X_NUC_8.L_CORE X_NUC_90.L_CORE 0.003106
K_741 X_NUC_8.L_CORE X_NUC_91.L_CORE 0.005016
K_742 X_NUC_8.L_CORE X_NUC_92.L_CORE 0.003237
K_743 X_NUC_8.L_CORE X_NUC_93.L_CORE 0.003004
K_744 X_NUC_8.L_CORE X_NUC_94.L_CORE 0.003840
K_745 X_NUC_8.L_CORE X_NUC_95.L_CORE 0.002623
K_746 X_NUC_8.L_CORE X_NUC_96.L_CORE 0.003039
K_747 X_NUC_8.L_CORE X_NUC_97.L_CORE 0.002831
K_748 X_NUC_8.L_CORE X_NUC_98.L_CORE 0.002548
K_749 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_750 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_751 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_752 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.004178
K_753 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.004140
K_754 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.004191
K_755 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.004118
K_756 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.005345
K_757 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.005218
K_758 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.005246
K_759 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.005279
K_760 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.007137
K_761 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.007252
K_762 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.007225
K_763 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.007031
K_764 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.003375
K_765 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.003332
K_766 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.003359
K_767 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.003330
K_768 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.007566
K_769 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.007484
K_770 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.007311
K_771 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.007489
K_772 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.003810
K_773 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.003805
K_774 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.003820
K_775 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.003757
K_776 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.003477
K_777 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.003425
K_778 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.003434
K_779 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.003433
K_780 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006149
K_781 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006239
K_782 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006090
K_783 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006075
K_784 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.002979
K_785 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.002956
K_786 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.002968
K_787 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.002939
K_788 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.004112
K_789 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.004066
K_790 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.004033
K_791 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.004064
K_792 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.003788
K_793 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.003802
K_794 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.003781
K_795 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.003738
K_796 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.002861
K_797 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.002832
K_798 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.002836
K_799 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.002825
K_800 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.004284
K_801 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.004286
K_802 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.004216
K_803 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.004235
K_804 X_NUC_9.L_CORE X_NUC_65.L_CORE 0.002916
K_805 X_NUC_9.L_CORE X_NUC_66.L_CORE 0.002907
K_806 X_NUC_9.L_CORE X_NUC_67.L_CORE 0.002904
K_807 X_NUC_9.L_CORE X_NUC_68.L_CORE 0.002878
K_808 X_NUC_9.L_CORE X_NUC_69.L_CORE 0.003071
K_809 X_NUC_9.L_CORE X_NUC_70.L_CORE 0.003044
K_810 X_NUC_9.L_CORE X_NUC_71.L_CORE 0.003031
K_811 X_NUC_9.L_CORE X_NUC_72.L_CORE 0.003033
K_812 X_NUC_9.L_CORE X_NUC_73.L_CORE 0.003428
K_813 X_NUC_9.L_CORE X_NUC_74.L_CORE 0.003433
K_814 X_NUC_9.L_CORE X_NUC_75.L_CORE 0.003400
K_815 X_NUC_9.L_CORE X_NUC_76.L_CORE 0.003385
K_816 X_NUC_9.L_CORE X_NUC_77.L_CORE 0.002730
K_817 X_NUC_9.L_CORE X_NUC_78.L_CORE 0.002714
K_818 X_NUC_9.L_CORE X_NUC_79.L_CORE 0.002709
K_819 X_NUC_9.L_CORE X_NUC_80.L_CORE 0.002695
K_820 X_NUC_9.L_CORE X_NUC_81.L_CORE 0.003056
K_821 X_NUC_9.L_CORE X_NUC_82.L_CORE 0.003044
K_822 X_NUC_9.L_CORE X_NUC_83.L_CORE 0.003021
K_823 X_NUC_9.L_CORE X_NUC_84.L_CORE 0.003018
K_824 X_NUC_9.L_CORE X_NUC_85.L_CORE 0.006696
K_825 X_NUC_9.L_CORE X_NUC_86.L_CORE 0.004195
K_826 X_NUC_9.L_CORE X_NUC_87.L_CORE 0.022968
K_827 X_NUC_9.L_CORE X_NUC_88.L_CORE 0.003472
K_828 X_NUC_9.L_CORE X_NUC_89.L_CORE 0.004251
K_829 X_NUC_9.L_CORE X_NUC_90.L_CORE 0.005247
K_830 X_NUC_9.L_CORE X_NUC_91.L_CORE 0.002803
K_831 X_NUC_9.L_CORE X_NUC_92.L_CORE 0.004895
K_832 X_NUC_9.L_CORE X_NUC_93.L_CORE 0.003069
K_833 X_NUC_9.L_CORE X_NUC_94.L_CORE 0.002826
K_834 X_NUC_9.L_CORE X_NUC_95.L_CORE 0.003816
K_835 X_NUC_9.L_CORE X_NUC_96.L_CORE 0.002530
K_836 X_NUC_9.L_CORE X_NUC_97.L_CORE 0.002947
K_837 X_NUC_9.L_CORE X_NUC_98.L_CORE 0.002762
K_838 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_839 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_840 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.004216
K_841 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.004178
K_842 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.004230
K_843 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.004155
K_844 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.005479
K_845 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.005345
K_846 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.005374
K_847 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.005409
K_848 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.007020
K_849 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.007137
K_850 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.007107
K_851 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.006922
K_852 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.003420
K_853 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.003375
K_854 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.003403
K_855 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.003373
K_856 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.007642
K_857 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.007566
K_858 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.007384
K_859 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.007567
K_860 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.003813
K_861 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.003810
K_862 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.003824
K_863 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.003761
K_864 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.003530
K_865 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.003477
K_866 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.003486
K_867 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.003485
K_868 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006057
K_869 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006149
K_870 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006003
K_871 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.005988
K_872 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.003001
K_873 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.002979
K_874 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.002991
K_875 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.002961
K_876 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.004158
K_877 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.004112
K_878 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.004077
K_879 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.004109
K_880 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.003772
K_881 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.003788
K_882 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.003767
K_883 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.003723
K_884 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.002891
K_885 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.002861
K_886 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.002865
K_887 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.002853
K_888 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.004281
K_889 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.004284
K_890 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.004213
K_891 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.004232
K_892 X_NUC_10.L_CORE X_NUC_65.L_CORE 0.002925
K_893 X_NUC_10.L_CORE X_NUC_66.L_CORE 0.002916
K_894 X_NUC_10.L_CORE X_NUC_67.L_CORE 0.002913
K_895 X_NUC_10.L_CORE X_NUC_68.L_CORE 0.002887
K_896 X_NUC_10.L_CORE X_NUC_69.L_CORE 0.003098
K_897 X_NUC_10.L_CORE X_NUC_70.L_CORE 0.003071
K_898 X_NUC_10.L_CORE X_NUC_71.L_CORE 0.003057
K_899 X_NUC_10.L_CORE X_NUC_72.L_CORE 0.003059
K_900 X_NUC_10.L_CORE X_NUC_73.L_CORE 0.003422
K_901 X_NUC_10.L_CORE X_NUC_74.L_CORE 0.003428
K_902 X_NUC_10.L_CORE X_NUC_75.L_CORE 0.003395
K_903 X_NUC_10.L_CORE X_NUC_76.L_CORE 0.003380
K_904 X_NUC_10.L_CORE X_NUC_77.L_CORE 0.002746
K_905 X_NUC_10.L_CORE X_NUC_78.L_CORE 0.002730
K_906 X_NUC_10.L_CORE X_NUC_79.L_CORE 0.002724
K_907 X_NUC_10.L_CORE X_NUC_80.L_CORE 0.002711
K_908 X_NUC_10.L_CORE X_NUC_81.L_CORE 0.003067
K_909 X_NUC_10.L_CORE X_NUC_82.L_CORE 0.003056
K_910 X_NUC_10.L_CORE X_NUC_83.L_CORE 0.003032
K_911 X_NUC_10.L_CORE X_NUC_84.L_CORE 0.003030
K_912 X_NUC_10.L_CORE X_NUC_85.L_CORE 0.006747
K_913 X_NUC_10.L_CORE X_NUC_86.L_CORE 0.004277
K_914 X_NUC_10.L_CORE X_NUC_87.L_CORE 0.021183
K_915 X_NUC_10.L_CORE X_NUC_88.L_CORE 0.003495
K_916 X_NUC_10.L_CORE X_NUC_89.L_CORE 0.004329
K_917 X_NUC_10.L_CORE X_NUC_90.L_CORE 0.005170
K_918 X_NUC_10.L_CORE X_NUC_91.L_CORE 0.002832
K_919 X_NUC_10.L_CORE X_NUC_92.L_CORE 0.004910
K_920 X_NUC_10.L_CORE X_NUC_93.L_CORE 0.003069
K_921 X_NUC_10.L_CORE X_NUC_94.L_CORE 0.002857
K_922 X_NUC_10.L_CORE X_NUC_95.L_CORE 0.003794
K_923 X_NUC_10.L_CORE X_NUC_96.L_CORE 0.002543
K_924 X_NUC_10.L_CORE X_NUC_97.L_CORE 0.002962
K_925 X_NUC_10.L_CORE X_NUC_98.L_CORE 0.002765
K_926 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_927 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.004164
K_928 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.004126
K_929 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.004178
K_930 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.004105
K_931 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.005447
K_932 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.005314
K_933 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.005345
K_934 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.005379
K_935 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.007044
K_936 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.007159
K_937 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.007137
K_938 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.006946
K_939 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.003391
K_940 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.003348
K_941 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.003375
K_942 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.003346
K_943 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.007839
K_944 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.007753
K_945 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.007566
K_946 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.007759
K_947 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.003799
K_948 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.003795
K_949 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.003810
K_950 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.003747
K_951 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.003521
K_952 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.003467
K_953 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.003477
K_954 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.003475
K_955 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006204
K_956 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006300
K_957 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006149
K_958 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006131
K_959 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.002989
K_960 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.002966
K_961 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.002979
K_962 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.002949
K_963 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.004194
K_964 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.004146
K_965 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.004112
K_966 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.004144
K_967 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.003793
K_968 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.003808
K_969 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.003788
K_970 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.003743
K_971 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.002887
K_972 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.002857
K_973 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.002861
K_974 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.002849
K_975 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.004354
K_976 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.004357
K_977 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.004284
K_978 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.004303
K_979 X_NUC_11.L_CORE X_NUC_65.L_CORE 0.002928
K_980 X_NUC_11.L_CORE X_NUC_66.L_CORE 0.002918
K_981 X_NUC_11.L_CORE X_NUC_67.L_CORE 0.002916
K_982 X_NUC_11.L_CORE X_NUC_68.L_CORE 0.002889
K_983 X_NUC_11.L_CORE X_NUC_69.L_CORE 0.003112
K_984 X_NUC_11.L_CORE X_NUC_70.L_CORE 0.003084
K_985 X_NUC_11.L_CORE X_NUC_71.L_CORE 0.003071
K_986 X_NUC_11.L_CORE X_NUC_72.L_CORE 0.003073
K_987 X_NUC_11.L_CORE X_NUC_73.L_CORE 0.003456
K_988 X_NUC_11.L_CORE X_NUC_74.L_CORE 0.003462
K_989 X_NUC_11.L_CORE X_NUC_75.L_CORE 0.003428
K_990 X_NUC_11.L_CORE X_NUC_76.L_CORE 0.003413
K_991 X_NUC_11.L_CORE X_NUC_77.L_CORE 0.002752
K_992 X_NUC_11.L_CORE X_NUC_78.L_CORE 0.002736
K_993 X_NUC_11.L_CORE X_NUC_79.L_CORE 0.002730
K_994 X_NUC_11.L_CORE X_NUC_80.L_CORE 0.002716
K_995 X_NUC_11.L_CORE X_NUC_81.L_CORE 0.003091
K_996 X_NUC_11.L_CORE X_NUC_82.L_CORE 0.003079
K_997 X_NUC_11.L_CORE X_NUC_83.L_CORE 0.003056
K_998 X_NUC_11.L_CORE X_NUC_84.L_CORE 0.003053
K_999 X_NUC_11.L_CORE X_NUC_85.L_CORE 0.006569
K_1000 X_NUC_11.L_CORE X_NUC_86.L_CORE 0.004215
K_1001 X_NUC_11.L_CORE X_NUC_87.L_CORE 0.022896
K_1002 X_NUC_11.L_CORE X_NUC_88.L_CORE 0.003462
K_1003 X_NUC_11.L_CORE X_NUC_89.L_CORE 0.004324
K_1004 X_NUC_11.L_CORE X_NUC_90.L_CORE 0.005212
K_1005 X_NUC_11.L_CORE X_NUC_91.L_CORE 0.002817
K_1006 X_NUC_11.L_CORE X_NUC_92.L_CORE 0.005004
K_1007 X_NUC_11.L_CORE X_NUC_93.L_CORE 0.003069
K_1008 X_NUC_11.L_CORE X_NUC_94.L_CORE 0.002858
K_1009 X_NUC_11.L_CORE X_NUC_95.L_CORE 0.003850
K_1010 X_NUC_11.L_CORE X_NUC_96.L_CORE 0.002543
K_1011 X_NUC_11.L_CORE X_NUC_97.L_CORE 0.002985
K_1012 X_NUC_11.L_CORE X_NUC_98.L_CORE 0.002782
K_1013 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.004240
K_1014 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.004200
K_1015 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.004254
K_1016 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.004178
K_1017 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.005411
K_1018 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.005280
K_1019 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.005309
K_1020 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.005345
K_1021 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.007239
K_1022 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.007364
K_1023 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.007336
K_1024 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.007137
K_1025 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.003422
K_1026 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.003377
K_1027 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.003405
K_1028 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.003375
K_1029 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.007636
K_1030 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.007556
K_1031 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.007378
K_1032 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.007566
K_1033 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.003864
K_1034 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.003860
K_1035 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.003875
K_1036 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.003810
K_1037 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.003522
K_1038 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.003468
K_1039 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.003478
K_1040 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.003477
K_1041 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006220
K_1042 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006317
K_1043 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006162
K_1044 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006149
K_1045 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.003020
K_1046 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.002997
K_1047 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.003009
K_1048 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.002979
K_1049 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.004160
K_1050 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.004113
K_1051 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.004079
K_1052 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.004112
K_1053 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.003839
K_1054 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.003854
K_1055 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.003833
K_1056 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.003788
K_1057 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.002899
K_1058 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.002869
K_1059 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.002873
K_1060 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.002861
K_1061 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.004334
K_1062 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.004337
K_1063 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.004264
K_1064 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.004284
K_1065 X_NUC_12.L_CORE X_NUC_65.L_CORE 0.002955
K_1066 X_NUC_12.L_CORE X_NUC_66.L_CORE 0.002946
K_1067 X_NUC_12.L_CORE X_NUC_67.L_CORE 0.002943
K_1068 X_NUC_12.L_CORE X_NUC_68.L_CORE 0.002916
K_1069 X_NUC_12.L_CORE X_NUC_69.L_CORE 0.003109
K_1070 X_NUC_12.L_CORE X_NUC_70.L_CORE 0.003082
K_1071 X_NUC_12.L_CORE X_NUC_71.L_CORE 0.003068
K_1072 X_NUC_12.L_CORE X_NUC_72.L_CORE 0.003071
K_1073 X_NUC_12.L_CORE X_NUC_73.L_CORE 0.003472
K_1074 X_NUC_12.L_CORE X_NUC_74.L_CORE 0.003477
K_1075 X_NUC_12.L_CORE X_NUC_75.L_CORE 0.003443
K_1076 X_NUC_12.L_CORE X_NUC_76.L_CORE 0.003428
K_1077 X_NUC_12.L_CORE X_NUC_77.L_CORE 0.002766
K_1078 X_NUC_12.L_CORE X_NUC_78.L_CORE 0.002750
K_1079 X_NUC_12.L_CORE X_NUC_79.L_CORE 0.002744
K_1080 X_NUC_12.L_CORE X_NUC_80.L_CORE 0.002730
K_1081 X_NUC_12.L_CORE X_NUC_81.L_CORE 0.003094
K_1082 X_NUC_12.L_CORE X_NUC_82.L_CORE 0.003082
K_1083 X_NUC_12.L_CORE X_NUC_83.L_CORE 0.003058
K_1084 X_NUC_12.L_CORE X_NUC_84.L_CORE 0.003056
K_1085 X_NUC_12.L_CORE X_NUC_85.L_CORE 0.006758
K_1086 X_NUC_12.L_CORE X_NUC_86.L_CORE 0.004241
K_1087 X_NUC_12.L_CORE X_NUC_87.L_CORE 0.021385
K_1088 X_NUC_12.L_CORE X_NUC_88.L_CORE 0.003515
K_1089 X_NUC_12.L_CORE X_NUC_89.L_CORE 0.004290
K_1090 X_NUC_12.L_CORE X_NUC_90.L_CORE 0.005297
K_1091 X_NUC_12.L_CORE X_NUC_91.L_CORE 0.002837
K_1092 X_NUC_12.L_CORE X_NUC_92.L_CORE 0.004929
K_1093 X_NUC_12.L_CORE X_NUC_93.L_CORE 0.003106
K_1094 X_NUC_12.L_CORE X_NUC_94.L_CORE 0.002858
K_1095 X_NUC_12.L_CORE X_NUC_95.L_CORE 0.003854
K_1096 X_NUC_12.L_CORE X_NUC_96.L_CORE 0.002561
K_1097 X_NUC_12.L_CORE X_NUC_97.L_CORE 0.002978
K_1098 X_NUC_12.L_CORE X_NUC_98.L_CORE 0.002794
K_1099 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_1100 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_1101 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_1102 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.003720
K_1103 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.003702
K_1104 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.003676
K_1105 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.003740
K_1106 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.004866
K_1107 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.004965
K_1108 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.004872
K_1109 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.004929
K_1110 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.006732
K_1111 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.006546
K_1112 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.006549
K_1113 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.006619
K_1114 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.003128
K_1115 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.003138
K_1116 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.003104
K_1117 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.003148
K_1118 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.007610
K_1119 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.007812
K_1120 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.007603
K_1121 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.007545
K_1122 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.003621
K_1123 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.003587
K_1124 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.003564
K_1125 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.003610
K_1126 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.003320
K_1127 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.003353
K_1128 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.003303
K_1129 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.003338
K_1130 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006355
K_1131 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006272
K_1132 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006210
K_1133 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006180
K_1134 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.002865
K_1135 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.002862
K_1136 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.002834
K_1137 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.002868
K_1138 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.004084
K_1139 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.004139
K_1140 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.004063
K_1141 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.004076
K_1142 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.003759
K_1143 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.003721
K_1144 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.003693
K_1145 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.003719
K_1146 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.002803
K_1147 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.002815
K_1148 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.002779
K_1149 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.002807
K_1150 X_NUC_13.L_CORE X_NUC_65.L_CORE 0.004347
K_1151 X_NUC_13.L_CORE X_NUC_66.L_CORE 0.004358
K_1152 X_NUC_13.L_CORE X_NUC_67.L_CORE 0.004292
K_1153 X_NUC_13.L_CORE X_NUC_68.L_CORE 0.004287
K_1154 X_NUC_13.L_CORE X_NUC_69.L_CORE 0.002897
K_1155 X_NUC_13.L_CORE X_NUC_70.L_CORE 0.002887
K_1156 X_NUC_13.L_CORE X_NUC_71.L_CORE 0.002859
K_1157 X_NUC_13.L_CORE X_NUC_72.L_CORE 0.002885
K_1158 X_NUC_13.L_CORE X_NUC_73.L_CORE 0.003071
K_1159 X_NUC_13.L_CORE X_NUC_74.L_CORE 0.003090
K_1160 X_NUC_13.L_CORE X_NUC_75.L_CORE 0.003045
K_1161 X_NUC_13.L_CORE X_NUC_76.L_CORE 0.003064
K_1162 X_NUC_13.L_CORE X_NUC_77.L_CORE 0.003404
K_1163 X_NUC_13.L_CORE X_NUC_78.L_CORE 0.003394
K_1164 X_NUC_13.L_CORE X_NUC_79.L_CORE 0.003355
K_1165 X_NUC_13.L_CORE X_NUC_80.L_CORE 0.003368
K_1166 X_NUC_13.L_CORE X_NUC_81.L_CORE 0.002820
K_1167 X_NUC_13.L_CORE X_NUC_82.L_CORE 0.002822
K_1168 X_NUC_13.L_CORE X_NUC_83.L_CORE 0.002788
K_1169 X_NUC_13.L_CORE X_NUC_84.L_CORE 0.002809
K_1170 X_NUC_13.L_CORE X_NUC_85.L_CORE 0.007651
K_1171 X_NUC_13.L_CORE X_NUC_86.L_CORE 0.005294
K_1172 X_NUC_13.L_CORE X_NUC_87.L_CORE 0.003572
K_1173 X_NUC_13.L_CORE X_NUC_88.L_CORE 0.019260
K_1174 X_NUC_13.L_CORE X_NUC_89.L_CORE 0.003130
K_1175 X_NUC_13.L_CORE X_NUC_90.L_CORE 0.003995
K_1176 X_NUC_13.L_CORE X_NUC_91.L_CORE 0.004908
K_1177 X_NUC_13.L_CORE X_NUC_92.L_CORE 0.002661
K_1178 X_NUC_13.L_CORE X_NUC_93.L_CORE 0.004842
K_1179 X_NUC_13.L_CORE X_NUC_94.L_CORE 0.002959
K_1180 X_NUC_13.L_CORE X_NUC_95.L_CORE 0.002781
K_1181 X_NUC_13.L_CORE X_NUC_96.L_CORE 0.003716
K_1182 X_NUC_13.L_CORE X_NUC_97.L_CORE 0.002535
K_1183 X_NUC_13.L_CORE X_NUC_98.L_CORE 0.002887
K_1184 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_1185 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_1186 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.003736
K_1187 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.003720
K_1188 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.003693
K_1189 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.003757
K_1190 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.004770
K_1191 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.004866
K_1192 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.004777
K_1193 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.004831
K_1194 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.006926
K_1195 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.006732
K_1196 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.006731
K_1197 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.006807
K_1198 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.003118
K_1199 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.003128
K_1200 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.003094
K_1201 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.003138
K_1202 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.007414
K_1203 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.007610
K_1204 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.007412
K_1205 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.007358
K_1206 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.003655
K_1207 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.003621
K_1208 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.003598
K_1209 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.003645
K_1210 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.003286
K_1211 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.003320
K_1212 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.003271
K_1213 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.003305
K_1214 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006436
K_1215 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006355
K_1216 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006289
K_1217 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006258
K_1218 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.002868
K_1219 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.002865
K_1220 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.002837
K_1221 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.002872
K_1222 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.004030
K_1223 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.004084
K_1224 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.004011
K_1225 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.004023
K_1226 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.003797
K_1227 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.003759
K_1228 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.003730
K_1229 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.003756
K_1230 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.002790
K_1231 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.002803
K_1232 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.002767
K_1233 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.002795
K_1234 X_NUC_14.L_CORE X_NUC_65.L_CORE 0.004334
K_1235 X_NUC_14.L_CORE X_NUC_66.L_CORE 0.004347
K_1236 X_NUC_14.L_CORE X_NUC_67.L_CORE 0.004281
K_1237 X_NUC_14.L_CORE X_NUC_68.L_CORE 0.004275
K_1238 X_NUC_14.L_CORE X_NUC_69.L_CORE 0.002907
K_1239 X_NUC_14.L_CORE X_NUC_70.L_CORE 0.002897
K_1240 X_NUC_14.L_CORE X_NUC_71.L_CORE 0.002868
K_1241 X_NUC_14.L_CORE X_NUC_72.L_CORE 0.002895
K_1242 X_NUC_14.L_CORE X_NUC_73.L_CORE 0.003052
K_1243 X_NUC_14.L_CORE X_NUC_74.L_CORE 0.003071
K_1244 X_NUC_14.L_CORE X_NUC_75.L_CORE 0.003027
K_1245 X_NUC_14.L_CORE X_NUC_76.L_CORE 0.003045
K_1246 X_NUC_14.L_CORE X_NUC_77.L_CORE 0.003413
K_1247 X_NUC_14.L_CORE X_NUC_78.L_CORE 0.003404
K_1248 X_NUC_14.L_CORE X_NUC_79.L_CORE 0.003365
K_1249 X_NUC_14.L_CORE X_NUC_80.L_CORE 0.003378
K_1250 X_NUC_14.L_CORE X_NUC_81.L_CORE 0.002817
K_1251 X_NUC_14.L_CORE X_NUC_82.L_CORE 0.002820
K_1252 X_NUC_14.L_CORE X_NUC_83.L_CORE 0.002786
K_1253 X_NUC_14.L_CORE X_NUC_84.L_CORE 0.002806
K_1254 X_NUC_14.L_CORE X_NUC_85.L_CORE 0.007496
K_1255 X_NUC_14.L_CORE X_NUC_86.L_CORE 0.005378
K_1256 X_NUC_14.L_CORE X_NUC_87.L_CORE 0.003540
K_1257 X_NUC_14.L_CORE X_NUC_88.L_CORE 0.019483
K_1258 X_NUC_14.L_CORE X_NUC_89.L_CORE 0.003145
K_1259 X_NUC_14.L_CORE X_NUC_90.L_CORE 0.003929
K_1260 X_NUC_14.L_CORE X_NUC_91.L_CORE 0.005006
K_1261 X_NUC_14.L_CORE X_NUC_92.L_CORE 0.002653
K_1262 X_NUC_14.L_CORE X_NUC_93.L_CORE 0.004785
K_1263 X_NUC_14.L_CORE X_NUC_94.L_CORE 0.002980
K_1264 X_NUC_14.L_CORE X_NUC_95.L_CORE 0.002761
K_1265 X_NUC_14.L_CORE X_NUC_96.L_CORE 0.003731
K_1266 X_NUC_14.L_CORE X_NUC_97.L_CORE 0.002536
K_1267 X_NUC_14.L_CORE X_NUC_98.L_CORE 0.002878
K_1268 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_1269 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.003763
K_1270 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.003746
K_1271 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.003720
K_1272 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.003785
K_1273 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.004858
K_1274 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.004958
K_1275 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.004866
K_1276 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.004922
K_1277 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.006923
K_1278 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.006725
K_1279 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.006732
K_1280 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.006804
K_1281 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.003153
K_1282 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.003163
K_1283 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.003128
K_1284 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.003174
K_1285 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.007607
K_1286 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.007814
K_1287 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.007610
K_1288 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.007547
K_1289 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.003680
K_1290 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.003644
K_1291 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.003621
K_1292 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.003668
K_1293 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.003335
K_1294 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.003370
K_1295 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.003320
K_1296 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.003355
K_1297 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006505
K_1298 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006418
K_1299 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006355
K_1300 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.006320
K_1301 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.002897
K_1302 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.002894
K_1303 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.002865
K_1304 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.002901
K_1305 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.004103
K_1306 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.004160
K_1307 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.004084
K_1308 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.004097
K_1309 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.003828
K_1310 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.003788
K_1311 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.003759
K_1312 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.003786
K_1313 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.002826
K_1314 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.002839
K_1315 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.002803
K_1316 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.002831
K_1317 X_NUC_15.L_CORE X_NUC_65.L_CORE 0.004402
K_1318 X_NUC_15.L_CORE X_NUC_66.L_CORE 0.004414
K_1319 X_NUC_15.L_CORE X_NUC_67.L_CORE 0.004347
K_1320 X_NUC_15.L_CORE X_NUC_68.L_CORE 0.004340
K_1321 X_NUC_15.L_CORE X_NUC_69.L_CORE 0.002936
K_1322 X_NUC_15.L_CORE X_NUC_70.L_CORE 0.002926
K_1323 X_NUC_15.L_CORE X_NUC_71.L_CORE 0.002897
K_1324 X_NUC_15.L_CORE X_NUC_72.L_CORE 0.002924
K_1325 X_NUC_15.L_CORE X_NUC_73.L_CORE 0.003097
K_1326 X_NUC_15.L_CORE X_NUC_74.L_CORE 0.003116
K_1327 X_NUC_15.L_CORE X_NUC_75.L_CORE 0.003071
K_1328 X_NUC_15.L_CORE X_NUC_76.L_CORE 0.003090
K_1329 X_NUC_15.L_CORE X_NUC_77.L_CORE 0.003454
K_1330 X_NUC_15.L_CORE X_NUC_78.L_CORE 0.003443
K_1331 X_NUC_15.L_CORE X_NUC_79.L_CORE 0.003404
K_1332 X_NUC_15.L_CORE X_NUC_80.L_CORE 0.003417
K_1333 X_NUC_15.L_CORE X_NUC_81.L_CORE 0.002852
K_1334 X_NUC_15.L_CORE X_NUC_82.L_CORE 0.002854
K_1335 X_NUC_15.L_CORE X_NUC_83.L_CORE 0.002820
K_1336 X_NUC_15.L_CORE X_NUC_84.L_CORE 0.002840
K_1337 X_NUC_15.L_CORE X_NUC_85.L_CORE 0.007543
K_1338 X_NUC_15.L_CORE X_NUC_86.L_CORE 0.005363
K_1339 X_NUC_15.L_CORE X_NUC_87.L_CORE 0.003580
K_1340 X_NUC_15.L_CORE X_NUC_88.L_CORE 0.018922
K_1341 X_NUC_15.L_CORE X_NUC_89.L_CORE 0.003165
K_1342 X_NUC_15.L_CORE X_NUC_90.L_CORE 0.003991
K_1343 X_NUC_15.L_CORE X_NUC_91.L_CORE 0.005010
K_1344 X_NUC_15.L_CORE X_NUC_92.L_CORE 0.002682
K_1345 X_NUC_15.L_CORE X_NUC_93.L_CORE 0.004863
K_1346 X_NUC_15.L_CORE X_NUC_94.L_CORE 0.003001
K_1347 X_NUC_15.L_CORE X_NUC_95.L_CORE 0.002798
K_1348 X_NUC_15.L_CORE X_NUC_96.L_CORE 0.003769
K_1349 X_NUC_15.L_CORE X_NUC_97.L_CORE 0.002562
K_1350 X_NUC_15.L_CORE X_NUC_98.L_CORE 0.002914
K_1351 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.003699
K_1352 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.003682
K_1353 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.003657
K_1354 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.003720
K_1355 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.004803
K_1356 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.004900
K_1357 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.004810
K_1358 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.004866
K_1359 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.006843
K_1360 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.006652
K_1361 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.006655
K_1362 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.006732
K_1363 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.003108
K_1364 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.003118
K_1365 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.003084
K_1366 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.003128
K_1367 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.007667
K_1368 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.007879
K_1369 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.007665
K_1370 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.007610
K_1371 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.003631
K_1372 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.003597
K_1373 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.003574
K_1374 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.003621
K_1375 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.003300
K_1376 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.003334
K_1377 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.003285
K_1378 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.003320
K_1379 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006540
K_1380 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006452
K_1381 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006385
K_1382 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006355
K_1383 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.002862
K_1384 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.002859
K_1385 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.002831
K_1386 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.002865
K_1387 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.004090
K_1388 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.004145
K_1389 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.004070
K_1390 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.004084
K_1391 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.003799
K_1392 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.003761
K_1393 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.003732
K_1394 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.003759
K_1395 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.002798
K_1396 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.002811
K_1397 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.002775
K_1398 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.002803
K_1399 X_NUC_16.L_CORE X_NUC_65.L_CORE 0.004408
K_1400 X_NUC_16.L_CORE X_NUC_66.L_CORE 0.004420
K_1401 X_NUC_16.L_CORE X_NUC_67.L_CORE 0.004352
K_1402 X_NUC_16.L_CORE X_NUC_68.L_CORE 0.004347
K_1403 X_NUC_16.L_CORE X_NUC_69.L_CORE 0.002909
K_1404 X_NUC_16.L_CORE X_NUC_70.L_CORE 0.002899
K_1405 X_NUC_16.L_CORE X_NUC_71.L_CORE 0.002870
K_1406 X_NUC_16.L_CORE X_NUC_72.L_CORE 0.002897
K_1407 X_NUC_16.L_CORE X_NUC_73.L_CORE 0.003077
K_1408 X_NUC_16.L_CORE X_NUC_74.L_CORE 0.003097
K_1409 X_NUC_16.L_CORE X_NUC_75.L_CORE 0.003052
K_1410 X_NUC_16.L_CORE X_NUC_76.L_CORE 0.003071
K_1411 X_NUC_16.L_CORE X_NUC_77.L_CORE 0.003440
K_1412 X_NUC_16.L_CORE X_NUC_78.L_CORE 0.003429
K_1413 X_NUC_16.L_CORE X_NUC_79.L_CORE 0.003390
K_1414 X_NUC_16.L_CORE X_NUC_80.L_CORE 0.003404
K_1415 X_NUC_16.L_CORE X_NUC_81.L_CORE 0.002831
K_1416 X_NUC_16.L_CORE X_NUC_82.L_CORE 0.002833
K_1417 X_NUC_16.L_CORE X_NUC_83.L_CORE 0.002799
K_1418 X_NUC_16.L_CORE X_NUC_84.L_CORE 0.002820
K_1419 X_NUC_16.L_CORE X_NUC_85.L_CORE 0.007384
K_1420 X_NUC_16.L_CORE X_NUC_86.L_CORE 0.005261
K_1421 X_NUC_16.L_CORE X_NUC_87.L_CORE 0.003528
K_1422 X_NUC_16.L_CORE X_NUC_88.L_CORE 0.020722
K_1423 X_NUC_16.L_CORE X_NUC_89.L_CORE 0.003120
K_1424 X_NUC_16.L_CORE X_NUC_90.L_CORE 0.003964
K_1425 X_NUC_16.L_CORE X_NUC_91.L_CORE 0.004993
K_1426 X_NUC_16.L_CORE X_NUC_92.L_CORE 0.002651
K_1427 X_NUC_16.L_CORE X_NUC_93.L_CORE 0.004894
K_1428 X_NUC_16.L_CORE X_NUC_94.L_CORE 0.002974
K_1429 X_NUC_16.L_CORE X_NUC_95.L_CORE 0.002778
K_1430 X_NUC_16.L_CORE X_NUC_96.L_CORE 0.003771
K_1431 X_NUC_16.L_CORE X_NUC_97.L_CORE 0.002541
K_1432 X_NUC_16.L_CORE X_NUC_98.L_CORE 0.002903
K_1433 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_1434 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_1435 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_1436 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.003428
K_1437 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.003476
K_1438 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.003465
K_1439 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.003433
K_1440 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.004547
K_1441 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.004519
K_1442 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.004569
K_1443 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.004476
K_1444 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.006429
K_1445 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.006611
K_1446 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.006439
K_1447 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.006497
K_1448 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.002965
K_1449 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.002985
K_1450 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.002987
K_1451 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.002950
K_1452 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.007600
K_1453 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.007427
K_1454 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.007439
K_1455 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.007336
K_1456 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.003494
K_1457 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.003547
K_1458 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.003511
K_1459 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.003498
K_1460 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.003217
K_1461 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.003217
K_1462 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.003225
K_1463 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.003180
K_1464 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006485
K_1465 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006534
K_1466 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.006349
K_1467 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.006412
K_1468 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.002799
K_1469 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.002824
K_1470 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.002811
K_1471 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.002788
K_1472 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.004065
K_1473 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.004038
K_1474 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.004036
K_1475 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.003988
K_1476 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.003744
K_1477 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.003791
K_1478 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.003732
K_1479 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.003733
K_1480 X_NUC_17.L_CORE X_NUC_65.L_CORE 0.002785
K_1481 X_NUC_17.L_CORE X_NUC_66.L_CORE 0.002795
K_1482 X_NUC_17.L_CORE X_NUC_67.L_CORE 0.002788
K_1483 X_NUC_17.L_CORE X_NUC_68.L_CORE 0.002760
K_1484 X_NUC_17.L_CORE X_NUC_69.L_CORE 0.004347
K_1485 X_NUC_17.L_CORE X_NUC_70.L_CORE 0.004340
K_1486 X_NUC_17.L_CORE X_NUC_71.L_CORE 0.004287
K_1487 X_NUC_17.L_CORE X_NUC_72.L_CORE 0.004275
K_1488 X_NUC_17.L_CORE X_NUC_73.L_CORE 0.002916
K_1489 X_NUC_17.L_CORE X_NUC_74.L_CORE 0.002941
K_1490 X_NUC_17.L_CORE X_NUC_75.L_CORE 0.002915
K_1491 X_NUC_17.L_CORE X_NUC_76.L_CORE 0.002900
K_1492 X_NUC_17.L_CORE X_NUC_77.L_CORE 0.003096
K_1493 X_NUC_17.L_CORE X_NUC_78.L_CORE 0.003099
K_1494 X_NUC_17.L_CORE X_NUC_79.L_CORE 0.003084
K_1495 X_NUC_17.L_CORE X_NUC_80.L_CORE 0.003058
K_1496 X_NUC_17.L_CORE X_NUC_81.L_CORE 0.003308
K_1497 X_NUC_17.L_CORE X_NUC_82.L_CORE 0.003324
K_1498 X_NUC_17.L_CORE X_NUC_83.L_CORE 0.003287
K_1499 X_NUC_17.L_CORE X_NUC_84.L_CORE 0.003276
K_1500 X_NUC_17.L_CORE X_NUC_85.L_CORE 0.004064
K_1501 X_NUC_17.L_CORE X_NUC_86.L_CORE 0.007066
K_1502 X_NUC_17.L_CORE X_NUC_87.L_CORE 0.004697
K_1503 X_NUC_17.L_CORE X_NUC_88.L_CORE 0.003191
K_1504 X_NUC_17.L_CORE X_NUC_89.L_CORE 0.016919
K_1505 X_NUC_17.L_CORE X_NUC_90.L_CORE 0.002943
K_1506 X_NUC_17.L_CORE X_NUC_91.L_CORE 0.003736
K_1507 X_NUC_17.L_CORE X_NUC_92.L_CORE 0.004801
K_1508 X_NUC_17.L_CORE X_NUC_93.L_CORE 0.002571
K_1509 X_NUC_17.L_CORE X_NUC_94.L_CORE 0.004665
K_1510 X_NUC_17.L_CORE X_NUC_95.L_CORE 0.002933
K_1511 X_NUC_17.L_CORE X_NUC_96.L_CORE 0.002749
K_1512 X_NUC_17.L_CORE X_NUC_97.L_CORE 0.003576
K_1513 X_NUC_17.L_CORE X_NUC_98.L_CORE 0.002635
K_1514 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_1515 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_1516 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.003381
K_1517 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.003428
K_1518 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.003417
K_1519 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.003387
K_1520 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.004574
K_1521 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.004547
K_1522 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.004597
K_1523 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.004502
K_1524 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.006255
K_1525 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.006429
K_1526 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.006267
K_1527 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.006320
K_1528 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.002944
K_1529 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.002965
K_1530 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.002966
K_1531 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.002931
K_1532 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.007775
K_1533 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.007600
K_1534 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.007608
K_1535 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.007498
K_1536 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.003441
K_1537 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.003494
K_1538 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.003458
K_1539 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.003446
K_1540 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.003216
K_1541 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.003217
K_1542 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.003225
K_1543 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.003180
K_1544 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.006430
K_1545 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006485
K_1546 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.006300
K_1547 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.006362
K_1548 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.002774
K_1549 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.002799
K_1550 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.002786
K_1551 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.002763
K_1552 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.004090
K_1553 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.004065
K_1554 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.004062
K_1555 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.004013
K_1556 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.003698
K_1557 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.003744
K_1558 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.003687
K_1559 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.003688
K_1560 X_NUC_18.L_CORE X_NUC_65.L_CORE 0.002774
K_1561 X_NUC_18.L_CORE X_NUC_66.L_CORE 0.002785
K_1562 X_NUC_18.L_CORE X_NUC_67.L_CORE 0.002778
K_1563 X_NUC_18.L_CORE X_NUC_68.L_CORE 0.002750
K_1564 X_NUC_18.L_CORE X_NUC_69.L_CORE 0.004352
K_1565 X_NUC_18.L_CORE X_NUC_70.L_CORE 0.004347
K_1566 X_NUC_18.L_CORE X_NUC_71.L_CORE 0.004292
K_1567 X_NUC_18.L_CORE X_NUC_72.L_CORE 0.004281
K_1568 X_NUC_18.L_CORE X_NUC_73.L_CORE 0.002892
K_1569 X_NUC_18.L_CORE X_NUC_74.L_CORE 0.002916
K_1570 X_NUC_18.L_CORE X_NUC_75.L_CORE 0.002891
K_1571 X_NUC_18.L_CORE X_NUC_76.L_CORE 0.002876
K_1572 X_NUC_18.L_CORE X_NUC_77.L_CORE 0.003094
K_1573 X_NUC_18.L_CORE X_NUC_78.L_CORE 0.003096
K_1574 X_NUC_18.L_CORE X_NUC_79.L_CORE 0.003082
K_1575 X_NUC_18.L_CORE X_NUC_80.L_CORE 0.003056
K_1576 X_NUC_18.L_CORE X_NUC_81.L_CORE 0.003292
K_1577 X_NUC_18.L_CORE X_NUC_82.L_CORE 0.003308
K_1578 X_NUC_18.L_CORE X_NUC_83.L_CORE 0.003272
K_1579 X_NUC_18.L_CORE X_NUC_84.L_CORE 0.003260
K_1580 X_NUC_18.L_CORE X_NUC_85.L_CORE 0.004019
K_1581 X_NUC_18.L_CORE X_NUC_86.L_CORE 0.007145
K_1582 X_NUC_18.L_CORE X_NUC_87.L_CORE 0.004595
K_1583 X_NUC_18.L_CORE X_NUC_88.L_CORE 0.003181
K_1584 X_NUC_18.L_CORE X_NUC_89.L_CORE 0.017620
K_1585 X_NUC_18.L_CORE X_NUC_90.L_CORE 0.002908
K_1586 X_NUC_18.L_CORE X_NUC_91.L_CORE 0.003761
K_1587 X_NUC_18.L_CORE X_NUC_92.L_CORE 0.004722
K_1588 X_NUC_18.L_CORE X_NUC_93.L_CORE 0.002557
K_1589 X_NUC_18.L_CORE X_NUC_94.L_CORE 0.004714
K_1590 X_NUC_18.L_CORE X_NUC_95.L_CORE 0.002902
K_1591 X_NUC_18.L_CORE X_NUC_96.L_CORE 0.002748
K_1592 X_NUC_18.L_CORE X_NUC_97.L_CORE 0.003564
K_1593 X_NUC_18.L_CORE X_NUC_98.L_CORE 0.002622
K_1594 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_1595 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.003391
K_1596 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.003438
K_1597 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.003428
K_1598 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.003397
K_1599 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.004524
K_1600 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.004497
K_1601 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.004547
K_1602 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.004455
K_1603 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.006412
K_1604 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.006597
K_1605 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.006429
K_1606 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.006483
K_1607 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.002943
K_1608 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.002963
K_1609 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.002965
K_1610 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.002929
K_1611 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.007762
K_1612 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.007583
K_1613 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.007600
K_1614 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.007485
K_1615 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.003476
K_1616 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.003529
K_1617 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.003494
K_1618 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.003481
K_1619 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.003207
K_1620 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.003207
K_1621 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.003217
K_1622 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.003171
K_1623 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006622
K_1624 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006679
K_1625 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006485
K_1626 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.006549
K_1627 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.002786
K_1628 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.002811
K_1629 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.002799
K_1630 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.002776
K_1631 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.004093
K_1632 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.004066
K_1633 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.004065
K_1634 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.004016
K_1635 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.003755
K_1636 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.003803
K_1637 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.003744
K_1638 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.003745
K_1639 X_NUC_19.L_CORE X_NUC_65.L_CORE 0.002781
K_1640 X_NUC_19.L_CORE X_NUC_66.L_CORE 0.002791
K_1641 X_NUC_19.L_CORE X_NUC_67.L_CORE 0.002785
K_1642 X_NUC_19.L_CORE X_NUC_68.L_CORE 0.002756
K_1643 X_NUC_19.L_CORE X_NUC_69.L_CORE 0.004407
K_1644 X_NUC_19.L_CORE X_NUC_70.L_CORE 0.004402
K_1645 X_NUC_19.L_CORE X_NUC_71.L_CORE 0.004347
K_1646 X_NUC_19.L_CORE X_NUC_72.L_CORE 0.004334
K_1647 X_NUC_19.L_CORE X_NUC_73.L_CORE 0.002917
K_1648 X_NUC_19.L_CORE X_NUC_74.L_CORE 0.002942
K_1649 X_NUC_19.L_CORE X_NUC_75.L_CORE 0.002916
K_1650 X_NUC_19.L_CORE X_NUC_76.L_CORE 0.002901
K_1651 X_NUC_19.L_CORE X_NUC_77.L_CORE 0.003108
K_1652 X_NUC_19.L_CORE X_NUC_78.L_CORE 0.003111
K_1653 X_NUC_19.L_CORE X_NUC_79.L_CORE 0.003096
K_1654 X_NUC_19.L_CORE X_NUC_80.L_CORE 0.003070
K_1655 X_NUC_19.L_CORE X_NUC_81.L_CORE 0.003328
K_1656 X_NUC_19.L_CORE X_NUC_82.L_CORE 0.003345
K_1657 X_NUC_19.L_CORE X_NUC_83.L_CORE 0.003308
K_1658 X_NUC_19.L_CORE X_NUC_84.L_CORE 0.003296
K_1659 X_NUC_19.L_CORE X_NUC_85.L_CORE 0.003992
K_1660 X_NUC_19.L_CORE X_NUC_86.L_CORE 0.006933
K_1661 X_NUC_19.L_CORE X_NUC_87.L_CORE 0.004629
K_1662 X_NUC_19.L_CORE X_NUC_88.L_CORE 0.003162
K_1663 X_NUC_19.L_CORE X_NUC_89.L_CORE 0.018352
K_1664 X_NUC_19.L_CORE X_NUC_90.L_CORE 0.002920
K_1665 X_NUC_19.L_CORE X_NUC_91.L_CORE 0.003735
K_1666 X_NUC_19.L_CORE X_NUC_92.L_CORE 0.004827
K_1667 X_NUC_19.L_CORE X_NUC_93.L_CORE 0.002560
K_1668 X_NUC_19.L_CORE X_NUC_94.L_CORE 0.004742
K_1669 X_NUC_19.L_CORE X_NUC_95.L_CORE 0.002932
K_1670 X_NUC_19.L_CORE X_NUC_96.L_CORE 0.002753
K_1671 X_NUC_19.L_CORE X_NUC_97.L_CORE 0.003613
K_1672 X_NUC_19.L_CORE X_NUC_98.L_CORE 0.002640
K_1673 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.003422
K_1674 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.003470
K_1675 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.003459
K_1676 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.003428
K_1677 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.004620
K_1678 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.004591
K_1679 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.004643
K_1680 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.004547
K_1681 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.006357
K_1682 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.006537
K_1683 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.006370
K_1684 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.006429
K_1685 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.002978
K_1686 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.002999
K_1687 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.003001
K_1688 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.002965
K_1689 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.007885
K_1690 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.007697
K_1691 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.007710
K_1692 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.007600
K_1693 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.003488
K_1694 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.003542
K_1695 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.003506
K_1696 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.003494
K_1697 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.003253
K_1698 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.003254
K_1699 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.003263
K_1700 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.003217
K_1701 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006553
K_1702 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.006608
K_1703 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006416
K_1704 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006485
K_1705 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.002809
K_1706 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.002835
K_1707 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.002822
K_1708 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.002799
K_1709 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.004144
K_1710 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.004117
K_1711 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.004114
K_1712 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.004065
K_1713 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.003754
K_1714 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.003802
K_1715 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.003742
K_1716 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.003744
K_1717 X_NUC_20.L_CORE X_NUC_65.L_CORE 0.002809
K_1718 X_NUC_20.L_CORE X_NUC_66.L_CORE 0.002820
K_1719 X_NUC_20.L_CORE X_NUC_67.L_CORE 0.002813
K_1720 X_NUC_20.L_CORE X_NUC_68.L_CORE 0.002785
K_1721 X_NUC_20.L_CORE X_NUC_69.L_CORE 0.004420
K_1722 X_NUC_20.L_CORE X_NUC_70.L_CORE 0.004414
K_1723 X_NUC_20.L_CORE X_NUC_71.L_CORE 0.004358
K_1724 X_NUC_20.L_CORE X_NUC_72.L_CORE 0.004347
K_1725 X_NUC_20.L_CORE X_NUC_73.L_CORE 0.002932
K_1726 X_NUC_20.L_CORE X_NUC_74.L_CORE 0.002957
K_1727 X_NUC_20.L_CORE X_NUC_75.L_CORE 0.002931
K_1728 X_NUC_20.L_CORE X_NUC_76.L_CORE 0.002916
K_1729 X_NUC_20.L_CORE X_NUC_77.L_CORE 0.003136
K_1730 X_NUC_20.L_CORE X_NUC_78.L_CORE 0.003138
K_1731 X_NUC_20.L_CORE X_NUC_79.L_CORE 0.003123
K_1732 X_NUC_20.L_CORE X_NUC_80.L_CORE 0.003096
K_1733 X_NUC_20.L_CORE X_NUC_81.L_CORE 0.003341
K_1734 X_NUC_20.L_CORE X_NUC_82.L_CORE 0.003357
K_1735 X_NUC_20.L_CORE X_NUC_83.L_CORE 0.003320
K_1736 X_NUC_20.L_CORE X_NUC_84.L_CORE 0.003308
K_1737 X_NUC_20.L_CORE X_NUC_85.L_CORE 0.004048
K_1738 X_NUC_20.L_CORE X_NUC_86.L_CORE 0.007130
K_1739 X_NUC_20.L_CORE X_NUC_87.L_CORE 0.004638
K_1740 X_NUC_20.L_CORE X_NUC_88.L_CORE 0.003210
K_1741 X_NUC_20.L_CORE X_NUC_89.L_CORE 0.017255
K_1742 X_NUC_20.L_CORE X_NUC_90.L_CORE 0.002941
K_1743 X_NUC_20.L_CORE X_NUC_91.L_CORE 0.003794
K_1744 X_NUC_20.L_CORE X_NUC_92.L_CORE 0.004784
K_1745 X_NUC_20.L_CORE X_NUC_93.L_CORE 0.002586
K_1746 X_NUC_20.L_CORE X_NUC_94.L_CORE 0.004767
K_1747 X_NUC_20.L_CORE X_NUC_95.L_CORE 0.002939
K_1748 X_NUC_20.L_CORE X_NUC_96.L_CORE 0.002780
K_1749 X_NUC_20.L_CORE X_NUC_97.L_CORE 0.003612
K_1750 X_NUC_20.L_CORE X_NUC_98.L_CORE 0.002655
K_1751 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_1752 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_1753 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_1754 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.003231
K_1755 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.003182
K_1756 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.003208
K_1757 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.003200
K_1758 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.004328
K_1759 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.004287
K_1760 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.004259
K_1761 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.004337
K_1762 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.006209
K_1763 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.006114
K_1764 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.006190
K_1765 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.006049
K_1766 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.002855
K_1767 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.002819
K_1768 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.002825
K_1769 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.002837
K_1770 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.007575
K_1771 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.007601
K_1772 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.007363
K_1773 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.007558
K_1774 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.003411
K_1775 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.003365
K_1776 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.003386
K_1777 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.003362
K_1778 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.003154
K_1779 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.003123
K_1780 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.003110
K_1781 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.003141
K_1782 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.006556
K_1783 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.006540
K_1784 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.006455
K_1785 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.006379
K_1786 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.002768
K_1787 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.002735
K_1788 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.002740
K_1789 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.002740
K_1790 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.004058
K_1791 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.004039
K_1792 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.003984
K_1793 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.004034
K_1794 X_NUC_21.L_CORE X_NUC_65.L_CORE 0.003744
K_1795 X_NUC_21.L_CORE X_NUC_66.L_CORE 0.003707
K_1796 X_NUC_21.L_CORE X_NUC_67.L_CORE 0.003706
K_1797 X_NUC_21.L_CORE X_NUC_68.L_CORE 0.003678
K_1798 X_NUC_21.L_CORE X_NUC_69.L_CORE 0.002803
K_1799 X_NUC_21.L_CORE X_NUC_70.L_CORE 0.002776
K_1800 X_NUC_21.L_CORE X_NUC_71.L_CORE 0.002767
K_1801 X_NUC_21.L_CORE X_NUC_72.L_CORE 0.002780
K_1802 X_NUC_21.L_CORE X_NUC_73.L_CORE 0.004284
K_1803 X_NUC_21.L_CORE X_NUC_74.L_CORE 0.004269
K_1804 X_NUC_21.L_CORE X_NUC_75.L_CORE 0.004211
K_1805 X_NUC_21.L_CORE X_NUC_76.L_CORE 0.004223
K_1806 X_NUC_21.L_CORE X_NUC_77.L_CORE 0.002979
K_1807 X_NUC_21.L_CORE X_NUC_78.L_CORE 0.002950
K_1808 X_NUC_21.L_CORE X_NUC_79.L_CORE 0.002944
K_1809 X_NUC_21.L_CORE X_NUC_80.L_CORE 0.002941
K_1810 X_NUC_21.L_CORE X_NUC_81.L_CORE 0.003154
K_1811 X_NUC_21.L_CORE X_NUC_82.L_CORE 0.003131
K_1812 X_NUC_21.L_CORE X_NUC_83.L_CORE 0.003109
K_1813 X_NUC_21.L_CORE X_NUC_84.L_CORE 0.003122
K_1814 X_NUC_21.L_CORE X_NUC_85.L_CORE 0.006550
K_1815 X_NUC_21.L_CORE X_NUC_86.L_CORE 0.003269
K_1816 X_NUC_21.L_CORE X_NUC_87.L_CORE 0.006550
K_1817 X_NUC_21.L_CORE X_NUC_88.L_CORE 0.004206
K_1818 X_NUC_21.L_CORE X_NUC_89.L_CORE 0.002944
K_1819 X_NUC_21.L_CORE X_NUC_90.L_CORE 0.015935
K_1820 X_NUC_21.L_CORE X_NUC_91.L_CORE 0.002775
K_1821 X_NUC_21.L_CORE X_NUC_92.L_CORE 0.003600
K_1822 X_NUC_21.L_CORE X_NUC_93.L_CORE 0.004594
K_1823 X_NUC_21.L_CORE X_NUC_94.L_CORE 0.002507
K_1824 X_NUC_21.L_CORE X_NUC_95.L_CORE 0.004543
K_1825 X_NUC_21.L_CORE X_NUC_96.L_CORE 0.002893
K_1826 X_NUC_21.L_CORE X_NUC_97.L_CORE 0.002765
K_1827 X_NUC_21.L_CORE X_NUC_98.L_CORE 0.003300
K_1828 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_1829 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_1830 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.003281
K_1831 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.003231
K_1832 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.003258
K_1833 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.003250
K_1834 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.004369
K_1835 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.004328
K_1836 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.004299
K_1837 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.004379
K_1838 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.006302
K_1839 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.006209
K_1840 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.006286
K_1841 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.006138
K_1842 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.002892
K_1843 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.002855
K_1844 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.002861
K_1845 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.002873
K_1846 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.007538
K_1847 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.007575
K_1848 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.007334
K_1849 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.007527
K_1850 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.003458
K_1851 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.003411
K_1852 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.003432
K_1853 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.003407
K_1854 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.003185
K_1855 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.003154
K_1856 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.003140
K_1857 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.003172
K_1858 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.006565
K_1859 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.006556
K_1860 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.006467
K_1861 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.006391
K_1862 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.002801
K_1863 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.002768
K_1864 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.002772
K_1865 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.002773
K_1866 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.004076
K_1867 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.004058
K_1868 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.004002
K_1869 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.004053
K_1870 X_NUC_22.L_CORE X_NUC_65.L_CORE 0.003781
K_1871 X_NUC_22.L_CORE X_NUC_66.L_CORE 0.003744
K_1872 X_NUC_22.L_CORE X_NUC_67.L_CORE 0.003742
K_1873 X_NUC_22.L_CORE X_NUC_68.L_CORE 0.003713
K_1874 X_NUC_22.L_CORE X_NUC_69.L_CORE 0.002830
K_1875 X_NUC_22.L_CORE X_NUC_70.L_CORE 0.002803
K_1876 X_NUC_22.L_CORE X_NUC_71.L_CORE 0.002794
K_1877 X_NUC_22.L_CORE X_NUC_72.L_CORE 0.002807
K_1878 X_NUC_22.L_CORE X_NUC_73.L_CORE 0.004298
K_1879 X_NUC_22.L_CORE X_NUC_74.L_CORE 0.004284
K_1880 X_NUC_22.L_CORE X_NUC_75.L_CORE 0.004225
K_1881 X_NUC_22.L_CORE X_NUC_76.L_CORE 0.004237
K_1882 X_NUC_22.L_CORE X_NUC_77.L_CORE 0.003008
K_1883 X_NUC_22.L_CORE X_NUC_78.L_CORE 0.002979
K_1884 X_NUC_22.L_CORE X_NUC_79.L_CORE 0.002973
K_1885 X_NUC_22.L_CORE X_NUC_80.L_CORE 0.002969
K_1886 X_NUC_22.L_CORE X_NUC_81.L_CORE 0.003177
K_1887 X_NUC_22.L_CORE X_NUC_82.L_CORE 0.003154
K_1888 X_NUC_22.L_CORE X_NUC_83.L_CORE 0.003131
K_1889 X_NUC_22.L_CORE X_NUC_84.L_CORE 0.003144
K_1890 X_NUC_22.L_CORE X_NUC_85.L_CORE 0.006692
K_1891 X_NUC_22.L_CORE X_NUC_86.L_CORE 0.003319
K_1892 X_NUC_22.L_CORE X_NUC_87.L_CORE 0.006594
K_1893 X_NUC_22.L_CORE X_NUC_88.L_CORE 0.004272
K_1894 X_NUC_22.L_CORE X_NUC_89.L_CORE 0.002978
K_1895 X_NUC_22.L_CORE X_NUC_90.L_CORE 0.015098
K_1896 X_NUC_22.L_CORE X_NUC_91.L_CORE 0.002810
K_1897 X_NUC_22.L_CORE X_NUC_92.L_CORE 0.003621
K_1898 X_NUC_22.L_CORE X_NUC_93.L_CORE 0.004627
K_1899 X_NUC_22.L_CORE X_NUC_94.L_CORE 0.002534
K_1900 X_NUC_22.L_CORE X_NUC_95.L_CORE 0.004536
K_1901 X_NUC_22.L_CORE X_NUC_96.L_CORE 0.002920
K_1902 X_NUC_22.L_CORE X_NUC_97.L_CORE 0.002785
K_1903 X_NUC_22.L_CORE X_NUC_98.L_CORE 0.003316
K_1904 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_1905 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.003254
K_1906 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.003204
K_1907 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.003231
K_1908 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.003223
K_1909 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.004399
K_1910 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.004357
K_1911 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.004328
K_1912 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.004409
K_1913 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.006222
K_1914 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.006129
K_1915 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.006209
K_1916 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.006063
K_1917 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.002885
K_1918 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.002848
K_1919 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.002855
K_1920 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.002866
K_1921 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.007794
K_1922 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.007829
K_1923 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.007575
K_1924 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.007782
K_1925 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.003436
K_1926 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.003390
K_1927 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.003411
K_1928 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.003386
K_1929 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.003199
K_1930 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.003167
K_1931 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.003154
K_1932 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.003185
K_1933 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.006655
K_1934 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.006641
K_1935 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.006556
K_1936 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.006473
K_1937 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.002796
K_1938 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.002762
K_1939 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.002768
K_1940 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.002768
K_1941 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.004135
K_1942 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.004115
K_1943 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.004058
K_1944 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.004111
K_1945 X_NUC_23.L_CORE X_NUC_65.L_CORE 0.003782
K_1946 X_NUC_23.L_CORE X_NUC_66.L_CORE 0.003745
K_1947 X_NUC_23.L_CORE X_NUC_67.L_CORE 0.003744
K_1948 X_NUC_23.L_CORE X_NUC_68.L_CORE 0.003715
K_1949 X_NUC_23.L_CORE X_NUC_69.L_CORE 0.002840
K_1950 X_NUC_23.L_CORE X_NUC_70.L_CORE 0.002811
K_1951 X_NUC_23.L_CORE X_NUC_71.L_CORE 0.002803
K_1952 X_NUC_23.L_CORE X_NUC_72.L_CORE 0.002816
K_1953 X_NUC_23.L_CORE X_NUC_73.L_CORE 0.004360
K_1954 X_NUC_23.L_CORE X_NUC_74.L_CORE 0.004345
K_1955 X_NUC_23.L_CORE X_NUC_75.L_CORE 0.004284
K_1956 X_NUC_23.L_CORE X_NUC_76.L_CORE 0.004297
K_1957 X_NUC_23.L_CORE X_NUC_77.L_CORE 0.003014
K_1958 X_NUC_23.L_CORE X_NUC_78.L_CORE 0.002984
K_1959 X_NUC_23.L_CORE X_NUC_79.L_CORE 0.002979
K_1960 X_NUC_23.L_CORE X_NUC_80.L_CORE 0.002975
K_1961 X_NUC_23.L_CORE X_NUC_81.L_CORE 0.003201
K_1962 X_NUC_23.L_CORE X_NUC_82.L_CORE 0.003178
K_1963 X_NUC_23.L_CORE X_NUC_83.L_CORE 0.003154
K_1964 X_NUC_23.L_CORE X_NUC_84.L_CORE 0.003168
K_1965 X_NUC_23.L_CORE X_NUC_85.L_CORE 0.006498
K_1966 X_NUC_23.L_CORE X_NUC_86.L_CORE 0.003287
K_1967 X_NUC_23.L_CORE X_NUC_87.L_CORE 0.006620
K_1968 X_NUC_23.L_CORE X_NUC_88.L_CORE 0.004207
K_1969 X_NUC_23.L_CORE X_NUC_89.L_CORE 0.002974
K_1970 X_NUC_23.L_CORE X_NUC_90.L_CORE 0.015952
K_1971 X_NUC_23.L_CORE X_NUC_91.L_CORE 0.002794
K_1972 X_NUC_23.L_CORE X_NUC_92.L_CORE 0.003655
K_1973 X_NUC_23.L_CORE X_NUC_93.L_CORE 0.004618
K_1974 X_NUC_23.L_CORE X_NUC_94.L_CORE 0.002534
K_1975 X_NUC_23.L_CORE X_NUC_95.L_CORE 0.004626
K_1976 X_NUC_23.L_CORE X_NUC_96.L_CORE 0.002919
K_1977 X_NUC_23.L_CORE X_NUC_97.L_CORE 0.002803
K_1978 X_NUC_23.L_CORE X_NUC_98.L_CORE 0.003343
K_1979 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.003262
K_1980 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.003212
K_1981 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.003239
K_1982 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.003231
K_1983 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.004318
K_1984 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.004278
K_1985 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.004250
K_1986 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.004328
K_1987 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.006376
K_1988 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.006277
K_1989 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.006359
K_1990 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.006209
K_1991 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.002873
K_1992 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.002836
K_1993 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.002843
K_1994 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.002855
K_1995 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.007581
K_1996 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.007613
K_1997 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.007374
K_1998 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.007575
K_1999 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.003461
K_2000 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.003414
K_2001 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.003435
K_2002 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.003411
K_2003 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.003166
K_2004 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.003135
K_2005 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.003122
K_2006 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.003154
K_2007 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.006741
K_2008 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.006727
K_2009 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.006635
K_2010 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.006556
K_2011 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.002795
K_2012 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.002762
K_2013 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.002767
K_2014 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.002768
K_2015 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.004081
K_2016 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.004061
K_2017 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.004006
K_2018 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.004058
K_2019 X_NUC_24.L_CORE X_NUC_65.L_CORE 0.003813
K_2020 X_NUC_24.L_CORE X_NUC_66.L_CORE 0.003774
K_2021 X_NUC_24.L_CORE X_NUC_67.L_CORE 0.003773
K_2022 X_NUC_24.L_CORE X_NUC_68.L_CORE 0.003744
K_2023 X_NUC_24.L_CORE X_NUC_69.L_CORE 0.002826
K_2024 X_NUC_24.L_CORE X_NUC_70.L_CORE 0.002798
K_2025 X_NUC_24.L_CORE X_NUC_71.L_CORE 0.002789
K_2026 X_NUC_24.L_CORE X_NUC_72.L_CORE 0.002803
K_2027 X_NUC_24.L_CORE X_NUC_73.L_CORE 0.004346
K_2028 X_NUC_24.L_CORE X_NUC_74.L_CORE 0.004331
K_2029 X_NUC_24.L_CORE X_NUC_75.L_CORE 0.004270
K_2030 X_NUC_24.L_CORE X_NUC_76.L_CORE 0.004284
K_2031 X_NUC_24.L_CORE X_NUC_77.L_CORE 0.003017
K_2032 X_NUC_24.L_CORE X_NUC_78.L_CORE 0.002988
K_2033 X_NUC_24.L_CORE X_NUC_79.L_CORE 0.002982
K_2034 X_NUC_24.L_CORE X_NUC_80.L_CORE 0.002979
K_2035 X_NUC_24.L_CORE X_NUC_81.L_CORE 0.003187
K_2036 X_NUC_24.L_CORE X_NUC_82.L_CORE 0.003164
K_2037 X_NUC_24.L_CORE X_NUC_83.L_CORE 0.003140
K_2038 X_NUC_24.L_CORE X_NUC_84.L_CORE 0.003154
K_2039 X_NUC_24.L_CORE X_NUC_85.L_CORE 0.006527
K_2040 X_NUC_24.L_CORE X_NUC_86.L_CORE 0.003280
K_2041 X_NUC_24.L_CORE X_NUC_87.L_CORE 0.006432
K_2042 X_NUC_24.L_CORE X_NUC_88.L_CORE 0.004261
K_2043 X_NUC_24.L_CORE X_NUC_89.L_CORE 0.002949
K_2044 X_NUC_24.L_CORE X_NUC_90.L_CORE 0.016159
K_2045 X_NUC_24.L_CORE X_NUC_91.L_CORE 0.002801
K_2046 X_NUC_24.L_CORE X_NUC_92.L_CORE 0.003600
K_2047 X_NUC_24.L_CORE X_NUC_93.L_CORE 0.004693
K_2048 X_NUC_24.L_CORE X_NUC_94.L_CORE 0.002525
K_2049 X_NUC_24.L_CORE X_NUC_95.L_CORE 0.004580
K_2050 X_NUC_24.L_CORE X_NUC_96.L_CORE 0.002932
K_2051 X_NUC_24.L_CORE X_NUC_97.L_CORE 0.002786
K_2052 X_NUC_24.L_CORE X_NUC_98.L_CORE 0.003344
K_2053 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_2054 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_2055 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_2056 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.003096
K_2057 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.003125
K_2058 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.003090
K_2059 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.003127
K_2060 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.004178
K_2061 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.004258
K_2062 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.004222
K_2063 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.004194
K_2064 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.006056
K_2065 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.006030
K_2066 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.005924
K_2067 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.006085
K_2068 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.002784
K_2069 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.002817
K_2070 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.002787
K_2071 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.002803
K_2072 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.007551
K_2073 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.007678
K_2074 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.007562
K_2075 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.007406
K_2076 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.003364
K_2077 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.003382
K_2078 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.003336
K_2079 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.003383
K_2080 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.003124
K_2081 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.003168
K_2082 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.003133
K_2083 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.003132
K_2084 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.006578
K_2085 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.006548
K_2086 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.006396
K_2087 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.006467
K_2088 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.002768
K_2089 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.002793
K_2090 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.002758
K_2091 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.002779
K_2092 X_NUC_25.L_CORE X_NUC_65.L_CORE 0.004065
K_2093 X_NUC_25.L_CORE X_NUC_66.L_CORE 0.004117
K_2094 X_NUC_25.L_CORE X_NUC_67.L_CORE 0.004060
K_2095 X_NUC_25.L_CORE X_NUC_68.L_CORE 0.004040
K_2096 X_NUC_25.L_CORE X_NUC_69.L_CORE 0.003759
K_2097 X_NUC_25.L_CORE X_NUC_70.L_CORE 0.003770
K_2098 X_NUC_25.L_CORE X_NUC_71.L_CORE 0.003708
K_2099 X_NUC_25.L_CORE X_NUC_72.L_CORE 0.003752
K_2100 X_NUC_25.L_CORE X_NUC_73.L_CORE 0.002861
K_2101 X_NUC_25.L_CORE X_NUC_74.L_CORE 0.002892
K_2102 X_NUC_25.L_CORE X_NUC_75.L_CORE 0.002855
K_2103 X_NUC_25.L_CORE X_NUC_76.L_CORE 0.002864
K_2104 X_NUC_25.L_CORE X_NUC_77.L_CORE 0.004146
K_2105 X_NUC_25.L_CORE X_NUC_78.L_CORE 0.004172
K_2106 X_NUC_25.L_CORE X_NUC_79.L_CORE 0.004100
K_2107 X_NUC_25.L_CORE X_NUC_80.L_CORE 0.004107
K_2108 X_NUC_25.L_CORE X_NUC_81.L_CORE 0.003116
K_2109 X_NUC_25.L_CORE X_NUC_82.L_CORE 0.003138
K_2110 X_NUC_25.L_CORE X_NUC_83.L_CORE 0.003091
K_2111 X_NUC_25.L_CORE X_NUC_84.L_CORE 0.003112
K_2112 X_NUC_25.L_CORE X_NUC_85.L_CORE 0.004172
K_2113 X_NUC_25.L_CORE X_NUC_86.L_CORE 0.007511
K_2114 X_NUC_25.L_CORE X_NUC_87.L_CORE 0.002964
K_2115 X_NUC_25.L_CORE X_NUC_88.L_CORE 0.006247
K_2116 X_NUC_25.L_CORE X_NUC_89.L_CORE 0.003988
K_2117 X_NUC_25.L_CORE X_NUC_90.L_CORE 0.002838
K_2118 X_NUC_25.L_CORE X_NUC_91.L_CORE 0.013740
K_2119 X_NUC_25.L_CORE X_NUC_92.L_CORE 0.002724
K_2120 X_NUC_25.L_CORE X_NUC_93.L_CORE 0.003553
K_2121 X_NUC_25.L_CORE X_NUC_94.L_CORE 0.004484
K_2122 X_NUC_25.L_CORE X_NUC_95.L_CORE 0.002532
K_2123 X_NUC_25.L_CORE X_NUC_96.L_CORE 0.004372
K_2124 X_NUC_25.L_CORE X_NUC_97.L_CORE 0.002945
K_2125 X_NUC_25.L_CORE X_NUC_98.L_CORE 0.002887
K_2126 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_2127 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_2128 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.003068
K_2129 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.003096
K_2130 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.003062
K_2131 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.003098
K_2132 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.004101
K_2133 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.004178
K_2134 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.004144
K_2135 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.004117
K_2136 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.006077
K_2137 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.006056
K_2138 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.005945
K_2139 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.006109
K_2140 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.002751
K_2141 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.002784
K_2142 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.002755
K_2143 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.002770
K_2144 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.007420
K_2145 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.007551
K_2146 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.007435
K_2147 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.007287
K_2148 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.003345
K_2149 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.003364
K_2150 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.003318
K_2151 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.003365
K_2152 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.003081
K_2153 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.003124
K_2154 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.003090
K_2155 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.003089
K_2156 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.006603
K_2157 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.006578
K_2158 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.006421
K_2159 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.006493
K_2160 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.002743
K_2161 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.002768
K_2162 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.002733
K_2163 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.002754
K_2164 X_NUC_26.L_CORE X_NUC_65.L_CORE 0.004013
K_2165 X_NUC_26.L_CORE X_NUC_66.L_CORE 0.004065
K_2166 X_NUC_26.L_CORE X_NUC_67.L_CORE 0.004010
K_2167 X_NUC_26.L_CORE X_NUC_68.L_CORE 0.003990
K_2168 X_NUC_26.L_CORE X_NUC_69.L_CORE 0.003747
K_2169 X_NUC_26.L_CORE X_NUC_70.L_CORE 0.003759
K_2170 X_NUC_26.L_CORE X_NUC_71.L_CORE 0.003697
K_2171 X_NUC_26.L_CORE X_NUC_72.L_CORE 0.003741
K_2172 X_NUC_26.L_CORE X_NUC_73.L_CORE 0.002832
K_2173 X_NUC_26.L_CORE X_NUC_74.L_CORE 0.002861
K_2174 X_NUC_26.L_CORE X_NUC_75.L_CORE 0.002825
K_2175 X_NUC_26.L_CORE X_NUC_76.L_CORE 0.002834
K_2176 X_NUC_26.L_CORE X_NUC_77.L_CORE 0.004119
K_2177 X_NUC_26.L_CORE X_NUC_78.L_CORE 0.004146
K_2178 X_NUC_26.L_CORE X_NUC_79.L_CORE 0.004075
K_2179 X_NUC_26.L_CORE X_NUC_80.L_CORE 0.004082
K_2180 X_NUC_26.L_CORE X_NUC_81.L_CORE 0.003094
K_2181 X_NUC_26.L_CORE X_NUC_82.L_CORE 0.003116
K_2182 X_NUC_26.L_CORE X_NUC_83.L_CORE 0.003070
K_2183 X_NUC_26.L_CORE X_NUC_84.L_CORE 0.003090
K_2184 X_NUC_26.L_CORE X_NUC_85.L_CORE 0.004102
K_2185 X_NUC_26.L_CORE X_NUC_86.L_CORE 0.007482
K_2186 X_NUC_26.L_CORE X_NUC_87.L_CORE 0.002930
K_2187 X_NUC_26.L_CORE X_NUC_88.L_CORE 0.006108
K_2188 X_NUC_26.L_CORE X_NUC_89.L_CORE 0.003978
K_2189 X_NUC_26.L_CORE X_NUC_90.L_CORE 0.002800
K_2190 X_NUC_26.L_CORE X_NUC_91.L_CORE 0.014240
K_2191 X_NUC_26.L_CORE X_NUC_92.L_CORE 0.002704
K_2192 X_NUC_26.L_CORE X_NUC_93.L_CORE 0.003503
K_2193 X_NUC_26.L_CORE X_NUC_94.L_CORE 0.004501
K_2194 X_NUC_26.L_CORE X_NUC_95.L_CORE 0.002508
K_2195 X_NUC_26.L_CORE X_NUC_96.L_CORE 0.004344
K_2196 X_NUC_26.L_CORE X_NUC_97.L_CORE 0.002931
K_2197 X_NUC_26.L_CORE X_NUC_98.L_CORE 0.002863
K_2198 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_2199 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.003101
K_2200 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.003130
K_2201 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.003096
K_2202 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.003132
K_2203 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.004134
K_2204 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.004212
K_2205 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.004178
K_2206 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.004150
K_2207 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.006192
K_2208 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.006167
K_2209 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.006056
K_2210 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.006226
K_2211 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.002780
K_2212 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.002813
K_2213 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.002784
K_2214 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.002799
K_2215 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.007529
K_2216 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.007661
K_2217 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.007551
K_2218 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.007391
K_2219 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.003392
K_2220 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.003411
K_2221 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.003364
K_2222 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.003412
K_2223 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.003114
K_2224 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.003158
K_2225 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.003124
K_2226 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.003122
K_2227 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.006771
K_2228 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.006741
K_2229 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.006578
K_2230 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.006653
K_2231 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.002777
K_2232 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.002803
K_2233 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.002768
K_2234 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.002789
K_2235 X_NUC_27.L_CORE X_NUC_65.L_CORE 0.004068
K_2236 X_NUC_27.L_CORE X_NUC_66.L_CORE 0.004120
K_2237 X_NUC_27.L_CORE X_NUC_67.L_CORE 0.004065
K_2238 X_NUC_27.L_CORE X_NUC_68.L_CORE 0.004043
K_2239 X_NUC_27.L_CORE X_NUC_69.L_CORE 0.003811
K_2240 X_NUC_27.L_CORE X_NUC_70.L_CORE 0.003824
K_2241 X_NUC_27.L_CORE X_NUC_71.L_CORE 0.003759
K_2242 X_NUC_27.L_CORE X_NUC_72.L_CORE 0.003805
K_2243 X_NUC_27.L_CORE X_NUC_73.L_CORE 0.002868
K_2244 X_NUC_27.L_CORE X_NUC_74.L_CORE 0.002898
K_2245 X_NUC_27.L_CORE X_NUC_75.L_CORE 0.002861
K_2246 X_NUC_27.L_CORE X_NUC_76.L_CORE 0.002871
K_2247 X_NUC_27.L_CORE X_NUC_77.L_CORE 0.004191
K_2248 X_NUC_27.L_CORE X_NUC_78.L_CORE 0.004219
K_2249 X_NUC_27.L_CORE X_NUC_79.L_CORE 0.004146
K_2250 X_NUC_27.L_CORE X_NUC_80.L_CORE 0.004152
K_2251 X_NUC_27.L_CORE X_NUC_81.L_CORE 0.003140
K_2252 X_NUC_27.L_CORE X_NUC_82.L_CORE 0.003163
K_2253 X_NUC_27.L_CORE X_NUC_83.L_CORE 0.003116
K_2254 X_NUC_27.L_CORE X_NUC_84.L_CORE 0.003136
K_2255 X_NUC_27.L_CORE X_NUC_85.L_CORE 0.004111
K_2256 X_NUC_27.L_CORE X_NUC_86.L_CORE 0.007448
K_2257 X_NUC_27.L_CORE X_NUC_87.L_CORE 0.002953
K_2258 X_NUC_27.L_CORE X_NUC_88.L_CORE 0.006092
K_2259 X_NUC_27.L_CORE X_NUC_89.L_CORE 0.004020
K_2260 X_NUC_27.L_CORE X_NUC_90.L_CORE 0.002823
K_2261 X_NUC_27.L_CORE X_NUC_91.L_CORE 0.014362
K_2262 X_NUC_27.L_CORE X_NUC_92.L_CORE 0.002734
K_2263 X_NUC_27.L_CORE X_NUC_93.L_CORE 0.003534
K_2264 X_NUC_27.L_CORE X_NUC_94.L_CORE 0.004575
K_2265 X_NUC_27.L_CORE X_NUC_95.L_CORE 0.002535
K_2266 X_NUC_27.L_CORE X_NUC_96.L_CORE 0.004405
K_2267 X_NUC_27.L_CORE X_NUC_97.L_CORE 0.002972
K_2268 X_NUC_27.L_CORE X_NUC_98.L_CORE 0.002899
K_2269 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.003066
K_2270 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.003094
K_2271 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.003060
K_2272 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.003096
K_2273 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.004161
K_2274 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.004240
K_2275 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.004205
K_2276 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.004178
K_2277 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.006022
K_2278 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.005999
K_2279 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.005894
K_2280 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.006056
K_2281 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.002765
K_2282 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.002798
K_2283 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.002768
K_2284 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.002784
K_2285 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.007693
K_2286 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.007833
K_2287 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.007711
K_2288 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.007551
K_2289 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.003345
K_2290 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.003363
K_2291 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.003317
K_2292 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.003364
K_2293 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.003115
K_2294 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.003159
K_2295 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.003125
K_2296 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.003124
K_2297 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.006689
K_2298 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.006660
K_2299 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.006500
K_2300 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.006578
K_2301 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.002755
K_2302 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.002780
K_2303 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.002746
K_2304 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.002768
K_2305 X_NUC_28.L_CORE X_NUC_65.L_CORE 0.004089
K_2306 X_NUC_28.L_CORE X_NUC_66.L_CORE 0.004143
K_2307 X_NUC_28.L_CORE X_NUC_67.L_CORE 0.004085
K_2308 X_NUC_28.L_CORE X_NUC_68.L_CORE 0.004065
K_2309 X_NUC_28.L_CORE X_NUC_69.L_CORE 0.003765
K_2310 X_NUC_28.L_CORE X_NUC_70.L_CORE 0.003777
K_2311 X_NUC_28.L_CORE X_NUC_71.L_CORE 0.003714
K_2312 X_NUC_28.L_CORE X_NUC_72.L_CORE 0.003759
K_2313 X_NUC_28.L_CORE X_NUC_73.L_CORE 0.002858
K_2314 X_NUC_28.L_CORE X_NUC_74.L_CORE 0.002888
K_2315 X_NUC_28.L_CORE X_NUC_75.L_CORE 0.002852
K_2316 X_NUC_28.L_CORE X_NUC_76.L_CORE 0.002861
K_2317 X_NUC_28.L_CORE X_NUC_77.L_CORE 0.004184
K_2318 X_NUC_28.L_CORE X_NUC_78.L_CORE 0.004211
K_2319 X_NUC_28.L_CORE X_NUC_79.L_CORE 0.004138
K_2320 X_NUC_28.L_CORE X_NUC_80.L_CORE 0.004146
K_2321 X_NUC_28.L_CORE X_NUC_81.L_CORE 0.003119
K_2322 X_NUC_28.L_CORE X_NUC_82.L_CORE 0.003142
K_2323 X_NUC_28.L_CORE X_NUC_83.L_CORE 0.003095
K_2324 X_NUC_28.L_CORE X_NUC_84.L_CORE 0.003116
K_2325 X_NUC_28.L_CORE X_NUC_85.L_CORE 0.004101
K_2326 X_NUC_28.L_CORE X_NUC_86.L_CORE 0.007274
K_2327 X_NUC_28.L_CORE X_NUC_87.L_CORE 0.002929
K_2328 X_NUC_28.L_CORE X_NUC_88.L_CORE 0.006203
K_2329 X_NUC_28.L_CORE X_NUC_89.L_CORE 0.003944
K_2330 X_NUC_28.L_CORE X_NUC_90.L_CORE 0.002819
K_2331 X_NUC_28.L_CORE X_NUC_91.L_CORE 0.014685
K_2332 X_NUC_28.L_CORE X_NUC_92.L_CORE 0.002706
K_2333 X_NUC_28.L_CORE X_NUC_93.L_CORE 0.003557
K_2334 X_NUC_28.L_CORE X_NUC_94.L_CORE 0.004502
K_2335 X_NUC_28.L_CORE X_NUC_95.L_CORE 0.002524
K_2336 X_NUC_28.L_CORE X_NUC_96.L_CORE 0.004430
K_2337 X_NUC_28.L_CORE X_NUC_97.L_CORE 0.002946
K_2338 X_NUC_28.L_CORE X_NUC_98.L_CORE 0.002895
K_2339 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_2340 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_2341 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_2342 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.003005
K_2343 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.003008
K_2344 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.003027
K_2345 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.002983
K_2346 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.004080
K_2347 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.004009
K_2348 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.004051
K_2349 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.004020
K_2350 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.005959
K_2351 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.006082
K_2352 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.006035
K_2353 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.005926
K_2354 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.002744
K_2355 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.002730
K_2356 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.002748
K_2357 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.002716
K_2358 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.007537
K_2359 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.007335
K_2360 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.007306
K_2361 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.007319
K_2362 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.003349
K_2363 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.003366
K_2364 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.003368
K_2365 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.003320
K_2366 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.003124
K_2367 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.003092
K_2368 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.003109
K_2369 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.003081
K_2370 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.006556
K_2371 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.006615
K_2372 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.006478
K_2373 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.006426
K_2374 X_NUC_29.L_CORE X_NUC_65.L_CORE 0.002799
K_2375 X_NUC_29.L_CORE X_NUC_66.L_CORE 0.002794
K_2376 X_NUC_29.L_CORE X_NUC_67.L_CORE 0.002801
K_2377 X_NUC_29.L_CORE X_NUC_68.L_CORE 0.002768
K_2378 X_NUC_29.L_CORE X_NUC_69.L_CORE 0.004084
K_2379 X_NUC_29.L_CORE X_NUC_70.L_CORE 0.004034
K_2380 X_NUC_29.L_CORE X_NUC_71.L_CORE 0.004031
K_2381 X_NUC_29.L_CORE X_NUC_72.L_CORE 0.004007
K_2382 X_NUC_29.L_CORE X_NUC_73.L_CORE 0.003788
K_2383 X_NUC_29.L_CORE X_NUC_74.L_CORE 0.003804
K_2384 X_NUC_29.L_CORE X_NUC_75.L_CORE 0.003782
K_2385 X_NUC_29.L_CORE X_NUC_76.L_CORE 0.003739
K_2386 X_NUC_29.L_CORE X_NUC_77.L_CORE 0.002976
K_2387 X_NUC_29.L_CORE X_NUC_78.L_CORE 0.002960
K_2388 X_NUC_29.L_CORE X_NUC_79.L_CORE 0.002964
K_2389 X_NUC_29.L_CORE X_NUC_80.L_CORE 0.002935
K_2390 X_NUC_29.L_CORE X_NUC_81.L_CORE 0.003874
K_2391 X_NUC_29.L_CORE X_NUC_82.L_CORE 0.003860
K_2392 X_NUC_29.L_CORE X_NUC_83.L_CORE 0.003837
K_2393 X_NUC_29.L_CORE X_NUC_84.L_CORE 0.003807
K_2394 X_NUC_29.L_CORE X_NUC_85.L_CORE 0.003747
K_2395 X_NUC_29.L_CORE X_NUC_86.L_CORE 0.003660
K_2396 X_NUC_29.L_CORE X_NUC_87.L_CORE 0.007950
K_2397 X_NUC_29.L_CORE X_NUC_88.L_CORE 0.002741
K_2398 X_NUC_29.L_CORE X_NUC_89.L_CORE 0.005821
K_2399 X_NUC_29.L_CORE X_NUC_90.L_CORE 0.003842
K_2400 X_NUC_29.L_CORE X_NUC_91.L_CORE 0.002722
K_2401 X_NUC_29.L_CORE X_NUC_92.L_CORE 0.012694
K_2402 X_NUC_29.L_CORE X_NUC_93.L_CORE 0.002681
K_2403 X_NUC_29.L_CORE X_NUC_94.L_CORE 0.003467
K_2404 X_NUC_29.L_CORE X_NUC_95.L_CORE 0.004421
K_2405 X_NUC_29.L_CORE X_NUC_96.L_CORE 0.002561
K_2406 X_NUC_29.L_CORE X_NUC_97.L_CORE 0.004111
K_2407 X_NUC_29.L_CORE X_NUC_98.L_CORE 0.003033
K_2408 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_2409 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_2410 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.003002
K_2411 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.003005
K_2412 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.003024
K_2413 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.002981
K_2414 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.004154
K_2415 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.004080
K_2416 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.004124
K_2417 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.004092
K_2418 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.005839
K_2419 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.005959
K_2420 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.005912
K_2421 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.005810
K_2422 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.002757
K_2423 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.002744
K_2424 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.002762
K_2425 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.002729
K_2426 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.007745
K_2427 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.007537
K_2428 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.007501
K_2429 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.007514
K_2430 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.003332
K_2431 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.003349
K_2432 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.003350
K_2433 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.003304
K_2434 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.003156
K_2435 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.003124
K_2436 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.003142
K_2437 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.003113
K_2438 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.006492
K_2439 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.006556
K_2440 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.006419
K_2441 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.006369
K_2442 X_NUC_30.L_CORE X_NUC_65.L_CORE 0.002803
K_2443 X_NUC_30.L_CORE X_NUC_66.L_CORE 0.002799
K_2444 X_NUC_30.L_CORE X_NUC_67.L_CORE 0.002806
K_2445 X_NUC_30.L_CORE X_NUC_68.L_CORE 0.002772
K_2446 X_NUC_30.L_CORE X_NUC_69.L_CORE 0.004134
K_2447 X_NUC_30.L_CORE X_NUC_70.L_CORE 0.004084
K_2448 X_NUC_30.L_CORE X_NUC_71.L_CORE 0.004080
K_2449 X_NUC_30.L_CORE X_NUC_72.L_CORE 0.004056
K_2450 X_NUC_30.L_CORE X_NUC_73.L_CORE 0.003770
K_2451 X_NUC_30.L_CORE X_NUC_74.L_CORE 0.003788
K_2452 X_NUC_30.L_CORE X_NUC_75.L_CORE 0.003765
K_2453 X_NUC_30.L_CORE X_NUC_76.L_CORE 0.003723
K_2454 X_NUC_30.L_CORE X_NUC_77.L_CORE 0.002991
K_2455 X_NUC_30.L_CORE X_NUC_78.L_CORE 0.002976
K_2456 X_NUC_30.L_CORE X_NUC_79.L_CORE 0.002979
K_2457 X_NUC_30.L_CORE X_NUC_80.L_CORE 0.002950
K_2458 X_NUC_30.L_CORE X_NUC_81.L_CORE 0.003886
K_2459 X_NUC_30.L_CORE X_NUC_82.L_CORE 0.003874
K_2460 X_NUC_30.L_CORE X_NUC_83.L_CORE 0.003851
K_2461 X_NUC_30.L_CORE X_NUC_84.L_CORE 0.003820
K_2462 X_NUC_30.L_CORE X_NUC_85.L_CORE 0.003746
K_2463 X_NUC_30.L_CORE X_NUC_86.L_CORE 0.003704
K_2464 X_NUC_30.L_CORE X_NUC_87.L_CORE 0.007780
K_2465 X_NUC_30.L_CORE X_NUC_88.L_CORE 0.002749
K_2466 X_NUC_30.L_CORE X_NUC_89.L_CORE 0.005987
K_2467 X_NUC_30.L_CORE X_NUC_90.L_CORE 0.003801
K_2468 X_NUC_30.L_CORE X_NUC_91.L_CORE 0.002746
K_2469 X_NUC_30.L_CORE X_NUC_92.L_CORE 0.012583
K_2470 X_NUC_30.L_CORE X_NUC_93.L_CORE 0.002678
K_2471 X_NUC_30.L_CORE X_NUC_94.L_CORE 0.003516
K_2472 X_NUC_30.L_CORE X_NUC_95.L_CORE 0.004371
K_2473 X_NUC_30.L_CORE X_NUC_96.L_CORE 0.002572
K_2474 X_NUC_30.L_CORE X_NUC_97.L_CORE 0.004140
K_2475 X_NUC_30.L_CORE X_NUC_98.L_CORE 0.003031
K_2476 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_2477 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.002984
K_2478 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.002987
K_2479 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.003005
K_2480 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.002963
K_2481 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.004108
K_2482 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.004036
K_2483 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.004080
K_2484 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.004048
K_2485 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.005882
K_2486 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.006002
K_2487 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.005959
K_2488 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.005852
K_2489 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.002739
K_2490 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.002725
K_2491 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.002744
K_2492 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.002711
K_2493 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.007780
K_2494 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.007564
K_2495 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.007537
K_2496 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.007545
K_2497 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.003330
K_2498 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.003347
K_2499 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.003349
K_2500 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.003302
K_2501 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.003138
K_2502 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.003106
K_2503 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.003124
K_2504 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.003095
K_2505 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.006630
K_2506 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.006695
K_2507 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.006556
K_2508 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.006499
K_2509 X_NUC_31.L_CORE X_NUC_65.L_CORE 0.002796
K_2510 X_NUC_31.L_CORE X_NUC_66.L_CORE 0.002791
K_2511 X_NUC_31.L_CORE X_NUC_67.L_CORE 0.002799
K_2512 X_NUC_31.L_CORE X_NUC_68.L_CORE 0.002766
K_2513 X_NUC_31.L_CORE X_NUC_69.L_CORE 0.004138
K_2514 X_NUC_31.L_CORE X_NUC_70.L_CORE 0.004086
K_2515 X_NUC_31.L_CORE X_NUC_71.L_CORE 0.004084
K_2516 X_NUC_31.L_CORE X_NUC_72.L_CORE 0.004059
K_2517 X_NUC_31.L_CORE X_NUC_73.L_CORE 0.003792
K_2518 X_NUC_31.L_CORE X_NUC_74.L_CORE 0.003810
K_2519 X_NUC_31.L_CORE X_NUC_75.L_CORE 0.003788
K_2520 X_NUC_31.L_CORE X_NUC_76.L_CORE 0.003744
K_2521 X_NUC_31.L_CORE X_NUC_77.L_CORE 0.002987
K_2522 X_NUC_31.L_CORE X_NUC_78.L_CORE 0.002972
K_2523 X_NUC_31.L_CORE X_NUC_79.L_CORE 0.002976
K_2524 X_NUC_31.L_CORE X_NUC_80.L_CORE 0.002947
K_2525 X_NUC_31.L_CORE X_NUC_81.L_CORE 0.003909
K_2526 X_NUC_31.L_CORE X_NUC_82.L_CORE 0.003896
K_2527 X_NUC_31.L_CORE X_NUC_83.L_CORE 0.003874
K_2528 X_NUC_31.L_CORE X_NUC_84.L_CORE 0.003842
K_2529 X_NUC_31.L_CORE X_NUC_85.L_CORE 0.003693
K_2530 X_NUC_31.L_CORE X_NUC_86.L_CORE 0.003643
K_2531 X_NUC_31.L_CORE X_NUC_87.L_CORE 0.007658
K_2532 X_NUC_31.L_CORE X_NUC_88.L_CORE 0.002724
K_2533 X_NUC_31.L_CORE X_NUC_89.L_CORE 0.005884
K_2534 X_NUC_31.L_CORE X_NUC_90.L_CORE 0.003794
K_2535 X_NUC_31.L_CORE X_NUC_91.L_CORE 0.002723
K_2536 X_NUC_31.L_CORE X_NUC_92.L_CORE 0.013331
K_2537 X_NUC_31.L_CORE X_NUC_93.L_CORE 0.002670
K_2538 X_NUC_31.L_CORE X_NUC_94.L_CORE 0.003501
K_2539 X_NUC_31.L_CORE X_NUC_95.L_CORE 0.004421
K_2540 X_NUC_31.L_CORE X_NUC_96.L_CORE 0.002565
K_2541 X_NUC_31.L_CORE X_NUC_97.L_CORE 0.004172
K_2542 X_NUC_31.L_CORE X_NUC_98.L_CORE 0.003042
K_2543 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.003027
K_2544 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.003030
K_2545 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.003049
K_2546 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.003005
K_2547 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.004141
K_2548 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.004067
K_2549 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.004112
K_2550 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.004080
K_2551 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.005987
K_2552 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.006115
K_2553 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.006067
K_2554 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.005959
K_2555 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.002772
K_2556 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.002758
K_2557 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.002777
K_2558 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.002744
K_2559 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.007765
K_2560 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.007550
K_2561 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.007519
K_2562 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.007537
K_2563 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.003377
K_2564 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.003395
K_2565 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.003397
K_2566 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.003349
K_2567 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.003168
K_2568 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.003134
K_2569 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.003153
K_2570 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.003124
K_2571 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.006687
K_2572 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.006753
K_2573 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.006607
K_2574 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.006556
K_2575 X_NUC_32.L_CORE X_NUC_65.L_CORE 0.002830
K_2576 X_NUC_32.L_CORE X_NUC_66.L_CORE 0.002825
K_2577 X_NUC_32.L_CORE X_NUC_67.L_CORE 0.002833
K_2578 X_NUC_32.L_CORE X_NUC_68.L_CORE 0.002799
K_2579 X_NUC_32.L_CORE X_NUC_69.L_CORE 0.004163
K_2580 X_NUC_32.L_CORE X_NUC_70.L_CORE 0.004111
K_2581 X_NUC_32.L_CORE X_NUC_71.L_CORE 0.004108
K_2582 X_NUC_32.L_CORE X_NUC_72.L_CORE 0.004084
K_2583 X_NUC_32.L_CORE X_NUC_73.L_CORE 0.003837
K_2584 X_NUC_32.L_CORE X_NUC_74.L_CORE 0.003855
K_2585 X_NUC_32.L_CORE X_NUC_75.L_CORE 0.003832
K_2586 X_NUC_32.L_CORE X_NUC_76.L_CORE 0.003788
K_2587 X_NUC_32.L_CORE X_NUC_77.L_CORE 0.003018
K_2588 X_NUC_32.L_CORE X_NUC_78.L_CORE 0.003001
K_2589 X_NUC_32.L_CORE X_NUC_79.L_CORE 0.003005
K_2590 X_NUC_32.L_CORE X_NUC_80.L_CORE 0.002976
K_2591 X_NUC_32.L_CORE X_NUC_81.L_CORE 0.003942
K_2592 X_NUC_32.L_CORE X_NUC_82.L_CORE 0.003928
K_2593 X_NUC_32.L_CORE X_NUC_83.L_CORE 0.003905
K_2594 X_NUC_32.L_CORE X_NUC_84.L_CORE 0.003874
K_2595 X_NUC_32.L_CORE X_NUC_85.L_CORE 0.003748
K_2596 X_NUC_32.L_CORE X_NUC_86.L_CORE 0.003681
K_2597 X_NUC_32.L_CORE X_NUC_87.L_CORE 0.007796
K_2598 X_NUC_32.L_CORE X_NUC_88.L_CORE 0.002759
K_2599 X_NUC_32.L_CORE X_NUC_89.L_CORE 0.005888
K_2600 X_NUC_32.L_CORE X_NUC_90.L_CORE 0.003851
K_2601 X_NUC_32.L_CORE X_NUC_91.L_CORE 0.002750
K_2602 X_NUC_32.L_CORE X_NUC_92.L_CORE 0.012940
K_2603 X_NUC_32.L_CORE X_NUC_93.L_CORE 0.002703
K_2604 X_NUC_32.L_CORE X_NUC_94.L_CORE 0.003519
K_2605 X_NUC_32.L_CORE X_NUC_95.L_CORE 0.004465
K_2606 X_NUC_32.L_CORE X_NUC_96.L_CORE 0.002591
K_2607 X_NUC_32.L_CORE X_NUC_97.L_CORE 0.004186
K_2608 X_NUC_32.L_CORE X_NUC_98.L_CORE 0.003071
K_2609 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_2610 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_2611 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_2612 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.002949
K_2613 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.002919
K_2614 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.002918
K_2615 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.002946
K_2616 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.004024
K_2617 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.004054
K_2618 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.003996
K_2619 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.004067
K_2620 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.005912
K_2621 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.005757
K_2622 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.005796
K_2623 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.005797
K_2624 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.002731
K_2625 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.002719
K_2626 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.002704
K_2627 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.002736
K_2628 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.007537
K_2629 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.007685
K_2630 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.007411
K_2631 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.007550
K_2632 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.003364
K_2633 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.003320
K_2634 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.003317
K_2635 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.003340
K_2636 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.003154
K_2637 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.003157
K_2638 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.003121
K_2639 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.003164
K_2640 X_NUC_33.L_CORE X_NUC_65.L_CORE 0.006485
K_2641 X_NUC_33.L_CORE X_NUC_66.L_CORE 0.006400
K_2642 X_NUC_33.L_CORE X_NUC_67.L_CORE 0.006309
K_2643 X_NUC_33.L_CORE X_NUC_68.L_CORE 0.006325
K_2644 X_NUC_33.L_CORE X_NUC_69.L_CORE 0.002865
K_2645 X_NUC_33.L_CORE X_NUC_70.L_CORE 0.002845
K_2646 X_NUC_33.L_CORE X_NUC_71.L_CORE 0.002829
K_2647 X_NUC_33.L_CORE X_NUC_72.L_CORE 0.002857
K_2648 X_NUC_33.L_CORE X_NUC_73.L_CORE 0.004112
K_2649 X_NUC_33.L_CORE X_NUC_74.L_CORE 0.004126
K_2650 X_NUC_33.L_CORE X_NUC_75.L_CORE 0.004051
K_2651 X_NUC_33.L_CORE X_NUC_76.L_CORE 0.004104
K_2652 X_NUC_33.L_CORE X_NUC_77.L_CORE 0.003825
K_2653 X_NUC_33.L_CORE X_NUC_78.L_CORE 0.003786
K_2654 X_NUC_33.L_CORE X_NUC_79.L_CORE 0.003757
K_2655 X_NUC_33.L_CORE X_NUC_80.L_CORE 0.003782
K_2656 X_NUC_33.L_CORE X_NUC_81.L_CORE 0.003206
K_2657 X_NUC_33.L_CORE X_NUC_82.L_CORE 0.003194
K_2658 X_NUC_33.L_CORE X_NUC_83.L_CORE 0.003160
K_2659 X_NUC_33.L_CORE X_NUC_84.L_CORE 0.003194
K_2660 X_NUC_33.L_CORE X_NUC_85.L_CORE 0.005105
K_2661 X_NUC_33.L_CORE X_NUC_86.L_CORE 0.003323
K_2662 X_NUC_33.L_CORE X_NUC_87.L_CORE 0.003432
K_2663 X_NUC_33.L_CORE X_NUC_88.L_CORE 0.007918
K_2664 X_NUC_33.L_CORE X_NUC_89.L_CORE 0.002615
K_2665 X_NUC_33.L_CORE X_NUC_90.L_CORE 0.005783
K_2666 X_NUC_33.L_CORE X_NUC_91.L_CORE 0.003695
K_2667 X_NUC_33.L_CORE X_NUC_92.L_CORE 0.002693
K_2668 X_NUC_33.L_CORE X_NUC_93.L_CORE 0.011458
K_2669 X_NUC_33.L_CORE X_NUC_94.L_CORE 0.002673
K_2670 X_NUC_33.L_CORE X_NUC_95.L_CORE 0.003505
K_2671 X_NUC_33.L_CORE X_NUC_96.L_CORE 0.004278
K_2672 X_NUC_33.L_CORE X_NUC_97.L_CORE 0.002674
K_2673 X_NUC_33.L_CORE X_NUC_98.L_CORE 0.003772
K_2674 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_2675 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_2676 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.002979
K_2677 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.002949
K_2678 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.002948
K_2679 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.002977
K_2680 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.003994
K_2681 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.004024
K_2682 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.003967
K_2683 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.004036
K_2684 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.006076
K_2685 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.005912
K_2686 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.005953
K_2687 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.005954
K_2688 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.002743
K_2689 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.002731
K_2690 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.002715
K_2691 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.002748
K_2692 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.007388
K_2693 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.007537
K_2694 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.007274
K_2695 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.007404
K_2696 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.003409
K_2697 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.003364
K_2698 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.003360
K_2699 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.003385
K_2700 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.003150
K_2701 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.003154
K_2702 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.003117
K_2703 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.003161
K_2704 X_NUC_34.L_CORE X_NUC_65.L_CORE 0.006566
K_2705 X_NUC_34.L_CORE X_NUC_66.L_CORE 0.006485
K_2706 X_NUC_34.L_CORE X_NUC_67.L_CORE 0.006387
K_2707 X_NUC_34.L_CORE X_NUC_68.L_CORE 0.006403
K_2708 X_NUC_34.L_CORE X_NUC_69.L_CORE 0.002885
K_2709 X_NUC_34.L_CORE X_NUC_70.L_CORE 0.002865
K_2710 X_NUC_34.L_CORE X_NUC_71.L_CORE 0.002848
K_2711 X_NUC_34.L_CORE X_NUC_72.L_CORE 0.002877
K_2712 X_NUC_34.L_CORE X_NUC_73.L_CORE 0.004097
K_2713 X_NUC_34.L_CORE X_NUC_74.L_CORE 0.004112
K_2714 X_NUC_34.L_CORE X_NUC_75.L_CORE 0.004037
K_2715 X_NUC_34.L_CORE X_NUC_76.L_CORE 0.004090
K_2716 X_NUC_34.L_CORE X_NUC_77.L_CORE 0.003864
K_2717 X_NUC_34.L_CORE X_NUC_78.L_CORE 0.003825
K_2718 X_NUC_34.L_CORE X_NUC_79.L_CORE 0.003794
K_2719 X_NUC_34.L_CORE X_NUC_80.L_CORE 0.003821
K_2720 X_NUC_34.L_CORE X_NUC_81.L_CORE 0.003217
K_2721 X_NUC_34.L_CORE X_NUC_82.L_CORE 0.003206
K_2722 X_NUC_34.L_CORE X_NUC_83.L_CORE 0.003171
K_2723 X_NUC_34.L_CORE X_NUC_84.L_CORE 0.003205
K_2724 X_NUC_34.L_CORE X_NUC_85.L_CORE 0.005118
K_2725 X_NUC_34.L_CORE X_NUC_86.L_CORE 0.003361
K_2726 X_NUC_34.L_CORE X_NUC_87.L_CORE 0.003423
K_2727 X_NUC_34.L_CORE X_NUC_88.L_CORE 0.008169
K_2728 X_NUC_34.L_CORE X_NUC_89.L_CORE 0.002631
K_2729 X_NUC_34.L_CORE X_NUC_90.L_CORE 0.005668
K_2730 X_NUC_34.L_CORE X_NUC_91.L_CORE 0.003760
K_2731 X_NUC_34.L_CORE X_NUC_92.L_CORE 0.002694
K_2732 X_NUC_34.L_CORE X_NUC_93.L_CORE 0.011371
K_2733 X_NUC_34.L_CORE X_NUC_94.L_CORE 0.002697
K_2734 X_NUC_34.L_CORE X_NUC_95.L_CORE 0.003485
K_2735 X_NUC_34.L_CORE X_NUC_96.L_CORE 0.004336
K_2736 X_NUC_34.L_CORE X_NUC_97.L_CORE 0.002684
K_2737 X_NUC_34.L_CORE X_NUC_98.L_CORE 0.003774
K_2738 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_2739 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.002980
K_2740 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.002950
K_2741 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.002949
K_2742 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.002978
K_2743 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.004052
K_2744 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.004083
K_2745 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.004024
K_2746 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.004096
K_2747 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.006031
K_2748 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.005868
K_2749 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.005912
K_2750 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.005911
K_2751 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.002758
K_2752 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.002746
K_2753 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.002731
K_2754 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.002764
K_2755 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.007658
K_2756 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.007820
K_2757 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.007537
K_2758 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.007677
K_2759 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.003413
K_2760 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.003367
K_2761 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.003364
K_2762 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.003389
K_2763 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.003187
K_2764 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.003191
K_2765 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.003154
K_2766 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.003198
K_2767 X_NUC_35.L_CORE X_NUC_65.L_CORE 0.006669
K_2768 X_NUC_35.L_CORE X_NUC_66.L_CORE 0.006581
K_2769 X_NUC_35.L_CORE X_NUC_67.L_CORE 0.006485
K_2770 X_NUC_35.L_CORE X_NUC_68.L_CORE 0.006499
K_2771 X_NUC_35.L_CORE X_NUC_69.L_CORE 0.002903
K_2772 X_NUC_35.L_CORE X_NUC_70.L_CORE 0.002882
K_2773 X_NUC_35.L_CORE X_NUC_71.L_CORE 0.002865
K_2774 X_NUC_35.L_CORE X_NUC_72.L_CORE 0.002894
K_2775 X_NUC_35.L_CORE X_NUC_73.L_CORE 0.004174
K_2776 X_NUC_35.L_CORE X_NUC_74.L_CORE 0.004189
K_2777 X_NUC_35.L_CORE X_NUC_75.L_CORE 0.004112
K_2778 X_NUC_35.L_CORE X_NUC_76.L_CORE 0.004167
K_2779 X_NUC_35.L_CORE X_NUC_77.L_CORE 0.003896
K_2780 X_NUC_35.L_CORE X_NUC_78.L_CORE 0.003855
K_2781 X_NUC_35.L_CORE X_NUC_79.L_CORE 0.003825
K_2782 X_NUC_35.L_CORE X_NUC_80.L_CORE 0.003852
K_2783 X_NUC_35.L_CORE X_NUC_81.L_CORE 0.003253
K_2784 X_NUC_35.L_CORE X_NUC_82.L_CORE 0.003242
K_2785 X_NUC_35.L_CORE X_NUC_83.L_CORE 0.003206
K_2786 X_NUC_35.L_CORE X_NUC_84.L_CORE 0.003241
K_2787 X_NUC_35.L_CORE X_NUC_85.L_CORE 0.005072
K_2788 X_NUC_35.L_CORE X_NUC_86.L_CORE 0.003340
K_2789 X_NUC_35.L_CORE X_NUC_87.L_CORE 0.003440
K_2790 X_NUC_35.L_CORE X_NUC_88.L_CORE 0.007892
K_2791 X_NUC_35.L_CORE X_NUC_89.L_CORE 0.002634
K_2792 X_NUC_35.L_CORE X_NUC_90.L_CORE 0.005772
K_2793 X_NUC_35.L_CORE X_NUC_91.L_CORE 0.003738
K_2794 X_NUC_35.L_CORE X_NUC_92.L_CORE 0.002714
K_2795 X_NUC_35.L_CORE X_NUC_93.L_CORE 0.011743
K_2796 X_NUC_35.L_CORE X_NUC_94.L_CORE 0.002703
K_2797 X_NUC_35.L_CORE X_NUC_95.L_CORE 0.003540
K_2798 X_NUC_35.L_CORE X_NUC_96.L_CORE 0.004358
K_2799 X_NUC_35.L_CORE X_NUC_97.L_CORE 0.002706
K_2800 X_NUC_35.L_CORE X_NUC_98.L_CORE 0.003833
K_2801 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.002951
K_2802 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.002921
K_2803 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.002920
K_2804 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.002949
K_2805 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.003981
K_2806 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.004011
K_2807 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.003955
K_2808 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.004024
K_2809 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.006029
K_2810 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.005867
K_2811 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.005908
K_2812 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.005912
K_2813 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.002725
K_2814 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.002713
K_2815 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.002698
K_2816 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.002731
K_2817 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.007514
K_2818 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.007666
K_2819 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.007395
K_2820 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.007537
K_2821 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.003388
K_2822 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.003343
K_2823 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.003339
K_2824 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.003364
K_2825 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.003143
K_2826 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.003146
K_2827 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.003110
K_2828 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.003154
K_2829 X_NUC_36.L_CORE X_NUC_65.L_CORE 0.006650
K_2830 X_NUC_36.L_CORE X_NUC_66.L_CORE 0.006562
K_2831 X_NUC_36.L_CORE X_NUC_67.L_CORE 0.006464
K_2832 X_NUC_36.L_CORE X_NUC_68.L_CORE 0.006485
K_2833 X_NUC_36.L_CORE X_NUC_69.L_CORE 0.002873
K_2834 X_NUC_36.L_CORE X_NUC_70.L_CORE 0.002853
K_2835 X_NUC_36.L_CORE X_NUC_71.L_CORE 0.002836
K_2836 X_NUC_36.L_CORE X_NUC_72.L_CORE 0.002865
K_2837 X_NUC_36.L_CORE X_NUC_73.L_CORE 0.004118
K_2838 X_NUC_36.L_CORE X_NUC_74.L_CORE 0.004133
K_2839 X_NUC_36.L_CORE X_NUC_75.L_CORE 0.004058
K_2840 X_NUC_36.L_CORE X_NUC_76.L_CORE 0.004112
K_2841 X_NUC_36.L_CORE X_NUC_77.L_CORE 0.003868
K_2842 X_NUC_36.L_CORE X_NUC_78.L_CORE 0.003828
K_2843 X_NUC_36.L_CORE X_NUC_79.L_CORE 0.003798
K_2844 X_NUC_36.L_CORE X_NUC_80.L_CORE 0.003825
K_2845 X_NUC_36.L_CORE X_NUC_81.L_CORE 0.003218
K_2846 X_NUC_36.L_CORE X_NUC_82.L_CORE 0.003206
K_2847 X_NUC_36.L_CORE X_NUC_83.L_CORE 0.003171
K_2848 X_NUC_36.L_CORE X_NUC_84.L_CORE 0.003206
K_2849 X_NUC_36.L_CORE X_NUC_85.L_CORE 0.005006
K_2850 X_NUC_36.L_CORE X_NUC_86.L_CORE 0.003310
K_2851 X_NUC_36.L_CORE X_NUC_87.L_CORE 0.003388
K_2852 X_NUC_36.L_CORE X_NUC_88.L_CORE 0.007941
K_2853 X_NUC_36.L_CORE X_NUC_89.L_CORE 0.002606
K_2854 X_NUC_36.L_CORE X_NUC_90.L_CORE 0.005665
K_2855 X_NUC_36.L_CORE X_NUC_91.L_CORE 0.003724
K_2856 X_NUC_36.L_CORE X_NUC_92.L_CORE 0.002679
K_2857 X_NUC_36.L_CORE X_NUC_93.L_CORE 0.011954
K_2858 X_NUC_36.L_CORE X_NUC_94.L_CORE 0.002681
K_2859 X_NUC_36.L_CORE X_NUC_95.L_CORE 0.003492
K_2860 X_NUC_36.L_CORE X_NUC_96.L_CORE 0.004351
K_2861 X_NUC_36.L_CORE X_NUC_97.L_CORE 0.002679
K_2862 X_NUC_36.L_CORE X_NUC_98.L_CORE 0.003801
K_2863 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_2864 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_2865 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_2866 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.002922
K_2867 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.002964
K_2868 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.002941
K_2869 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.002940
K_2870 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.004006
K_2871 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.004032
K_2872 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.004047
K_2873 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.003975
K_2874 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.005912
K_2875 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.006035
K_2876 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.005882
K_2877 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.005987
K_2878 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.002744
K_2879 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.002776
K_2880 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.002763
K_2881 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.002746
K_2882 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.007551
K_2883 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.007549
K_2884 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.007522
K_2885 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.007327
K_2886 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.003411
K_2887 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.003463
K_2888 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.003416
K_2889 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.003427
K_2890 X_NUC_37.L_CORE X_NUC_65.L_CORE 0.003217
K_2891 X_NUC_37.L_CORE X_NUC_66.L_CORE 0.003246
K_2892 X_NUC_37.L_CORE X_NUC_67.L_CORE 0.003235
K_2893 X_NUC_37.L_CORE X_NUC_68.L_CORE 0.003199
K_2894 X_NUC_37.L_CORE X_NUC_69.L_CORE 0.006355
K_2895 X_NUC_37.L_CORE X_NUC_70.L_CORE 0.006438
K_2896 X_NUC_37.L_CORE X_NUC_71.L_CORE 0.006261
K_2897 X_NUC_37.L_CORE X_NUC_72.L_CORE 0.006287
K_2898 X_NUC_37.L_CORE X_NUC_73.L_CORE 0.002979
K_2899 X_NUC_37.L_CORE X_NUC_74.L_CORE 0.003016
K_2900 X_NUC_37.L_CORE X_NUC_75.L_CORE 0.002987
K_2901 X_NUC_37.L_CORE X_NUC_76.L_CORE 0.002978
K_2902 X_NUC_37.L_CORE X_NUC_77.L_CORE 0.004139
K_2903 X_NUC_37.L_CORE X_NUC_78.L_CORE 0.004172
K_2904 X_NUC_37.L_CORE X_NUC_79.L_CORE 0.004136
K_2905 X_NUC_37.L_CORE X_NUC_80.L_CORE 0.004091
K_2906 X_NUC_37.L_CORE X_NUC_81.L_CORE 0.003848
K_2907 X_NUC_37.L_CORE X_NUC_82.L_CORE 0.003896
K_2908 X_NUC_37.L_CORE X_NUC_83.L_CORE 0.003836
K_2909 X_NUC_37.L_CORE X_NUC_84.L_CORE 0.003832
K_2910 X_NUC_37.L_CORE X_NUC_85.L_CORE 0.003195
K_2911 X_NUC_37.L_CORE X_NUC_86.L_CORE 0.006022
K_2912 X_NUC_37.L_CORE X_NUC_87.L_CORE 0.003150
K_2913 X_NUC_37.L_CORE X_NUC_88.L_CORE 0.003286
K_2914 X_NUC_37.L_CORE X_NUC_89.L_CORE 0.008225
K_2915 X_NUC_37.L_CORE X_NUC_90.L_CORE 0.002568
K_2916 X_NUC_37.L_CORE X_NUC_91.L_CORE 0.005618
K_2917 X_NUC_37.L_CORE X_NUC_92.L_CORE 0.003716
K_2918 X_NUC_37.L_CORE X_NUC_93.L_CORE 0.002704
K_2919 X_NUC_37.L_CORE X_NUC_94.L_CORE 0.010232
K_2920 X_NUC_37.L_CORE X_NUC_95.L_CORE 0.002749
K_2921 X_NUC_37.L_CORE X_NUC_96.L_CORE 0.003549
K_2922 X_NUC_37.L_CORE X_NUC_97.L_CORE 0.004222
K_2923 X_NUC_37.L_CORE X_NUC_98.L_CORE 0.002949
K_2924 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_2925 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_2926 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.002882
K_2927 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.002922
K_2928 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.002900
K_2929 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.002900
K_2930 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.003980
K_2931 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.004006
K_2932 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.004021
K_2933 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.003950
K_2934 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.005792
K_2935 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.005912
K_2936 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.005766
K_2937 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.005864
K_2938 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.002713
K_2939 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.002744
K_2940 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.002731
K_2941 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.002715
K_2942 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.007542
K_2943 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.007551
K_2944 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.007519
K_2945 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.007324
K_2946 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.003360
K_2947 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.003411
K_2948 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.003366
K_2949 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.003377
K_2950 X_NUC_38.L_CORE X_NUC_65.L_CORE 0.003188
K_2951 X_NUC_38.L_CORE X_NUC_66.L_CORE 0.003217
K_2952 X_NUC_38.L_CORE X_NUC_67.L_CORE 0.003206
K_2953 X_NUC_38.L_CORE X_NUC_68.L_CORE 0.003171
K_2954 X_NUC_38.L_CORE X_NUC_69.L_CORE 0.006270
K_2955 X_NUC_38.L_CORE X_NUC_70.L_CORE 0.006355
K_2956 X_NUC_38.L_CORE X_NUC_71.L_CORE 0.006182
K_2957 X_NUC_38.L_CORE X_NUC_72.L_CORE 0.006207
K_2958 X_NUC_38.L_CORE X_NUC_73.L_CORE 0.002943
K_2959 X_NUC_38.L_CORE X_NUC_74.L_CORE 0.002979
K_2960 X_NUC_38.L_CORE X_NUC_75.L_CORE 0.002951
K_2961 X_NUC_38.L_CORE X_NUC_76.L_CORE 0.002942
K_2962 X_NUC_38.L_CORE X_NUC_77.L_CORE 0.004105
K_2963 X_NUC_38.L_CORE X_NUC_78.L_CORE 0.004139
K_2964 X_NUC_38.L_CORE X_NUC_79.L_CORE 0.004102
K_2965 X_NUC_38.L_CORE X_NUC_80.L_CORE 0.004058
K_2966 X_NUC_38.L_CORE X_NUC_81.L_CORE 0.003801
K_2967 X_NUC_38.L_CORE X_NUC_82.L_CORE 0.003848
K_2968 X_NUC_38.L_CORE X_NUC_83.L_CORE 0.003790
K_2969 X_NUC_38.L_CORE X_NUC_84.L_CORE 0.003786
K_2970 X_NUC_38.L_CORE X_NUC_85.L_CORE 0.003160
K_2971 X_NUC_38.L_CORE X_NUC_86.L_CORE 0.005984
K_2972 X_NUC_38.L_CORE X_NUC_87.L_CORE 0.003107
K_2973 X_NUC_38.L_CORE X_NUC_88.L_CORE 0.003262
K_2974 X_NUC_38.L_CORE X_NUC_89.L_CORE 0.008084
K_2975 X_NUC_38.L_CORE X_NUC_90.L_CORE 0.002538
K_2976 X_NUC_38.L_CORE X_NUC_91.L_CORE 0.005632
K_2977 X_NUC_38.L_CORE X_NUC_92.L_CORE 0.003660
K_2978 X_NUC_38.L_CORE X_NUC_93.L_CORE 0.002679
K_2979 X_NUC_38.L_CORE X_NUC_94.L_CORE 0.010315
K_2980 X_NUC_38.L_CORE X_NUC_95.L_CORE 0.002715
K_2981 X_NUC_38.L_CORE X_NUC_96.L_CORE 0.003529
K_2982 X_NUC_38.L_CORE X_NUC_97.L_CORE 0.004174
K_2983 X_NUC_38.L_CORE X_NUC_98.L_CORE 0.002921
K_2984 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_2985 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.002902
K_2986 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.002943
K_2987 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.002922
K_2988 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.002921
K_2989 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.003965
K_2990 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.003990
K_2991 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.004006
K_2992 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.003936
K_2993 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.005938
K_2994 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.006065
K_2995 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.005912
K_2996 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.006016
K_2997 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.002725
K_2998 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.002756
K_2999 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.002744
K_3000 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.002727
K_3001 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.007569
K_3002 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.007572
K_3003 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.007551
K_3004 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.007348
K_3005 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.003405
K_3006 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.003457
K_3007 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.003411
K_3008 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.003421
K_3009 X_NUC_39.L_CORE X_NUC_65.L_CORE 0.003198
K_3010 X_NUC_39.L_CORE X_NUC_66.L_CORE 0.003227
K_3011 X_NUC_39.L_CORE X_NUC_67.L_CORE 0.003217
K_3012 X_NUC_39.L_CORE X_NUC_68.L_CORE 0.003182
K_3013 X_NUC_39.L_CORE X_NUC_69.L_CORE 0.006449
K_3014 X_NUC_39.L_CORE X_NUC_70.L_CORE 0.006538
K_3015 X_NUC_39.L_CORE X_NUC_71.L_CORE 0.006355
K_3016 X_NUC_39.L_CORE X_NUC_72.L_CORE 0.006380
K_3017 X_NUC_39.L_CORE X_NUC_73.L_CORE 0.002970
K_3018 X_NUC_39.L_CORE X_NUC_74.L_CORE 0.003007
K_3019 X_NUC_39.L_CORE X_NUC_75.L_CORE 0.002979
K_3020 X_NUC_39.L_CORE X_NUC_76.L_CORE 0.002970
K_3021 X_NUC_39.L_CORE X_NUC_77.L_CORE 0.004140
K_3022 X_NUC_39.L_CORE X_NUC_78.L_CORE 0.004175
K_3023 X_NUC_39.L_CORE X_NUC_79.L_CORE 0.004139
K_3024 X_NUC_39.L_CORE X_NUC_80.L_CORE 0.004093
K_3025 X_NUC_39.L_CORE X_NUC_81.L_CORE 0.003859
K_3026 X_NUC_39.L_CORE X_NUC_82.L_CORE 0.003908
K_3027 X_NUC_39.L_CORE X_NUC_83.L_CORE 0.003848
K_3028 X_NUC_39.L_CORE X_NUC_84.L_CORE 0.003843
K_3029 X_NUC_39.L_CORE X_NUC_85.L_CORE 0.003148
K_3030 X_NUC_39.L_CORE X_NUC_86.L_CORE 0.005863
K_3031 X_NUC_39.L_CORE X_NUC_87.L_CORE 0.003118
K_3032 X_NUC_39.L_CORE X_NUC_88.L_CORE 0.003242
K_3033 X_NUC_39.L_CORE X_NUC_89.L_CORE 0.008167
K_3034 X_NUC_39.L_CORE X_NUC_90.L_CORE 0.002546
K_3035 X_NUC_39.L_CORE X_NUC_91.L_CORE 0.005552
K_3036 X_NUC_39.L_CORE X_NUC_92.L_CORE 0.003709
K_3037 X_NUC_39.L_CORE X_NUC_93.L_CORE 0.002683
K_3038 X_NUC_39.L_CORE X_NUC_94.L_CORE 0.010658
K_3039 X_NUC_39.L_CORE X_NUC_95.L_CORE 0.002740
K_3040 X_NUC_39.L_CORE X_NUC_96.L_CORE 0.003540
K_3041 X_NUC_39.L_CORE X_NUC_97.L_CORE 0.004256
K_3042 X_NUC_39.L_CORE X_NUC_98.L_CORE 0.002947
K_3043 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.002903
K_3044 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.002944
K_3045 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.002923
K_3046 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.002922
K_3047 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.004036
K_3048 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.004063
K_3049 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.004079
K_3050 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.004006
K_3051 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.005836
K_3052 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.005956
K_3053 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.005809
K_3054 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.005912
K_3055 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.002741
K_3056 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.002773
K_3057 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.002760
K_3058 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.002744
K_3059 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.007785
K_3060 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.007789
K_3061 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.007760
K_3062 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.007551
K_3063 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.003394
K_3064 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.003445
K_3065 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.003399
K_3066 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.003411
K_3067 X_NUC_40.L_CORE X_NUC_65.L_CORE 0.003233
K_3068 X_NUC_40.L_CORE X_NUC_66.L_CORE 0.003263
K_3069 X_NUC_40.L_CORE X_NUC_67.L_CORE 0.003252
K_3070 X_NUC_40.L_CORE X_NUC_68.L_CORE 0.003217
K_3071 X_NUC_40.L_CORE X_NUC_69.L_CORE 0.006420
K_3072 X_NUC_40.L_CORE X_NUC_70.L_CORE 0.006508
K_3073 X_NUC_40.L_CORE X_NUC_71.L_CORE 0.006325
K_3074 X_NUC_40.L_CORE X_NUC_72.L_CORE 0.006355
K_3075 X_NUC_40.L_CORE X_NUC_73.L_CORE 0.002979
K_3076 X_NUC_40.L_CORE X_NUC_74.L_CORE 0.003016
K_3077 X_NUC_40.L_CORE X_NUC_75.L_CORE 0.002988
K_3078 X_NUC_40.L_CORE X_NUC_76.L_CORE 0.002979
K_3079 X_NUC_40.L_CORE X_NUC_77.L_CORE 0.004187
K_3080 X_NUC_40.L_CORE X_NUC_78.L_CORE 0.004222
K_3081 X_NUC_40.L_CORE X_NUC_79.L_CORE 0.004184
K_3082 X_NUC_40.L_CORE X_NUC_80.L_CORE 0.004139
K_3083 X_NUC_40.L_CORE X_NUC_81.L_CORE 0.003863
K_3084 X_NUC_40.L_CORE X_NUC_82.L_CORE 0.003912
K_3085 X_NUC_40.L_CORE X_NUC_83.L_CORE 0.003851
K_3086 X_NUC_40.L_CORE X_NUC_84.L_CORE 0.003848
K_3087 X_NUC_40.L_CORE X_NUC_85.L_CORE 0.003167
K_3088 X_NUC_40.L_CORE X_NUC_86.L_CORE 0.005927
K_3089 X_NUC_40.L_CORE X_NUC_87.L_CORE 0.003113
K_3090 X_NUC_40.L_CORE X_NUC_88.L_CORE 0.003284
K_3091 X_NUC_40.L_CORE X_NUC_89.L_CORE 0.007932
K_3092 X_NUC_40.L_CORE X_NUC_90.L_CORE 0.002556
K_3093 X_NUC_40.L_CORE X_NUC_91.L_CORE 0.005703
K_3094 X_NUC_40.L_CORE X_NUC_92.L_CORE 0.003677
K_3095 X_NUC_40.L_CORE X_NUC_93.L_CORE 0.002708
K_3096 X_NUC_40.L_CORE X_NUC_94.L_CORE 0.010619
K_3097 X_NUC_40.L_CORE X_NUC_95.L_CORE 0.002741
K_3098 X_NUC_40.L_CORE X_NUC_96.L_CORE 0.003587
K_3099 X_NUC_40.L_CORE X_NUC_97.L_CORE 0.004235
K_3100 X_NUC_40.L_CORE X_NUC_98.L_CORE 0.002961
K_3101 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_3102 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_3103 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_3104 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.002922
K_3105 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.002891
K_3106 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.002918
K_3107 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.002892
K_3108 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.004024
K_3109 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.003957
K_3110 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.003965
K_3111 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.003999
K_3112 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.005959
K_3113 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.005932
K_3114 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.005987
K_3115 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.005831
K_3116 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.002784
K_3117 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.002749
K_3118 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.002766
K_3119 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.002756
K_3120 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.007575
K_3121 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.007420
K_3122 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.007309
K_3123 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.007435
K_3124 X_NUC_41.L_CORE X_NUC_65.L_CORE 0.003494
K_3125 X_NUC_41.L_CORE X_NUC_66.L_CORE 0.003461
K_3126 X_NUC_41.L_CORE X_NUC_67.L_CORE 0.003483
K_3127 X_NUC_41.L_CORE X_NUC_68.L_CORE 0.003441
K_3128 X_NUC_41.L_CORE X_NUC_69.L_CORE 0.003320
K_3129 X_NUC_41.L_CORE X_NUC_70.L_CORE 0.003272
K_3130 X_NUC_41.L_CORE X_NUC_71.L_CORE 0.003278
K_3131 X_NUC_41.L_CORE X_NUC_72.L_CORE 0.003283
K_3132 X_NUC_41.L_CORE X_NUC_73.L_CORE 0.006149
K_3133 X_NUC_41.L_CORE X_NUC_74.L_CORE 0.006087
K_3134 X_NUC_41.L_CORE X_NUC_75.L_CORE 0.006043
K_3135 X_NUC_41.L_CORE X_NUC_76.L_CORE 0.005978
K_3136 X_NUC_41.L_CORE X_NUC_77.L_CORE 0.003167
K_3137 X_NUC_41.L_CORE X_NUC_78.L_CORE 0.003130
K_3138 X_NUC_41.L_CORE X_NUC_79.L_CORE 0.003141
K_3139 X_NUC_41.L_CORE X_NUC_80.L_CORE 0.003122
K_3140 X_NUC_41.L_CORE X_NUC_81.L_CORE 0.004123
K_3141 X_NUC_41.L_CORE X_NUC_82.L_CORE 0.004067
K_3142 X_NUC_41.L_CORE X_NUC_83.L_CORE 0.004056
K_3143 X_NUC_41.L_CORE X_NUC_84.L_CORE 0.004053
K_3144 X_NUC_41.L_CORE X_NUC_85.L_CORE 0.003857
K_3145 X_NUC_41.L_CORE X_NUC_86.L_CORE 0.002821
K_3146 X_NUC_41.L_CORE X_NUC_87.L_CORE 0.006622
K_3147 X_NUC_41.L_CORE X_NUC_88.L_CORE 0.002991
K_3148 X_NUC_41.L_CORE X_NUC_89.L_CORE 0.003163
K_3149 X_NUC_41.L_CORE X_NUC_90.L_CORE 0.008307
K_3150 X_NUC_41.L_CORE X_NUC_91.L_CORE 0.002509
K_3151 X_NUC_41.L_CORE X_NUC_92.L_CORE 0.005548
K_3152 X_NUC_41.L_CORE X_NUC_93.L_CORE 0.003687
K_3153 X_NUC_41.L_CORE X_NUC_94.L_CORE 0.002712
K_3154 X_NUC_41.L_CORE X_NUC_95.L_CORE 0.009184
K_3155 X_NUC_41.L_CORE X_NUC_96.L_CORE 0.002818
K_3156 X_NUC_41.L_CORE X_NUC_97.L_CORE 0.003603
K_3157 X_NUC_41.L_CORE X_NUC_98.L_CORE 0.003980
K_3158 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_3159 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_3160 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.002953
K_3161 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.002922
K_3162 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.002950
K_3163 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.002922
K_3164 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.004094
K_3165 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.004024
K_3166 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.004033
K_3167 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.004068
K_3168 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.005982
K_3169 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.005959
K_3170 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.006012
K_3171 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.005854
K_3172 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.002820
K_3173 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.002784
K_3174 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.002801
K_3175 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.002791
K_3176 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.007729
K_3177 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.007575
K_3178 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.007452
K_3179 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.007586
K_3180 X_NUC_42.L_CORE X_NUC_65.L_CORE 0.003526
K_3181 X_NUC_42.L_CORE X_NUC_66.L_CORE 0.003494
K_3182 X_NUC_42.L_CORE X_NUC_67.L_CORE 0.003516
K_3183 X_NUC_42.L_CORE X_NUC_68.L_CORE 0.003473
K_3184 X_NUC_42.L_CORE X_NUC_69.L_CORE 0.003368
K_3185 X_NUC_42.L_CORE X_NUC_70.L_CORE 0.003320
K_3186 X_NUC_42.L_CORE X_NUC_71.L_CORE 0.003325
K_3187 X_NUC_42.L_CORE X_NUC_72.L_CORE 0.003331
K_3188 X_NUC_42.L_CORE X_NUC_73.L_CORE 0.006207
K_3189 X_NUC_42.L_CORE X_NUC_74.L_CORE 0.006149
K_3190 X_NUC_42.L_CORE X_NUC_75.L_CORE 0.006101
K_3191 X_NUC_42.L_CORE X_NUC_76.L_CORE 0.006034
K_3192 X_NUC_42.L_CORE X_NUC_77.L_CORE 0.003204
K_3193 X_NUC_42.L_CORE X_NUC_78.L_CORE 0.003167
K_3194 X_NUC_42.L_CORE X_NUC_79.L_CORE 0.003178
K_3195 X_NUC_42.L_CORE X_NUC_80.L_CORE 0.003159
K_3196 X_NUC_42.L_CORE X_NUC_81.L_CORE 0.004180
K_3197 X_NUC_42.L_CORE X_NUC_82.L_CORE 0.004123
K_3198 X_NUC_42.L_CORE X_NUC_83.L_CORE 0.004110
K_3199 X_NUC_42.L_CORE X_NUC_84.L_CORE 0.004108
K_3200 X_NUC_42.L_CORE X_NUC_85.L_CORE 0.003889
K_3201 X_NUC_42.L_CORE X_NUC_86.L_CORE 0.002854
K_3202 X_NUC_42.L_CORE X_NUC_87.L_CORE 0.006689
K_3203 X_NUC_42.L_CORE X_NUC_88.L_CORE 0.003017
K_3204 X_NUC_42.L_CORE X_NUC_89.L_CORE 0.003208
K_3205 X_NUC_42.L_CORE X_NUC_90.L_CORE 0.008221
K_3206 X_NUC_42.L_CORE X_NUC_91.L_CORE 0.002537
K_3207 X_NUC_42.L_CORE X_NUC_92.L_CORE 0.005639
K_3208 X_NUC_42.L_CORE X_NUC_93.L_CORE 0.003707
K_3209 X_NUC_42.L_CORE X_NUC_94.L_CORE 0.002747
K_3210 X_NUC_42.L_CORE X_NUC_95.L_CORE 0.009177
K_3211 X_NUC_42.L_CORE X_NUC_96.L_CORE 0.002845
K_3212 X_NUC_42.L_CORE X_NUC_97.L_CORE 0.003650
K_3213 X_NUC_42.L_CORE X_NUC_98.L_CORE 0.004013
K_3214 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_3215 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.002925
K_3216 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.002895
K_3217 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.002922
K_3218 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.002895
K_3219 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.004085
K_3220 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.004015
K_3221 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.004024
K_3222 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.004059
K_3223 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.005927
K_3224 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.005903
K_3225 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.005959
K_3226 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.005803
K_3227 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.002802
K_3228 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.002766
K_3229 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.002784
K_3230 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.002774
K_3231 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.007860
K_3232 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.007692
K_3233 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.007575
K_3234 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.007710
K_3235 X_NUC_43.L_CORE X_NUC_65.L_CORE 0.003503
K_3236 X_NUC_43.L_CORE X_NUC_66.L_CORE 0.003470
K_3237 X_NUC_43.L_CORE X_NUC_67.L_CORE 0.003494
K_3238 X_NUC_43.L_CORE X_NUC_68.L_CORE 0.003450
K_3239 X_NUC_43.L_CORE X_NUC_69.L_CORE 0.003362
K_3240 X_NUC_43.L_CORE X_NUC_70.L_CORE 0.003313
K_3241 X_NUC_43.L_CORE X_NUC_71.L_CORE 0.003320
K_3242 X_NUC_43.L_CORE X_NUC_72.L_CORE 0.003324
K_3243 X_NUC_43.L_CORE X_NUC_73.L_CORE 0.006254
K_3244 X_NUC_43.L_CORE X_NUC_74.L_CORE 0.006192
K_3245 X_NUC_43.L_CORE X_NUC_75.L_CORE 0.006149
K_3246 X_NUC_43.L_CORE X_NUC_76.L_CORE 0.006077
K_3247 X_NUC_43.L_CORE X_NUC_77.L_CORE 0.003193
K_3248 X_NUC_43.L_CORE X_NUC_78.L_CORE 0.003156
K_3249 X_NUC_43.L_CORE X_NUC_79.L_CORE 0.003167
K_3250 X_NUC_43.L_CORE X_NUC_80.L_CORE 0.003148
K_3251 X_NUC_43.L_CORE X_NUC_81.L_CORE 0.004193
K_3252 X_NUC_43.L_CORE X_NUC_82.L_CORE 0.004135
K_3253 X_NUC_43.L_CORE X_NUC_83.L_CORE 0.004123
K_3254 X_NUC_43.L_CORE X_NUC_84.L_CORE 0.004120
K_3255 X_NUC_43.L_CORE X_NUC_85.L_CORE 0.003818
K_3256 X_NUC_43.L_CORE X_NUC_86.L_CORE 0.002821
K_3257 X_NUC_43.L_CORE X_NUC_87.L_CORE 0.006550
K_3258 X_NUC_43.L_CORE X_NUC_88.L_CORE 0.002978
K_3259 X_NUC_43.L_CORE X_NUC_89.L_CORE 0.003184
K_3260 X_NUC_43.L_CORE X_NUC_90.L_CORE 0.008039
K_3261 X_NUC_43.L_CORE X_NUC_91.L_CORE 0.002516
K_3262 X_NUC_43.L_CORE X_NUC_92.L_CORE 0.005663
K_3263 X_NUC_43.L_CORE X_NUC_93.L_CORE 0.003674
K_3264 X_NUC_43.L_CORE X_NUC_94.L_CORE 0.002735
K_3265 X_NUC_43.L_CORE X_NUC_95.L_CORE 0.009477
K_3266 X_NUC_43.L_CORE X_NUC_96.L_CORE 0.002831
K_3267 X_NUC_43.L_CORE X_NUC_97.L_CORE 0.003662
K_3268 X_NUC_43.L_CORE X_NUC_98.L_CORE 0.004023
K_3269 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.002953
K_3270 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.002921
K_3271 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.002949
K_3272 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.002922
K_3273 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.004048
K_3274 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.003980
K_3275 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.003989
K_3276 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.004024
K_3277 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.006091
K_3278 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.006065
K_3279 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.006123
K_3280 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.005959
K_3281 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.002812
K_3282 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.002776
K_3283 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.002793
K_3284 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.002784
K_3285 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.007712
K_3286 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.007553
K_3287 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.007437
K_3288 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.007575
K_3289 X_NUC_44.L_CORE X_NUC_65.L_CORE 0.003548
K_3290 X_NUC_44.L_CORE X_NUC_66.L_CORE 0.003514
K_3291 X_NUC_44.L_CORE X_NUC_67.L_CORE 0.003538
K_3292 X_NUC_44.L_CORE X_NUC_68.L_CORE 0.003494
K_3293 X_NUC_44.L_CORE X_NUC_69.L_CORE 0.003356
K_3294 X_NUC_44.L_CORE X_NUC_70.L_CORE 0.003308
K_3295 X_NUC_44.L_CORE X_NUC_71.L_CORE 0.003314
K_3296 X_NUC_44.L_CORE X_NUC_72.L_CORE 0.003320
K_3297 X_NUC_44.L_CORE X_NUC_73.L_CORE 0.006330
K_3298 X_NUC_44.L_CORE X_NUC_74.L_CORE 0.006265
K_3299 X_NUC_44.L_CORE X_NUC_75.L_CORE 0.006217
K_3300 X_NUC_44.L_CORE X_NUC_76.L_CORE 0.006149
K_3301 X_NUC_44.L_CORE X_NUC_77.L_CORE 0.003213
K_3302 X_NUC_44.L_CORE X_NUC_78.L_CORE 0.003175
K_3303 X_NUC_44.L_CORE X_NUC_79.L_CORE 0.003186
K_3304 X_NUC_44.L_CORE X_NUC_80.L_CORE 0.003167
K_3305 X_NUC_44.L_CORE X_NUC_81.L_CORE 0.004196
K_3306 X_NUC_44.L_CORE X_NUC_82.L_CORE 0.004137
K_3307 X_NUC_44.L_CORE X_NUC_83.L_CORE 0.004125
K_3308 X_NUC_44.L_CORE X_NUC_84.L_CORE 0.004123
K_3309 X_NUC_44.L_CORE X_NUC_85.L_CORE 0.003851
K_3310 X_NUC_44.L_CORE X_NUC_86.L_CORE 0.002827
K_3311 X_NUC_44.L_CORE X_NUC_87.L_CORE 0.006493
K_3312 X_NUC_44.L_CORE X_NUC_88.L_CORE 0.003010
K_3313 X_NUC_44.L_CORE X_NUC_89.L_CORE 0.003169
K_3314 X_NUC_44.L_CORE X_NUC_90.L_CORE 0.008323
K_3315 X_NUC_44.L_CORE X_NUC_91.L_CORE 0.002529
K_3316 X_NUC_44.L_CORE X_NUC_92.L_CORE 0.005543
K_3317 X_NUC_44.L_CORE X_NUC_93.L_CORE 0.003736
K_3318 X_NUC_44.L_CORE X_NUC_94.L_CORE 0.002734
K_3319 X_NUC_44.L_CORE X_NUC_95.L_CORE 0.009475
K_3320 X_NUC_44.L_CORE X_NUC_96.L_CORE 0.002854
K_3321 X_NUC_44.L_CORE X_NUC_97.L_CORE 0.003646
K_3322 X_NUC_44.L_CORE X_NUC_98.L_CORE 0.004057
K_3323 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_3324 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_3325 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_3326 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.002949
K_3327 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.002953
K_3328 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.002929
K_3329 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.002971
K_3330 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.004080
K_3331 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.004158
K_3332 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.004098
K_3333 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.004121
K_3334 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.006056
K_3335 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.005967
K_3336 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.005904
K_3337 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.006040
K_3338 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.002855
K_3339 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.002875
K_3340 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.002843
K_3341 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.002876
K_3342 X_NUC_45.L_CORE X_NUC_65.L_CORE 0.007600
K_3343 X_NUC_45.L_CORE X_NUC_66.L_CORE 0.007810
K_3344 X_NUC_45.L_CORE X_NUC_67.L_CORE 0.007556
K_3345 X_NUC_45.L_CORE X_NUC_68.L_CORE 0.007580
K_3346 X_NUC_45.L_CORE X_NUC_69.L_CORE 0.003621
K_3347 X_NUC_45.L_CORE X_NUC_70.L_CORE 0.003617
K_3348 X_NUC_45.L_CORE X_NUC_71.L_CORE 0.003574
K_3349 X_NUC_45.L_CORE X_NUC_72.L_CORE 0.003631
K_3350 X_NUC_45.L_CORE X_NUC_73.L_CORE 0.003477
K_3351 X_NUC_45.L_CORE X_NUC_74.L_CORE 0.003518
K_3352 X_NUC_45.L_CORE X_NUC_75.L_CORE 0.003463
K_3353 X_NUC_45.L_CORE X_NUC_76.L_CORE 0.003496
K_3354 X_NUC_45.L_CORE X_NUC_77.L_CORE 0.005822
K_3355 X_NUC_45.L_CORE X_NUC_78.L_CORE 0.005834
K_3356 X_NUC_45.L_CORE X_NUC_79.L_CORE 0.005691
K_3357 X_NUC_45.L_CORE X_NUC_80.L_CORE 0.005780
K_3358 X_NUC_45.L_CORE X_NUC_81.L_CORE 0.003527
K_3359 X_NUC_45.L_CORE X_NUC_82.L_CORE 0.003546
K_3360 X_NUC_45.L_CORE X_NUC_83.L_CORE 0.003491
K_3361 X_NUC_45.L_CORE X_NUC_84.L_CORE 0.003536
K_3362 X_NUC_45.L_CORE X_NUC_85.L_CORE 0.003614
K_3363 X_NUC_45.L_CORE X_NUC_86.L_CORE 0.003932
K_3364 X_NUC_45.L_CORE X_NUC_87.L_CORE 0.002687
K_3365 X_NUC_45.L_CORE X_NUC_88.L_CORE 0.007260
K_3366 X_NUC_45.L_CORE X_NUC_89.L_CORE 0.002936
K_3367 X_NUC_45.L_CORE X_NUC_90.L_CORE 0.003168
K_3368 X_NUC_45.L_CORE X_NUC_91.L_CORE 0.008266
K_3369 X_NUC_45.L_CORE X_NUC_92.L_CORE 0.002536
K_3370 X_NUC_45.L_CORE X_NUC_93.L_CORE 0.005700
K_3371 X_NUC_45.L_CORE X_NUC_94.L_CORE 0.003744
K_3372 X_NUC_45.L_CORE X_NUC_95.L_CORE 0.002827
K_3373 X_NUC_45.L_CORE X_NUC_96.L_CORE 0.008111
K_3374 X_NUC_45.L_CORE X_NUC_97.L_CORE 0.003017
K_3375 X_NUC_45.L_CORE X_NUC_98.L_CORE 0.003777
K_3376 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_3377 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_3378 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.002944
K_3379 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.002949
K_3380 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.002924
K_3381 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.002966
K_3382 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.004005
K_3383 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.004080
K_3384 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.004023
K_3385 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.004045
K_3386 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.006143
K_3387 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.006056
K_3388 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.005988
K_3389 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.006130
K_3390 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.002834
K_3391 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.002855
K_3392 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.002823
K_3393 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.002855
K_3394 X_NUC_46.L_CORE X_NUC_65.L_CORE 0.007398
K_3395 X_NUC_46.L_CORE X_NUC_66.L_CORE 0.007600
K_3396 X_NUC_46.L_CORE X_NUC_67.L_CORE 0.007361
K_3397 X_NUC_46.L_CORE X_NUC_68.L_CORE 0.007384
K_3398 X_NUC_46.L_CORE X_NUC_69.L_CORE 0.003624
K_3399 X_NUC_46.L_CORE X_NUC_70.L_CORE 0.003621
K_3400 X_NUC_46.L_CORE X_NUC_71.L_CORE 0.003577
K_3401 X_NUC_46.L_CORE X_NUC_72.L_CORE 0.003635
K_3402 X_NUC_46.L_CORE X_NUC_73.L_CORE 0.003436
K_3403 X_NUC_46.L_CORE X_NUC_74.L_CORE 0.003477
K_3404 X_NUC_46.L_CORE X_NUC_75.L_CORE 0.003423
K_3405 X_NUC_46.L_CORE X_NUC_76.L_CORE 0.003455
K_3406 X_NUC_46.L_CORE X_NUC_77.L_CORE 0.005806
K_3407 X_NUC_46.L_CORE X_NUC_78.L_CORE 0.005822
K_3408 X_NUC_46.L_CORE X_NUC_79.L_CORE 0.005678
K_3409 X_NUC_46.L_CORE X_NUC_80.L_CORE 0.005767
K_3410 X_NUC_46.L_CORE X_NUC_81.L_CORE 0.003508
K_3411 X_NUC_46.L_CORE X_NUC_82.L_CORE 0.003527
K_3412 X_NUC_46.L_CORE X_NUC_83.L_CORE 0.003472
K_3413 X_NUC_46.L_CORE X_NUC_84.L_CORE 0.003517
K_3414 X_NUC_46.L_CORE X_NUC_85.L_CORE 0.003582
K_3415 X_NUC_46.L_CORE X_NUC_86.L_CORE 0.003947
K_3416 X_NUC_46.L_CORE X_NUC_87.L_CORE 0.002667
K_3417 X_NUC_46.L_CORE X_NUC_88.L_CORE 0.007152
K_3418 X_NUC_46.L_CORE X_NUC_89.L_CORE 0.002940
K_3419 X_NUC_46.L_CORE X_NUC_90.L_CORE 0.003125
K_3420 X_NUC_46.L_CORE X_NUC_91.L_CORE 0.008554
K_3421 X_NUC_46.L_CORE X_NUC_92.L_CORE 0.002524
K_3422 X_NUC_46.L_CORE X_NUC_93.L_CORE 0.005552
K_3423 X_NUC_46.L_CORE X_NUC_94.L_CORE 0.003770
K_3424 X_NUC_46.L_CORE X_NUC_95.L_CORE 0.002799
K_3425 X_NUC_46.L_CORE X_NUC_96.L_CORE 0.008089
K_3426 X_NUC_46.L_CORE X_NUC_97.L_CORE 0.003010
K_3427 X_NUC_46.L_CORE X_NUC_98.L_CORE 0.003738
K_3428 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_3429 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.002969
K_3430 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.002974
K_3431 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.002949
K_3432 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.002991
K_3433 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.004060
K_3434 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.004138
K_3435 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.004080
K_3436 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.004101
K_3437 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.006214
K_3438 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.006121
K_3439 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.006056
K_3440 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.006200
K_3441 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.002866
K_3442 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.002887
K_3443 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.002855
K_3444 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.002888
K_3445 X_NUC_47.L_CORE X_NUC_65.L_CORE 0.007636
K_3446 X_NUC_47.L_CORE X_NUC_66.L_CORE 0.007854
K_3447 X_NUC_47.L_CORE X_NUC_67.L_CORE 0.007600
K_3448 X_NUC_47.L_CORE X_NUC_68.L_CORE 0.007621
K_3449 X_NUC_47.L_CORE X_NUC_69.L_CORE 0.003669
K_3450 X_NUC_47.L_CORE X_NUC_70.L_CORE 0.003666
K_3451 X_NUC_47.L_CORE X_NUC_71.L_CORE 0.003621
K_3452 X_NUC_47.L_CORE X_NUC_72.L_CORE 0.003680
K_3453 X_NUC_47.L_CORE X_NUC_73.L_CORE 0.003490
K_3454 X_NUC_47.L_CORE X_NUC_74.L_CORE 0.003532
K_3455 X_NUC_47.L_CORE X_NUC_75.L_CORE 0.003477
K_3456 X_NUC_47.L_CORE X_NUC_76.L_CORE 0.003510
K_3457 X_NUC_47.L_CORE X_NUC_77.L_CORE 0.005958
K_3458 X_NUC_47.L_CORE X_NUC_78.L_CORE 0.005973
K_3459 X_NUC_47.L_CORE X_NUC_79.L_CORE 0.005822
K_3460 X_NUC_47.L_CORE X_NUC_80.L_CORE 0.005916
K_3461 X_NUC_47.L_CORE X_NUC_81.L_CORE 0.003565
K_3462 X_NUC_47.L_CORE X_NUC_82.L_CORE 0.003584
K_3463 X_NUC_47.L_CORE X_NUC_83.L_CORE 0.003527
K_3464 X_NUC_47.L_CORE X_NUC_84.L_CORE 0.003574
K_3465 X_NUC_47.L_CORE X_NUC_85.L_CORE 0.003576
K_3466 X_NUC_47.L_CORE X_NUC_86.L_CORE 0.003926
K_3467 X_NUC_47.L_CORE X_NUC_87.L_CORE 0.002679
K_3468 X_NUC_47.L_CORE X_NUC_88.L_CORE 0.007034
K_3469 X_NUC_47.L_CORE X_NUC_89.L_CORE 0.002950
K_3470 X_NUC_47.L_CORE X_NUC_90.L_CORE 0.003148
K_3471 X_NUC_47.L_CORE X_NUC_91.L_CORE 0.008419
K_3472 X_NUC_47.L_CORE X_NUC_92.L_CORE 0.002544
K_3473 X_NUC_47.L_CORE X_NUC_93.L_CORE 0.005630
K_3474 X_NUC_47.L_CORE X_NUC_94.L_CORE 0.003799
K_3475 X_NUC_47.L_CORE X_NUC_95.L_CORE 0.002832
K_3476 X_NUC_47.L_CORE X_NUC_96.L_CORE 0.008349
K_3477 X_NUC_47.L_CORE X_NUC_97.L_CORE 0.003047
K_3478 X_NUC_47.L_CORE X_NUC_98.L_CORE 0.003806
K_3479 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.002927
K_3480 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.002932
K_3481 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.002908
K_3482 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.002949
K_3483 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.004039
K_3484 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.004115
K_3485 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.004057
K_3486 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.004080
K_3487 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.006066
K_3488 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.005979
K_3489 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.005916
K_3490 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.006056
K_3491 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.002834
K_3492 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.002854
K_3493 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.002823
K_3494 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.002855
K_3495 X_NUC_48.L_CORE X_NUC_65.L_CORE 0.007611
K_3496 X_NUC_48.L_CORE X_NUC_66.L_CORE 0.007826
K_3497 X_NUC_48.L_CORE X_NUC_67.L_CORE 0.007570
K_3498 X_NUC_48.L_CORE X_NUC_68.L_CORE 0.007600
K_3499 X_NUC_48.L_CORE X_NUC_69.L_CORE 0.003610
K_3500 X_NUC_48.L_CORE X_NUC_70.L_CORE 0.003607
K_3501 X_NUC_48.L_CORE X_NUC_71.L_CORE 0.003564
K_3502 X_NUC_48.L_CORE X_NUC_72.L_CORE 0.003621
K_3503 X_NUC_48.L_CORE X_NUC_73.L_CORE 0.003457
K_3504 X_NUC_48.L_CORE X_NUC_74.L_CORE 0.003499
K_3505 X_NUC_48.L_CORE X_NUC_75.L_CORE 0.003444
K_3506 X_NUC_48.L_CORE X_NUC_76.L_CORE 0.003477
K_3507 X_NUC_48.L_CORE X_NUC_77.L_CORE 0.005861
K_3508 X_NUC_48.L_CORE X_NUC_78.L_CORE 0.005875
K_3509 X_NUC_48.L_CORE X_NUC_79.L_CORE 0.005729
K_3510 X_NUC_48.L_CORE X_NUC_80.L_CORE 0.005822
K_3511 X_NUC_48.L_CORE X_NUC_81.L_CORE 0.003518
K_3512 X_NUC_48.L_CORE X_NUC_82.L_CORE 0.003537
K_3513 X_NUC_48.L_CORE X_NUC_83.L_CORE 0.003482
K_3514 X_NUC_48.L_CORE X_NUC_84.L_CORE 0.003527
K_3515 X_NUC_48.L_CORE X_NUC_85.L_CORE 0.003553
K_3516 X_NUC_48.L_CORE X_NUC_86.L_CORE 0.003878
K_3517 X_NUC_48.L_CORE X_NUC_87.L_CORE 0.002655
K_3518 X_NUC_48.L_CORE X_NUC_88.L_CORE 0.007071
K_3519 X_NUC_48.L_CORE X_NUC_89.L_CORE 0.002910
K_3520 X_NUC_48.L_CORE X_NUC_90.L_CORE 0.003131
K_3521 X_NUC_48.L_CORE X_NUC_91.L_CORE 0.008265
K_3522 X_NUC_48.L_CORE X_NUC_92.L_CORE 0.002516
K_3523 X_NUC_48.L_CORE X_NUC_93.L_CORE 0.005654
K_3524 X_NUC_48.L_CORE X_NUC_94.L_CORE 0.003737
K_3525 X_NUC_48.L_CORE X_NUC_95.L_CORE 0.002808
K_3526 X_NUC_48.L_CORE X_NUC_96.L_CORE 0.008303
K_3527 X_NUC_48.L_CORE X_NUC_97.L_CORE 0.003008
K_3528 X_NUC_48.L_CORE X_NUC_98.L_CORE 0.003775
K_3529 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_3530 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_3531 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_3532 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.003005
K_3533 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.003031
K_3534 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.003034
K_3535 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.002999
K_3536 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.004178
K_3537 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.004136
K_3538 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.004183
K_3539 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.004113
K_3540 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.006209
K_3541 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.006380
K_3542 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.006274
K_3543 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.006220
K_3544 X_NUC_49.L_CORE X_NUC_65.L_CORE 0.002965
K_3545 X_NUC_49.L_CORE X_NUC_66.L_CORE 0.002972
K_3546 X_NUC_49.L_CORE X_NUC_67.L_CORE 0.002982
K_3547 X_NUC_49.L_CORE X_NUC_68.L_CORE 0.002942
K_3548 X_NUC_49.L_CORE X_NUC_69.L_CORE 0.007610
K_3549 X_NUC_49.L_CORE X_NUC_70.L_CORE 0.007493
K_3550 X_NUC_49.L_CORE X_NUC_71.L_CORE 0.007505
K_3551 X_NUC_49.L_CORE X_NUC_72.L_CORE 0.007345
K_3552 X_NUC_49.L_CORE X_NUC_73.L_CORE 0.003810
K_3553 X_NUC_49.L_CORE X_NUC_74.L_CORE 0.003854
K_3554 X_NUC_49.L_CORE X_NUC_75.L_CORE 0.003835
K_3555 X_NUC_49.L_CORE X_NUC_76.L_CORE 0.003789
K_3556 X_NUC_49.L_CORE X_NUC_77.L_CORE 0.003720
K_3557 X_NUC_49.L_CORE X_NUC_78.L_CORE 0.003714
K_3558 X_NUC_49.L_CORE X_NUC_79.L_CORE 0.003725
K_3559 X_NUC_49.L_CORE X_NUC_80.L_CORE 0.003667
K_3560 X_NUC_49.L_CORE X_NUC_81.L_CORE 0.005249
K_3561 X_NUC_49.L_CORE X_NUC_82.L_CORE 0.005283
K_3562 X_NUC_49.L_CORE X_NUC_83.L_CORE 0.005237
K_3563 X_NUC_49.L_CORE X_NUC_84.L_CORE 0.005157
K_3564 X_NUC_49.L_CORE X_NUC_85.L_CORE 0.002921
K_3565 X_NUC_49.L_CORE X_NUC_86.L_CORE 0.003605
K_3566 X_NUC_49.L_CORE X_NUC_87.L_CORE 0.003989
K_3567 X_NUC_49.L_CORE X_NUC_88.L_CORE 0.002594
K_3568 X_NUC_49.L_CORE X_NUC_89.L_CORE 0.007629
K_3569 X_NUC_49.L_CORE X_NUC_90.L_CORE 0.002932
K_3570 X_NUC_49.L_CORE X_NUC_91.L_CORE 0.003141
K_3571 X_NUC_49.L_CORE X_NUC_92.L_CORE 0.008782
K_3572 X_NUC_49.L_CORE X_NUC_93.L_CORE 0.002579
K_3573 X_NUC_49.L_CORE X_NUC_94.L_CORE 0.005659
K_3574 X_NUC_49.L_CORE X_NUC_95.L_CORE 0.003906
K_3575 X_NUC_49.L_CORE X_NUC_96.L_CORE 0.002958
K_3576 X_NUC_49.L_CORE X_NUC_97.L_CORE 0.006986
K_3577 X_NUC_49.L_CORE X_NUC_98.L_CORE 0.003391
K_3578 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_3579 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_3580 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.002980
K_3581 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.003005
K_3582 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.003008
K_3583 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.002974
K_3584 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.004220
K_3585 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.004178
K_3586 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.004226
K_3587 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.004154
K_3588 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.006046
K_3589 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.006209
K_3590 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.006109
K_3591 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.006059
K_3592 X_NUC_50.L_CORE X_NUC_65.L_CORE 0.002957
K_3593 X_NUC_50.L_CORE X_NUC_66.L_CORE 0.002965
K_3594 X_NUC_50.L_CORE X_NUC_67.L_CORE 0.002975
K_3595 X_NUC_50.L_CORE X_NUC_68.L_CORE 0.002935
K_3596 X_NUC_50.L_CORE X_NUC_69.L_CORE 0.007723
K_3597 X_NUC_50.L_CORE X_NUC_70.L_CORE 0.007610
K_3598 X_NUC_50.L_CORE X_NUC_71.L_CORE 0.007618
K_3599 X_NUC_50.L_CORE X_NUC_72.L_CORE 0.007450
K_3600 X_NUC_50.L_CORE X_NUC_73.L_CORE 0.003766
K_3601 X_NUC_50.L_CORE X_NUC_74.L_CORE 0.003810
K_3602 X_NUC_50.L_CORE X_NUC_75.L_CORE 0.003791
K_3603 X_NUC_50.L_CORE X_NUC_76.L_CORE 0.003746
K_3604 X_NUC_50.L_CORE X_NUC_77.L_CORE 0.003725
K_3605 X_NUC_50.L_CORE X_NUC_78.L_CORE 0.003720
K_3606 X_NUC_50.L_CORE X_NUC_79.L_CORE 0.003731
K_3607 X_NUC_50.L_CORE X_NUC_80.L_CORE 0.003672
K_3608 X_NUC_50.L_CORE X_NUC_81.L_CORE 0.005212
K_3609 X_NUC_50.L_CORE X_NUC_82.L_CORE 0.005249
K_3610 X_NUC_50.L_CORE X_NUC_83.L_CORE 0.005202
K_3611 X_NUC_50.L_CORE X_NUC_84.L_CORE 0.005124
K_3612 X_NUC_50.L_CORE X_NUC_85.L_CORE 0.002909
K_3613 X_NUC_50.L_CORE X_NUC_86.L_CORE 0.003625
K_3614 X_NUC_50.L_CORE X_NUC_87.L_CORE 0.003937
K_3615 X_NUC_50.L_CORE X_NUC_88.L_CORE 0.002593
K_3616 X_NUC_50.L_CORE X_NUC_89.L_CORE 0.007779
K_3617 X_NUC_50.L_CORE X_NUC_90.L_CORE 0.002902
K_3618 X_NUC_50.L_CORE X_NUC_91.L_CORE 0.003162
K_3619 X_NUC_50.L_CORE X_NUC_92.L_CORE 0.008441
K_3620 X_NUC_50.L_CORE X_NUC_93.L_CORE 0.002568
K_3621 X_NUC_50.L_CORE X_NUC_94.L_CORE 0.005784
K_3622 X_NUC_50.L_CORE X_NUC_95.L_CORE 0.003844
K_3623 X_NUC_50.L_CORE X_NUC_96.L_CORE 0.002962
K_3624 X_NUC_50.L_CORE X_NUC_97.L_CORE 0.006966
K_3625 X_NUC_50.L_CORE X_NUC_98.L_CORE 0.003370
K_3626 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_3627 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.002977
K_3628 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.003002
K_3629 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.003005
K_3630 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.002970
K_3631 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.004172
K_3632 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.004130
K_3633 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.004178
K_3634 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.004108
K_3635 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.006140
K_3636 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.006308
K_3637 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.006209
K_3638 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.006153
K_3639 X_NUC_51.L_CORE X_NUC_65.L_CORE 0.002947
K_3640 X_NUC_51.L_CORE X_NUC_66.L_CORE 0.002954
K_3641 X_NUC_51.L_CORE X_NUC_67.L_CORE 0.002965
K_3642 X_NUC_51.L_CORE X_NUC_68.L_CORE 0.002925
K_3643 X_NUC_51.L_CORE X_NUC_69.L_CORE 0.007709
K_3644 X_NUC_51.L_CORE X_NUC_70.L_CORE 0.007592
K_3645 X_NUC_51.L_CORE X_NUC_71.L_CORE 0.007610
K_3646 X_NUC_51.L_CORE X_NUC_72.L_CORE 0.007438
K_3647 X_NUC_51.L_CORE X_NUC_73.L_CORE 0.003784
K_3648 X_NUC_51.L_CORE X_NUC_74.L_CORE 0.003828
K_3649 X_NUC_51.L_CORE X_NUC_75.L_CORE 0.003810
K_3650 X_NUC_51.L_CORE X_NUC_76.L_CORE 0.003764
K_3651 X_NUC_51.L_CORE X_NUC_77.L_CORE 0.003714
K_3652 X_NUC_51.L_CORE X_NUC_78.L_CORE 0.003709
K_3653 X_NUC_51.L_CORE X_NUC_79.L_CORE 0.003720
K_3654 X_NUC_51.L_CORE X_NUC_80.L_CORE 0.003662
K_3655 X_NUC_51.L_CORE X_NUC_81.L_CORE 0.005257
K_3656 X_NUC_51.L_CORE X_NUC_82.L_CORE 0.005293
K_3657 X_NUC_51.L_CORE X_NUC_83.L_CORE 0.005249
K_3658 X_NUC_51.L_CORE X_NUC_84.L_CORE 0.005167
K_3659 X_NUC_51.L_CORE X_NUC_85.L_CORE 0.002882
K_3660 X_NUC_51.L_CORE X_NUC_86.L_CORE 0.003564
K_3661 X_NUC_51.L_CORE X_NUC_87.L_CORE 0.003917
K_3662 X_NUC_51.L_CORE X_NUC_88.L_CORE 0.002570
K_3663 X_NUC_51.L_CORE X_NUC_89.L_CORE 0.007525
K_3664 X_NUC_51.L_CORE X_NUC_90.L_CORE 0.002898
K_3665 X_NUC_51.L_CORE X_NUC_91.L_CORE 0.003126
K_3666 X_NUC_51.L_CORE X_NUC_92.L_CORE 0.008609
K_3667 X_NUC_51.L_CORE X_NUC_93.L_CORE 0.002560
K_3668 X_NUC_51.L_CORE X_NUC_94.L_CORE 0.005703
K_3669 X_NUC_51.L_CORE X_NUC_95.L_CORE 0.003873
K_3670 X_NUC_51.L_CORE X_NUC_96.L_CORE 0.002949
K_3671 X_NUC_51.L_CORE X_NUC_97.L_CORE 0.007095
K_3672 X_NUC_51.L_CORE X_NUC_98.L_CORE 0.003382
K_3673 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.003011
K_3674 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.003037
K_3675 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.003041
K_3676 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.003005
K_3677 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.004245
K_3678 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.004201
K_3679 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.004251
K_3680 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.004178
K_3681 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.006192
K_3682 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.006365
K_3683 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.006260
K_3684 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.006209
K_3685 X_NUC_52.L_CORE X_NUC_65.L_CORE 0.002987
K_3686 X_NUC_52.L_CORE X_NUC_66.L_CORE 0.002995
K_3687 X_NUC_52.L_CORE X_NUC_67.L_CORE 0.003006
K_3688 X_NUC_52.L_CORE X_NUC_68.L_CORE 0.002965
K_3689 X_NUC_52.L_CORE X_NUC_69.L_CORE 0.007896
K_3690 X_NUC_52.L_CORE X_NUC_70.L_CORE 0.007770
K_3691 X_NUC_52.L_CORE X_NUC_71.L_CORE 0.007784
K_3692 X_NUC_52.L_CORE X_NUC_72.L_CORE 0.007610
K_3693 X_NUC_52.L_CORE X_NUC_73.L_CORE 0.003830
K_3694 X_NUC_52.L_CORE X_NUC_74.L_CORE 0.003876
K_3695 X_NUC_52.L_CORE X_NUC_75.L_CORE 0.003857
K_3696 X_NUC_52.L_CORE X_NUC_76.L_CORE 0.003810
K_3697 X_NUC_52.L_CORE X_NUC_77.L_CORE 0.003775
K_3698 X_NUC_52.L_CORE X_NUC_78.L_CORE 0.003768
K_3699 X_NUC_52.L_CORE X_NUC_79.L_CORE 0.003780
K_3700 X_NUC_52.L_CORE X_NUC_80.L_CORE 0.003720
K_3701 X_NUC_52.L_CORE X_NUC_81.L_CORE 0.005342
K_3702 X_NUC_52.L_CORE X_NUC_82.L_CORE 0.005380
K_3703 X_NUC_52.L_CORE X_NUC_83.L_CORE 0.005331
K_3704 X_NUC_52.L_CORE X_NUC_84.L_CORE 0.005249
K_3705 X_NUC_52.L_CORE X_NUC_85.L_CORE 0.002909
K_3706 X_NUC_52.L_CORE X_NUC_86.L_CORE 0.003602
K_3707 X_NUC_52.L_CORE X_NUC_87.L_CORE 0.003937
K_3708 X_NUC_52.L_CORE X_NUC_88.L_CORE 0.002600
K_3709 X_NUC_52.L_CORE X_NUC_89.L_CORE 0.007546
K_3710 X_NUC_52.L_CORE X_NUC_90.L_CORE 0.002924
K_3711 X_NUC_52.L_CORE X_NUC_91.L_CORE 0.003168
K_3712 X_NUC_52.L_CORE X_NUC_92.L_CORE 0.008520
K_3713 X_NUC_52.L_CORE X_NUC_93.L_CORE 0.002590
K_3714 X_NUC_52.L_CORE X_NUC_94.L_CORE 0.005792
K_3715 X_NUC_52.L_CORE X_NUC_95.L_CORE 0.003904
K_3716 X_NUC_52.L_CORE X_NUC_96.L_CORE 0.002990
K_3717 X_NUC_52.L_CORE X_NUC_97.L_CORE 0.007176
K_3718 X_NUC_52.L_CORE X_NUC_98.L_CORE 0.003423
K_3719 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_3720 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_3721 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_3722 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.003096
K_3723 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.003052
K_3724 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.003067
K_3725 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.003076
K_3726 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.004328
K_3727 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.004308
K_3728 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.004266
K_3729 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.004352
K_3730 X_NUC_53.L_CORE X_NUC_65.L_CORE 0.006429
K_3731 X_NUC_53.L_CORE X_NUC_66.L_CORE 0.006259
K_3732 X_NUC_53.L_CORE X_NUC_67.L_CORE 0.006329
K_3733 X_NUC_53.L_CORE X_NUC_68.L_CORE 0.006263
K_3734 X_NUC_53.L_CORE X_NUC_69.L_CORE 0.003128
K_3735 X_NUC_53.L_CORE X_NUC_70.L_CORE 0.003092
K_3736 X_NUC_53.L_CORE X_NUC_71.L_CORE 0.003089
K_3737 X_NUC_53.L_CORE X_NUC_72.L_CORE 0.003116
K_3738 X_NUC_53.L_CORE X_NUC_73.L_CORE 0.007566
K_3739 X_NUC_53.L_CORE X_NUC_74.L_CORE 0.007501
K_3740 X_NUC_53.L_CORE X_NUC_75.L_CORE 0.007316
K_3741 X_NUC_53.L_CORE X_NUC_76.L_CORE 0.007501
K_3742 X_NUC_53.L_CORE X_NUC_77.L_CORE 0.004094
K_3743 X_NUC_53.L_CORE X_NUC_78.L_CORE 0.004023
K_3744 X_NUC_53.L_CORE X_NUC_79.L_CORE 0.004029
K_3745 X_NUC_53.L_CORE X_NUC_80.L_CORE 0.004039
K_3746 X_NUC_53.L_CORE X_NUC_81.L_CORE 0.004143
K_3747 X_NUC_53.L_CORE X_NUC_82.L_CORE 0.004094
K_3748 X_NUC_53.L_CORE X_NUC_83.L_CORE 0.004065
K_3749 X_NUC_53.L_CORE X_NUC_84.L_CORE 0.004114
K_3750 X_NUC_53.L_CORE X_NUC_85.L_CORE 0.003705
K_3751 X_NUC_53.L_CORE X_NUC_86.L_CORE 0.002688
K_3752 X_NUC_53.L_CORE X_NUC_87.L_CORE 0.003619
K_3753 X_NUC_53.L_CORE X_NUC_88.L_CORE 0.003966
K_3754 X_NUC_53.L_CORE X_NUC_89.L_CORE 0.002550
K_3755 X_NUC_53.L_CORE X_NUC_90.L_CORE 0.008254
K_3756 X_NUC_53.L_CORE X_NUC_91.L_CORE 0.002918
K_3757 X_NUC_53.L_CORE X_NUC_92.L_CORE 0.003195
K_3758 X_NUC_53.L_CORE X_NUC_93.L_CORE 0.008788
K_3759 X_NUC_53.L_CORE X_NUC_94.L_CORE 0.002646
K_3760 X_NUC_53.L_CORE X_NUC_95.L_CORE 0.005897
K_3761 X_NUC_53.L_CORE X_NUC_96.L_CORE 0.004030
K_3762 X_NUC_53.L_CORE X_NUC_97.L_CORE 0.003198
K_3763 X_NUC_53.L_CORE X_NUC_98.L_CORE 0.005617
K_3764 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_3765 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_3766 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.003142
K_3767 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.003096
K_3768 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.003112
K_3769 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.003122
K_3770 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.004347
K_3771 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.004328
K_3772 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.004285
K_3773 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.004372
K_3774 X_NUC_54.L_CORE X_NUC_65.L_CORE 0.006606
K_3775 X_NUC_54.L_CORE X_NUC_66.L_CORE 0.006429
K_3776 X_NUC_54.L_CORE X_NUC_67.L_CORE 0.006501
K_3777 X_NUC_54.L_CORE X_NUC_68.L_CORE 0.006429
K_3778 X_NUC_54.L_CORE X_NUC_69.L_CORE 0.003165
K_3779 X_NUC_54.L_CORE X_NUC_70.L_CORE 0.003128
K_3780 X_NUC_54.L_CORE X_NUC_71.L_CORE 0.003125
K_3781 X_NUC_54.L_CORE X_NUC_72.L_CORE 0.003153
K_3782 X_NUC_54.L_CORE X_NUC_73.L_CORE 0.007623
K_3783 X_NUC_54.L_CORE X_NUC_74.L_CORE 0.007566
K_3784 X_NUC_54.L_CORE X_NUC_75.L_CORE 0.007372
K_3785 X_NUC_54.L_CORE X_NUC_76.L_CORE 0.007562
K_3786 X_NUC_54.L_CORE X_NUC_77.L_CORE 0.004167
K_3787 X_NUC_54.L_CORE X_NUC_78.L_CORE 0.004094
K_3788 X_NUC_54.L_CORE X_NUC_79.L_CORE 0.004100
K_3789 X_NUC_54.L_CORE X_NUC_80.L_CORE 0.004110
K_3790 X_NUC_54.L_CORE X_NUC_81.L_CORE 0.004192
K_3791 X_NUC_54.L_CORE X_NUC_82.L_CORE 0.004143
K_3792 X_NUC_54.L_CORE X_NUC_83.L_CORE 0.004112
K_3793 X_NUC_54.L_CORE X_NUC_84.L_CORE 0.004163
K_3794 X_NUC_54.L_CORE X_NUC_85.L_CORE 0.003728
K_3795 X_NUC_54.L_CORE X_NUC_86.L_CORE 0.002714
K_3796 X_NUC_54.L_CORE X_NUC_87.L_CORE 0.003624
K_3797 X_NUC_54.L_CORE X_NUC_88.L_CORE 0.004019
K_3798 X_NUC_54.L_CORE X_NUC_89.L_CORE 0.002571
K_3799 X_NUC_54.L_CORE X_NUC_90.L_CORE 0.008107
K_3800 X_NUC_54.L_CORE X_NUC_91.L_CORE 0.002959
K_3801 X_NUC_54.L_CORE X_NUC_92.L_CORE 0.003208
K_3802 X_NUC_54.L_CORE X_NUC_93.L_CORE 0.008991
K_3803 X_NUC_54.L_CORE X_NUC_94.L_CORE 0.002676
K_3804 X_NUC_54.L_CORE X_NUC_95.L_CORE 0.005872
K_3805 X_NUC_54.L_CORE X_NUC_96.L_CORE 0.004102
K_3806 X_NUC_54.L_CORE X_NUC_97.L_CORE 0.003227
K_3807 X_NUC_54.L_CORE X_NUC_98.L_CORE 0.005687
K_3808 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_3809 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.003125
K_3810 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.003080
K_3811 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.003096
K_3812 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.003105
K_3813 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.004392
K_3814 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.004371
K_3815 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.004328
K_3816 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.004417
K_3817 X_NUC_55.L_CORE X_NUC_65.L_CORE 0.006527
K_3818 X_NUC_55.L_CORE X_NUC_66.L_CORE 0.006353
K_3819 X_NUC_55.L_CORE X_NUC_67.L_CORE 0.006429
K_3820 X_NUC_55.L_CORE X_NUC_68.L_CORE 0.006356
K_3821 X_NUC_55.L_CORE X_NUC_69.L_CORE 0.003168
K_3822 X_NUC_55.L_CORE X_NUC_70.L_CORE 0.003131
K_3823 X_NUC_55.L_CORE X_NUC_71.L_CORE 0.003128
K_3824 X_NUC_55.L_CORE X_NUC_72.L_CORE 0.003156
K_3825 X_NUC_55.L_CORE X_NUC_73.L_CORE 0.007833
K_3826 X_NUC_55.L_CORE X_NUC_74.L_CORE 0.007766
K_3827 X_NUC_55.L_CORE X_NUC_75.L_CORE 0.007566
K_3828 X_NUC_55.L_CORE X_NUC_76.L_CORE 0.007766
K_3829 X_NUC_55.L_CORE X_NUC_77.L_CORE 0.004161
K_3830 X_NUC_55.L_CORE X_NUC_78.L_CORE 0.004087
K_3831 X_NUC_55.L_CORE X_NUC_79.L_CORE 0.004094
K_3832 X_NUC_55.L_CORE X_NUC_80.L_CORE 0.004104
K_3833 X_NUC_55.L_CORE X_NUC_81.L_CORE 0.004224
K_3834 X_NUC_55.L_CORE X_NUC_82.L_CORE 0.004173
K_3835 X_NUC_55.L_CORE X_NUC_83.L_CORE 0.004143
K_3836 X_NUC_55.L_CORE X_NUC_84.L_CORE 0.004195
K_3837 X_NUC_55.L_CORE X_NUC_85.L_CORE 0.003678
K_3838 X_NUC_55.L_CORE X_NUC_86.L_CORE 0.002691
K_3839 X_NUC_55.L_CORE X_NUC_87.L_CORE 0.003614
K_3840 X_NUC_55.L_CORE X_NUC_88.L_CORE 0.003945
K_3841 X_NUC_55.L_CORE X_NUC_89.L_CORE 0.002564
K_3842 X_NUC_55.L_CORE X_NUC_90.L_CORE 0.008064
K_3843 X_NUC_55.L_CORE X_NUC_91.L_CORE 0.002932
K_3844 X_NUC_55.L_CORE X_NUC_92.L_CORE 0.003221
K_3845 X_NUC_55.L_CORE X_NUC_93.L_CORE 0.008717
K_3846 X_NUC_55.L_CORE X_NUC_94.L_CORE 0.002670
K_3847 X_NUC_55.L_CORE X_NUC_95.L_CORE 0.006003
K_3848 X_NUC_55.L_CORE X_NUC_96.L_CORE 0.004077
K_3849 X_NUC_55.L_CORE X_NUC_97.L_CORE 0.003244
K_3850 X_NUC_55.L_CORE X_NUC_98.L_CORE 0.005768
K_3851 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.003116
K_3852 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.003071
K_3853 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.003086
K_3854 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.003096
K_3855 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.004304
K_3856 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.004285
K_3857 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.004243
K_3858 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.004328
K_3859 X_NUC_56.L_CORE X_NUC_65.L_CORE 0.006602
K_3860 X_NUC_56.L_CORE X_NUC_66.L_CORE 0.006422
K_3861 X_NUC_56.L_CORE X_NUC_67.L_CORE 0.006498
K_3862 X_NUC_56.L_CORE X_NUC_68.L_CORE 0.006429
K_3863 X_NUC_56.L_CORE X_NUC_69.L_CORE 0.003140
K_3864 X_NUC_56.L_CORE X_NUC_70.L_CORE 0.003103
K_3865 X_NUC_56.L_CORE X_NUC_71.L_CORE 0.003101
K_3866 X_NUC_56.L_CORE X_NUC_72.L_CORE 0.003128
K_3867 X_NUC_56.L_CORE X_NUC_73.L_CORE 0.007623
K_3868 X_NUC_56.L_CORE X_NUC_74.L_CORE 0.007561
K_3869 X_NUC_56.L_CORE X_NUC_75.L_CORE 0.007372
K_3870 X_NUC_56.L_CORE X_NUC_76.L_CORE 0.007566
K_3871 X_NUC_56.L_CORE X_NUC_77.L_CORE 0.004150
K_3872 X_NUC_56.L_CORE X_NUC_78.L_CORE 0.004077
K_3873 X_NUC_56.L_CORE X_NUC_79.L_CORE 0.004083
K_3874 X_NUC_56.L_CORE X_NUC_80.L_CORE 0.004094
K_3875 X_NUC_56.L_CORE X_NUC_81.L_CORE 0.004171
K_3876 X_NUC_56.L_CORE X_NUC_82.L_CORE 0.004122
K_3877 X_NUC_56.L_CORE X_NUC_83.L_CORE 0.004092
K_3878 X_NUC_56.L_CORE X_NUC_84.L_CORE 0.004143
K_3879 X_NUC_56.L_CORE X_NUC_85.L_CORE 0.003668
K_3880 X_NUC_56.L_CORE X_NUC_86.L_CORE 0.002682
K_3881 X_NUC_56.L_CORE X_NUC_87.L_CORE 0.003569
K_3882 X_NUC_56.L_CORE X_NUC_88.L_CORE 0.003972
K_3883 X_NUC_56.L_CORE X_NUC_89.L_CORE 0.002543
K_3884 X_NUC_56.L_CORE X_NUC_90.L_CORE 0.007942
K_3885 X_NUC_56.L_CORE X_NUC_91.L_CORE 0.002933
K_3886 X_NUC_56.L_CORE X_NUC_92.L_CORE 0.003174
K_3887 X_NUC_56.L_CORE X_NUC_93.L_CORE 0.009036
K_3888 X_NUC_56.L_CORE X_NUC_94.L_CORE 0.002655
K_3889 X_NUC_56.L_CORE X_NUC_95.L_CORE 0.005845
K_3890 X_NUC_56.L_CORE X_NUC_96.L_CORE 0.004094
K_3891 X_NUC_56.L_CORE X_NUC_97.L_CORE 0.003208
K_3892 X_NUC_56.L_CORE X_NUC_98.L_CORE 0.005720
K_3893 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.207973
K_3894 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.207973
K_3895 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.207973
K_3896 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.003231
K_3897 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.003275
K_3898 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.003238
K_3899 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.003264
K_3900 X_NUC_57.L_CORE X_NUC_65.L_CORE 0.004547
K_3901 X_NUC_57.L_CORE X_NUC_66.L_CORE 0.004630
K_3902 X_NUC_57.L_CORE X_NUC_67.L_CORE 0.004604
K_3903 X_NUC_57.L_CORE X_NUC_68.L_CORE 0.004548
K_3904 X_NUC_57.L_CORE X_NUC_69.L_CORE 0.006732
K_3905 X_NUC_57.L_CORE X_NUC_70.L_CORE 0.006828
K_3906 X_NUC_57.L_CORE X_NUC_71.L_CORE 0.006635
K_3907 X_NUC_57.L_CORE X_NUC_72.L_CORE 0.006813
K_3908 X_NUC_57.L_CORE X_NUC_73.L_CORE 0.003375
K_3909 X_NUC_57.L_CORE X_NUC_74.L_CORE 0.003429
K_3910 X_NUC_57.L_CORE X_NUC_75.L_CORE 0.003390
K_3911 X_NUC_57.L_CORE X_NUC_76.L_CORE 0.003395
K_3912 X_NUC_57.L_CORE X_NUC_77.L_CORE 0.007383
K_3913 X_NUC_57.L_CORE X_NUC_78.L_CORE 0.007574
K_3914 X_NUC_57.L_CORE X_NUC_79.L_CORE 0.007386
K_3915 X_NUC_57.L_CORE X_NUC_80.L_CORE 0.007320
K_3916 X_NUC_57.L_CORE X_NUC_81.L_CORE 0.004565
K_3917 X_NUC_57.L_CORE X_NUC_82.L_CORE 0.004645
K_3918 X_NUC_57.L_CORE X_NUC_83.L_CORE 0.004550
K_3919 X_NUC_57.L_CORE X_NUC_84.L_CORE 0.004589
K_3920 X_NUC_57.L_CORE X_NUC_85.L_CORE 0.002873
K_3921 X_NUC_57.L_CORE X_NUC_86.L_CORE 0.004141
K_3922 X_NUC_57.L_CORE X_NUC_87.L_CORE 0.002624
K_3923 X_NUC_57.L_CORE X_NUC_88.L_CORE 0.003662
K_3924 X_NUC_57.L_CORE X_NUC_89.L_CORE 0.004053
K_3925 X_NUC_57.L_CORE X_NUC_90.L_CORE 0.002584
K_3926 X_NUC_57.L_CORE X_NUC_91.L_CORE 0.008632
K_3927 X_NUC_57.L_CORE X_NUC_92.L_CORE 0.003018
K_3928 X_NUC_57.L_CORE X_NUC_93.L_CORE 0.003325
K_3929 X_NUC_57.L_CORE X_NUC_94.L_CORE 0.009241
K_3930 X_NUC_57.L_CORE X_NUC_95.L_CORE 0.002825
K_3931 X_NUC_57.L_CORE X_NUC_96.L_CORE 0.006169
K_3932 X_NUC_57.L_CORE X_NUC_97.L_CORE 0.004389
K_3933 X_NUC_57.L_CORE X_NUC_98.L_CORE 0.003750
K_3934 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.207973
K_3935 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.207973
K_3936 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.003188
K_3937 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.003231
K_3938 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.003195
K_3939 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.003220
K_3940 X_NUC_58.L_CORE X_NUC_65.L_CORE 0.004467
K_3941 X_NUC_58.L_CORE X_NUC_66.L_CORE 0.004547
K_3942 X_NUC_58.L_CORE X_NUC_67.L_CORE 0.004522
K_3943 X_NUC_58.L_CORE X_NUC_68.L_CORE 0.004469
K_3944 X_NUC_58.L_CORE X_NUC_69.L_CORE 0.006633
K_3945 X_NUC_58.L_CORE X_NUC_70.L_CORE 0.006732
K_3946 X_NUC_58.L_CORE X_NUC_71.L_CORE 0.006544
K_3947 X_NUC_58.L_CORE X_NUC_72.L_CORE 0.006714
K_3948 X_NUC_58.L_CORE X_NUC_73.L_CORE 0.003323
K_3949 X_NUC_58.L_CORE X_NUC_74.L_CORE 0.003375
K_3950 X_NUC_58.L_CORE X_NUC_75.L_CORE 0.003337
K_3951 X_NUC_58.L_CORE X_NUC_76.L_CORE 0.003343
K_3952 X_NUC_58.L_CORE X_NUC_77.L_CORE 0.007197
K_3953 X_NUC_58.L_CORE X_NUC_78.L_CORE 0.007383
K_3954 X_NUC_58.L_CORE X_NUC_79.L_CORE 0.007204
K_3955 X_NUC_58.L_CORE X_NUC_80.L_CORE 0.007143
K_3956 X_NUC_58.L_CORE X_NUC_81.L_CORE 0.004487
K_3957 X_NUC_58.L_CORE X_NUC_82.L_CORE 0.004565
K_3958 X_NUC_58.L_CORE X_NUC_83.L_CORE 0.004474
K_3959 X_NUC_58.L_CORE X_NUC_84.L_CORE 0.004511
K_3960 X_NUC_58.L_CORE X_NUC_85.L_CORE 0.002848
K_3961 X_NUC_58.L_CORE X_NUC_86.L_CORE 0.004129
K_3962 X_NUC_58.L_CORE X_NUC_87.L_CORE 0.002599
K_3963 X_NUC_58.L_CORE X_NUC_88.L_CORE 0.003629
K_3964 X_NUC_58.L_CORE X_NUC_89.L_CORE 0.004037
K_3965 X_NUC_58.L_CORE X_NUC_90.L_CORE 0.002554
K_3966 X_NUC_58.L_CORE X_NUC_91.L_CORE 0.008688
K_3967 X_NUC_58.L_CORE X_NUC_92.L_CORE 0.002988
K_3968 X_NUC_58.L_CORE X_NUC_93.L_CORE 0.003280
K_3969 X_NUC_58.L_CORE X_NUC_94.L_CORE 0.009309
K_3970 X_NUC_58.L_CORE X_NUC_95.L_CORE 0.002788
K_3971 X_NUC_58.L_CORE X_NUC_96.L_CORE 0.006068
K_3972 X_NUC_58.L_CORE X_NUC_97.L_CORE 0.004336
K_3973 X_NUC_58.L_CORE X_NUC_98.L_CORE 0.003692
K_3974 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.207973
K_3975 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.003224
K_3976 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.003268
K_3977 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.003231
K_3978 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.003257
K_3979 X_NUC_59.L_CORE X_NUC_65.L_CORE 0.004490
K_3980 X_NUC_59.L_CORE X_NUC_66.L_CORE 0.004571
K_3981 X_NUC_59.L_CORE X_NUC_67.L_CORE 0.004547
K_3982 X_NUC_59.L_CORE X_NUC_68.L_CORE 0.004493
K_3983 X_NUC_59.L_CORE X_NUC_69.L_CORE 0.006825
K_3984 X_NUC_59.L_CORE X_NUC_70.L_CORE 0.006929
K_3985 X_NUC_59.L_CORE X_NUC_71.L_CORE 0.006732
K_3986 X_NUC_59.L_CORE X_NUC_72.L_CORE 0.006914
K_3987 X_NUC_59.L_CORE X_NUC_73.L_CORE 0.003360
K_3988 X_NUC_59.L_CORE X_NUC_74.L_CORE 0.003414
K_3989 X_NUC_59.L_CORE X_NUC_75.L_CORE 0.003375
K_3990 X_NUC_59.L_CORE X_NUC_76.L_CORE 0.003380
K_3991 X_NUC_59.L_CORE X_NUC_77.L_CORE 0.007370
K_3992 X_NUC_59.L_CORE X_NUC_78.L_CORE 0.007565
K_3993 X_NUC_59.L_CORE X_NUC_79.L_CORE 0.007383
K_3994 X_NUC_59.L_CORE X_NUC_80.L_CORE 0.007312
K_3995 X_NUC_59.L_CORE X_NUC_81.L_CORE 0.004578
K_3996 X_NUC_59.L_CORE X_NUC_82.L_CORE 0.004660
K_3997 X_NUC_59.L_CORE X_NUC_83.L_CORE 0.004565
K_3998 X_NUC_59.L_CORE X_NUC_84.L_CORE 0.004604
K_3999 X_NUC_59.L_CORE X_NUC_85.L_CORE 0.002838
K_4000 X_NUC_59.L_CORE X_NUC_86.L_CORE 0.004084
K_4001 X_NUC_59.L_CORE X_NUC_87.L_CORE 0.002605
K_4002 X_NUC_59.L_CORE X_NUC_88.L_CORE 0.003599
K_4003 X_NUC_59.L_CORE X_NUC_89.L_CORE 0.004043
K_4004 X_NUC_59.L_CORE X_NUC_90.L_CORE 0.002561
K_4005 X_NUC_59.L_CORE X_NUC_91.L_CORE 0.008366
K_4006 X_NUC_59.L_CORE X_NUC_92.L_CORE 0.003013
K_4007 X_NUC_59.L_CORE X_NUC_93.L_CORE 0.003286
K_4008 X_NUC_59.L_CORE X_NUC_94.L_CORE 0.009504
K_4009 X_NUC_59.L_CORE X_NUC_95.L_CORE 0.002814
K_4010 X_NUC_59.L_CORE X_NUC_96.L_CORE 0.006107
K_4011 X_NUC_59.L_CORE X_NUC_97.L_CORE 0.004423
K_4012 X_NUC_59.L_CORE X_NUC_98.L_CORE 0.003742
K_4013 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.003199
K_4014 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.003242
K_4015 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.003206
K_4016 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.003231
K_4017 X_NUC_60.L_CORE X_NUC_65.L_CORE 0.004544
K_4018 X_NUC_60.L_CORE X_NUC_66.L_CORE 0.004628
K_4019 X_NUC_60.L_CORE X_NUC_67.L_CORE 0.004602
K_4020 X_NUC_60.L_CORE X_NUC_68.L_CORE 0.004547
K_4021 X_NUC_60.L_CORE X_NUC_69.L_CORE 0.006646
K_4022 X_NUC_60.L_CORE X_NUC_70.L_CORE 0.006742
K_4023 X_NUC_60.L_CORE X_NUC_71.L_CORE 0.006556
K_4024 X_NUC_60.L_CORE X_NUC_72.L_CORE 0.006732
K_4025 X_NUC_60.L_CORE X_NUC_73.L_CORE 0.003355
K_4026 X_NUC_60.L_CORE X_NUC_74.L_CORE 0.003408
K_4027 X_NUC_60.L_CORE X_NUC_75.L_CORE 0.003370
K_4028 X_NUC_60.L_CORE X_NUC_76.L_CORE 0.003375
K_4029 X_NUC_60.L_CORE X_NUC_77.L_CORE 0.007438
K_4030 X_NUC_60.L_CORE X_NUC_78.L_CORE 0.007638
K_4031 X_NUC_60.L_CORE X_NUC_79.L_CORE 0.007446
K_4032 X_NUC_60.L_CORE X_NUC_80.L_CORE 0.007383
K_4033 X_NUC_60.L_CORE X_NUC_81.L_CORE 0.004539
K_4034 X_NUC_60.L_CORE X_NUC_82.L_CORE 0.004619
K_4035 X_NUC_60.L_CORE X_NUC_83.L_CORE 0.004526
K_4036 X_NUC_60.L_CORE X_NUC_84.L_CORE 0.004565
K_4037 X_NUC_60.L_CORE X_NUC_85.L_CORE 0.002840
K_4038 X_NUC_60.L_CORE X_NUC_86.L_CORE 0.004073
K_4039 X_NUC_60.L_CORE X_NUC_87.L_CORE 0.002594
K_4040 X_NUC_60.L_CORE X_NUC_88.L_CORE 0.003634
K_4041 X_NUC_60.L_CORE X_NUC_89.L_CORE 0.003983
K_4042 X_NUC_60.L_CORE X_NUC_90.L_CORE 0.002563
K_4043 X_NUC_60.L_CORE X_NUC_91.L_CORE 0.008593
K_4044 X_NUC_60.L_CORE X_NUC_92.L_CORE 0.002983
K_4045 X_NUC_60.L_CORE X_NUC_93.L_CORE 0.003313
K_4046 X_NUC_60.L_CORE X_NUC_94.L_CORE 0.009095
K_4047 X_NUC_60.L_CORE X_NUC_95.L_CORE 0.002804
K_4048 X_NUC_60.L_CORE X_NUC_96.L_CORE 0.006238
K_4049 X_NUC_60.L_CORE X_NUC_97.L_CORE 0.004359
K_4050 X_NUC_60.L_CORE X_NUC_98.L_CORE 0.003745
K_4051 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.207973
K_4052 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.207973
K_4053 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.207973
K_4054 X_NUC_61.L_CORE X_NUC_65.L_CORE 0.003428
K_4055 X_NUC_61.L_CORE X_NUC_66.L_CORE 0.003411
K_4056 X_NUC_61.L_CORE X_NUC_67.L_CORE 0.003444
K_4057 X_NUC_61.L_CORE X_NUC_68.L_CORE 0.003390
K_4058 X_NUC_61.L_CORE X_NUC_69.L_CORE 0.004866
K_4059 X_NUC_61.L_CORE X_NUC_70.L_CORE 0.004758
K_4060 X_NUC_61.L_CORE X_NUC_71.L_CORE 0.004807
K_4061 X_NUC_61.L_CORE X_NUC_72.L_CORE 0.004788
K_4062 X_NUC_61.L_CORE X_NUC_73.L_CORE 0.007137
K_4063 X_NUC_61.L_CORE X_NUC_74.L_CORE 0.007169
K_4064 X_NUC_61.L_CORE X_NUC_75.L_CORE 0.007199
K_4065 X_NUC_61.L_CORE X_NUC_76.L_CORE 0.006979
K_4066 X_NUC_61.L_CORE X_NUC_77.L_CORE 0.003777
K_4067 X_NUC_61.L_CORE X_NUC_78.L_CORE 0.003733
K_4068 X_NUC_61.L_CORE X_NUC_79.L_CORE 0.003767
K_4069 X_NUC_61.L_CORE X_NUC_80.L_CORE 0.003718
K_4070 X_NUC_61.L_CORE X_NUC_81.L_CORE 0.006799
K_4071 X_NUC_61.L_CORE X_NUC_82.L_CORE 0.006659
K_4072 X_NUC_61.L_CORE X_NUC_83.L_CORE 0.006689
K_4073 X_NUC_61.L_CORE X_NUC_84.L_CORE 0.006587
K_4074 X_NUC_61.L_CORE X_NUC_85.L_CORE 0.002922
K_4075 X_NUC_61.L_CORE X_NUC_86.L_CORE 0.002731
K_4076 X_NUC_61.L_CORE X_NUC_87.L_CORE 0.004423
K_4077 X_NUC_61.L_CORE X_NUC_88.L_CORE 0.002579
K_4078 X_NUC_61.L_CORE X_NUC_89.L_CORE 0.003670
K_4079 X_NUC_61.L_CORE X_NUC_90.L_CORE 0.004148
K_4080 X_NUC_61.L_CORE X_NUC_91.L_CORE 0.002605
K_4081 X_NUC_61.L_CORE X_NUC_92.L_CORE 0.009106
K_4082 X_NUC_61.L_CORE X_NUC_93.L_CORE 0.003119
K_4083 X_NUC_61.L_CORE X_NUC_94.L_CORE 0.003441
K_4084 X_NUC_61.L_CORE X_NUC_95.L_CORE 0.009975
K_4085 X_NUC_61.L_CORE X_NUC_96.L_CORE 0.003031
K_4086 X_NUC_61.L_CORE X_NUC_97.L_CORE 0.006313
K_4087 X_NUC_61.L_CORE X_NUC_98.L_CORE 0.004812
K_4088 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.207973
K_4089 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.207973
K_4090 X_NUC_62.L_CORE X_NUC_65.L_CORE 0.003444
K_4091 X_NUC_62.L_CORE X_NUC_66.L_CORE 0.003428
K_4092 X_NUC_62.L_CORE X_NUC_67.L_CORE 0.003461
K_4093 X_NUC_62.L_CORE X_NUC_68.L_CORE 0.003407
K_4094 X_NUC_62.L_CORE X_NUC_69.L_CORE 0.004979
K_4095 X_NUC_62.L_CORE X_NUC_70.L_CORE 0.004866
K_4096 X_NUC_62.L_CORE X_NUC_71.L_CORE 0.004917
K_4097 X_NUC_62.L_CORE X_NUC_72.L_CORE 0.004897
K_4098 X_NUC_62.L_CORE X_NUC_73.L_CORE 0.007098
K_4099 X_NUC_62.L_CORE X_NUC_74.L_CORE 0.007137
K_4100 X_NUC_62.L_CORE X_NUC_75.L_CORE 0.007162
K_4101 X_NUC_62.L_CORE X_NUC_76.L_CORE 0.006946
K_4102 X_NUC_62.L_CORE X_NUC_77.L_CORE 0.003821
K_4103 X_NUC_62.L_CORE X_NUC_78.L_CORE 0.003777
K_4104 X_NUC_62.L_CORE X_NUC_79.L_CORE 0.003811
K_4105 X_NUC_62.L_CORE X_NUC_80.L_CORE 0.003761
K_4106 X_NUC_62.L_CORE X_NUC_81.L_CORE 0.006941
K_4107 X_NUC_62.L_CORE X_NUC_82.L_CORE 0.006799
K_4108 X_NUC_62.L_CORE X_NUC_83.L_CORE 0.006828
K_4109 X_NUC_62.L_CORE X_NUC_84.L_CORE 0.006720
K_4110 X_NUC_62.L_CORE X_NUC_85.L_CORE 0.002927
K_4111 X_NUC_62.L_CORE X_NUC_86.L_CORE 0.002754
K_4112 X_NUC_62.L_CORE X_NUC_87.L_CORE 0.004411
K_4113 X_NUC_62.L_CORE X_NUC_88.L_CORE 0.002589
K_4114 X_NUC_62.L_CORE X_NUC_89.L_CORE 0.003722
K_4115 X_NUC_62.L_CORE X_NUC_90.L_CORE 0.004112
K_4116 X_NUC_62.L_CORE X_NUC_91.L_CORE 0.002630
K_4117 X_NUC_62.L_CORE X_NUC_92.L_CORE 0.009232
K_4118 X_NUC_62.L_CORE X_NUC_93.L_CORE 0.003121
K_4119 X_NUC_62.L_CORE X_NUC_94.L_CORE 0.003498
K_4120 X_NUC_62.L_CORE X_NUC_95.L_CORE 0.009631
K_4121 X_NUC_62.L_CORE X_NUC_96.L_CORE 0.003054
K_4122 X_NUC_62.L_CORE X_NUC_97.L_CORE 0.006480
K_4123 X_NUC_62.L_CORE X_NUC_98.L_CORE 0.004829
K_4124 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.207973
K_4125 X_NUC_63.L_CORE X_NUC_65.L_CORE 0.003411
K_4126 X_NUC_63.L_CORE X_NUC_66.L_CORE 0.003395
K_4127 X_NUC_63.L_CORE X_NUC_67.L_CORE 0.003428
K_4128 X_NUC_63.L_CORE X_NUC_68.L_CORE 0.003375
K_4129 X_NUC_63.L_CORE X_NUC_69.L_CORE 0.004925
K_4130 X_NUC_63.L_CORE X_NUC_70.L_CORE 0.004814
K_4131 X_NUC_63.L_CORE X_NUC_71.L_CORE 0.004866
K_4132 X_NUC_63.L_CORE X_NUC_72.L_CORE 0.004845
K_4133 X_NUC_63.L_CORE X_NUC_73.L_CORE 0.007069
K_4134 X_NUC_63.L_CORE X_NUC_74.L_CORE 0.007104
K_4135 X_NUC_63.L_CORE X_NUC_75.L_CORE 0.007137
K_4136 X_NUC_63.L_CORE X_NUC_76.L_CORE 0.006919
K_4137 X_NUC_63.L_CORE X_NUC_77.L_CORE 0.003786
K_4138 X_NUC_63.L_CORE X_NUC_78.L_CORE 0.003743
K_4139 X_NUC_63.L_CORE X_NUC_79.L_CORE 0.003777
K_4140 X_NUC_63.L_CORE X_NUC_80.L_CORE 0.003728
K_4141 X_NUC_63.L_CORE X_NUC_81.L_CORE 0.006908
K_4142 X_NUC_63.L_CORE X_NUC_82.L_CORE 0.006764
K_4143 X_NUC_63.L_CORE X_NUC_83.L_CORE 0.006799
K_4144 X_NUC_63.L_CORE X_NUC_84.L_CORE 0.006689
K_4145 X_NUC_63.L_CORE X_NUC_85.L_CORE 0.002890
K_4146 X_NUC_63.L_CORE X_NUC_86.L_CORE 0.002718
K_4147 X_NUC_63.L_CORE X_NUC_87.L_CORE 0.004348
K_4148 X_NUC_63.L_CORE X_NUC_88.L_CORE 0.002560
K_4149 X_NUC_63.L_CORE X_NUC_89.L_CORE 0.003672
K_4150 X_NUC_63.L_CORE X_NUC_90.L_CORE 0.004070
K_4151 X_NUC_63.L_CORE X_NUC_91.L_CORE 0.002601
K_4152 X_NUC_63.L_CORE X_NUC_92.L_CORE 0.009120
K_4153 X_NUC_63.L_CORE X_NUC_93.L_CORE 0.003093
K_4154 X_NUC_63.L_CORE X_NUC_94.L_CORE 0.003462
K_4155 X_NUC_63.L_CORE X_NUC_95.L_CORE 0.009716
K_4156 X_NUC_63.L_CORE X_NUC_96.L_CORE 0.003029
K_4157 X_NUC_63.L_CORE X_NUC_97.L_CORE 0.006468
K_4158 X_NUC_63.L_CORE X_NUC_98.L_CORE 0.004817
K_4159 X_NUC_64.L_CORE X_NUC_65.L_CORE 0.003466
K_4160 X_NUC_64.L_CORE X_NUC_66.L_CORE 0.003449
K_4161 X_NUC_64.L_CORE X_NUC_67.L_CORE 0.003483
K_4162 X_NUC_64.L_CORE X_NUC_68.L_CORE 0.003428
K_4163 X_NUC_64.L_CORE X_NUC_69.L_CORE 0.004945
K_4164 X_NUC_64.L_CORE X_NUC_70.L_CORE 0.004833
K_4165 X_NUC_64.L_CORE X_NUC_71.L_CORE 0.004884
K_4166 X_NUC_64.L_CORE X_NUC_72.L_CORE 0.004866
K_4167 X_NUC_64.L_CORE X_NUC_73.L_CORE 0.007297
K_4168 X_NUC_64.L_CORE X_NUC_74.L_CORE 0.007336
K_4169 X_NUC_64.L_CORE X_NUC_75.L_CORE 0.007368
K_4170 X_NUC_64.L_CORE X_NUC_76.L_CORE 0.007137
K_4171 X_NUC_64.L_CORE X_NUC_77.L_CORE 0.003837
K_4172 X_NUC_64.L_CORE X_NUC_78.L_CORE 0.003792
K_4173 X_NUC_64.L_CORE X_NUC_79.L_CORE 0.003827
K_4174 X_NUC_64.L_CORE X_NUC_80.L_CORE 0.003777
K_4175 X_NUC_64.L_CORE X_NUC_81.L_CORE 0.007025
K_4176 X_NUC_64.L_CORE X_NUC_82.L_CORE 0.006874
K_4177 X_NUC_64.L_CORE X_NUC_83.L_CORE 0.006907
K_4178 X_NUC_64.L_CORE X_NUC_84.L_CORE 0.006799
K_4179 X_NUC_64.L_CORE X_NUC_85.L_CORE 0.002912
K_4180 X_NUC_64.L_CORE X_NUC_86.L_CORE 0.002730
K_4181 X_NUC_64.L_CORE X_NUC_87.L_CORE 0.004357
K_4182 X_NUC_64.L_CORE X_NUC_88.L_CORE 0.002586
K_4183 X_NUC_64.L_CORE X_NUC_89.L_CORE 0.003664
K_4184 X_NUC_64.L_CORE X_NUC_90.L_CORE 0.004127
K_4185 X_NUC_64.L_CORE X_NUC_91.L_CORE 0.002621
K_4186 X_NUC_64.L_CORE X_NUC_92.L_CORE 0.008855
K_4187 X_NUC_64.L_CORE X_NUC_93.L_CORE 0.003139
K_4188 X_NUC_64.L_CORE X_NUC_94.L_CORE 0.003473
K_4189 X_NUC_64.L_CORE X_NUC_95.L_CORE 0.010015
K_4190 X_NUC_64.L_CORE X_NUC_96.L_CORE 0.003066
K_4191 X_NUC_64.L_CORE X_NUC_97.L_CORE 0.006468
K_4192 X_NUC_64.L_CORE X_NUC_98.L_CORE 0.004912
K_4193 X_NUC_65.L_CORE X_NUC_66.L_CORE 0.207973
K_4194 X_NUC_65.L_CORE X_NUC_67.L_CORE 0.207973
K_4195 X_NUC_65.L_CORE X_NUC_68.L_CORE 0.207973
K_4196 X_NUC_65.L_CORE X_NUC_69.L_CORE 0.003720
K_4197 X_NUC_65.L_CORE X_NUC_70.L_CORE 0.003691
K_4198 X_NUC_65.L_CORE X_NUC_71.L_CORE 0.003673
K_4199 X_NUC_65.L_CORE X_NUC_72.L_CORE 0.003732
K_4200 X_NUC_65.L_CORE X_NUC_73.L_CORE 0.005345
K_4201 X_NUC_65.L_CORE X_NUC_74.L_CORE 0.005423
K_4202 X_NUC_65.L_CORE X_NUC_75.L_CORE 0.005310
K_4203 X_NUC_65.L_CORE X_NUC_76.L_CORE 0.005421
K_4204 X_NUC_65.L_CORE X_NUC_77.L_CORE 0.007650
K_4205 X_NUC_65.L_CORE X_NUC_78.L_CORE 0.007473
K_4206 X_NUC_65.L_CORE X_NUC_79.L_CORE 0.007396
K_4207 X_NUC_65.L_CORE X_NUC_80.L_CORE 0.007570
K_4208 X_NUC_65.L_CORE X_NUC_81.L_CORE 0.004592
K_4209 X_NUC_65.L_CORE X_NUC_82.L_CORE 0.004587
K_4210 X_NUC_65.L_CORE X_NUC_83.L_CORE 0.004520
K_4211 X_NUC_65.L_CORE X_NUC_84.L_CORE 0.004614
K_4212 X_NUC_65.L_CORE X_NUC_85.L_CORE 0.003132
K_4213 X_NUC_65.L_CORE X_NUC_86.L_CORE 0.002887
K_4214 X_NUC_65.L_CORE X_NUC_87.L_CORE 0.002714
K_4215 X_NUC_65.L_CORE X_NUC_88.L_CORE 0.004612
K_4216 X_NUC_65.L_CORE X_NUC_89.L_CORE 0.002599
K_4217 X_NUC_65.L_CORE X_NUC_90.L_CORE 0.003806
K_4218 X_NUC_65.L_CORE X_NUC_91.L_CORE 0.004220
K_4219 X_NUC_65.L_CORE X_NUC_92.L_CORE 0.002716
K_4220 X_NUC_65.L_CORE X_NUC_93.L_CORE 0.009902
K_4221 X_NUC_65.L_CORE X_NUC_94.L_CORE 0.003291
K_4222 X_NUC_65.L_CORE X_NUC_95.L_CORE 0.003753
K_4223 X_NUC_65.L_CORE X_NUC_96.L_CORE 0.010238
K_4224 X_NUC_65.L_CORE X_NUC_97.L_CORE 0.003446
K_4225 X_NUC_65.L_CORE X_NUC_98.L_CORE 0.006539
K_4226 X_NUC_66.L_CORE X_NUC_67.L_CORE 0.207973
K_4227 X_NUC_66.L_CORE X_NUC_68.L_CORE 0.207973
K_4228 X_NUC_66.L_CORE X_NUC_69.L_CORE 0.003747
K_4229 X_NUC_66.L_CORE X_NUC_70.L_CORE 0.003720
K_4230 X_NUC_66.L_CORE X_NUC_71.L_CORE 0.003700
K_4231 X_NUC_66.L_CORE X_NUC_72.L_CORE 0.003761
K_4232 X_NUC_66.L_CORE X_NUC_73.L_CORE 0.005267
K_4233 X_NUC_66.L_CORE X_NUC_74.L_CORE 0.005345
K_4234 X_NUC_66.L_CORE X_NUC_75.L_CORE 0.005235
K_4235 X_NUC_66.L_CORE X_NUC_76.L_CORE 0.005342
K_4236 X_NUC_66.L_CORE X_NUC_77.L_CORE 0.007829
K_4237 X_NUC_66.L_CORE X_NUC_78.L_CORE 0.007650
K_4238 X_NUC_66.L_CORE X_NUC_79.L_CORE 0.007562
K_4239 X_NUC_66.L_CORE X_NUC_80.L_CORE 0.007749
K_4240 X_NUC_66.L_CORE X_NUC_81.L_CORE 0.004594
K_4241 X_NUC_66.L_CORE X_NUC_82.L_CORE 0.004592
K_4242 X_NUC_66.L_CORE X_NUC_83.L_CORE 0.004523
K_4243 X_NUC_66.L_CORE X_NUC_84.L_CORE 0.004618
K_4244 X_NUC_66.L_CORE X_NUC_85.L_CORE 0.003126
K_4245 X_NUC_66.L_CORE X_NUC_86.L_CORE 0.002903
K_4246 X_NUC_66.L_CORE X_NUC_87.L_CORE 0.002703
K_4247 X_NUC_66.L_CORE X_NUC_88.L_CORE 0.004630
K_4248 X_NUC_66.L_CORE X_NUC_89.L_CORE 0.002610
K_4249 X_NUC_66.L_CORE X_NUC_90.L_CORE 0.003756
K_4250 X_NUC_66.L_CORE X_NUC_91.L_CORE 0.004293
K_4251 X_NUC_66.L_CORE X_NUC_92.L_CORE 0.002711
K_4252 X_NUC_66.L_CORE X_NUC_93.L_CORE 0.009568
K_4253 X_NUC_66.L_CORE X_NUC_94.L_CORE 0.003325
K_4254 X_NUC_66.L_CORE X_NUC_95.L_CORE 0.003713
K_4255 X_NUC_66.L_CORE X_NUC_96.L_CORE 0.010729
K_4256 X_NUC_66.L_CORE X_NUC_97.L_CORE 0.003456
K_4257 X_NUC_66.L_CORE X_NUC_98.L_CORE 0.006468
K_4258 X_NUC_67.L_CORE X_NUC_68.L_CORE 0.207973
K_4259 X_NUC_67.L_CORE X_NUC_69.L_CORE 0.003767
K_4260 X_NUC_67.L_CORE X_NUC_70.L_CORE 0.003738
K_4261 X_NUC_67.L_CORE X_NUC_71.L_CORE 0.003720
K_4262 X_NUC_67.L_CORE X_NUC_72.L_CORE 0.003781
K_4263 X_NUC_67.L_CORE X_NUC_73.L_CORE 0.005378
K_4264 X_NUC_67.L_CORE X_NUC_74.L_CORE 0.005459
K_4265 X_NUC_67.L_CORE X_NUC_75.L_CORE 0.005345
K_4266 X_NUC_67.L_CORE X_NUC_76.L_CORE 0.005457
K_4267 X_NUC_67.L_CORE X_NUC_77.L_CORE 0.007920
K_4268 X_NUC_67.L_CORE X_NUC_78.L_CORE 0.007730
K_4269 X_NUC_67.L_CORE X_NUC_79.L_CORE 0.007650
K_4270 X_NUC_67.L_CORE X_NUC_80.L_CORE 0.007837
K_4271 X_NUC_67.L_CORE X_NUC_81.L_CORE 0.004665
K_4272 X_NUC_67.L_CORE X_NUC_82.L_CORE 0.004661
K_4273 X_NUC_67.L_CORE X_NUC_83.L_CORE 0.004592
K_4274 X_NUC_67.L_CORE X_NUC_84.L_CORE 0.004690
K_4275 X_NUC_67.L_CORE X_NUC_85.L_CORE 0.003104
K_4276 X_NUC_67.L_CORE X_NUC_86.L_CORE 0.002882
K_4277 X_NUC_67.L_CORE X_NUC_87.L_CORE 0.002704
K_4278 X_NUC_67.L_CORE X_NUC_88.L_CORE 0.004544
K_4279 X_NUC_67.L_CORE X_NUC_89.L_CORE 0.002607
K_4280 X_NUC_67.L_CORE X_NUC_90.L_CORE 0.003766
K_4281 X_NUC_67.L_CORE X_NUC_91.L_CORE 0.004233
K_4282 X_NUC_67.L_CORE X_NUC_92.L_CORE 0.002724
K_4283 X_NUC_67.L_CORE X_NUC_93.L_CORE 0.009469
K_4284 X_NUC_67.L_CORE X_NUC_94.L_CORE 0.003324
K_4285 X_NUC_67.L_CORE X_NUC_95.L_CORE 0.003760
K_4286 X_NUC_67.L_CORE X_NUC_96.L_CORE 0.010619
K_4287 X_NUC_67.L_CORE X_NUC_97.L_CORE 0.003488
K_4288 X_NUC_67.L_CORE X_NUC_98.L_CORE 0.006668
K_4289 X_NUC_68.L_CORE X_NUC_69.L_CORE 0.003706
K_4290 X_NUC_68.L_CORE X_NUC_70.L_CORE 0.003679
K_4291 X_NUC_68.L_CORE X_NUC_71.L_CORE 0.003660
K_4292 X_NUC_68.L_CORE X_NUC_72.L_CORE 0.003720
K_4293 X_NUC_68.L_CORE X_NUC_73.L_CORE 0.005269
K_4294 X_NUC_68.L_CORE X_NUC_74.L_CORE 0.005346
K_4295 X_NUC_68.L_CORE X_NUC_75.L_CORE 0.005237
K_4296 X_NUC_68.L_CORE X_NUC_76.L_CORE 0.005345
K_4297 X_NUC_68.L_CORE X_NUC_77.L_CORE 0.007721
K_4298 X_NUC_68.L_CORE X_NUC_78.L_CORE 0.007544
K_4299 X_NUC_68.L_CORE X_NUC_79.L_CORE 0.007465
K_4300 X_NUC_68.L_CORE X_NUC_80.L_CORE 0.007650
K_4301 X_NUC_68.L_CORE X_NUC_81.L_CORE 0.004568
K_4302 X_NUC_68.L_CORE X_NUC_82.L_CORE 0.004564
K_4303 X_NUC_68.L_CORE X_NUC_83.L_CORE 0.004498
K_4304 X_NUC_68.L_CORE X_NUC_84.L_CORE 0.004592
K_4305 X_NUC_68.L_CORE X_NUC_85.L_CORE 0.003091
K_4306 X_NUC_68.L_CORE X_NUC_86.L_CORE 0.002864
K_4307 X_NUC_68.L_CORE X_NUC_87.L_CORE 0.002680
K_4308 X_NUC_68.L_CORE X_NUC_88.L_CORE 0.004559
K_4309 X_NUC_68.L_CORE X_NUC_89.L_CORE 0.002580
K_4310 X_NUC_68.L_CORE X_NUC_90.L_CORE 0.003740
K_4311 X_NUC_68.L_CORE X_NUC_91.L_CORE 0.004217
K_4312 X_NUC_68.L_CORE X_NUC_92.L_CORE 0.002691
K_4313 X_NUC_68.L_CORE X_NUC_93.L_CORE 0.009635
K_4314 X_NUC_68.L_CORE X_NUC_94.L_CORE 0.003285
K_4315 X_NUC_68.L_CORE X_NUC_95.L_CORE 0.003707
K_4316 X_NUC_68.L_CORE X_NUC_96.L_CORE 0.010592
K_4317 X_NUC_68.L_CORE X_NUC_97.L_CORE 0.003433
K_4318 X_NUC_68.L_CORE X_NUC_98.L_CORE 0.006520
K_4319 X_NUC_69.L_CORE X_NUC_70.L_CORE 0.207973
K_4320 X_NUC_69.L_CORE X_NUC_71.L_CORE 0.207973
K_4321 X_NUC_69.L_CORE X_NUC_72.L_CORE 0.207973
K_4322 X_NUC_69.L_CORE X_NUC_73.L_CORE 0.004178
K_4323 X_NUC_69.L_CORE X_NUC_74.L_CORE 0.004257
K_4324 X_NUC_69.L_CORE X_NUC_75.L_CORE 0.004229
K_4325 X_NUC_69.L_CORE X_NUC_76.L_CORE 0.004195
K_4326 X_NUC_69.L_CORE X_NUC_77.L_CORE 0.006122
K_4327 X_NUC_69.L_CORE X_NUC_78.L_CORE 0.006154
K_4328 X_NUC_69.L_CORE X_NUC_79.L_CORE 0.006197
K_4329 X_NUC_69.L_CORE X_NUC_80.L_CORE 0.006025
K_4330 X_NUC_69.L_CORE X_NUC_81.L_CORE 0.008080
K_4331 X_NUC_69.L_CORE X_NUC_82.L_CORE 0.008355
K_4332 X_NUC_69.L_CORE X_NUC_83.L_CORE 0.008162
K_4333 X_NUC_69.L_CORE X_NUC_84.L_CORE 0.008067
K_4334 X_NUC_69.L_CORE X_NUC_85.L_CORE 0.002596
K_4335 X_NUC_69.L_CORE X_NUC_86.L_CORE 0.003290
K_4336 X_NUC_69.L_CORE X_NUC_87.L_CORE 0.002920
K_4337 X_NUC_69.L_CORE X_NUC_88.L_CORE 0.002731
K_4338 X_NUC_69.L_CORE X_NUC_89.L_CORE 0.004751
K_4339 X_NUC_69.L_CORE X_NUC_90.L_CORE 0.002686
K_4340 X_NUC_69.L_CORE X_NUC_91.L_CORE 0.003896
K_4341 X_NUC_69.L_CORE X_NUC_92.L_CORE 0.004472
K_4342 X_NUC_69.L_CORE X_NUC_93.L_CORE 0.002883
K_4343 X_NUC_69.L_CORE X_NUC_94.L_CORE 0.010154
K_4344 X_NUC_69.L_CORE X_NUC_95.L_CORE 0.003638
K_4345 X_NUC_69.L_CORE X_NUC_96.L_CORE 0.004167
K_4346 X_NUC_69.L_CORE X_NUC_97.L_CORE 0.011435
K_4347 X_NUC_69.L_CORE X_NUC_98.L_CORE 0.004390
K_4348 X_NUC_70.L_CORE X_NUC_71.L_CORE 0.207973
K_4349 X_NUC_70.L_CORE X_NUC_72.L_CORE 0.207973
K_4350 X_NUC_70.L_CORE X_NUC_73.L_CORE 0.004103
K_4351 X_NUC_70.L_CORE X_NUC_74.L_CORE 0.004178
K_4352 X_NUC_70.L_CORE X_NUC_75.L_CORE 0.004151
K_4353 X_NUC_70.L_CORE X_NUC_76.L_CORE 0.004120
K_4354 X_NUC_70.L_CORE X_NUC_77.L_CORE 0.006086
K_4355 X_NUC_70.L_CORE X_NUC_78.L_CORE 0.006122
K_4356 X_NUC_70.L_CORE X_NUC_79.L_CORE 0.006162
K_4357 X_NUC_70.L_CORE X_NUC_80.L_CORE 0.005993
K_4358 X_NUC_70.L_CORE X_NUC_81.L_CORE 0.007818
K_4359 X_NUC_70.L_CORE X_NUC_82.L_CORE 0.008080
K_4360 X_NUC_70.L_CORE X_NUC_83.L_CORE 0.007898
K_4361 X_NUC_70.L_CORE X_NUC_84.L_CORE 0.007812
K_4362 X_NUC_70.L_CORE X_NUC_85.L_CORE 0.002582
K_4363 X_NUC_70.L_CORE X_NUC_86.L_CORE 0.003295
K_4364 X_NUC_70.L_CORE X_NUC_87.L_CORE 0.002893
K_4365 X_NUC_70.L_CORE X_NUC_88.L_CORE 0.002723
K_4366 X_NUC_70.L_CORE X_NUC_89.L_CORE 0.004758
K_4367 X_NUC_70.L_CORE X_NUC_90.L_CORE 0.002658
K_4368 X_NUC_70.L_CORE X_NUC_91.L_CORE 0.003920
K_4369 X_NUC_70.L_CORE X_NUC_92.L_CORE 0.004403
K_4370 X_NUC_70.L_CORE X_NUC_93.L_CORE 0.002861
K_4371 X_NUC_70.L_CORE X_NUC_94.L_CORE 0.010606
K_4372 X_NUC_70.L_CORE X_NUC_95.L_CORE 0.003576
K_4373 X_NUC_70.L_CORE X_NUC_96.L_CORE 0.004159
K_4374 X_NUC_70.L_CORE X_NUC_97.L_CORE 0.010984
K_4375 X_NUC_70.L_CORE X_NUC_98.L_CORE 0.004324
K_4376 X_NUC_71.L_CORE X_NUC_72.L_CORE 0.207973
K_4377 X_NUC_71.L_CORE X_NUC_73.L_CORE 0.004128
K_4378 X_NUC_71.L_CORE X_NUC_74.L_CORE 0.004204
K_4379 X_NUC_71.L_CORE X_NUC_75.L_CORE 0.004178
K_4380 X_NUC_71.L_CORE X_NUC_76.L_CORE 0.004145
K_4381 X_NUC_71.L_CORE X_NUC_77.L_CORE 0.006045
K_4382 X_NUC_71.L_CORE X_NUC_78.L_CORE 0.006078
K_4383 X_NUC_71.L_CORE X_NUC_79.L_CORE 0.006122
K_4384 X_NUC_71.L_CORE X_NUC_80.L_CORE 0.005954
K_4385 X_NUC_71.L_CORE X_NUC_81.L_CORE 0.007988
K_4386 X_NUC_71.L_CORE X_NUC_82.L_CORE 0.008261
K_4387 X_NUC_71.L_CORE X_NUC_83.L_CORE 0.008080
K_4388 X_NUC_71.L_CORE X_NUC_84.L_CORE 0.007982
K_4389 X_NUC_71.L_CORE X_NUC_85.L_CORE 0.002564
K_4390 X_NUC_71.L_CORE X_NUC_86.L_CORE 0.003251
K_4391 X_NUC_71.L_CORE X_NUC_87.L_CORE 0.002885
K_4392 X_NUC_71.L_CORE X_NUC_88.L_CORE 0.002698
K_4393 X_NUC_71.L_CORE X_NUC_89.L_CORE 0.004701
K_4394 X_NUC_71.L_CORE X_NUC_90.L_CORE 0.002655
K_4395 X_NUC_71.L_CORE X_NUC_91.L_CORE 0.003852
K_4396 X_NUC_71.L_CORE X_NUC_92.L_CORE 0.004429
K_4397 X_NUC_71.L_CORE X_NUC_93.L_CORE 0.002850
K_4398 X_NUC_71.L_CORE X_NUC_94.L_CORE 0.010162
K_4399 X_NUC_71.L_CORE X_NUC_95.L_CORE 0.003601
K_4400 X_NUC_71.L_CORE X_NUC_96.L_CORE 0.004126
K_4401 X_NUC_71.L_CORE X_NUC_97.L_CORE 0.011558
K_4402 X_NUC_71.L_CORE X_NUC_98.L_CORE 0.004351
K_4403 X_NUC_72.L_CORE X_NUC_73.L_CORE 0.004160
K_4404 X_NUC_72.L_CORE X_NUC_74.L_CORE 0.004238
K_4405 X_NUC_72.L_CORE X_NUC_75.L_CORE 0.004211
K_4406 X_NUC_72.L_CORE X_NUC_76.L_CORE 0.004178
K_4407 X_NUC_72.L_CORE X_NUC_77.L_CORE 0.006218
K_4408 X_NUC_72.L_CORE X_NUC_78.L_CORE 0.006254
K_4409 X_NUC_72.L_CORE X_NUC_79.L_CORE 0.006300
K_4410 X_NUC_72.L_CORE X_NUC_80.L_CORE 0.006122
K_4411 X_NUC_72.L_CORE X_NUC_81.L_CORE 0.008080
K_4412 X_NUC_72.L_CORE X_NUC_82.L_CORE 0.008363
K_4413 X_NUC_72.L_CORE X_NUC_83.L_CORE 0.008169
K_4414 X_NUC_72.L_CORE X_NUC_84.L_CORE 0.008080
K_4415 X_NUC_72.L_CORE X_NUC_85.L_CORE 0.002576
K_4416 X_NUC_72.L_CORE X_NUC_86.L_CORE 0.003265
K_4417 X_NUC_72.L_CORE X_NUC_87.L_CORE 0.002884
K_4418 X_NUC_72.L_CORE X_NUC_88.L_CORE 0.002725
K_4419 X_NUC_72.L_CORE X_NUC_89.L_CORE 0.004666
K_4420 X_NUC_72.L_CORE X_NUC_90.L_CORE 0.002668
K_4421 X_NUC_72.L_CORE X_NUC_91.L_CORE 0.003908
K_4422 X_NUC_72.L_CORE X_NUC_92.L_CORE 0.004383
K_4423 X_NUC_72.L_CORE X_NUC_93.L_CORE 0.002882
K_4424 X_NUC_72.L_CORE X_NUC_94.L_CORE 0.010244
K_4425 X_NUC_72.L_CORE X_NUC_95.L_CORE 0.003608
K_4426 X_NUC_72.L_CORE X_NUC_96.L_CORE 0.004209
K_4427 X_NUC_72.L_CORE X_NUC_97.L_CORE 0.011304
K_4428 X_NUC_72.L_CORE X_NUC_98.L_CORE 0.004406
K_4429 X_NUC_73.L_CORE X_NUC_74.L_CORE 0.207973
K_4430 X_NUC_73.L_CORE X_NUC_75.L_CORE 0.207973
K_4431 X_NUC_73.L_CORE X_NUC_76.L_CORE 0.207973
K_4432 X_NUC_73.L_CORE X_NUC_77.L_CORE 0.004997
K_4433 X_NUC_73.L_CORE X_NUC_78.L_CORE 0.004886
K_4434 X_NUC_73.L_CORE X_NUC_79.L_CORE 0.004951
K_4435 X_NUC_73.L_CORE X_NUC_80.L_CORE 0.004914
K_4436 X_NUC_73.L_CORE X_NUC_81.L_CORE 0.007588
K_4437 X_NUC_73.L_CORE X_NUC_82.L_CORE 0.007355
K_4438 X_NUC_73.L_CORE X_NUC_83.L_CORE 0.007363
K_4439 X_NUC_73.L_CORE X_NUC_84.L_CORE 0.007473
K_4440 X_NUC_73.L_CORE X_NUC_85.L_CORE 0.002872
K_4441 X_NUC_73.L_CORE X_NUC_86.L_CORE 0.002511
K_4442 X_NUC_73.L_CORE X_NUC_87.L_CORE 0.003381
K_4443 X_NUC_73.L_CORE X_NUC_88.L_CORE 0.002945
K_4444 X_NUC_73.L_CORE X_NUC_89.L_CORE 0.002784
K_4445 X_NUC_73.L_CORE X_NUC_90.L_CORE 0.004830
K_4446 X_NUC_73.L_CORE X_NUC_91.L_CORE 0.002784
K_4447 X_NUC_73.L_CORE X_NUC_92.L_CORE 0.004081
K_4448 X_NUC_73.L_CORE X_NUC_93.L_CORE 0.004684
K_4449 X_NUC_73.L_CORE X_NUC_94.L_CORE 0.003107
K_4450 X_NUC_73.L_CORE X_NUC_95.L_CORE 0.011302
K_4451 X_NUC_73.L_CORE X_NUC_96.L_CORE 0.004079
K_4452 X_NUC_73.L_CORE X_NUC_97.L_CORE 0.004903
K_4453 X_NUC_73.L_CORE X_NUC_98.L_CORE 0.010871
K_4454 X_NUC_74.L_CORE X_NUC_75.L_CORE 0.207973
K_4455 X_NUC_74.L_CORE X_NUC_76.L_CORE 0.207973
K_4456 X_NUC_74.L_CORE X_NUC_77.L_CORE 0.005113
K_4457 X_NUC_74.L_CORE X_NUC_78.L_CORE 0.004997
K_4458 X_NUC_74.L_CORE X_NUC_79.L_CORE 0.005065
K_4459 X_NUC_74.L_CORE X_NUC_80.L_CORE 0.005026
K_4460 X_NUC_74.L_CORE X_NUC_81.L_CORE 0.007834
K_4461 X_NUC_74.L_CORE X_NUC_82.L_CORE 0.007588
K_4462 X_NUC_74.L_CORE X_NUC_83.L_CORE 0.007592
K_4463 X_NUC_74.L_CORE X_NUC_84.L_CORE 0.007713
K_4464 X_NUC_74.L_CORE X_NUC_85.L_CORE 0.002880
K_4465 X_NUC_74.L_CORE X_NUC_86.L_CORE 0.002530
K_4466 X_NUC_74.L_CORE X_NUC_87.L_CORE 0.003380
K_4467 X_NUC_74.L_CORE X_NUC_88.L_CORE 0.002963
K_4468 X_NUC_74.L_CORE X_NUC_89.L_CORE 0.002809
K_4469 X_NUC_74.L_CORE X_NUC_90.L_CORE 0.004784
K_4470 X_NUC_74.L_CORE X_NUC_91.L_CORE 0.002816
K_4471 X_NUC_74.L_CORE X_NUC_92.L_CORE 0.004099
K_4472 X_NUC_74.L_CORE X_NUC_93.L_CORE 0.004700
K_4473 X_NUC_74.L_CORE X_NUC_94.L_CORE 0.003152
K_4474 X_NUC_74.L_CORE X_NUC_95.L_CORE 0.010936
K_4475 X_NUC_74.L_CORE X_NUC_96.L_CORE 0.004145
K_4476 X_NUC_74.L_CORE X_NUC_97.L_CORE 0.004992
K_4477 X_NUC_74.L_CORE X_NUC_98.L_CORE 0.011207
K_4478 X_NUC_75.L_CORE X_NUC_76.L_CORE 0.207973
K_4479 X_NUC_75.L_CORE X_NUC_77.L_CORE 0.005041
K_4480 X_NUC_75.L_CORE X_NUC_78.L_CORE 0.004929
K_4481 X_NUC_75.L_CORE X_NUC_79.L_CORE 0.004997
K_4482 X_NUC_75.L_CORE X_NUC_80.L_CORE 0.004958
K_4483 X_NUC_75.L_CORE X_NUC_81.L_CORE 0.007825
K_4484 X_NUC_75.L_CORE X_NUC_82.L_CORE 0.007575
K_4485 X_NUC_75.L_CORE X_NUC_83.L_CORE 0.007588
K_4486 X_NUC_75.L_CORE X_NUC_84.L_CORE 0.007704
K_4487 X_NUC_75.L_CORE X_NUC_85.L_CORE 0.002846
K_4488 X_NUC_75.L_CORE X_NUC_86.L_CORE 0.002504
K_4489 X_NUC_75.L_CORE X_NUC_87.L_CORE 0.003354
K_4490 X_NUC_75.L_CORE X_NUC_88.L_CORE 0.002922
K_4491 X_NUC_75.L_CORE X_NUC_89.L_CORE 0.002789
K_4492 X_NUC_75.L_CORE X_NUC_90.L_CORE 0.004726
K_4493 X_NUC_75.L_CORE X_NUC_91.L_CORE 0.002783
K_4494 X_NUC_75.L_CORE X_NUC_92.L_CORE 0.004094
K_4495 X_NUC_75.L_CORE X_NUC_93.L_CORE 0.004614
K_4496 X_NUC_75.L_CORE X_NUC_94.L_CORE 0.003128
K_4497 X_NUC_75.L_CORE X_NUC_95.L_CORE 0.011171
K_4498 X_NUC_75.L_CORE X_NUC_96.L_CORE 0.004087
K_4499 X_NUC_75.L_CORE X_NUC_97.L_CORE 0.004997
K_4500 X_NUC_75.L_CORE X_NUC_98.L_CORE 0.011170
K_4501 X_NUC_76.L_CORE X_NUC_77.L_CORE 0.005081
K_4502 X_NUC_76.L_CORE X_NUC_78.L_CORE 0.004966
K_4503 X_NUC_76.L_CORE X_NUC_79.L_CORE 0.005034
K_4504 X_NUC_76.L_CORE X_NUC_80.L_CORE 0.004997
K_4505 X_NUC_76.L_CORE X_NUC_81.L_CORE 0.007699
K_4506 X_NUC_76.L_CORE X_NUC_82.L_CORE 0.007460
K_4507 X_NUC_76.L_CORE X_NUC_83.L_CORE 0.007468
K_4508 X_NUC_76.L_CORE X_NUC_84.L_CORE 0.007588
K_4509 X_NUC_76.L_CORE X_NUC_85.L_CORE 0.002852
K_4510 X_NUC_76.L_CORE X_NUC_86.L_CORE 0.002504
K_4511 X_NUC_76.L_CORE X_NUC_87.L_CORE 0.003335
K_4512 X_NUC_76.L_CORE X_NUC_88.L_CORE 0.002944
K_4513 X_NUC_76.L_CORE X_NUC_89.L_CORE 0.002772
K_4514 X_NUC_76.L_CORE X_NUC_90.L_CORE 0.004750
K_4515 X_NUC_76.L_CORE X_NUC_91.L_CORE 0.002794
K_4516 X_NUC_76.L_CORE X_NUC_92.L_CORE 0.004029
K_4517 X_NUC_76.L_CORE X_NUC_93.L_CORE 0.004706
K_4518 X_NUC_76.L_CORE X_NUC_94.L_CORE 0.003117
K_4519 X_NUC_76.L_CORE X_NUC_95.L_CORE 0.010768
K_4520 X_NUC_76.L_CORE X_NUC_96.L_CORE 0.004136
K_4521 X_NUC_76.L_CORE X_NUC_97.L_CORE 0.004922
K_4522 X_NUC_76.L_CORE X_NUC_98.L_CORE 0.011466
K_4523 X_NUC_77.L_CORE X_NUC_78.L_CORE 0.207973
K_4524 X_NUC_77.L_CORE X_NUC_79.L_CORE 0.207973
K_4525 X_NUC_77.L_CORE X_NUC_80.L_CORE 0.207973
K_4526 X_NUC_77.L_CORE X_NUC_81.L_CORE 0.007031
K_4527 X_NUC_77.L_CORE X_NUC_82.L_CORE 0.007156
K_4528 X_NUC_77.L_CORE X_NUC_83.L_CORE 0.006970
K_4529 X_NUC_77.L_CORE X_NUC_84.L_CORE 0.007173
K_4530 X_NUC_77.L_CORE X_NUC_85.L_CORE 0.002660
K_4531 X_NUC_77.L_CORE X_NUC_86.L_CORE 0.002959
K_4532 X_NUC_77.L_CORE X_NUC_87.L_CORE 0.002563
K_4533 X_NUC_77.L_CORE X_NUC_88.L_CORE 0.003420
K_4534 X_NUC_77.L_CORE X_NUC_89.L_CORE 0.003041
K_4535 X_NUC_77.L_CORE X_NUC_90.L_CORE 0.002949
K_4536 X_NUC_77.L_CORE X_NUC_91.L_CORE 0.004715
K_4537 X_NUC_77.L_CORE X_NUC_92.L_CORE 0.003032
K_4538 X_NUC_77.L_CORE X_NUC_93.L_CORE 0.004374
K_4539 X_NUC_77.L_CORE X_NUC_94.L_CORE 0.005011
K_4540 X_NUC_77.L_CORE X_NUC_95.L_CORE 0.003601
K_4541 X_NUC_77.L_CORE X_NUC_96.L_CORE 0.011882
K_4542 X_NUC_77.L_CORE X_NUC_97.L_CORE 0.005123
K_4543 X_NUC_77.L_CORE X_NUC_98.L_CORE 0.006998
K_4544 X_NUC_78.L_CORE X_NUC_79.L_CORE 0.207973
K_4545 X_NUC_78.L_CORE X_NUC_80.L_CORE 0.207973
K_4546 X_NUC_78.L_CORE X_NUC_81.L_CORE 0.006905
K_4547 X_NUC_78.L_CORE X_NUC_82.L_CORE 0.007031
K_4548 X_NUC_78.L_CORE X_NUC_83.L_CORE 0.006851
K_4549 X_NUC_78.L_CORE X_NUC_84.L_CORE 0.007044
K_4550 X_NUC_78.L_CORE X_NUC_85.L_CORE 0.002649
K_4551 X_NUC_78.L_CORE X_NUC_86.L_CORE 0.002967
K_4552 X_NUC_78.L_CORE X_NUC_87.L_CORE 0.002547
K_4553 X_NUC_78.L_CORE X_NUC_88.L_CORE 0.003411
K_4554 X_NUC_78.L_CORE X_NUC_89.L_CORE 0.003047
K_4555 X_NUC_78.L_CORE X_NUC_90.L_CORE 0.002916
K_4556 X_NUC_78.L_CORE X_NUC_91.L_CORE 0.004774
K_4557 X_NUC_78.L_CORE X_NUC_92.L_CORE 0.003014
K_4558 X_NUC_78.L_CORE X_NUC_93.L_CORE 0.004312
K_4559 X_NUC_78.L_CORE X_NUC_94.L_CORE 0.005082
K_4560 X_NUC_78.L_CORE X_NUC_95.L_CORE 0.003548
K_4561 X_NUC_78.L_CORE X_NUC_96.L_CORE 0.011932
K_4562 X_NUC_78.L_CORE X_NUC_97.L_CORE 0.005100
K_4563 X_NUC_78.L_CORE X_NUC_98.L_CORE 0.006783
K_4564 X_NUC_79.L_CORE X_NUC_80.L_CORE 0.207973
K_4565 X_NUC_79.L_CORE X_NUC_81.L_CORE 0.007086
K_4566 X_NUC_79.L_CORE X_NUC_82.L_CORE 0.007218
K_4567 X_NUC_79.L_CORE X_NUC_83.L_CORE 0.007031
K_4568 X_NUC_79.L_CORE X_NUC_84.L_CORE 0.007236
K_4569 X_NUC_79.L_CORE X_NUC_85.L_CORE 0.002632
K_4570 X_NUC_79.L_CORE X_NUC_86.L_CORE 0.002939
K_4571 X_NUC_79.L_CORE X_NUC_87.L_CORE 0.002545
K_4572 X_NUC_79.L_CORE X_NUC_88.L_CORE 0.003369
K_4573 X_NUC_79.L_CORE X_NUC_89.L_CORE 0.003037
K_4574 X_NUC_79.L_CORE X_NUC_90.L_CORE 0.002916
K_4575 X_NUC_79.L_CORE X_NUC_91.L_CORE 0.004672
K_4576 X_NUC_79.L_CORE X_NUC_92.L_CORE 0.003027
K_4577 X_NUC_79.L_CORE X_NUC_93.L_CORE 0.004288
K_4578 X_NUC_79.L_CORE X_NUC_94.L_CORE 0.005054
K_4579 X_NUC_79.L_CORE X_NUC_95.L_CORE 0.003580
K_4580 X_NUC_79.L_CORE X_NUC_96.L_CORE 0.011486
K_4581 X_NUC_79.L_CORE X_NUC_97.L_CORE 0.005179
K_4582 X_NUC_79.L_CORE X_NUC_98.L_CORE 0.006952
K_4583 X_NUC_80.L_CORE X_NUC_81.L_CORE 0.006890
K_4584 X_NUC_80.L_CORE X_NUC_82.L_CORE 0.007011
K_4585 X_NUC_80.L_CORE X_NUC_83.L_CORE 0.006836
K_4586 X_NUC_80.L_CORE X_NUC_84.L_CORE 0.007031
K_4587 X_NUC_80.L_CORE X_NUC_85.L_CORE 0.002632
K_4588 X_NUC_80.L_CORE X_NUC_86.L_CORE 0.002930
K_4589 X_NUC_80.L_CORE X_NUC_87.L_CORE 0.002532
K_4590 X_NUC_80.L_CORE X_NUC_88.L_CORE 0.003391
K_4591 X_NUC_80.L_CORE X_NUC_89.L_CORE 0.003007
K_4592 X_NUC_80.L_CORE X_NUC_90.L_CORE 0.002914
K_4593 X_NUC_80.L_CORE X_NUC_91.L_CORE 0.004693
K_4594 X_NUC_80.L_CORE X_NUC_92.L_CORE 0.002992
K_4595 X_NUC_80.L_CORE X_NUC_93.L_CORE 0.004337
K_4596 X_NUC_80.L_CORE X_NUC_94.L_CORE 0.004969
K_4597 X_NUC_80.L_CORE X_NUC_95.L_CORE 0.003553
K_4598 X_NUC_80.L_CORE X_NUC_96.L_CORE 0.012132
K_4599 X_NUC_80.L_CORE X_NUC_97.L_CORE 0.005055
K_4600 X_NUC_80.L_CORE X_NUC_98.L_CORE 0.006918
K_4601 X_NUC_81.L_CORE X_NUC_82.L_CORE 0.207973
K_4602 X_NUC_81.L_CORE X_NUC_83.L_CORE 0.207973
K_4603 X_NUC_81.L_CORE X_NUC_84.L_CORE 0.207973
K_4604 X_NUC_81.L_CORE X_NUC_85.L_CORE 0.002551
K_4605 X_NUC_81.L_CORE X_NUC_86.L_CORE 0.002683
K_4606 X_NUC_81.L_CORE X_NUC_87.L_CORE 0.002971
K_4607 X_NUC_81.L_CORE X_NUC_88.L_CORE 0.002700
K_4608 X_NUC_81.L_CORE X_NUC_89.L_CORE 0.003350
K_4609 X_NUC_81.L_CORE X_NUC_90.L_CORE 0.003209
K_4610 X_NUC_81.L_CORE X_NUC_91.L_CORE 0.003176
K_4611 X_NUC_81.L_CORE X_NUC_92.L_CORE 0.004466
K_4612 X_NUC_81.L_CORE X_NUC_93.L_CORE 0.003469
K_4613 X_NUC_81.L_CORE X_NUC_94.L_CORE 0.004623
K_4614 X_NUC_81.L_CORE X_NUC_95.L_CORE 0.005560
K_4615 X_NUC_81.L_CORE X_NUC_96.L_CORE 0.004528
K_4616 X_NUC_81.L_CORE X_NUC_97.L_CORE 0.011967
K_4617 X_NUC_81.L_CORE X_NUC_98.L_CORE 0.008467
K_4618 X_NUC_82.L_CORE X_NUC_83.L_CORE 0.207973
K_4619 X_NUC_82.L_CORE X_NUC_84.L_CORE 0.207973
K_4620 X_NUC_82.L_CORE X_NUC_85.L_CORE 0.002547
K_4621 X_NUC_82.L_CORE X_NUC_86.L_CORE 0.002696
K_4622 X_NUC_82.L_CORE X_NUC_87.L_CORE 0.002956
K_4623 X_NUC_82.L_CORE X_NUC_88.L_CORE 0.002702
K_4624 X_NUC_82.L_CORE X_NUC_89.L_CORE 0.003372
K_4625 X_NUC_82.L_CORE X_NUC_90.L_CORE 0.003178
K_4626 X_NUC_82.L_CORE X_NUC_91.L_CORE 0.003206
K_4627 X_NUC_82.L_CORE X_NUC_92.L_CORE 0.004441
K_4628 X_NUC_82.L_CORE X_NUC_93.L_CORE 0.003452
K_4629 X_NUC_82.L_CORE X_NUC_94.L_CORE 0.004716
K_4630 X_NUC_82.L_CORE X_NUC_95.L_CORE 0.005425
K_4631 X_NUC_82.L_CORE X_NUC_96.L_CORE 0.004565
K_4632 X_NUC_82.L_CORE X_NUC_97.L_CORE 0.012303
K_4633 X_NUC_82.L_CORE X_NUC_98.L_CORE 0.008291
K_4634 X_NUC_83.L_CORE X_NUC_84.L_CORE 0.207973
K_4635 X_NUC_83.L_CORE X_NUC_85.L_CORE 0.002524
K_4636 X_NUC_83.L_CORE X_NUC_86.L_CORE 0.002665
K_4637 X_NUC_83.L_CORE X_NUC_87.L_CORE 0.002939
K_4638 X_NUC_83.L_CORE X_NUC_88.L_CORE 0.002671
K_4639 X_NUC_83.L_CORE X_NUC_89.L_CORE 0.003339
K_4640 X_NUC_83.L_CORE X_NUC_90.L_CORE 0.003161
K_4641 X_NUC_83.L_CORE X_NUC_91.L_CORE 0.003157
K_4642 X_NUC_83.L_CORE X_NUC_92.L_CORE 0.004437
K_4643 X_NUC_83.L_CORE X_NUC_93.L_CORE 0.003418
K_4644 X_NUC_83.L_CORE X_NUC_94.L_CORE 0.004640
K_4645 X_NUC_83.L_CORE X_NUC_95.L_CORE 0.005456
K_4646 X_NUC_83.L_CORE X_NUC_96.L_CORE 0.004490
K_4647 X_NUC_83.L_CORE X_NUC_97.L_CORE 0.012411
K_4648 X_NUC_83.L_CORE X_NUC_98.L_CORE 0.008288
K_4649 X_NUC_84.L_CORE X_NUC_85.L_CORE 0.002533
K_4650 X_NUC_84.L_CORE X_NUC_86.L_CORE 0.002670
K_4651 X_NUC_84.L_CORE X_NUC_87.L_CORE 0.002933
K_4652 X_NUC_84.L_CORE X_NUC_88.L_CORE 0.002693
K_4653 X_NUC_84.L_CORE X_NUC_89.L_CORE 0.003320
K_4654 X_NUC_84.L_CORE X_NUC_90.L_CORE 0.003177
K_4655 X_NUC_84.L_CORE X_NUC_91.L_CORE 0.003182
K_4656 X_NUC_84.L_CORE X_NUC_92.L_CORE 0.004376
K_4657 X_NUC_84.L_CORE X_NUC_93.L_CORE 0.003467
K_4658 X_NUC_84.L_CORE X_NUC_94.L_CORE 0.004630
K_4659 X_NUC_84.L_CORE X_NUC_95.L_CORE 0.005450
K_4660 X_NUC_84.L_CORE X_NUC_96.L_CORE 0.004580
K_4661 X_NUC_84.L_CORE X_NUC_97.L_CORE 0.011795
K_4662 X_NUC_84.L_CORE X_NUC_98.L_CORE 0.008572
K_4663 X_NUC_85.L_CORE X_NUC_86.L_CORE 0.004974
K_4664 X_NUC_85.L_CORE X_NUC_87.L_CORE 0.005364
K_4665 X_NUC_85.L_CORE X_NUC_88.L_CORE 0.005656
K_4666 X_NUC_85.L_CORE X_NUC_89.L_CORE 0.003283
K_4667 X_NUC_85.L_CORE X_NUC_90.L_CORE 0.004688
K_4668 X_NUC_85.L_CORE X_NUC_91.L_CORE 0.003250
K_4669 X_NUC_85.L_CORE X_NUC_92.L_CORE 0.002966
K_4670 X_NUC_85.L_CORE X_NUC_93.L_CORE 0.003560
K_4671 X_NUC_85.L_CORE X_NUC_94.L_CORE 0.002566
K_4672 X_NUC_85.L_CORE X_NUC_95.L_CORE 0.002862
K_4673 X_NUC_85.L_CORE X_NUC_96.L_CORE 0.002683
K_4674 X_NUC_85.L_CORE X_NUC_97.L_CORE 0.002375
K_4675 X_NUC_85.L_CORE X_NUC_98.L_CORE 0.002509
K_4676 X_NUC_86.L_CORE X_NUC_87.L_CORE 0.003590
K_4677 X_NUC_86.L_CORE X_NUC_88.L_CORE 0.004407
K_4678 X_NUC_86.L_CORE X_NUC_89.L_CORE 0.005439
K_4679 X_NUC_86.L_CORE X_NUC_90.L_CORE 0.002762
K_4680 X_NUC_86.L_CORE X_NUC_91.L_CORE 0.005070
K_4681 X_NUC_86.L_CORE X_NUC_92.L_CORE 0.002991
K_4682 X_NUC_86.L_CORE X_NUC_93.L_CORE 0.002742
K_4683 X_NUC_86.L_CORE X_NUC_94.L_CORE 0.003840
K_4684 X_NUC_86.L_CORE X_NUC_95.L_CORE 0.002401
K_4685 X_NUC_86.L_CORE X_NUC_96.L_CORE 0.002888
K_4686 X_NUC_86.L_CORE X_NUC_97.L_CORE 0.002691
K_4687 X_NUC_86.L_CORE X_NUC_98.L_CORE 0.002375
K_4688 X_NUC_87.L_CORE X_NUC_88.L_CORE 0.003052
K_4689 X_NUC_87.L_CORE X_NUC_89.L_CORE 0.003921
K_4690 X_NUC_87.L_CORE X_NUC_90.L_CORE 0.005170
K_4691 X_NUC_87.L_CORE X_NUC_91.L_CORE 0.002525
K_4692 X_NUC_87.L_CORE X_NUC_92.L_CORE 0.005207
K_4693 X_NUC_87.L_CORE X_NUC_93.L_CORE 0.002858
K_4694 X_NUC_87.L_CORE X_NUC_94.L_CORE 0.002641
K_4695 X_NUC_87.L_CORE X_NUC_95.L_CORE 0.003947
K_4696 X_NUC_87.L_CORE X_NUC_96.L_CORE 0.002359
K_4697 X_NUC_87.L_CORE X_NUC_97.L_CORE 0.002888
K_4698 X_NUC_87.L_CORE X_NUC_98.L_CORE 0.002683
K_4699 X_NUC_88.L_CORE X_NUC_89.L_CORE 0.002770
K_4700 X_NUC_88.L_CORE X_NUC_90.L_CORE 0.003645
K_4701 X_NUC_88.L_CORE X_NUC_91.L_CORE 0.004980
K_4702 X_NUC_88.L_CORE X_NUC_92.L_CORE 0.002402
K_4703 X_NUC_88.L_CORE X_NUC_93.L_CORE 0.005259
K_4704 X_NUC_88.L_CORE X_NUC_94.L_CORE 0.002799
K_4705 X_NUC_88.L_CORE X_NUC_95.L_CORE 0.002611
K_4706 X_NUC_88.L_CORE X_NUC_96.L_CORE 0.003947
K_4707 X_NUC_88.L_CORE X_NUC_97.L_CORE 0.002401
K_4708 X_NUC_88.L_CORE X_NUC_98.L_CORE 0.002862
K_4709 X_NUC_89.L_CORE X_NUC_90.L_CORE 0.002611
K_4710 X_NUC_89.L_CORE X_NUC_91.L_CORE 0.003490
K_4711 X_NUC_89.L_CORE X_NUC_92.L_CORE 0.004871
K_4712 X_NUC_89.L_CORE X_NUC_93.L_CORE 0.002347
K_4713 X_NUC_89.L_CORE X_NUC_94.L_CORE 0.005272
K_4714 X_NUC_89.L_CORE X_NUC_95.L_CORE 0.002799
K_4715 X_NUC_89.L_CORE X_NUC_96.L_CORE 0.002641
K_4716 X_NUC_89.L_CORE X_NUC_97.L_CORE 0.003840
K_4717 X_NUC_89.L_CORE X_NUC_98.L_CORE 0.002566
K_4718 X_NUC_90.L_CORE X_NUC_91.L_CORE 0.002528
K_4719 X_NUC_90.L_CORE X_NUC_92.L_CORE 0.003420
K_4720 X_NUC_90.L_CORE X_NUC_93.L_CORE 0.004835
K_4721 X_NUC_90.L_CORE X_NUC_94.L_CORE 0.002347
K_4722 X_NUC_90.L_CORE X_NUC_95.L_CORE 0.005259
K_4723 X_NUC_90.L_CORE X_NUC_96.L_CORE 0.002858
K_4724 X_NUC_90.L_CORE X_NUC_97.L_CORE 0.002742
K_4725 X_NUC_90.L_CORE X_NUC_98.L_CORE 0.003560
K_4726 X_NUC_91.L_CORE X_NUC_92.L_CORE 0.002502
K_4727 X_NUC_91.L_CORE X_NUC_93.L_CORE 0.003420
K_4728 X_NUC_91.L_CORE X_NUC_94.L_CORE 0.004871
K_4729 X_NUC_91.L_CORE X_NUC_95.L_CORE 0.002402
K_4730 X_NUC_91.L_CORE X_NUC_96.L_CORE 0.005207
K_4731 X_NUC_91.L_CORE X_NUC_97.L_CORE 0.002991
K_4732 X_NUC_91.L_CORE X_NUC_98.L_CORE 0.002966
K_4733 X_NUC_92.L_CORE X_NUC_93.L_CORE 0.002528
K_4734 X_NUC_92.L_CORE X_NUC_94.L_CORE 0.003490
K_4735 X_NUC_92.L_CORE X_NUC_95.L_CORE 0.004980
K_4736 X_NUC_92.L_CORE X_NUC_96.L_CORE 0.002525
K_4737 X_NUC_92.L_CORE X_NUC_97.L_CORE 0.005070
K_4738 X_NUC_92.L_CORE X_NUC_98.L_CORE 0.003250
K_4739 X_NUC_93.L_CORE X_NUC_94.L_CORE 0.002611
K_4740 X_NUC_93.L_CORE X_NUC_95.L_CORE 0.003645
K_4741 X_NUC_93.L_CORE X_NUC_96.L_CORE 0.005170
K_4742 X_NUC_93.L_CORE X_NUC_97.L_CORE 0.002762
K_4743 X_NUC_93.L_CORE X_NUC_98.L_CORE 0.004688
K_4744 X_NUC_94.L_CORE X_NUC_95.L_CORE 0.002770
K_4745 X_NUC_94.L_CORE X_NUC_96.L_CORE 0.003921
K_4746 X_NUC_94.L_CORE X_NUC_97.L_CORE 0.005439
K_4747 X_NUC_94.L_CORE X_NUC_98.L_CORE 0.003283
K_4748 X_NUC_95.L_CORE X_NUC_96.L_CORE 0.003052
K_4749 X_NUC_95.L_CORE X_NUC_97.L_CORE 0.004407
K_4750 X_NUC_95.L_CORE X_NUC_98.L_CORE 0.005656
K_4751 X_NUC_96.L_CORE X_NUC_97.L_CORE 0.003590
K_4752 X_NUC_96.L_CORE X_NUC_98.L_CORE 0.005364
K_4753 X_NUC_97.L_CORE X_NUC_98.L_CORE 0.004974

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
