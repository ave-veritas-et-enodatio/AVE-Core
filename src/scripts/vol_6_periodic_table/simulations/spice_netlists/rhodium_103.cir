* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Rhodium-103 (Z=45, A=103)
* Auto-generated topological mutual impedance array
* Nodes: 103

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON
X_NUC_65 NODE_65 0 NUCLEON
X_NUC_66 NODE_66 0 NUCLEON
X_NUC_67 NODE_67 0 NUCLEON
X_NUC_68 NODE_68 0 NUCLEON
X_NUC_69 NODE_69 0 NUCLEON
X_NUC_70 NODE_70 0 NUCLEON
X_NUC_71 NODE_71 0 NUCLEON
X_NUC_72 NODE_72 0 NUCLEON
X_NUC_73 NODE_73 0 NUCLEON
X_NUC_74 NODE_74 0 NUCLEON
X_NUC_75 NODE_75 0 NUCLEON
X_NUC_76 NODE_76 0 NUCLEON
X_NUC_77 NODE_77 0 NUCLEON
X_NUC_78 NODE_78 0 NUCLEON
X_NUC_79 NODE_79 0 NUCLEON
X_NUC_80 NODE_80 0 NUCLEON
X_NUC_81 NODE_81 0 NUCLEON
X_NUC_82 NODE_82 0 NUCLEON
X_NUC_83 NODE_83 0 NUCLEON
X_NUC_84 NODE_84 0 NUCLEON
X_NUC_85 NODE_85 0 NUCLEON
X_NUC_86 NODE_86 0 NUCLEON
X_NUC_87 NODE_87 0 NUCLEON
X_NUC_88 NODE_88 0 NUCLEON
X_NUC_89 NODE_89 0 NUCLEON
X_NUC_90 NODE_90 0 NUCLEON
X_NUC_91 NODE_91 0 NUCLEON
X_NUC_92 NODE_92 0 NUCLEON
X_NUC_93 NODE_93 0 NUCLEON
X_NUC_94 NODE_94 0 NUCLEON
X_NUC_95 NODE_95 0 NUCLEON
X_NUC_96 NODE_96 0 NUCLEON
X_NUC_97 NODE_97 0 NUCLEON
X_NUC_98 NODE_98 0 NUCLEON
X_NUC_99 NODE_99 0 NUCLEON
X_NUC_100 NODE_100 0 NUCLEON
X_NUC_101 NODE_101 0 NUCLEON
X_NUC_102 NODE_102 0 NUCLEON
X_NUC_103 NODE_103 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.006887
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.006678
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.006727
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.006793
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.007434
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.007535
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.007318
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.007552
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.007921
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.007779
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.007875
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.007653
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.004494
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.004437
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.004409
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.004480
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.006675
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.006852
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.006667
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.006673
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.004469
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.004388
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.004407
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.004388
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.004054
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.004058
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.003995
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.004062
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.005159
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.005183
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.005148
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.005065
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.003448
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.003406
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.003394
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.003416
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.004045
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.004089
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.004011
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.004044
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.003773
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.003740
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.003738
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.003706
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.003131
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.003118
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.003087
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.003119
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.003815
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.003846
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.003795
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.003780
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.003044
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.003014
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.003005
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.003007
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.003087
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.003096
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.003053
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.003078
K_64 X_NUC_1.L_CORE X_NUC_65.L_CORE 0.003258
K_65 X_NUC_1.L_CORE X_NUC_66.L_CORE 0.003253
K_66 X_NUC_1.L_CORE X_NUC_67.L_CORE 0.003233
K_67 X_NUC_1.L_CORE X_NUC_68.L_CORE 0.003213
K_68 X_NUC_1.L_CORE X_NUC_69.L_CORE 0.002744
K_69 X_NUC_1.L_CORE X_NUC_70.L_CORE 0.002729
K_70 X_NUC_1.L_CORE X_NUC_71.L_CORE 0.002709
K_71 X_NUC_1.L_CORE X_NUC_72.L_CORE 0.002723
K_72 X_NUC_1.L_CORE X_NUC_73.L_CORE 0.003013
K_73 X_NUC_1.L_CORE X_NUC_74.L_CORE 0.003026
K_74 X_NUC_1.L_CORE X_NUC_75.L_CORE 0.002988
K_75 X_NUC_1.L_CORE X_NUC_76.L_CORE 0.002993
K_76 X_NUC_1.L_CORE X_NUC_77.L_CORE 0.002789
K_77 X_NUC_1.L_CORE X_NUC_78.L_CORE 0.002775
K_78 X_NUC_1.L_CORE X_NUC_79.L_CORE 0.002760
K_79 X_NUC_1.L_CORE X_NUC_80.L_CORE 0.002756
K_80 X_NUC_1.L_CORE X_NUC_81.L_CORE 0.002660
K_81 X_NUC_1.L_CORE X_NUC_82.L_CORE 0.002656
K_82 X_NUC_1.L_CORE X_NUC_83.L_CORE 0.002630
K_83 X_NUC_1.L_CORE X_NUC_84.L_CORE 0.002642
K_84 X_NUC_1.L_CORE X_NUC_85.L_CORE 0.002730
K_85 X_NUC_1.L_CORE X_NUC_86.L_CORE 0.002729
K_86 X_NUC_1.L_CORE X_NUC_87.L_CORE 0.002705
K_87 X_NUC_1.L_CORE X_NUC_88.L_CORE 0.002704
K_88 X_NUC_1.L_CORE X_NUC_89.L_CORE 0.032235
K_89 X_NUC_1.L_CORE X_NUC_90.L_CORE 0.005486
K_90 X_NUC_1.L_CORE X_NUC_91.L_CORE 0.005771
K_91 X_NUC_1.L_CORE X_NUC_92.L_CORE 0.005746
K_92 X_NUC_1.L_CORE X_NUC_93.L_CORE 0.003586
K_93 X_NUC_1.L_CORE X_NUC_94.L_CORE 0.004795
K_94 X_NUC_1.L_CORE X_NUC_95.L_CORE 0.003458
K_95 X_NUC_1.L_CORE X_NUC_96.L_CORE 0.003186
K_96 X_NUC_1.L_CORE X_NUC_97.L_CORE 0.003677
K_97 X_NUC_1.L_CORE X_NUC_98.L_CORE 0.002746
K_98 X_NUC_1.L_CORE X_NUC_99.L_CORE 0.003026
K_99 X_NUC_1.L_CORE X_NUC_100.L_CORE 0.002829
K_100 X_NUC_1.L_CORE X_NUC_101.L_CORE 0.002511
K_101 X_NUC_1.L_CORE X_NUC_102.L_CORE 0.002697
K_102 X_NUC_1.L_CORE X_NUC_103.L_CORE 0.002429
K_103 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_104 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_105 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.007109
K_106 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.006887
K_107 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.006937
K_108 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.007010
K_109 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.007327
K_110 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.007434
K_111 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.007220
K_112 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.007445
K_113 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.008060
K_114 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.007921
K_115 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.008017
K_116 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.007783
K_117 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.004550
K_118 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.004494
K_119 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.004463
K_120 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.004536
K_121 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.006504
K_122 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.006675
K_123 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.006500
K_124 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.006506
K_125 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.004553
K_126 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.004469
K_127 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.004488
K_128 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.004468
K_129 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.004049
K_130 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.004054
K_131 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.003991
K_132 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.004058
K_133 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.005132
K_134 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.005159
K_135 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.005123
K_136 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.005041
K_137 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.003491
K_138 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.003448
K_139 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.003436
K_140 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.003458
K_141 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.004000
K_142 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.004045
K_143 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.003968
K_144 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.004000
K_145 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.003806
K_146 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.003773
K_147 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.003771
K_148 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.003738
K_149 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.003144
K_150 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.003131
K_151 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.003100
K_152 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.003132
K_153 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.003783
K_154 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.003815
K_155 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.003765
K_156 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.003750
K_157 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.003074
K_158 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.003044
K_159 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.003034
K_160 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.003036
K_161 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.003077
K_162 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.003087
K_163 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.003044
K_164 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.003069
K_165 X_NUC_2.L_CORE X_NUC_65.L_CORE 0.003262
K_166 X_NUC_2.L_CORE X_NUC_66.L_CORE 0.003258
K_167 X_NUC_2.L_CORE X_NUC_67.L_CORE 0.003238
K_168 X_NUC_2.L_CORE X_NUC_68.L_CORE 0.003217
K_169 X_NUC_2.L_CORE X_NUC_69.L_CORE 0.002759
K_170 X_NUC_2.L_CORE X_NUC_70.L_CORE 0.002744
K_171 X_NUC_2.L_CORE X_NUC_71.L_CORE 0.002724
K_172 X_NUC_2.L_CORE X_NUC_72.L_CORE 0.002738
K_173 X_NUC_2.L_CORE X_NUC_73.L_CORE 0.003000
K_174 X_NUC_2.L_CORE X_NUC_74.L_CORE 0.003013
K_175 X_NUC_2.L_CORE X_NUC_75.L_CORE 0.002975
K_176 X_NUC_2.L_CORE X_NUC_76.L_CORE 0.002980
K_177 X_NUC_2.L_CORE X_NUC_77.L_CORE 0.002803
K_178 X_NUC_2.L_CORE X_NUC_78.L_CORE 0.002789
K_179 X_NUC_2.L_CORE X_NUC_79.L_CORE 0.002774
K_180 X_NUC_2.L_CORE X_NUC_80.L_CORE 0.002769
K_181 X_NUC_2.L_CORE X_NUC_81.L_CORE 0.002662
K_182 X_NUC_2.L_CORE X_NUC_82.L_CORE 0.002660
K_183 X_NUC_2.L_CORE X_NUC_83.L_CORE 0.002633
K_184 X_NUC_2.L_CORE X_NUC_84.L_CORE 0.002645
K_185 X_NUC_2.L_CORE X_NUC_85.L_CORE 0.002730
K_186 X_NUC_2.L_CORE X_NUC_86.L_CORE 0.002730
K_187 X_NUC_2.L_CORE X_NUC_87.L_CORE 0.002705
K_188 X_NUC_2.L_CORE X_NUC_88.L_CORE 0.002705
K_189 X_NUC_2.L_CORE X_NUC_89.L_CORE 0.029926
K_190 X_NUC_2.L_CORE X_NUC_90.L_CORE 0.005629
K_191 X_NUC_2.L_CORE X_NUC_91.L_CORE 0.005693
K_192 X_NUC_2.L_CORE X_NUC_92.L_CORE 0.005807
K_193 X_NUC_2.L_CORE X_NUC_93.L_CORE 0.003622
K_194 X_NUC_2.L_CORE X_NUC_94.L_CORE 0.004708
K_195 X_NUC_2.L_CORE X_NUC_95.L_CORE 0.003505
K_196 X_NUC_2.L_CORE X_NUC_96.L_CORE 0.003182
K_197 X_NUC_2.L_CORE X_NUC_97.L_CORE 0.003665
K_198 X_NUC_2.L_CORE X_NUC_98.L_CORE 0.002770
K_199 X_NUC_2.L_CORE X_NUC_99.L_CORE 0.003006
K_200 X_NUC_2.L_CORE X_NUC_100.L_CORE 0.002843
K_201 X_NUC_2.L_CORE X_NUC_101.L_CORE 0.002518
K_202 X_NUC_2.L_CORE X_NUC_102.L_CORE 0.002691
K_203 X_NUC_2.L_CORE X_NUC_103.L_CORE 0.002437
K_204 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_205 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.007051
K_206 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.006831
K_207 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.006887
K_208 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.006954
K_209 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.007545
K_210 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.007657
K_211 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.007434
K_212 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.007674
K_213 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.007957
K_214 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.007818
K_215 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.007921
K_216 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.007690
K_217 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.004581
K_218 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.004523
K_219 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.004494
K_220 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.004567
K_221 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.006676
K_222 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.006857
K_223 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.006675
K_224 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.006678
K_225 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.004533
K_226 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.004449
K_227 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.004469
K_228 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.004448
K_229 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.004114
K_230 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.004119
K_231 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.004054
K_232 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.004124
K_233 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.005167
K_234 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.005193
K_235 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.005159
K_236 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.005075
K_237 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.003503
K_238 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.003459
K_239 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.003448
K_240 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.003470
K_241 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.004078
K_242 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.004125
K_243 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.004045
K_244 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.004078
K_245 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.003808
K_246 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.003774
K_247 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.003773
K_248 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.003740
K_249 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.003177
K_250 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.003163
K_251 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.003131
K_252 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.003164
K_253 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.003834
K_254 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.003866
K_255 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.003815
K_256 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.003798
K_257 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.003083
K_258 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.003053
K_259 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.003044
K_260 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.003045
K_261 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.003122
K_262 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.003131
K_263 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.003087
K_264 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.003112
K_265 X_NUC_3.L_CORE X_NUC_65.L_CORE 0.003282
K_266 X_NUC_3.L_CORE X_NUC_66.L_CORE 0.003278
K_267 X_NUC_3.L_CORE X_NUC_67.L_CORE 0.003258
K_268 X_NUC_3.L_CORE X_NUC_68.L_CORE 0.003237
K_269 X_NUC_3.L_CORE X_NUC_69.L_CORE 0.002780
K_270 X_NUC_3.L_CORE X_NUC_70.L_CORE 0.002764
K_271 X_NUC_3.L_CORE X_NUC_71.L_CORE 0.002744
K_272 X_NUC_3.L_CORE X_NUC_72.L_CORE 0.002758
K_273 X_NUC_3.L_CORE X_NUC_73.L_CORE 0.003038
K_274 X_NUC_3.L_CORE X_NUC_74.L_CORE 0.003052
K_275 X_NUC_3.L_CORE X_NUC_75.L_CORE 0.003013
K_276 X_NUC_3.L_CORE X_NUC_76.L_CORE 0.003018
K_277 X_NUC_3.L_CORE X_NUC_77.L_CORE 0.002818
K_278 X_NUC_3.L_CORE X_NUC_78.L_CORE 0.002804
K_279 X_NUC_3.L_CORE X_NUC_79.L_CORE 0.002789
K_280 X_NUC_3.L_CORE X_NUC_80.L_CORE 0.002785
K_281 X_NUC_3.L_CORE X_NUC_81.L_CORE 0.002690
K_282 X_NUC_3.L_CORE X_NUC_82.L_CORE 0.002687
K_283 X_NUC_3.L_CORE X_NUC_83.L_CORE 0.002660
K_284 X_NUC_3.L_CORE X_NUC_84.L_CORE 0.002672
K_285 X_NUC_3.L_CORE X_NUC_85.L_CORE 0.002755
K_286 X_NUC_3.L_CORE X_NUC_86.L_CORE 0.002755
K_287 X_NUC_3.L_CORE X_NUC_87.L_CORE 0.002730
K_288 X_NUC_3.L_CORE X_NUC_88.L_CORE 0.002729
K_289 X_NUC_3.L_CORE X_NUC_89.L_CORE 0.027917
K_290 X_NUC_3.L_CORE X_NUC_90.L_CORE 0.005579
K_291 X_NUC_3.L_CORE X_NUC_91.L_CORE 0.005822
K_292 X_NUC_3.L_CORE X_NUC_92.L_CORE 0.005751
K_293 X_NUC_3.L_CORE X_NUC_93.L_CORE 0.003643
K_294 X_NUC_3.L_CORE X_NUC_94.L_CORE 0.004795
K_295 X_NUC_3.L_CORE X_NUC_95.L_CORE 0.003497
K_296 X_NUC_3.L_CORE X_NUC_96.L_CORE 0.003224
K_297 X_NUC_3.L_CORE X_NUC_97.L_CORE 0.003688
K_298 X_NUC_3.L_CORE X_NUC_98.L_CORE 0.002781
K_299 X_NUC_3.L_CORE X_NUC_99.L_CORE 0.003049
K_300 X_NUC_3.L_CORE X_NUC_100.L_CORE 0.002853
K_301 X_NUC_3.L_CORE X_NUC_101.L_CORE 0.002541
K_302 X_NUC_3.L_CORE X_NUC_102.L_CORE 0.002717
K_303 X_NUC_3.L_CORE X_NUC_103.L_CORE 0.002453
K_304 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.006977
K_305 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.006763
K_306 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.006814
K_307 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.006887
K_308 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.007311
K_309 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.007413
K_310 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.007205
K_311 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.007434
K_312 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.008207
K_313 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.008055
K_314 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.008162
K_315 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.007921
K_316 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.004506
K_317 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.004450
K_318 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.004422
K_319 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.004494
K_320 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.006669
K_321 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.006850
K_322 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.006665
K_323 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.006675
K_324 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.004554
K_325 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.004469
K_326 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.004489
K_327 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.004469
K_328 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.004045
K_329 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.004049
K_330 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.003987
K_331 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.004054
K_332 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.005255
K_333 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.005282
K_334 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.005245
K_335 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.005159
K_336 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.003480
K_337 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.003437
K_338 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.003425
K_339 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.003448
K_340 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.004044
K_341 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.004089
K_342 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.004011
K_343 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.004045
K_344 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.003843
K_345 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.003808
K_346 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.003806
K_347 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.003773
K_348 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.003143
K_349 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.003130
K_350 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.003098
K_351 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.003131
K_352 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.003850
K_353 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.003883
K_354 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.003830
K_355 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.003815
K_356 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.003082
K_357 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.003052
K_358 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.003042
K_359 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.003044
K_360 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.003096
K_361 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.003105
K_362 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.003062
K_363 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.003087
K_364 X_NUC_4.L_CORE X_NUC_65.L_CORE 0.003304
K_365 X_NUC_4.L_CORE X_NUC_66.L_CORE 0.003299
K_366 X_NUC_4.L_CORE X_NUC_67.L_CORE 0.003279
K_367 X_NUC_4.L_CORE X_NUC_68.L_CORE 0.003258
K_368 X_NUC_4.L_CORE X_NUC_69.L_CORE 0.002765
K_369 X_NUC_4.L_CORE X_NUC_70.L_CORE 0.002750
K_370 X_NUC_4.L_CORE X_NUC_71.L_CORE 0.002729
K_371 X_NUC_4.L_CORE X_NUC_72.L_CORE 0.002744
K_372 X_NUC_4.L_CORE X_NUC_73.L_CORE 0.003033
K_373 X_NUC_4.L_CORE X_NUC_74.L_CORE 0.003047
K_374 X_NUC_4.L_CORE X_NUC_75.L_CORE 0.003008
K_375 X_NUC_4.L_CORE X_NUC_76.L_CORE 0.003013
K_376 X_NUC_4.L_CORE X_NUC_77.L_CORE 0.002823
K_377 X_NUC_4.L_CORE X_NUC_78.L_CORE 0.002809
K_378 X_NUC_4.L_CORE X_NUC_79.L_CORE 0.002793
K_379 X_NUC_4.L_CORE X_NUC_80.L_CORE 0.002789
K_380 X_NUC_4.L_CORE X_NUC_81.L_CORE 0.002677
K_381 X_NUC_4.L_CORE X_NUC_82.L_CORE 0.002674
K_382 X_NUC_4.L_CORE X_NUC_83.L_CORE 0.002647
K_383 X_NUC_4.L_CORE X_NUC_84.L_CORE 0.002660
K_384 X_NUC_4.L_CORE X_NUC_85.L_CORE 0.002756
K_385 X_NUC_4.L_CORE X_NUC_86.L_CORE 0.002755
K_386 X_NUC_4.L_CORE X_NUC_87.L_CORE 0.002730
K_387 X_NUC_4.L_CORE X_NUC_88.L_CORE 0.002730
K_388 X_NUC_4.L_CORE X_NUC_89.L_CORE 0.029763
K_389 X_NUC_4.L_CORE X_NUC_90.L_CORE 0.005540
K_390 X_NUC_4.L_CORE X_NUC_91.L_CORE 0.005688
K_391 X_NUC_4.L_CORE X_NUC_92.L_CORE 0.005890
K_392 X_NUC_4.L_CORE X_NUC_93.L_CORE 0.003596
K_393 X_NUC_4.L_CORE X_NUC_94.L_CORE 0.004798
K_394 X_NUC_4.L_CORE X_NUC_95.L_CORE 0.003511
K_395 X_NUC_4.L_CORE X_NUC_96.L_CORE 0.003184
K_396 X_NUC_4.L_CORE X_NUC_97.L_CORE 0.003727
K_397 X_NUC_4.L_CORE X_NUC_98.L_CORE 0.002769
K_398 X_NUC_4.L_CORE X_NUC_99.L_CORE 0.003034
K_399 X_NUC_4.L_CORE X_NUC_100.L_CORE 0.002867
K_400 X_NUC_4.L_CORE X_NUC_101.L_CORE 0.002525
K_401 X_NUC_4.L_CORE X_NUC_102.L_CORE 0.002720
K_402 X_NUC_4.L_CORE X_NUC_103.L_CORE 0.002452
K_403 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_404 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_405 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_406 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.004888
K_407 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.004997
K_408 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.004912
K_409 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.004955
K_410 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.005988
K_411 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.006068
K_412 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.006076
K_413 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.005927
K_414 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.007489
K_415 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.007500
K_416 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.007301
K_417 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.007542
K_418 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.003689
K_419 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.003753
K_420 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.003713
K_421 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.003703
K_422 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.007249
K_423 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.007146
K_424 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.007166
K_425 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.007009
K_426 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.004000
K_427 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.004046
K_428 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.003974
K_429 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.004026
K_430 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.003632
K_431 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.003672
K_432 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.003652
K_433 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.003612
K_434 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.005734
K_435 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.005662
K_436 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.005582
K_437 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.005641
K_438 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.003086
K_439 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.003126
K_440 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.003086
K_441 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.003094
K_442 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.004056
K_443 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.004058
K_444 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.004045
K_445 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.003991
K_446 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.003746
K_447 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.003757
K_448 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.003695
K_449 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.003739
K_450 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.002895
K_451 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.002925
K_452 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.002898
K_453 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.002886
K_454 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.004100
K_455 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.004072
K_456 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.004040
K_457 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.004029
K_458 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.002898
K_459 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.002922
K_460 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.002881
K_461 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.002897
K_462 X_NUC_5.L_CORE X_NUC_65.L_CORE 0.003022
K_463 X_NUC_5.L_CORE X_NUC_66.L_CORE 0.003036
K_464 X_NUC_5.L_CORE X_NUC_67.L_CORE 0.003015
K_465 X_NUC_5.L_CORE X_NUC_68.L_CORE 0.002993
K_466 X_NUC_5.L_CORE X_NUC_69.L_CORE 0.003366
K_467 X_NUC_5.L_CORE X_NUC_70.L_CORE 0.003362
K_468 X_NUC_5.L_CORE X_NUC_71.L_CORE 0.003319
K_469 X_NUC_5.L_CORE X_NUC_72.L_CORE 0.003337
K_470 X_NUC_5.L_CORE X_NUC_73.L_CORE 0.002635
K_471 X_NUC_5.L_CORE X_NUC_74.L_CORE 0.002655
K_472 X_NUC_5.L_CORE X_NUC_75.L_CORE 0.002627
K_473 X_NUC_5.L_CORE X_NUC_76.L_CORE 0.002626
K_474 X_NUC_5.L_CORE X_NUC_77.L_CORE 0.003071
K_475 X_NUC_5.L_CORE X_NUC_78.L_CORE 0.003072
K_476 X_NUC_5.L_CORE X_NUC_79.L_CORE 0.003046
K_477 X_NUC_5.L_CORE X_NUC_80.L_CORE 0.003035
K_478 X_NUC_5.L_CORE X_NUC_81.L_CORE 0.002780
K_479 X_NUC_5.L_CORE X_NUC_82.L_CORE 0.002791
K_480 X_NUC_5.L_CORE X_NUC_83.L_CORE 0.002757
K_481 X_NUC_5.L_CORE X_NUC_84.L_CORE 0.002766
K_482 X_NUC_5.L_CORE X_NUC_85.L_CORE 0.002660
K_483 X_NUC_5.L_CORE X_NUC_86.L_CORE 0.002671
K_484 X_NUC_5.L_CORE X_NUC_87.L_CORE 0.002645
K_485 X_NUC_5.L_CORE X_NUC_88.L_CORE 0.002641
K_486 X_NUC_5.L_CORE X_NUC_89.L_CORE 0.005975
K_487 X_NUC_5.L_CORE X_NUC_90.L_CORE 0.024655
K_488 X_NUC_5.L_CORE X_NUC_91.L_CORE 0.004090
K_489 X_NUC_5.L_CORE X_NUC_92.L_CORE 0.004788
K_490 X_NUC_5.L_CORE X_NUC_93.L_CORE 0.005490
K_491 X_NUC_5.L_CORE X_NUC_94.L_CORE 0.003066
K_492 X_NUC_5.L_CORE X_NUC_95.L_CORE 0.004915
K_493 X_NUC_5.L_CORE X_NUC_96.L_CORE 0.003207
K_494 X_NUC_5.L_CORE X_NUC_97.L_CORE 0.002942
K_495 X_NUC_5.L_CORE X_NUC_98.L_CORE 0.003828
K_496 X_NUC_5.L_CORE X_NUC_99.L_CORE 0.002567
K_497 X_NUC_5.L_CORE X_NUC_100.L_CORE 0.003000
K_498 X_NUC_5.L_CORE X_NUC_101.L_CORE 0.002810
K_499 X_NUC_5.L_CORE X_NUC_102.L_CORE 0.002441
K_500 X_NUC_5.L_CORE X_NUC_103.L_CORE 0.002661
K_501 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_502 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_503 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.004783
K_504 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.004888
K_505 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.004808
K_506 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.004848
K_507 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.005906
K_508 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.005988
K_509 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.005993
K_510 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.005850
K_511 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.007468
K_512 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.007489
K_513 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.007286
K_514 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.007526
K_515 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.003628
K_516 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.003689
K_517 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.003651
K_518 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.003642
K_519 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.007347
K_520 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.007249
K_521 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.007266
K_522 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.007102
K_523 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.003953
K_524 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.004000
K_525 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.003929
K_526 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.003979
K_527 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.003591
K_528 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.003632
K_529 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.003611
K_530 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.003573
K_531 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.005805
K_532 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.005734
K_533 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.005649
K_534 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.005710
K_535 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.003048
K_536 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.003086
K_537 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.003047
K_538 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.003055
K_539 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.004053
K_540 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.004056
K_541 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.004042
K_542 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.003988
K_543 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.003733
K_544 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.003746
K_545 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.003684
K_546 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.003728
K_547 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.002865
K_548 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.002895
K_549 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.002869
K_550 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.002857
K_551 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.004127
K_552 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.004100
K_553 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.004066
K_554 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.004055
K_555 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.002874
K_556 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.002898
K_557 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.002858
K_558 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.002874
K_559 X_NUC_6.L_CORE X_NUC_65.L_CORE 0.003007
K_560 X_NUC_6.L_CORE X_NUC_66.L_CORE 0.003022
K_561 X_NUC_6.L_CORE X_NUC_67.L_CORE 0.003001
K_562 X_NUC_6.L_CORE X_NUC_68.L_CORE 0.002979
K_563 X_NUC_6.L_CORE X_NUC_69.L_CORE 0.003368
K_564 X_NUC_6.L_CORE X_NUC_70.L_CORE 0.003366
K_565 X_NUC_6.L_CORE X_NUC_71.L_CORE 0.003322
K_566 X_NUC_6.L_CORE X_NUC_72.L_CORE 0.003340
K_567 X_NUC_6.L_CORE X_NUC_73.L_CORE 0.002614
K_568 X_NUC_6.L_CORE X_NUC_74.L_CORE 0.002635
K_569 X_NUC_6.L_CORE X_NUC_75.L_CORE 0.002606
K_570 X_NUC_6.L_CORE X_NUC_76.L_CORE 0.002606
K_571 X_NUC_6.L_CORE X_NUC_77.L_CORE 0.003070
K_572 X_NUC_6.L_CORE X_NUC_78.L_CORE 0.003071
K_573 X_NUC_6.L_CORE X_NUC_79.L_CORE 0.003046
K_574 X_NUC_6.L_CORE X_NUC_80.L_CORE 0.003034
K_575 X_NUC_6.L_CORE X_NUC_81.L_CORE 0.002769
K_576 X_NUC_6.L_CORE X_NUC_82.L_CORE 0.002780
K_577 X_NUC_6.L_CORE X_NUC_83.L_CORE 0.002746
K_578 X_NUC_6.L_CORE X_NUC_84.L_CORE 0.002755
K_579 X_NUC_6.L_CORE X_NUC_85.L_CORE 0.002648
K_580 X_NUC_6.L_CORE X_NUC_86.L_CORE 0.002660
K_581 X_NUC_6.L_CORE X_NUC_87.L_CORE 0.002634
K_582 X_NUC_6.L_CORE X_NUC_88.L_CORE 0.002629
K_583 X_NUC_6.L_CORE X_NUC_89.L_CORE 0.005824
K_584 X_NUC_6.L_CORE X_NUC_90.L_CORE 0.027822
K_585 X_NUC_6.L_CORE X_NUC_91.L_CORE 0.004018
K_586 X_NUC_6.L_CORE X_NUC_92.L_CORE 0.004751
K_587 X_NUC_6.L_CORE X_NUC_93.L_CORE 0.005506
K_588 X_NUC_6.L_CORE X_NUC_94.L_CORE 0.003025
K_589 X_NUC_6.L_CORE X_NUC_95.L_CORE 0.004969
K_590 X_NUC_6.L_CORE X_NUC_96.L_CORE 0.003181
K_591 X_NUC_6.L_CORE X_NUC_97.L_CORE 0.002919
K_592 X_NUC_6.L_CORE X_NUC_98.L_CORE 0.003855
K_593 X_NUC_6.L_CORE X_NUC_99.L_CORE 0.002544
K_594 X_NUC_6.L_CORE X_NUC_100.L_CORE 0.002999
K_595 X_NUC_6.L_CORE X_NUC_101.L_CORE 0.002804
K_596 X_NUC_6.L_CORE X_NUC_102.L_CORE 0.002427
K_597 X_NUC_6.L_CORE X_NUC_103.L_CORE 0.002660
K_598 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_599 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.004861
K_600 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.004970
K_601 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.004888
K_602 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.004929
K_603 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.005898
K_604 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.005977
K_605 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.005988
K_606 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.005843
K_607 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.007682
K_608 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.007699
K_609 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.007489
K_610 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.007744
K_611 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.003665
K_612 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.003728
K_613 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.003689
K_614 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.003679
K_615 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.007325
K_616 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.007223
K_617 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.007249
K_618 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.007082
K_619 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.004025
K_620 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.004073
K_621 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.004000
K_622 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.004052
K_623 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.003611
K_624 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.003651
K_625 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.003632
K_626 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.003592
K_627 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.005895
K_628 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.005819
K_629 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.005734
K_630 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.005796
K_631 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.003086
K_632 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.003126
K_633 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.003086
K_634 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.003095
K_635 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.004066
K_636 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.004068
K_637 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.004056
K_638 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.004001
K_639 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.003797
K_640 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.003810
K_641 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.003746
K_642 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.003791
K_643 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.002891
K_644 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.002921
K_645 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.002895
K_646 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.002882
K_647 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.004162
K_648 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.004134
K_649 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.004100
K_650 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.004088
K_651 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.002914
K_652 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.002938
K_653 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.002898
K_654 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.002913
K_655 X_NUC_7.L_CORE X_NUC_65.L_CORE 0.003027
K_656 X_NUC_7.L_CORE X_NUC_66.L_CORE 0.003042
K_657 X_NUC_7.L_CORE X_NUC_67.L_CORE 0.003022
K_658 X_NUC_7.L_CORE X_NUC_68.L_CORE 0.002999
K_659 X_NUC_7.L_CORE X_NUC_69.L_CORE 0.003413
K_660 X_NUC_7.L_CORE X_NUC_70.L_CORE 0.003410
K_661 X_NUC_7.L_CORE X_NUC_71.L_CORE 0.003366
K_662 X_NUC_7.L_CORE X_NUC_72.L_CORE 0.003384
K_663 X_NUC_7.L_CORE X_NUC_73.L_CORE 0.002642
K_664 X_NUC_7.L_CORE X_NUC_74.L_CORE 0.002663
K_665 X_NUC_7.L_CORE X_NUC_75.L_CORE 0.002635
K_666 X_NUC_7.L_CORE X_NUC_76.L_CORE 0.002634
K_667 X_NUC_7.L_CORE X_NUC_77.L_CORE 0.003095
K_668 X_NUC_7.L_CORE X_NUC_78.L_CORE 0.003096
K_669 X_NUC_7.L_CORE X_NUC_79.L_CORE 0.003071
K_670 X_NUC_7.L_CORE X_NUC_80.L_CORE 0.003059
K_671 X_NUC_7.L_CORE X_NUC_81.L_CORE 0.002804
K_672 X_NUC_7.L_CORE X_NUC_82.L_CORE 0.002815
K_673 X_NUC_7.L_CORE X_NUC_83.L_CORE 0.002780
K_674 X_NUC_7.L_CORE X_NUC_84.L_CORE 0.002789
K_675 X_NUC_7.L_CORE X_NUC_85.L_CORE 0.002674
K_676 X_NUC_7.L_CORE X_NUC_86.L_CORE 0.002686
K_677 X_NUC_7.L_CORE X_NUC_87.L_CORE 0.002660
K_678 X_NUC_7.L_CORE X_NUC_88.L_CORE 0.002655
K_679 X_NUC_7.L_CORE X_NUC_89.L_CORE 0.005840
K_680 X_NUC_7.L_CORE X_NUC_90.L_CORE 0.025448
K_681 X_NUC_7.L_CORE X_NUC_91.L_CORE 0.004074
K_682 X_NUC_7.L_CORE X_NUC_92.L_CORE 0.004737
K_683 X_NUC_7.L_CORE X_NUC_93.L_CORE 0.005610
K_684 X_NUC_7.L_CORE X_NUC_94.L_CORE 0.003052
K_685 X_NUC_7.L_CORE X_NUC_95.L_CORE 0.004964
K_686 X_NUC_7.L_CORE X_NUC_96.L_CORE 0.003229
K_687 X_NUC_7.L_CORE X_NUC_97.L_CORE 0.002935
K_688 X_NUC_7.L_CORE X_NUC_98.L_CORE 0.003897
K_689 X_NUC_7.L_CORE X_NUC_99.L_CORE 0.002573
K_690 X_NUC_7.L_CORE X_NUC_100.L_CORE 0.003015
K_691 X_NUC_7.L_CORE X_NUC_101.L_CORE 0.002840
K_692 X_NUC_7.L_CORE X_NUC_102.L_CORE 0.002449
K_693 X_NUC_7.L_CORE X_NUC_103.L_CORE 0.002684
K_694 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.004821
K_695 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.004927
K_696 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.004846
K_697 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.004888
K_698 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.006045
K_699 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.006130
K_700 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.006139
K_701 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.005988
K_702 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.007428
K_703 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.007444
K_704 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.007249
K_705 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.007489
K_706 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.003674
K_707 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.003738
K_708 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.003699
K_709 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.003689
K_710 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.007504
K_711 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.007395
K_712 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.007418
K_713 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.007249
K_714 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.003973
K_715 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.004019
K_716 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.003948
K_717 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.004000
K_718 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.003651
K_719 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.003693
K_720 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.003672
K_721 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.003632
K_722 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.005829
K_723 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.005755
K_724 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.005671
K_725 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.005734
K_726 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.003078
K_727 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.003117
K_728 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.003077
K_729 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.003086
K_730 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.004123
K_731 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.004126
K_732 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.004112
K_733 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.004056
K_734 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.003751
K_735 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.003763
K_736 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.003701
K_737 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.003746
K_738 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.002903
K_739 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.002934
K_740 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.002907
K_741 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.002895
K_742 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.004174
K_743 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.004146
K_744 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.004111
K_745 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.004100
K_746 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.002898
K_747 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.002922
K_748 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.002882
K_749 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.002898
K_750 X_NUC_8.L_CORE X_NUC_65.L_CORE 0.003050
K_751 X_NUC_8.L_CORE X_NUC_66.L_CORE 0.003065
K_752 X_NUC_8.L_CORE X_NUC_67.L_CORE 0.003044
K_753 X_NUC_8.L_CORE X_NUC_68.L_CORE 0.003022
K_754 X_NUC_8.L_CORE X_NUC_69.L_CORE 0.003394
K_755 X_NUC_8.L_CORE X_NUC_70.L_CORE 0.003391
K_756 X_NUC_8.L_CORE X_NUC_71.L_CORE 0.003347
K_757 X_NUC_8.L_CORE X_NUC_72.L_CORE 0.003366
K_758 X_NUC_8.L_CORE X_NUC_73.L_CORE 0.002643
K_759 X_NUC_8.L_CORE X_NUC_74.L_CORE 0.002664
K_760 X_NUC_8.L_CORE X_NUC_75.L_CORE 0.002635
K_761 X_NUC_8.L_CORE X_NUC_76.L_CORE 0.002635
K_762 X_NUC_8.L_CORE X_NUC_77.L_CORE 0.003108
K_763 X_NUC_8.L_CORE X_NUC_78.L_CORE 0.003109
K_764 X_NUC_8.L_CORE X_NUC_79.L_CORE 0.003083
K_765 X_NUC_8.L_CORE X_NUC_80.L_CORE 0.003071
K_766 X_NUC_8.L_CORE X_NUC_81.L_CORE 0.002794
K_767 X_NUC_8.L_CORE X_NUC_82.L_CORE 0.002805
K_768 X_NUC_8.L_CORE X_NUC_83.L_CORE 0.002770
K_769 X_NUC_8.L_CORE X_NUC_84.L_CORE 0.002780
K_770 X_NUC_8.L_CORE X_NUC_85.L_CORE 0.002678
K_771 X_NUC_8.L_CORE X_NUC_86.L_CORE 0.002690
K_772 X_NUC_8.L_CORE X_NUC_87.L_CORE 0.002664
K_773 X_NUC_8.L_CORE X_NUC_88.L_CORE 0.002660
K_774 X_NUC_8.L_CORE X_NUC_89.L_CORE 0.005899
K_775 X_NUC_8.L_CORE X_NUC_90.L_CORE 0.025321
K_776 X_NUC_8.L_CORE X_NUC_91.L_CORE 0.004041
K_777 X_NUC_8.L_CORE X_NUC_92.L_CORE 0.004838
K_778 X_NUC_8.L_CORE X_NUC_93.L_CORE 0.005477
K_779 X_NUC_8.L_CORE X_NUC_94.L_CORE 0.003059
K_780 X_NUC_8.L_CORE X_NUC_95.L_CORE 0.005033
K_781 X_NUC_8.L_CORE X_NUC_96.L_CORE 0.003196
K_782 X_NUC_8.L_CORE X_NUC_97.L_CORE 0.002960
K_783 X_NUC_8.L_CORE X_NUC_98.L_CORE 0.003875
K_784 X_NUC_8.L_CORE X_NUC_99.L_CORE 0.002568
K_785 X_NUC_8.L_CORE X_NUC_100.L_CORE 0.003037
K_786 X_NUC_8.L_CORE X_NUC_101.L_CORE 0.002823
K_787 X_NUC_8.L_CORE X_NUC_102.L_CORE 0.002454
K_788 X_NUC_8.L_CORE X_NUC_103.L_CORE 0.002686
K_789 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_790 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_791 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_792 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.004081
K_793 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.004045
K_794 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.004094
K_795 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.004024
K_796 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.005220
K_797 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.005098
K_798 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.005125
K_799 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.005157
K_800 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.006976
K_801 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.007087
K_802 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.007063
K_803 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.006877
K_804 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.003291
K_805 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.003250
K_806 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.003276
K_807 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.003248
K_808 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.007425
K_809 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.007346
K_810 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.007180
K_811 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.007356
K_812 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.003714
K_813 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.003710
K_814 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.003724
K_815 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.003664
K_816 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.003387
K_817 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.003337
K_818 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.003346
K_819 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.003345
K_820 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006065
K_821 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006158
K_822 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006011
K_823 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.005998
K_824 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.002895
K_825 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.002873
K_826 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.002885
K_827 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.002857
K_828 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.004024
K_829 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.003980
K_830 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.003948
K_831 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.003980
K_832 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.003703
K_833 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.003718
K_834 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.003699
K_835 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.003656
K_836 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.002773
K_837 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.002745
K_838 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.002750
K_839 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.002739
K_840 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.004255
K_841 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.004259
K_842 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.004187
K_843 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.004209
K_844 X_NUC_9.L_CORE X_NUC_65.L_CORE 0.002825
K_845 X_NUC_9.L_CORE X_NUC_66.L_CORE 0.002816
K_846 X_NUC_9.L_CORE X_NUC_67.L_CORE 0.002815
K_847 X_NUC_9.L_CORE X_NUC_68.L_CORE 0.002789
K_848 X_NUC_9.L_CORE X_NUC_69.L_CORE 0.002987
K_849 X_NUC_9.L_CORE X_NUC_70.L_CORE 0.002961
K_850 X_NUC_9.L_CORE X_NUC_71.L_CORE 0.002949
K_851 X_NUC_9.L_CORE X_NUC_72.L_CORE 0.002952
K_852 X_NUC_9.L_CORE X_NUC_73.L_CORE 0.003405
K_853 X_NUC_9.L_CORE X_NUC_74.L_CORE 0.003413
K_854 X_NUC_9.L_CORE X_NUC_75.L_CORE 0.003379
K_855 X_NUC_9.L_CORE X_NUC_76.L_CORE 0.003365
K_856 X_NUC_9.L_CORE X_NUC_77.L_CORE 0.002606
K_857 X_NUC_9.L_CORE X_NUC_78.L_CORE 0.002591
K_858 X_NUC_9.L_CORE X_NUC_79.L_CORE 0.002588
K_859 X_NUC_9.L_CORE X_NUC_80.L_CORE 0.002574
K_860 X_NUC_9.L_CORE X_NUC_81.L_CORE 0.003071
K_861 X_NUC_9.L_CORE X_NUC_82.L_CORE 0.003059
K_862 X_NUC_9.L_CORE X_NUC_83.L_CORE 0.003033
K_863 X_NUC_9.L_CORE X_NUC_84.L_CORE 0.003036
K_864 X_NUC_9.L_CORE X_NUC_85.L_CORE 0.002789
K_865 X_NUC_9.L_CORE X_NUC_86.L_CORE 0.002783
K_866 X_NUC_9.L_CORE X_NUC_87.L_CORE 0.002768
K_867 X_NUC_9.L_CORE X_NUC_88.L_CORE 0.002756
K_868 X_NUC_9.L_CORE X_NUC_89.L_CORE 0.006592
K_869 X_NUC_9.L_CORE X_NUC_90.L_CORE 0.004135
K_870 X_NUC_9.L_CORE X_NUC_91.L_CORE 0.023670
K_871 X_NUC_9.L_CORE X_NUC_92.L_CORE 0.003418
K_872 X_NUC_9.L_CORE X_NUC_93.L_CORE 0.004196
K_873 X_NUC_9.L_CORE X_NUC_94.L_CORE 0.005221
K_874 X_NUC_9.L_CORE X_NUC_95.L_CORE 0.002751
K_875 X_NUC_9.L_CORE X_NUC_96.L_CORE 0.004926
K_876 X_NUC_9.L_CORE X_NUC_97.L_CORE 0.003020
K_877 X_NUC_9.L_CORE X_NUC_98.L_CORE 0.002773
K_878 X_NUC_9.L_CORE X_NUC_99.L_CORE 0.003882
K_879 X_NUC_9.L_CORE X_NUC_100.L_CORE 0.002457
K_880 X_NUC_9.L_CORE X_NUC_101.L_CORE 0.002951
K_881 X_NUC_9.L_CORE X_NUC_102.L_CORE 0.002770
K_882 X_NUC_9.L_CORE X_NUC_103.L_CORE 0.002449
K_883 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_884 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_885 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.004118
K_886 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.004081
K_887 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.004131
K_888 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.004060
K_889 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.005347
K_890 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.005220
K_891 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.005247
K_892 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.005281
K_893 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.006862
K_894 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.006976
K_895 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.006949
K_896 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.006771
K_897 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.003334
K_898 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.003291
K_899 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.003318
K_900 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.003289
K_901 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.007497
K_902 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.007425
K_903 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.007250
K_904 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.007431
K_905 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.003717
K_906 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.003714
K_907 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.003728
K_908 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.003667
K_909 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.003438
K_910 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.003387
K_911 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.003396
K_912 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.003395
K_913 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.005972
K_914 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006065
K_915 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.005923
K_916 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.005910
K_917 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.002916
K_918 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.002895
K_919 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.002907
K_920 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.002878
K_921 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.004069
K_922 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.004024
K_923 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.003991
K_924 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.004024
K_925 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.003687
K_926 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.003703
K_927 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.003684
K_928 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.003641
K_929 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.002801
K_930 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.002773
K_931 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.002777
K_932 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.002766
K_933 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.004249
K_934 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.004255
K_935 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.004183
K_936 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.004204
K_937 X_NUC_10.L_CORE X_NUC_65.L_CORE 0.002833
K_938 X_NUC_10.L_CORE X_NUC_66.L_CORE 0.002825
K_939 X_NUC_10.L_CORE X_NUC_67.L_CORE 0.002823
K_940 X_NUC_10.L_CORE X_NUC_68.L_CORE 0.002797
K_941 X_NUC_10.L_CORE X_NUC_69.L_CORE 0.003014
K_942 X_NUC_10.L_CORE X_NUC_70.L_CORE 0.002987
K_943 X_NUC_10.L_CORE X_NUC_71.L_CORE 0.002975
K_944 X_NUC_10.L_CORE X_NUC_72.L_CORE 0.002978
K_945 X_NUC_10.L_CORE X_NUC_73.L_CORE 0.003396
K_946 X_NUC_10.L_CORE X_NUC_74.L_CORE 0.003405
K_947 X_NUC_10.L_CORE X_NUC_75.L_CORE 0.003371
K_948 X_NUC_10.L_CORE X_NUC_76.L_CORE 0.003356
K_949 X_NUC_10.L_CORE X_NUC_77.L_CORE 0.002622
K_950 X_NUC_10.L_CORE X_NUC_78.L_CORE 0.002606
K_951 X_NUC_10.L_CORE X_NUC_79.L_CORE 0.002603
K_952 X_NUC_10.L_CORE X_NUC_80.L_CORE 0.002590
K_953 X_NUC_10.L_CORE X_NUC_81.L_CORE 0.003082
K_954 X_NUC_10.L_CORE X_NUC_82.L_CORE 0.003071
K_955 X_NUC_10.L_CORE X_NUC_83.L_CORE 0.003045
K_956 X_NUC_10.L_CORE X_NUC_84.L_CORE 0.003047
K_957 X_NUC_10.L_CORE X_NUC_85.L_CORE 0.002795
K_958 X_NUC_10.L_CORE X_NUC_86.L_CORE 0.002789
K_959 X_NUC_10.L_CORE X_NUC_87.L_CORE 0.002774
K_960 X_NUC_10.L_CORE X_NUC_88.L_CORE 0.002761
K_961 X_NUC_10.L_CORE X_NUC_89.L_CORE 0.006643
K_962 X_NUC_10.L_CORE X_NUC_90.L_CORE 0.004214
K_963 X_NUC_10.L_CORE X_NUC_91.L_CORE 0.021774
K_964 X_NUC_10.L_CORE X_NUC_92.L_CORE 0.003441
K_965 X_NUC_10.L_CORE X_NUC_93.L_CORE 0.004273
K_966 X_NUC_10.L_CORE X_NUC_94.L_CORE 0.005144
K_967 X_NUC_10.L_CORE X_NUC_95.L_CORE 0.002780
K_968 X_NUC_10.L_CORE X_NUC_96.L_CORE 0.004941
K_969 X_NUC_10.L_CORE X_NUC_97.L_CORE 0.003020
K_970 X_NUC_10.L_CORE X_NUC_98.L_CORE 0.002803
K_971 X_NUC_10.L_CORE X_NUC_99.L_CORE 0.003854
K_972 X_NUC_10.L_CORE X_NUC_100.L_CORE 0.002470
K_973 X_NUC_10.L_CORE X_NUC_101.L_CORE 0.002968
K_974 X_NUC_10.L_CORE X_NUC_102.L_CORE 0.002768
K_975 X_NUC_10.L_CORE X_NUC_103.L_CORE 0.002461
K_976 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_977 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.004068
K_978 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.004032
K_979 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.004081
K_980 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.004011
K_981 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.005316
K_982 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.005190
K_983 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.005220
K_984 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.005252
K_985 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.006885
K_986 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.006995
K_987 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.006976
K_988 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.006793
K_989 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.003306
K_990 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.003264
K_991 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.003291
K_992 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.003263
K_993 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.007687
K_994 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.007604
K_995 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.007425
K_996 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.007615
K_997 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.003703
K_998 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.003699
K_999 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.003714
K_1000 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.003654
K_1001 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.003428
K_1002 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.003377
K_1003 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.003387
K_1004 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.003385
K_1005 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006116
K_1006 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006214
K_1007 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006065
K_1008 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006049
K_1009 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.002904
K_1010 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.002882
K_1011 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.002895
K_1012 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.002866
K_1013 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.004103
K_1014 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.004057
K_1015 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.004024
K_1016 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.004057
K_1017 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.003706
K_1018 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.003722
K_1019 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.003703
K_1020 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.003660
K_1021 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.002797
K_1022 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.002769
K_1023 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.002773
K_1024 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.002762
K_1025 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.004324
K_1026 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.004329
K_1027 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.004255
K_1028 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.004276
K_1029 X_NUC_11.L_CORE X_NUC_65.L_CORE 0.002834
K_1030 X_NUC_11.L_CORE X_NUC_66.L_CORE 0.002826
K_1031 X_NUC_11.L_CORE X_NUC_67.L_CORE 0.002825
K_1032 X_NUC_11.L_CORE X_NUC_68.L_CORE 0.002799
K_1033 X_NUC_11.L_CORE X_NUC_69.L_CORE 0.003026
K_1034 X_NUC_11.L_CORE X_NUC_70.L_CORE 0.002999
K_1035 X_NUC_11.L_CORE X_NUC_71.L_CORE 0.002987
K_1036 X_NUC_11.L_CORE X_NUC_72.L_CORE 0.002990
K_1037 X_NUC_11.L_CORE X_NUC_73.L_CORE 0.003430
K_1038 X_NUC_11.L_CORE X_NUC_74.L_CORE 0.003439
K_1039 X_NUC_11.L_CORE X_NUC_75.L_CORE 0.003405
K_1040 X_NUC_11.L_CORE X_NUC_76.L_CORE 0.003390
K_1041 X_NUC_11.L_CORE X_NUC_77.L_CORE 0.002625
K_1042 X_NUC_11.L_CORE X_NUC_78.L_CORE 0.002610
K_1043 X_NUC_11.L_CORE X_NUC_79.L_CORE 0.002606
K_1044 X_NUC_11.L_CORE X_NUC_80.L_CORE 0.002593
K_1045 X_NUC_11.L_CORE X_NUC_81.L_CORE 0.003109
K_1046 X_NUC_11.L_CORE X_NUC_82.L_CORE 0.003097
K_1047 X_NUC_11.L_CORE X_NUC_83.L_CORE 0.003071
K_1048 X_NUC_11.L_CORE X_NUC_84.L_CORE 0.003073
K_1049 X_NUC_11.L_CORE X_NUC_85.L_CORE 0.002810
K_1050 X_NUC_11.L_CORE X_NUC_86.L_CORE 0.002804
K_1051 X_NUC_11.L_CORE X_NUC_87.L_CORE 0.002789
K_1052 X_NUC_11.L_CORE X_NUC_88.L_CORE 0.002776
K_1053 X_NUC_11.L_CORE X_NUC_89.L_CORE 0.006470
K_1054 X_NUC_11.L_CORE X_NUC_90.L_CORE 0.004154
K_1055 X_NUC_11.L_CORE X_NUC_91.L_CORE 0.023496
K_1056 X_NUC_11.L_CORE X_NUC_92.L_CORE 0.003408
K_1057 X_NUC_11.L_CORE X_NUC_93.L_CORE 0.004266
K_1058 X_NUC_11.L_CORE X_NUC_94.L_CORE 0.005182
K_1059 X_NUC_11.L_CORE X_NUC_95.L_CORE 0.002764
K_1060 X_NUC_11.L_CORE X_NUC_96.L_CORE 0.005036
K_1061 X_NUC_11.L_CORE X_NUC_97.L_CORE 0.003018
K_1062 X_NUC_11.L_CORE X_NUC_98.L_CORE 0.002804
K_1063 X_NUC_11.L_CORE X_NUC_99.L_CORE 0.003914
K_1064 X_NUC_11.L_CORE X_NUC_100.L_CORE 0.002469
K_1065 X_NUC_11.L_CORE X_NUC_101.L_CORE 0.002991
K_1066 X_NUC_11.L_CORE X_NUC_102.L_CORE 0.002785
K_1067 X_NUC_11.L_CORE X_NUC_103.L_CORE 0.002470
K_1068 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.004140
K_1069 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.004102
K_1070 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.004154
K_1071 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.004081
K_1072 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.005282
K_1073 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.005157
K_1074 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.005185
K_1075 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.005220
K_1076 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.007071
K_1077 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.007191
K_1078 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.007166
K_1079 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.006976
K_1080 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.003335
K_1081 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.003292
K_1082 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.003319
K_1083 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.003291
K_1084 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.007487
K_1085 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.007410
K_1086 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.007240
K_1087 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.007425
K_1088 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.003765
K_1089 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.003761
K_1090 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.003776
K_1091 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.003714
K_1092 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.003429
K_1093 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.003378
K_1094 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.003387
K_1095 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.003387
K_1096 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006130
K_1097 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006229
K_1098 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006077
K_1099 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006065
K_1100 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.002933
K_1101 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.002911
K_1102 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.002924
K_1103 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.002895
K_1104 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.004069
K_1105 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.004023
K_1106 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.003991
K_1107 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.004024
K_1108 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.003751
K_1109 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.003767
K_1110 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.003747
K_1111 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.003703
K_1112 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.002808
K_1113 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.002780
K_1114 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.002784
K_1115 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.002773
K_1116 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.004300
K_1117 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.004306
K_1118 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.004232
K_1119 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.004255
K_1120 X_NUC_12.L_CORE X_NUC_65.L_CORE 0.002861
K_1121 X_NUC_12.L_CORE X_NUC_66.L_CORE 0.002853
K_1122 X_NUC_12.L_CORE X_NUC_67.L_CORE 0.002851
K_1123 X_NUC_12.L_CORE X_NUC_68.L_CORE 0.002825
K_1124 X_NUC_12.L_CORE X_NUC_69.L_CORE 0.003023
K_1125 X_NUC_12.L_CORE X_NUC_70.L_CORE 0.002996
K_1126 X_NUC_12.L_CORE X_NUC_71.L_CORE 0.002984
K_1127 X_NUC_12.L_CORE X_NUC_72.L_CORE 0.002987
K_1128 X_NUC_12.L_CORE X_NUC_73.L_CORE 0.003446
K_1129 X_NUC_12.L_CORE X_NUC_74.L_CORE 0.003455
K_1130 X_NUC_12.L_CORE X_NUC_75.L_CORE 0.003419
K_1131 X_NUC_12.L_CORE X_NUC_76.L_CORE 0.003405
K_1132 X_NUC_12.L_CORE X_NUC_77.L_CORE 0.002639
K_1133 X_NUC_12.L_CORE X_NUC_78.L_CORE 0.002623
K_1134 X_NUC_12.L_CORE X_NUC_79.L_CORE 0.002620
K_1135 X_NUC_12.L_CORE X_NUC_80.L_CORE 0.002606
K_1136 X_NUC_12.L_CORE X_NUC_81.L_CORE 0.003107
K_1137 X_NUC_12.L_CORE X_NUC_82.L_CORE 0.003095
K_1138 X_NUC_12.L_CORE X_NUC_83.L_CORE 0.003068
K_1139 X_NUC_12.L_CORE X_NUC_84.L_CORE 0.003071
K_1140 X_NUC_12.L_CORE X_NUC_85.L_CORE 0.002823
K_1141 X_NUC_12.L_CORE X_NUC_86.L_CORE 0.002817
K_1142 X_NUC_12.L_CORE X_NUC_87.L_CORE 0.002802
K_1143 X_NUC_12.L_CORE X_NUC_88.L_CORE 0.002789
K_1144 X_NUC_12.L_CORE X_NUC_89.L_CORE 0.006653
K_1145 X_NUC_12.L_CORE X_NUC_90.L_CORE 0.004179
K_1146 X_NUC_12.L_CORE X_NUC_91.L_CORE 0.021908
K_1147 X_NUC_12.L_CORE X_NUC_92.L_CORE 0.003460
K_1148 X_NUC_12.L_CORE X_NUC_93.L_CORE 0.004233
K_1149 X_NUC_12.L_CORE X_NUC_94.L_CORE 0.005268
K_1150 X_NUC_12.L_CORE X_NUC_95.L_CORE 0.002784
K_1151 X_NUC_12.L_CORE X_NUC_96.L_CORE 0.004955
K_1152 X_NUC_12.L_CORE X_NUC_97.L_CORE 0.003056
K_1153 X_NUC_12.L_CORE X_NUC_98.L_CORE 0.002803
K_1154 X_NUC_12.L_CORE X_NUC_99.L_CORE 0.003917
K_1155 X_NUC_12.L_CORE X_NUC_100.L_CORE 0.002486
K_1156 X_NUC_12.L_CORE X_NUC_101.L_CORE 0.002981
K_1157 X_NUC_12.L_CORE X_NUC_102.L_CORE 0.002801
K_1158 X_NUC_12.L_CORE X_NUC_103.L_CORE 0.002477
K_1159 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_1160 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_1161 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_1162 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.003628
K_1163 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.003611
K_1164 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.003586
K_1165 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.003647
K_1166 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.004744
K_1167 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.004838
K_1168 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.004750
K_1169 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.004804
K_1170 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.006568
K_1171 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.006390
K_1172 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.006395
K_1173 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.006461
K_1174 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.003044
K_1175 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.003054
K_1176 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.003021
K_1177 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.003064
K_1178 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.007462
K_1179 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.007659
K_1180 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.007462
K_1181 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.007402
K_1182 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.003522
K_1183 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.003489
K_1184 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.003468
K_1185 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.003512
K_1186 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.003225
K_1187 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.003258
K_1188 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.003211
K_1189 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.003244
K_1190 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006279
K_1191 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006194
K_1192 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006140
K_1193 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006106
K_1194 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.002776
K_1195 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.002773
K_1196 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.002747
K_1197 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.002779
K_1198 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.003991
K_1199 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.004045
K_1200 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.003973
K_1201 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.003985
K_1202 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.003669
K_1203 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.003631
K_1204 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.003606
K_1205 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.003630
K_1206 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.002705
K_1207 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.002717
K_1208 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.002684
K_1209 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.002710
K_1210 X_NUC_13.L_CORE X_NUC_65.L_CORE 0.004337
K_1211 X_NUC_13.L_CORE X_NUC_66.L_CORE 0.004349
K_1212 X_NUC_13.L_CORE X_NUC_67.L_CORE 0.004286
K_1213 X_NUC_13.L_CORE X_NUC_68.L_CORE 0.004276
K_1214 X_NUC_13.L_CORE X_NUC_69.L_CORE 0.002792
K_1215 X_NUC_13.L_CORE X_NUC_70.L_CORE 0.002782
K_1216 X_NUC_13.L_CORE X_NUC_71.L_CORE 0.002757
K_1217 X_NUC_13.L_CORE X_NUC_72.L_CORE 0.002782
K_1218 X_NUC_13.L_CORE X_NUC_73.L_CORE 0.002976
K_1219 X_NUC_13.L_CORE X_NUC_74.L_CORE 0.002996
K_1220 X_NUC_13.L_CORE X_NUC_75.L_CORE 0.002954
K_1221 X_NUC_13.L_CORE X_NUC_76.L_CORE 0.002971
K_1222 X_NUC_13.L_CORE X_NUC_77.L_CORE 0.003405
K_1223 X_NUC_13.L_CORE X_NUC_78.L_CORE 0.003391
K_1224 X_NUC_13.L_CORE X_NUC_79.L_CORE 0.003356
K_1225 X_NUC_13.L_CORE X_NUC_80.L_CORE 0.003366
K_1226 X_NUC_13.L_CORE X_NUC_81.L_CORE 0.002635
K_1227 X_NUC_13.L_CORE X_NUC_82.L_CORE 0.002637
K_1228 X_NUC_13.L_CORE X_NUC_83.L_CORE 0.002607
K_1229 X_NUC_13.L_CORE X_NUC_84.L_CORE 0.002627
K_1230 X_NUC_13.L_CORE X_NUC_85.L_CORE 0.003013
K_1231 X_NUC_13.L_CORE X_NUC_86.L_CORE 0.003020
K_1232 X_NUC_13.L_CORE X_NUC_87.L_CORE 0.002982
K_1233 X_NUC_13.L_CORE X_NUC_88.L_CORE 0.002994
K_1234 X_NUC_13.L_CORE X_NUC_89.L_CORE 0.007512
K_1235 X_NUC_13.L_CORE X_NUC_90.L_CORE 0.005209
K_1236 X_NUC_13.L_CORE X_NUC_91.L_CORE 0.003512
K_1237 X_NUC_13.L_CORE X_NUC_92.L_CORE 0.019937
K_1238 X_NUC_13.L_CORE X_NUC_93.L_CORE 0.003074
K_1239 X_NUC_13.L_CORE X_NUC_94.L_CORE 0.003932
K_1240 X_NUC_13.L_CORE X_NUC_95.L_CORE 0.004876
K_1241 X_NUC_13.L_CORE X_NUC_96.L_CORE 0.002601
K_1242 X_NUC_13.L_CORE X_NUC_97.L_CORE 0.004888
K_1243 X_NUC_13.L_CORE X_NUC_98.L_CORE 0.002900
K_1244 X_NUC_13.L_CORE X_NUC_99.L_CORE 0.002715
K_1245 X_NUC_13.L_CORE X_NUC_100.L_CORE 0.003810
K_1246 X_NUC_13.L_CORE X_NUC_101.L_CORE 0.002431
K_1247 X_NUC_13.L_CORE X_NUC_102.L_CORE 0.002919
K_1248 X_NUC_13.L_CORE X_NUC_103.L_CORE 0.002718
K_1249 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_1250 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_1251 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.003643
K_1252 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.003628
K_1253 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.003602
K_1254 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.003664
K_1255 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.004653
K_1256 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.004744
K_1257 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.004659
K_1258 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.004710
K_1259 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.006754
K_1260 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.006568
K_1261 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.006570
K_1262 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.006641
K_1263 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.003034
K_1264 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.003044
K_1265 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.003012
K_1266 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.003053
K_1267 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.007271
K_1268 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.007462
K_1269 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.007275
K_1270 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.007219
K_1271 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.003555
K_1272 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.003522
K_1273 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.003500
K_1274 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.003545
K_1275 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.003194
K_1276 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.003225
K_1277 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.003180
K_1278 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.003212
K_1279 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006362
K_1280 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006279
K_1281 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006220
K_1282 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006185
K_1283 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.002779
K_1284 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.002776
K_1285 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.002750
K_1286 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.002783
K_1287 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.003937
K_1288 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.003991
K_1289 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.003921
K_1290 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.003933
K_1291 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.003707
K_1292 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.003669
K_1293 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.003642
K_1294 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.003668
K_1295 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.002693
K_1296 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.002705
K_1297 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.002672
K_1298 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.002698
K_1299 X_NUC_14.L_CORE X_NUC_65.L_CORE 0.004324
K_1300 X_NUC_14.L_CORE X_NUC_66.L_CORE 0.004337
K_1301 X_NUC_14.L_CORE X_NUC_67.L_CORE 0.004274
K_1302 X_NUC_14.L_CORE X_NUC_68.L_CORE 0.004264
K_1303 X_NUC_14.L_CORE X_NUC_69.L_CORE 0.002802
K_1304 X_NUC_14.L_CORE X_NUC_70.L_CORE 0.002792
K_1305 X_NUC_14.L_CORE X_NUC_71.L_CORE 0.002767
K_1306 X_NUC_14.L_CORE X_NUC_72.L_CORE 0.002792
K_1307 X_NUC_14.L_CORE X_NUC_73.L_CORE 0.002956
K_1308 X_NUC_14.L_CORE X_NUC_74.L_CORE 0.002976
K_1309 X_NUC_14.L_CORE X_NUC_75.L_CORE 0.002935
K_1310 X_NUC_14.L_CORE X_NUC_76.L_CORE 0.002952
K_1311 X_NUC_14.L_CORE X_NUC_77.L_CORE 0.003418
K_1312 X_NUC_14.L_CORE X_NUC_78.L_CORE 0.003405
K_1313 X_NUC_14.L_CORE X_NUC_79.L_CORE 0.003369
K_1314 X_NUC_14.L_CORE X_NUC_80.L_CORE 0.003380
K_1315 X_NUC_14.L_CORE X_NUC_81.L_CORE 0.002632
K_1316 X_NUC_14.L_CORE X_NUC_82.L_CORE 0.002635
K_1317 X_NUC_14.L_CORE X_NUC_83.L_CORE 0.002605
K_1318 X_NUC_14.L_CORE X_NUC_84.L_CORE 0.002625
K_1319 X_NUC_14.L_CORE X_NUC_85.L_CORE 0.003006
K_1320 X_NUC_14.L_CORE X_NUC_86.L_CORE 0.003013
K_1321 X_NUC_14.L_CORE X_NUC_87.L_CORE 0.002975
K_1322 X_NUC_14.L_CORE X_NUC_88.L_CORE 0.002987
K_1323 X_NUC_14.L_CORE X_NUC_89.L_CORE 0.007364
K_1324 X_NUC_14.L_CORE X_NUC_90.L_CORE 0.005289
K_1325 X_NUC_14.L_CORE X_NUC_91.L_CORE 0.003483
K_1326 X_NUC_14.L_CORE X_NUC_92.L_CORE 0.020180
K_1327 X_NUC_14.L_CORE X_NUC_93.L_CORE 0.003088
K_1328 X_NUC_14.L_CORE X_NUC_94.L_CORE 0.003868
K_1329 X_NUC_14.L_CORE X_NUC_95.L_CORE 0.004975
K_1330 X_NUC_14.L_CORE X_NUC_96.L_CORE 0.002594
K_1331 X_NUC_14.L_CORE X_NUC_97.L_CORE 0.004827
K_1332 X_NUC_14.L_CORE X_NUC_98.L_CORE 0.002921
K_1333 X_NUC_14.L_CORE X_NUC_99.L_CORE 0.002695
K_1334 X_NUC_14.L_CORE X_NUC_100.L_CORE 0.003828
K_1335 X_NUC_14.L_CORE X_NUC_101.L_CORE 0.002433
K_1336 X_NUC_14.L_CORE X_NUC_102.L_CORE 0.002903
K_1337 X_NUC_14.L_CORE X_NUC_103.L_CORE 0.002724
K_1338 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_1339 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.003669
K_1340 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.003653
K_1341 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.003628
K_1342 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.003690
K_1343 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.004735
K_1344 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.004830
K_1345 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.004744
K_1346 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.004796
K_1347 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.006748
K_1348 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.006559
K_1349 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.006568
K_1350 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.006636
K_1351 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.003067
K_1352 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.003077
K_1353 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.003044
K_1354 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.003087
K_1355 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.007453
K_1356 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.007655
K_1357 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.007462
K_1358 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.007398
K_1359 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.003577
K_1360 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.003543
K_1361 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.003522
K_1362 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.003567
K_1363 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.003240
K_1364 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.003273
K_1365 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.003225
K_1366 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.003259
K_1367 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006422
K_1368 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006334
K_1369 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006279
K_1370 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.006240
K_1371 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.002806
K_1372 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.002803
K_1373 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.002776
K_1374 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.002810
K_1375 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.004007
K_1376 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.004062
K_1377 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.003991
K_1378 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.004002
K_1379 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.003734
K_1380 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.003694
K_1381 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.003669
K_1382 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.003694
K_1383 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.002727
K_1384 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.002739
K_1385 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.002705
K_1386 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.002732
K_1387 X_NUC_15.L_CORE X_NUC_65.L_CORE 0.004389
K_1388 X_NUC_15.L_CORE X_NUC_66.L_CORE 0.004402
K_1389 X_NUC_15.L_CORE X_NUC_67.L_CORE 0.004337
K_1390 X_NUC_15.L_CORE X_NUC_68.L_CORE 0.004326
K_1391 X_NUC_15.L_CORE X_NUC_69.L_CORE 0.002829
K_1392 X_NUC_15.L_CORE X_NUC_70.L_CORE 0.002818
K_1393 X_NUC_15.L_CORE X_NUC_71.L_CORE 0.002792
K_1394 X_NUC_15.L_CORE X_NUC_72.L_CORE 0.002818
K_1395 X_NUC_15.L_CORE X_NUC_73.L_CORE 0.002998
K_1396 X_NUC_15.L_CORE X_NUC_74.L_CORE 0.003019
K_1397 X_NUC_15.L_CORE X_NUC_75.L_CORE 0.002976
K_1398 X_NUC_15.L_CORE X_NUC_76.L_CORE 0.002994
K_1399 X_NUC_15.L_CORE X_NUC_77.L_CORE 0.003455
K_1400 X_NUC_15.L_CORE X_NUC_78.L_CORE 0.003441
K_1401 X_NUC_15.L_CORE X_NUC_79.L_CORE 0.003405
K_1402 X_NUC_15.L_CORE X_NUC_80.L_CORE 0.003415
K_1403 X_NUC_15.L_CORE X_NUC_81.L_CORE 0.002662
K_1404 X_NUC_15.L_CORE X_NUC_82.L_CORE 0.002665
K_1405 X_NUC_15.L_CORE X_NUC_83.L_CORE 0.002635
K_1406 X_NUC_15.L_CORE X_NUC_84.L_CORE 0.002655
K_1407 X_NUC_15.L_CORE X_NUC_85.L_CORE 0.003045
K_1408 X_NUC_15.L_CORE X_NUC_86.L_CORE 0.003052
K_1409 X_NUC_15.L_CORE X_NUC_87.L_CORE 0.003013
K_1410 X_NUC_15.L_CORE X_NUC_88.L_CORE 0.003025
K_1411 X_NUC_15.L_CORE X_NUC_89.L_CORE 0.007411
K_1412 X_NUC_15.L_CORE X_NUC_90.L_CORE 0.005276
K_1413 X_NUC_15.L_CORE X_NUC_91.L_CORE 0.003520
K_1414 X_NUC_15.L_CORE X_NUC_92.L_CORE 0.019496
K_1415 X_NUC_15.L_CORE X_NUC_93.L_CORE 0.003107
K_1416 X_NUC_15.L_CORE X_NUC_94.L_CORE 0.003928
K_1417 X_NUC_15.L_CORE X_NUC_95.L_CORE 0.004975
K_1418 X_NUC_15.L_CORE X_NUC_96.L_CORE 0.002620
K_1419 X_NUC_15.L_CORE X_NUC_97.L_CORE 0.004903
K_1420 X_NUC_15.L_CORE X_NUC_98.L_CORE 0.002940
K_1421 X_NUC_15.L_CORE X_NUC_99.L_CORE 0.002730
K_1422 X_NUC_15.L_CORE X_NUC_100.L_CORE 0.003863
K_1423 X_NUC_15.L_CORE X_NUC_101.L_CORE 0.002456
K_1424 X_NUC_15.L_CORE X_NUC_102.L_CORE 0.002941
K_1425 X_NUC_15.L_CORE X_NUC_103.L_CORE 0.002751
K_1426 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.003608
K_1427 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.003592
K_1428 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.003568
K_1429 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.003628
K_1430 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.004684
K_1431 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.004775
K_1432 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.004691
K_1433 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.004744
K_1434 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.006673
K_1435 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.006490
K_1436 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.006495
K_1437 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.006568
K_1438 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.003025
K_1439 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.003034
K_1440 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.003002
K_1441 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.003044
K_1442 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.007514
K_1443 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.007721
K_1444 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.007519
K_1445 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.007462
K_1446 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.003531
K_1447 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.003499
K_1448 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.003478
K_1449 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.003522
K_1450 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.003207
K_1451 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.003239
K_1452 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.003193
K_1453 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.003225
K_1454 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006461
K_1455 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006372
K_1456 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006313
K_1457 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006279
K_1458 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.002772
K_1459 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.002769
K_1460 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.002743
K_1461 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.002776
K_1462 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.003995
K_1463 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.004050
K_1464 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.003978
K_1465 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.003991
K_1466 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.003707
K_1467 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.003668
K_1468 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.003643
K_1469 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.003669
K_1470 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.002700
K_1471 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.002712
K_1472 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.002679
K_1473 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.002705
K_1474 X_NUC_16.L_CORE X_NUC_65.L_CORE 0.004399
K_1475 X_NUC_16.L_CORE X_NUC_66.L_CORE 0.004413
K_1476 X_NUC_16.L_CORE X_NUC_67.L_CORE 0.004347
K_1477 X_NUC_16.L_CORE X_NUC_68.L_CORE 0.004337
K_1478 X_NUC_16.L_CORE X_NUC_69.L_CORE 0.002802
K_1479 X_NUC_16.L_CORE X_NUC_70.L_CORE 0.002792
K_1480 X_NUC_16.L_CORE X_NUC_71.L_CORE 0.002767
K_1481 X_NUC_16.L_CORE X_NUC_72.L_CORE 0.002792
K_1482 X_NUC_16.L_CORE X_NUC_73.L_CORE 0.002981
K_1483 X_NUC_16.L_CORE X_NUC_74.L_CORE 0.003001
K_1484 X_NUC_16.L_CORE X_NUC_75.L_CORE 0.002959
K_1485 X_NUC_16.L_CORE X_NUC_76.L_CORE 0.002976
K_1486 X_NUC_16.L_CORE X_NUC_77.L_CORE 0.003444
K_1487 X_NUC_16.L_CORE X_NUC_78.L_CORE 0.003430
K_1488 X_NUC_16.L_CORE X_NUC_79.L_CORE 0.003394
K_1489 X_NUC_16.L_CORE X_NUC_80.L_CORE 0.003405
K_1490 X_NUC_16.L_CORE X_NUC_81.L_CORE 0.002641
K_1491 X_NUC_16.L_CORE X_NUC_82.L_CORE 0.002644
K_1492 X_NUC_16.L_CORE X_NUC_83.L_CORE 0.002614
K_1493 X_NUC_16.L_CORE X_NUC_84.L_CORE 0.002635
K_1494 X_NUC_16.L_CORE X_NUC_85.L_CORE 0.003033
K_1495 X_NUC_16.L_CORE X_NUC_86.L_CORE 0.003040
K_1496 X_NUC_16.L_CORE X_NUC_87.L_CORE 0.003001
K_1497 X_NUC_16.L_CORE X_NUC_88.L_CORE 0.003013
K_1498 X_NUC_16.L_CORE X_NUC_89.L_CORE 0.007254
K_1499 X_NUC_16.L_CORE X_NUC_90.L_CORE 0.005176
K_1500 X_NUC_16.L_CORE X_NUC_91.L_CORE 0.003470
K_1501 X_NUC_16.L_CORE X_NUC_92.L_CORE 0.021443
K_1502 X_NUC_16.L_CORE X_NUC_93.L_CORE 0.003064
K_1503 X_NUC_16.L_CORE X_NUC_94.L_CORE 0.003901
K_1504 X_NUC_16.L_CORE X_NUC_95.L_CORE 0.004958
K_1505 X_NUC_16.L_CORE X_NUC_96.L_CORE 0.002590
K_1506 X_NUC_16.L_CORE X_NUC_97.L_CORE 0.004938
K_1507 X_NUC_16.L_CORE X_NUC_98.L_CORE 0.002913
K_1508 X_NUC_16.L_CORE X_NUC_99.L_CORE 0.002710
K_1509 X_NUC_16.L_CORE X_NUC_100.L_CORE 0.003871
K_1510 X_NUC_16.L_CORE X_NUC_101.L_CORE 0.002435
K_1511 X_NUC_16.L_CORE X_NUC_102.L_CORE 0.002933
K_1512 X_NUC_16.L_CORE X_NUC_103.L_CORE 0.002738
K_1513 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_1514 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_1515 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_1516 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.003337
K_1517 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.003383
K_1518 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.003372
K_1519 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.003343
K_1520 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.004425
K_1521 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.004398
K_1522 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.004445
K_1523 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.004357
K_1524 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.006260
K_1525 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.006434
K_1526 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.006271
K_1527 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.006327
K_1528 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.002879
K_1529 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.002898
K_1530 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.002900
K_1531 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.002866
K_1532 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.007445
K_1533 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.007274
K_1534 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.007290
K_1535 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.007192
K_1536 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.003390
K_1537 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.003441
K_1538 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.003406
K_1539 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.003395
K_1540 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.003117
K_1541 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.003117
K_1542 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.003126
K_1543 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.003083
K_1544 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006417
K_1545 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006466
K_1546 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.006283
K_1547 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.006351
K_1548 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.002702
K_1549 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.002726
K_1550 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.002714
K_1551 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.002692
K_1552 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.003966
K_1553 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.003938
K_1554 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.003938
K_1555 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.003893
K_1556 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.003647
K_1557 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.003693
K_1558 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.003636
K_1559 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.003639
K_1560 X_NUC_17.L_CORE X_NUC_65.L_CORE 0.002674
K_1561 X_NUC_17.L_CORE X_NUC_66.L_CORE 0.002683
K_1562 X_NUC_17.L_CORE X_NUC_67.L_CORE 0.002678
K_1563 X_NUC_17.L_CORE X_NUC_68.L_CORE 0.002652
K_1564 X_NUC_17.L_CORE X_NUC_69.L_CORE 0.004363
K_1565 X_NUC_17.L_CORE X_NUC_70.L_CORE 0.004352
K_1566 X_NUC_17.L_CORE X_NUC_71.L_CORE 0.004299
K_1567 X_NUC_17.L_CORE X_NUC_72.L_CORE 0.004291
K_1568 X_NUC_17.L_CORE X_NUC_73.L_CORE 0.002792
K_1569 X_NUC_17.L_CORE X_NUC_74.L_CORE 0.002816
K_1570 X_NUC_17.L_CORE X_NUC_75.L_CORE 0.002793
K_1571 X_NUC_17.L_CORE X_NUC_76.L_CORE 0.002779
K_1572 X_NUC_17.L_CORE X_NUC_77.L_CORE 0.002987
K_1573 X_NUC_17.L_CORE X_NUC_78.L_CORE 0.002987
K_1574 X_NUC_17.L_CORE X_NUC_79.L_CORE 0.002977
K_1575 X_NUC_17.L_CORE X_NUC_80.L_CORE 0.002950
K_1576 X_NUC_17.L_CORE X_NUC_81.L_CORE 0.003366
K_1577 X_NUC_17.L_CORE X_NUC_82.L_CORE 0.003383
K_1578 X_NUC_17.L_CORE X_NUC_83.L_CORE 0.003341
K_1579 X_NUC_17.L_CORE X_NUC_84.L_CORE 0.003336
K_1580 X_NUC_17.L_CORE X_NUC_85.L_CORE 0.002744
K_1581 X_NUC_17.L_CORE X_NUC_86.L_CORE 0.002756
K_1582 X_NUC_17.L_CORE X_NUC_87.L_CORE 0.002738
K_1583 X_NUC_17.L_CORE X_NUC_88.L_CORE 0.002721
K_1584 X_NUC_17.L_CORE X_NUC_89.L_CORE 0.003999
K_1585 X_NUC_17.L_CORE X_NUC_90.L_CORE 0.006933
K_1586 X_NUC_17.L_CORE X_NUC_91.L_CORE 0.004611
K_1587 X_NUC_17.L_CORE X_NUC_92.L_CORE 0.003131
K_1588 X_NUC_17.L_CORE X_NUC_93.L_CORE 0.017588
K_1589 X_NUC_17.L_CORE X_NUC_94.L_CORE 0.002880
K_1590 X_NUC_17.L_CORE X_NUC_95.L_CORE 0.003667
K_1591 X_NUC_17.L_CORE X_NUC_96.L_CORE 0.004765
K_1592 X_NUC_17.L_CORE X_NUC_97.L_CORE 0.002501
K_1593 X_NUC_17.L_CORE X_NUC_98.L_CORE 0.004721
K_1594 X_NUC_17.L_CORE X_NUC_99.L_CORE 0.002861
K_1595 X_NUC_17.L_CORE X_NUC_100.L_CORE 0.002665
K_1596 X_NUC_17.L_CORE X_NUC_101.L_CORE 0.003717
K_1597 X_NUC_17.L_CORE X_NUC_102.L_CORE 0.002463
K_1598 X_NUC_17.L_CORE X_NUC_103.L_CORE 0.002841
K_1599 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_1600 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_1601 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.003293
K_1602 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.003337
K_1603 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.003327
K_1604 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.003298
K_1605 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.004450
K_1606 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.004425
K_1607 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.004472
K_1608 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.004383
K_1609 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.006095
K_1610 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.006260
K_1611 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.006107
K_1612 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.006159
K_1613 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.002859
K_1614 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.002879
K_1615 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.002880
K_1616 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.002847
K_1617 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.007618
K_1618 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.007445
K_1619 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.007458
K_1620 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.007352
K_1621 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.003340
K_1622 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.003390
K_1623 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.003356
K_1624 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.003345
K_1625 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.003117
K_1626 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.003117
K_1627 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.003126
K_1628 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.003083
K_1629 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.006364
K_1630 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006417
K_1631 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.006236
K_1632 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.006303
K_1633 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.002679
K_1634 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.002702
K_1635 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.002691
K_1636 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.002670
K_1637 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.003992
K_1638 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.003966
K_1639 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.003965
K_1640 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.003919
K_1641 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.003602
K_1642 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.003647
K_1643 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.003592
K_1644 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.003595
K_1645 X_NUC_18.L_CORE X_NUC_65.L_CORE 0.002664
K_1646 X_NUC_18.L_CORE X_NUC_66.L_CORE 0.002674
K_1647 X_NUC_18.L_CORE X_NUC_67.L_CORE 0.002669
K_1648 X_NUC_18.L_CORE X_NUC_68.L_CORE 0.002643
K_1649 X_NUC_18.L_CORE X_NUC_69.L_CORE 0.004373
K_1650 X_NUC_18.L_CORE X_NUC_70.L_CORE 0.004363
K_1651 X_NUC_18.L_CORE X_NUC_71.L_CORE 0.004309
K_1652 X_NUC_18.L_CORE X_NUC_72.L_CORE 0.004300
K_1653 X_NUC_18.L_CORE X_NUC_73.L_CORE 0.002768
K_1654 X_NUC_18.L_CORE X_NUC_74.L_CORE 0.002792
K_1655 X_NUC_18.L_CORE X_NUC_75.L_CORE 0.002769
K_1656 X_NUC_18.L_CORE X_NUC_76.L_CORE 0.002756
K_1657 X_NUC_18.L_CORE X_NUC_77.L_CORE 0.002987
K_1658 X_NUC_18.L_CORE X_NUC_78.L_CORE 0.002987
K_1659 X_NUC_18.L_CORE X_NUC_79.L_CORE 0.002977
K_1660 X_NUC_18.L_CORE X_NUC_80.L_CORE 0.002951
K_1661 X_NUC_18.L_CORE X_NUC_81.L_CORE 0.003347
K_1662 X_NUC_18.L_CORE X_NUC_82.L_CORE 0.003366
K_1663 X_NUC_18.L_CORE X_NUC_83.L_CORE 0.003324
K_1664 X_NUC_18.L_CORE X_NUC_84.L_CORE 0.003318
K_1665 X_NUC_18.L_CORE X_NUC_85.L_CORE 0.002732
K_1666 X_NUC_18.L_CORE X_NUC_86.L_CORE 0.002744
K_1667 X_NUC_18.L_CORE X_NUC_87.L_CORE 0.002726
K_1668 X_NUC_18.L_CORE X_NUC_88.L_CORE 0.002709
K_1669 X_NUC_18.L_CORE X_NUC_89.L_CORE 0.003955
K_1670 X_NUC_18.L_CORE X_NUC_90.L_CORE 0.007005
K_1671 X_NUC_18.L_CORE X_NUC_91.L_CORE 0.004513
K_1672 X_NUC_18.L_CORE X_NUC_92.L_CORE 0.003121
K_1673 X_NUC_18.L_CORE X_NUC_93.L_CORE 0.018373
K_1674 X_NUC_18.L_CORE X_NUC_94.L_CORE 0.002847
K_1675 X_NUC_18.L_CORE X_NUC_95.L_CORE 0.003691
K_1676 X_NUC_18.L_CORE X_NUC_96.L_CORE 0.004686
K_1677 X_NUC_18.L_CORE X_NUC_97.L_CORE 0.002488
K_1678 X_NUC_18.L_CORE X_NUC_98.L_CORE 0.004777
K_1679 X_NUC_18.L_CORE X_NUC_99.L_CORE 0.002830
K_1680 X_NUC_18.L_CORE X_NUC_100.L_CORE 0.002665
K_1681 X_NUC_18.L_CORE X_NUC_101.L_CORE 0.003706
K_1682 X_NUC_18.L_CORE X_NUC_102.L_CORE 0.002449
K_1683 X_NUC_18.L_CORE X_NUC_103.L_CORE 0.002839
K_1684 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_1685 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.003303
K_1686 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.003347
K_1687 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.003337
K_1688 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.003308
K_1689 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.004403
K_1690 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.004377
K_1691 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.004425
K_1692 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.004337
K_1693 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.006244
K_1694 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.006419
K_1695 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.006260
K_1696 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.006313
K_1697 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.002858
K_1698 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.002877
K_1699 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.002879
K_1700 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.002845
K_1701 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.007600
K_1702 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.007423
K_1703 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.007445
K_1704 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.007336
K_1705 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.003372
K_1706 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.003423
K_1707 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.003390
K_1708 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.003378
K_1709 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.003108
K_1710 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.003108
K_1711 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.003117
K_1712 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.003074
K_1713 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006555
K_1714 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006609
K_1715 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006417
K_1716 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.006488
K_1717 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.002690
K_1718 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.002713
K_1719 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.002702
K_1720 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.002681
K_1721 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.003992
K_1722 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.003965
K_1723 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.003966
K_1724 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.003918
K_1725 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.003657
K_1726 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.003704
K_1727 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.003647
K_1728 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.003649
K_1729 X_NUC_19.L_CORE X_NUC_65.L_CORE 0.002669
K_1730 X_NUC_19.L_CORE X_NUC_66.L_CORE 0.002679
K_1731 X_NUC_19.L_CORE X_NUC_67.L_CORE 0.002674
K_1732 X_NUC_19.L_CORE X_NUC_68.L_CORE 0.002647
K_1733 X_NUC_19.L_CORE X_NUC_69.L_CORE 0.004429
K_1734 X_NUC_19.L_CORE X_NUC_70.L_CORE 0.004418
K_1735 X_NUC_19.L_CORE X_NUC_71.L_CORE 0.004363
K_1736 X_NUC_19.L_CORE X_NUC_72.L_CORE 0.004354
K_1737 X_NUC_19.L_CORE X_NUC_73.L_CORE 0.002792
K_1738 X_NUC_19.L_CORE X_NUC_74.L_CORE 0.002816
K_1739 X_NUC_19.L_CORE X_NUC_75.L_CORE 0.002792
K_1740 X_NUC_19.L_CORE X_NUC_76.L_CORE 0.002779
K_1741 X_NUC_19.L_CORE X_NUC_77.L_CORE 0.002997
K_1742 X_NUC_19.L_CORE X_NUC_78.L_CORE 0.002997
K_1743 X_NUC_19.L_CORE X_NUC_79.L_CORE 0.002987
K_1744 X_NUC_19.L_CORE X_NUC_80.L_CORE 0.002961
K_1745 X_NUC_19.L_CORE X_NUC_81.L_CORE 0.003390
K_1746 X_NUC_19.L_CORE X_NUC_82.L_CORE 0.003408
K_1747 X_NUC_19.L_CORE X_NUC_83.L_CORE 0.003366
K_1748 X_NUC_19.L_CORE X_NUC_84.L_CORE 0.003360
K_1749 X_NUC_19.L_CORE X_NUC_85.L_CORE 0.002750
K_1750 X_NUC_19.L_CORE X_NUC_86.L_CORE 0.002762
K_1751 X_NUC_19.L_CORE X_NUC_87.L_CORE 0.002744
K_1752 X_NUC_19.L_CORE X_NUC_88.L_CORE 0.002727
K_1753 X_NUC_19.L_CORE X_NUC_89.L_CORE 0.003929
K_1754 X_NUC_19.L_CORE X_NUC_90.L_CORE 0.006802
K_1755 X_NUC_19.L_CORE X_NUC_91.L_CORE 0.004545
K_1756 X_NUC_19.L_CORE X_NUC_92.L_CORE 0.003103
K_1757 X_NUC_19.L_CORE X_NUC_93.L_CORE 0.019110
K_1758 X_NUC_19.L_CORE X_NUC_94.L_CORE 0.002858
K_1759 X_NUC_19.L_CORE X_NUC_95.L_CORE 0.003665
K_1760 X_NUC_19.L_CORE X_NUC_96.L_CORE 0.004789
K_1761 X_NUC_19.L_CORE X_NUC_97.L_CORE 0.002490
K_1762 X_NUC_19.L_CORE X_NUC_98.L_CORE 0.004801
K_1763 X_NUC_19.L_CORE X_NUC_99.L_CORE 0.002858
K_1764 X_NUC_19.L_CORE X_NUC_100.L_CORE 0.002666
K_1765 X_NUC_19.L_CORE X_NUC_101.L_CORE 0.003762
K_1766 X_NUC_19.L_CORE X_NUC_102.L_CORE 0.002463
K_1767 X_NUC_19.L_CORE X_NUC_103.L_CORE 0.002857
K_1768 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.003331
K_1769 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.003377
K_1770 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.003366
K_1771 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.003337
K_1772 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.004493
K_1773 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.004466
K_1774 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.004516
K_1775 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.004425
K_1776 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.006190
K_1777 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.006361
K_1778 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.006203
K_1779 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.006260
K_1780 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.002892
K_1781 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.002911
K_1782 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.002913
K_1783 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.002879
K_1784 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.007716
K_1785 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.007532
K_1786 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.007549
K_1787 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.007445
K_1788 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.003384
K_1789 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.003435
K_1790 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.003401
K_1791 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.003390
K_1792 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.003151
K_1793 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.003151
K_1794 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.003161
K_1795 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.003117
K_1796 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006479
K_1797 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.006532
K_1798 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006343
K_1799 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006417
K_1800 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.002712
K_1801 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.002736
K_1802 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.002724
K_1803 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.002702
K_1804 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.004041
K_1805 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.004013
K_1806 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.004013
K_1807 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.003966
K_1808 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.003654
K_1809 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.003701
K_1810 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.003644
K_1811 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.003647
K_1812 X_NUC_20.L_CORE X_NUC_65.L_CORE 0.002696
K_1813 X_NUC_20.L_CORE X_NUC_66.L_CORE 0.002706
K_1814 X_NUC_20.L_CORE X_NUC_67.L_CORE 0.002701
K_1815 X_NUC_20.L_CORE X_NUC_68.L_CORE 0.002674
K_1816 X_NUC_20.L_CORE X_NUC_69.L_CORE 0.004438
K_1817 X_NUC_20.L_CORE X_NUC_70.L_CORE 0.004427
K_1818 X_NUC_20.L_CORE X_NUC_71.L_CORE 0.004371
K_1819 X_NUC_20.L_CORE X_NUC_72.L_CORE 0.004363
K_1820 X_NUC_20.L_CORE X_NUC_73.L_CORE 0.002805
K_1821 X_NUC_20.L_CORE X_NUC_74.L_CORE 0.002830
K_1822 X_NUC_20.L_CORE X_NUC_75.L_CORE 0.002806
K_1823 X_NUC_20.L_CORE X_NUC_76.L_CORE 0.002792
K_1824 X_NUC_20.L_CORE X_NUC_77.L_CORE 0.003025
K_1825 X_NUC_20.L_CORE X_NUC_78.L_CORE 0.003025
K_1826 X_NUC_20.L_CORE X_NUC_79.L_CORE 0.003014
K_1827 X_NUC_20.L_CORE X_NUC_80.L_CORE 0.002987
K_1828 X_NUC_20.L_CORE X_NUC_81.L_CORE 0.003396
K_1829 X_NUC_20.L_CORE X_NUC_82.L_CORE 0.003414
K_1830 X_NUC_20.L_CORE X_NUC_83.L_CORE 0.003371
K_1831 X_NUC_20.L_CORE X_NUC_84.L_CORE 0.003366
K_1832 X_NUC_20.L_CORE X_NUC_85.L_CORE 0.002767
K_1833 X_NUC_20.L_CORE X_NUC_86.L_CORE 0.002780
K_1834 X_NUC_20.L_CORE X_NUC_87.L_CORE 0.002761
K_1835 X_NUC_20.L_CORE X_NUC_88.L_CORE 0.002744
K_1836 X_NUC_20.L_CORE X_NUC_89.L_CORE 0.003984
K_1837 X_NUC_20.L_CORE X_NUC_90.L_CORE 0.006993
K_1838 X_NUC_20.L_CORE X_NUC_91.L_CORE 0.004555
K_1839 X_NUC_20.L_CORE X_NUC_92.L_CORE 0.003149
K_1840 X_NUC_20.L_CORE X_NUC_93.L_CORE 0.017888
K_1841 X_NUC_20.L_CORE X_NUC_94.L_CORE 0.002878
K_1842 X_NUC_20.L_CORE X_NUC_95.L_CORE 0.003722
K_1843 X_NUC_20.L_CORE X_NUC_96.L_CORE 0.004744
K_1844 X_NUC_20.L_CORE X_NUC_97.L_CORE 0.002515
K_1845 X_NUC_20.L_CORE X_NUC_98.L_CORE 0.004825
K_1846 X_NUC_20.L_CORE X_NUC_99.L_CORE 0.002864
K_1847 X_NUC_20.L_CORE X_NUC_100.L_CORE 0.002693
K_1848 X_NUC_20.L_CORE X_NUC_101.L_CORE 0.003753
K_1849 X_NUC_20.L_CORE X_NUC_102.L_CORE 0.002478
K_1850 X_NUC_20.L_CORE X_NUC_103.L_CORE 0.002873
K_1851 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_1852 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_1853 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_1854 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.003140
K_1855 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.003094
K_1856 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.003118
K_1857 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.003111
K_1858 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.004203
K_1859 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.004164
K_1860 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.004138
K_1861 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.004211
K_1862 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.006033
K_1863 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.005945
K_1864 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.006018
K_1865 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.005883
K_1866 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.002765
K_1867 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.002731
K_1868 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.002738
K_1869 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.002749
K_1870 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.007412
K_1871 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.007442
K_1872 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.007213
K_1873 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.007403
K_1874 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.003300
K_1875 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.003257
K_1876 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.003277
K_1877 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.003255
K_1878 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.003047
K_1879 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.003018
K_1880 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.003006
K_1881 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.003035
K_1882 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.006501
K_1883 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.006492
K_1884 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.006409
K_1885 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.006329
K_1886 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.002661
K_1887 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.002631
K_1888 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.002636
K_1889 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.002636
K_1890 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.003953
K_1891 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.003935
K_1892 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.003883
K_1893 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.003933
K_1894 X_NUC_21.L_CORE X_NUC_65.L_CORE 0.003640
K_1895 X_NUC_21.L_CORE X_NUC_66.L_CORE 0.003605
K_1896 X_NUC_21.L_CORE X_NUC_67.L_CORE 0.003606
K_1897 X_NUC_21.L_CORE X_NUC_68.L_CORE 0.003577
K_1898 X_NUC_21.L_CORE X_NUC_69.L_CORE 0.002674
K_1899 X_NUC_21.L_CORE X_NUC_70.L_CORE 0.002649
K_1900 X_NUC_21.L_CORE X_NUC_71.L_CORE 0.002642
K_1901 X_NUC_21.L_CORE X_NUC_72.L_CORE 0.002654
K_1902 X_NUC_21.L_CORE X_NUC_73.L_CORE 0.004337
K_1903 X_NUC_21.L_CORE X_NUC_74.L_CORE 0.004328
K_1904 X_NUC_21.L_CORE X_NUC_75.L_CORE 0.004264
K_1905 X_NUC_21.L_CORE X_NUC_76.L_CORE 0.004277
K_1906 X_NUC_21.L_CORE X_NUC_77.L_CORE 0.002825
K_1907 X_NUC_21.L_CORE X_NUC_78.L_CORE 0.002798
K_1908 X_NUC_21.L_CORE X_NUC_79.L_CORE 0.002795
K_1909 X_NUC_21.L_CORE X_NUC_80.L_CORE 0.002790
K_1910 X_NUC_21.L_CORE X_NUC_81.L_CORE 0.003022
K_1911 X_NUC_21.L_CORE X_NUC_82.L_CORE 0.003001
K_1912 X_NUC_21.L_CORE X_NUC_83.L_CORE 0.002979
K_1913 X_NUC_21.L_CORE X_NUC_84.L_CORE 0.002996
K_1914 X_NUC_21.L_CORE X_NUC_85.L_CORE 0.003258
K_1915 X_NUC_21.L_CORE X_NUC_86.L_CORE 0.003237
K_1916 X_NUC_21.L_CORE X_NUC_87.L_CORE 0.003216
K_1917 X_NUC_21.L_CORE X_NUC_88.L_CORE 0.003214
K_1918 X_NUC_21.L_CORE X_NUC_89.L_CORE 0.006428
K_1919 X_NUC_21.L_CORE X_NUC_90.L_CORE 0.003211
K_1920 X_NUC_21.L_CORE X_NUC_91.L_CORE 0.006413
K_1921 X_NUC_21.L_CORE X_NUC_92.L_CORE 0.004121
K_1922 X_NUC_21.L_CORE X_NUC_93.L_CORE 0.002880
K_1923 X_NUC_21.L_CORE X_NUC_94.L_CORE 0.016726
K_1924 X_NUC_21.L_CORE X_NUC_95.L_CORE 0.002706
K_1925 X_NUC_21.L_CORE X_NUC_96.L_CORE 0.003522
K_1926 X_NUC_21.L_CORE X_NUC_97.L_CORE 0.004556
K_1927 X_NUC_21.L_CORE X_NUC_98.L_CORE 0.002425
K_1928 X_NUC_21.L_CORE X_NUC_99.L_CORE 0.004628
K_1929 X_NUC_21.L_CORE X_NUC_100.L_CORE 0.002804
K_1930 X_NUC_21.L_CORE X_NUC_101.L_CORE 0.002654
K_1931 X_NUC_21.L_CORE X_NUC_102.L_CORE 0.003537
K_1932 X_NUC_21.L_CORE X_NUC_103.L_CORE 0.002558
K_1933 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_1934 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_1935 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.003187
K_1936 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.003140
K_1937 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.003165
K_1938 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.003157
K_1939 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.004241
K_1940 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.004203
K_1941 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.004175
K_1942 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.004250
K_1943 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.006121
K_1944 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.006033
K_1945 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.006107
K_1946 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.005966
K_1947 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.002800
K_1948 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.002765
K_1949 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.002772
K_1950 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.002783
K_1951 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.007372
K_1952 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.007412
K_1953 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.007181
K_1954 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.007368
K_1955 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.003344
K_1956 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.003300
K_1957 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.003320
K_1958 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.003297
K_1959 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.003075
K_1960 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.003047
K_1961 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.003034
K_1962 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.003064
K_1963 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.006504
K_1964 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.006501
K_1965 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.006415
K_1966 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.006335
K_1967 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.002693
K_1968 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.002661
K_1969 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.002666
K_1970 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.002667
K_1971 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.003968
K_1972 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.003953
K_1973 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.003899
K_1974 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.003949
K_1975 X_NUC_22.L_CORE X_NUC_65.L_CORE 0.003674
K_1976 X_NUC_22.L_CORE X_NUC_66.L_CORE 0.003640
K_1977 X_NUC_22.L_CORE X_NUC_67.L_CORE 0.003640
K_1978 X_NUC_22.L_CORE X_NUC_68.L_CORE 0.003610
K_1979 X_NUC_22.L_CORE X_NUC_69.L_CORE 0.002700
K_1980 X_NUC_22.L_CORE X_NUC_70.L_CORE 0.002674
K_1981 X_NUC_22.L_CORE X_NUC_71.L_CORE 0.002666
K_1982 X_NUC_22.L_CORE X_NUC_72.L_CORE 0.002679
K_1983 X_NUC_22.L_CORE X_NUC_73.L_CORE 0.004345
K_1984 X_NUC_22.L_CORE X_NUC_74.L_CORE 0.004337
K_1985 X_NUC_22.L_CORE X_NUC_75.L_CORE 0.004272
K_1986 X_NUC_22.L_CORE X_NUC_76.L_CORE 0.004286
K_1987 X_NUC_22.L_CORE X_NUC_77.L_CORE 0.002852
K_1988 X_NUC_22.L_CORE X_NUC_78.L_CORE 0.002825
K_1989 X_NUC_22.L_CORE X_NUC_79.L_CORE 0.002822
K_1990 X_NUC_22.L_CORE X_NUC_80.L_CORE 0.002817
K_1991 X_NUC_22.L_CORE X_NUC_81.L_CORE 0.003042
K_1992 X_NUC_22.L_CORE X_NUC_82.L_CORE 0.003022
K_1993 X_NUC_22.L_CORE X_NUC_83.L_CORE 0.002998
K_1994 X_NUC_22.L_CORE X_NUC_84.L_CORE 0.003016
K_1995 X_NUC_22.L_CORE X_NUC_85.L_CORE 0.003279
K_1996 X_NUC_22.L_CORE X_NUC_86.L_CORE 0.003258
K_1997 X_NUC_22.L_CORE X_NUC_87.L_CORE 0.003236
K_1998 X_NUC_22.L_CORE X_NUC_88.L_CORE 0.003235
K_1999 X_NUC_22.L_CORE X_NUC_89.L_CORE 0.006567
K_2000 X_NUC_22.L_CORE X_NUC_90.L_CORE 0.003259
K_2001 X_NUC_22.L_CORE X_NUC_91.L_CORE 0.006458
K_2002 X_NUC_22.L_CORE X_NUC_92.L_CORE 0.004185
K_2003 X_NUC_22.L_CORE X_NUC_93.L_CORE 0.002913
K_2004 X_NUC_22.L_CORE X_NUC_94.L_CORE 0.015758
K_2005 X_NUC_22.L_CORE X_NUC_95.L_CORE 0.002741
K_2006 X_NUC_22.L_CORE X_NUC_96.L_CORE 0.003542
K_2007 X_NUC_22.L_CORE X_NUC_97.L_CORE 0.004588
K_2008 X_NUC_22.L_CORE X_NUC_98.L_CORE 0.002450
K_2009 X_NUC_22.L_CORE X_NUC_99.L_CORE 0.004614
K_2010 X_NUC_22.L_CORE X_NUC_100.L_CORE 0.002830
K_2011 X_NUC_22.L_CORE X_NUC_101.L_CORE 0.002673
K_2012 X_NUC_22.L_CORE X_NUC_102.L_CORE 0.003547
K_2013 X_NUC_22.L_CORE X_NUC_103.L_CORE 0.002577
K_2014 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_2015 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.003161
K_2016 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.003114
K_2017 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.003140
K_2018 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.003132
K_2019 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.004269
K_2020 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.004229
K_2021 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.004203
K_2022 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.004279
K_2023 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.006043
K_2024 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.005957
K_2025 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.006033
K_2026 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.005895
K_2027 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.002793
K_2028 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.002758
K_2029 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.002765
K_2030 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.002776
K_2031 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.007617
K_2032 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.007656
K_2033 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.007412
K_2034 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.007613
K_2035 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.003323
K_2036 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.003280
K_2037 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.003300
K_2038 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.003277
K_2039 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.003088
K_2040 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.003059
K_2041 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.003047
K_2042 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.003077
K_2043 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.006590
K_2044 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.006584
K_2045 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.006501
K_2046 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.006414
K_2047 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.002687
K_2048 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.002656
K_2049 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.002661
K_2050 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.002662
K_2051 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.004024
K_2052 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.004007
K_2053 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.003953
K_2054 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.004005
K_2055 X_NUC_23.L_CORE X_NUC_65.L_CORE 0.003673
K_2056 X_NUC_23.L_CORE X_NUC_66.L_CORE 0.003638
K_2057 X_NUC_23.L_CORE X_NUC_67.L_CORE 0.003640
K_2058 X_NUC_23.L_CORE X_NUC_68.L_CORE 0.003609
K_2059 X_NUC_23.L_CORE X_NUC_69.L_CORE 0.002707
K_2060 X_NUC_23.L_CORE X_NUC_70.L_CORE 0.002681
K_2061 X_NUC_23.L_CORE X_NUC_71.L_CORE 0.002674
K_2062 X_NUC_23.L_CORE X_NUC_72.L_CORE 0.002687
K_2063 X_NUC_23.L_CORE X_NUC_73.L_CORE 0.004412
K_2064 X_NUC_23.L_CORE X_NUC_74.L_CORE 0.004403
K_2065 X_NUC_23.L_CORE X_NUC_75.L_CORE 0.004337
K_2066 X_NUC_23.L_CORE X_NUC_76.L_CORE 0.004350
K_2067 X_NUC_23.L_CORE X_NUC_77.L_CORE 0.002855
K_2068 X_NUC_23.L_CORE X_NUC_78.L_CORE 0.002827
K_2069 X_NUC_23.L_CORE X_NUC_79.L_CORE 0.002825
K_2070 X_NUC_23.L_CORE X_NUC_80.L_CORE 0.002820
K_2071 X_NUC_23.L_CORE X_NUC_81.L_CORE 0.003066
K_2072 X_NUC_23.L_CORE X_NUC_82.L_CORE 0.003045
K_2073 X_NUC_23.L_CORE X_NUC_83.L_CORE 0.003022
K_2074 X_NUC_23.L_CORE X_NUC_84.L_CORE 0.003039
K_2075 X_NUC_23.L_CORE X_NUC_85.L_CORE 0.003301
K_2076 X_NUC_23.L_CORE X_NUC_86.L_CORE 0.003279
K_2077 X_NUC_23.L_CORE X_NUC_87.L_CORE 0.003258
K_2078 X_NUC_23.L_CORE X_NUC_88.L_CORE 0.003256
K_2079 X_NUC_23.L_CORE X_NUC_89.L_CORE 0.006382
K_2080 X_NUC_23.L_CORE X_NUC_90.L_CORE 0.003229
K_2081 X_NUC_23.L_CORE X_NUC_91.L_CORE 0.006480
K_2082 X_NUC_23.L_CORE X_NUC_92.L_CORE 0.004121
K_2083 X_NUC_23.L_CORE X_NUC_93.L_CORE 0.002909
K_2084 X_NUC_23.L_CORE X_NUC_94.L_CORE 0.016662
K_2085 X_NUC_23.L_CORE X_NUC_95.L_CORE 0.002724
K_2086 X_NUC_23.L_CORE X_NUC_96.L_CORE 0.003573
K_2087 X_NUC_23.L_CORE X_NUC_97.L_CORE 0.004575
K_2088 X_NUC_23.L_CORE X_NUC_98.L_CORE 0.002449
K_2089 X_NUC_23.L_CORE X_NUC_99.L_CORE 0.004710
K_2090 X_NUC_23.L_CORE X_NUC_100.L_CORE 0.002826
K_2091 X_NUC_23.L_CORE X_NUC_101.L_CORE 0.002688
K_2092 X_NUC_23.L_CORE X_NUC_102.L_CORE 0.003580
K_2093 X_NUC_23.L_CORE X_NUC_103.L_CORE 0.002586
K_2094 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.003169
K_2095 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.003122
K_2096 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.003147
K_2097 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.003140
K_2098 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.004193
K_2099 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.004155
K_2100 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.004129
K_2101 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.004203
K_2102 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.006190
K_2103 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.006097
K_2104 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.006176
K_2105 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.006033
K_2106 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.002782
K_2107 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.002747
K_2108 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.002754
K_2109 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.002765
K_2110 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.007411
K_2111 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.007446
K_2112 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.007216
K_2113 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.007412
K_2114 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.003347
K_2115 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.003302
K_2116 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.003323
K_2117 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.003300
K_2118 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.003058
K_2119 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.003029
K_2120 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.003017
K_2121 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.003047
K_2122 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.006681
K_2123 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.006674
K_2124 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.006585
K_2125 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.006501
K_2126 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.002687
K_2127 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.002656
K_2128 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.002661
K_2129 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.002661
K_2130 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.003971
K_2131 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.003954
K_2132 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.003901
K_2133 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.003953
K_2134 X_NUC_24.L_CORE X_NUC_65.L_CORE 0.003704
K_2135 X_NUC_24.L_CORE X_NUC_66.L_CORE 0.003669
K_2136 X_NUC_24.L_CORE X_NUC_67.L_CORE 0.003669
K_2137 X_NUC_24.L_CORE X_NUC_68.L_CORE 0.003640
K_2138 X_NUC_24.L_CORE X_NUC_69.L_CORE 0.002694
K_2139 X_NUC_24.L_CORE X_NUC_70.L_CORE 0.002668
K_2140 X_NUC_24.L_CORE X_NUC_71.L_CORE 0.002661
K_2141 X_NUC_24.L_CORE X_NUC_72.L_CORE 0.002674
K_2142 X_NUC_24.L_CORE X_NUC_73.L_CORE 0.004398
K_2143 X_NUC_24.L_CORE X_NUC_74.L_CORE 0.004389
K_2144 X_NUC_24.L_CORE X_NUC_75.L_CORE 0.004322
K_2145 X_NUC_24.L_CORE X_NUC_76.L_CORE 0.004337
K_2146 X_NUC_24.L_CORE X_NUC_77.L_CORE 0.002860
K_2147 X_NUC_24.L_CORE X_NUC_78.L_CORE 0.002832
K_2148 X_NUC_24.L_CORE X_NUC_79.L_CORE 0.002830
K_2149 X_NUC_24.L_CORE X_NUC_80.L_CORE 0.002825
K_2150 X_NUC_24.L_CORE X_NUC_81.L_CORE 0.003048
K_2151 X_NUC_24.L_CORE X_NUC_82.L_CORE 0.003027
K_2152 X_NUC_24.L_CORE X_NUC_83.L_CORE 0.003004
K_2153 X_NUC_24.L_CORE X_NUC_84.L_CORE 0.003022
K_2154 X_NUC_24.L_CORE X_NUC_85.L_CORE 0.003303
K_2155 X_NUC_24.L_CORE X_NUC_86.L_CORE 0.003281
K_2156 X_NUC_24.L_CORE X_NUC_87.L_CORE 0.003259
K_2157 X_NUC_24.L_CORE X_NUC_88.L_CORE 0.003258
K_2158 X_NUC_24.L_CORE X_NUC_89.L_CORE 0.006408
K_2159 X_NUC_24.L_CORE X_NUC_90.L_CORE 0.003222
K_2160 X_NUC_24.L_CORE X_NUC_91.L_CORE 0.006301
K_2161 X_NUC_24.L_CORE X_NUC_92.L_CORE 0.004173
K_2162 X_NUC_24.L_CORE X_NUC_93.L_CORE 0.002885
K_2163 X_NUC_24.L_CORE X_NUC_94.L_CORE 0.016899
K_2164 X_NUC_24.L_CORE X_NUC_95.L_CORE 0.002731
K_2165 X_NUC_24.L_CORE X_NUC_96.L_CORE 0.003520
K_2166 X_NUC_24.L_CORE X_NUC_97.L_CORE 0.004652
K_2167 X_NUC_24.L_CORE X_NUC_98.L_CORE 0.002441
K_2168 X_NUC_24.L_CORE X_NUC_99.L_CORE 0.004658
K_2169 X_NUC_24.L_CORE X_NUC_100.L_CORE 0.002841
K_2170 X_NUC_24.L_CORE X_NUC_101.L_CORE 0.002670
K_2171 X_NUC_24.L_CORE X_NUC_102.L_CORE 0.003588
K_2172 X_NUC_24.L_CORE X_NUC_103.L_CORE 0.002584
K_2173 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_2174 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_2175 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_2176 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.003002
K_2177 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.003029
K_2178 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.002996
K_2179 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.003031
K_2180 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.004047
K_2181 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.004122
K_2182 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.004089
K_2183 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.004062
K_2184 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.005870
K_2185 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.005845
K_2186 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.005747
K_2187 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.005899
K_2188 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.002689
K_2189 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.002720
K_2190 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.002692
K_2191 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.002707
K_2192 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.007379
K_2193 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.007499
K_2194 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.007396
K_2195 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.007241
K_2196 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.003245
K_2197 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.003261
K_2198 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.003219
K_2199 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.003263
K_2200 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.003007
K_2201 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.003048
K_2202 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.003016
K_2203 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.003015
K_2204 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.006540
K_2205 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.006501
K_2206 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.006356
K_2207 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.006427
K_2208 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.002648
K_2209 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.002671
K_2210 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.002640
K_2211 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.002660
K_2212 X_NUC_25.L_CORE X_NUC_65.L_CORE 0.003953
K_2213 X_NUC_25.L_CORE X_NUC_66.L_CORE 0.004002
K_2214 X_NUC_25.L_CORE X_NUC_67.L_CORE 0.003951
K_2215 X_NUC_25.L_CORE X_NUC_68.L_CORE 0.003928
K_2216 X_NUC_25.L_CORE X_NUC_69.L_CORE 0.003647
K_2217 X_NUC_25.L_CORE X_NUC_70.L_CORE 0.003655
K_2218 X_NUC_25.L_CORE X_NUC_71.L_CORE 0.003598
K_2219 X_NUC_25.L_CORE X_NUC_72.L_CORE 0.003642
K_2220 X_NUC_25.L_CORE X_NUC_73.L_CORE 0.002705
K_2221 X_NUC_25.L_CORE X_NUC_74.L_CORE 0.002733
K_2222 X_NUC_25.L_CORE X_NUC_75.L_CORE 0.002701
K_2223 X_NUC_25.L_CORE X_NUC_76.L_CORE 0.002709
K_2224 X_NUC_25.L_CORE X_NUC_77.L_CORE 0.004255
K_2225 X_NUC_25.L_CORE X_NUC_78.L_CORE 0.004277
K_2226 X_NUC_25.L_CORE X_NUC_79.L_CORE 0.004206
K_2227 X_NUC_25.L_CORE X_NUC_80.L_CORE 0.004208
K_2228 X_NUC_25.L_CORE X_NUC_81.L_CORE 0.002898
K_2229 X_NUC_25.L_CORE X_NUC_82.L_CORE 0.002916
K_2230 X_NUC_25.L_CORE X_NUC_83.L_CORE 0.002876
K_2231 X_NUC_25.L_CORE X_NUC_84.L_CORE 0.002897
K_2232 X_NUC_25.L_CORE X_NUC_85.L_CORE 0.003087
K_2233 X_NUC_25.L_CORE X_NUC_86.L_CORE 0.003114
K_2234 X_NUC_25.L_CORE X_NUC_87.L_CORE 0.003071
K_2235 X_NUC_25.L_CORE X_NUC_88.L_CORE 0.003077
K_2236 X_NUC_25.L_CORE X_NUC_89.L_CORE 0.004099
K_2237 X_NUC_25.L_CORE X_NUC_90.L_CORE 0.007351
K_2238 X_NUC_25.L_CORE X_NUC_91.L_CORE 0.002904
K_2239 X_NUC_25.L_CORE X_NUC_92.L_CORE 0.006104
K_2240 X_NUC_25.L_CORE X_NUC_93.L_CORE 0.003896
K_2241 X_NUC_25.L_CORE X_NUC_94.L_CORE 0.002766
K_2242 X_NUC_25.L_CORE X_NUC_95.L_CORE 0.014421
K_2243 X_NUC_25.L_CORE X_NUC_96.L_CORE 0.002645
K_2244 X_NUC_25.L_CORE X_NUC_97.L_CORE 0.003463
K_2245 X_NUC_25.L_CORE X_NUC_98.L_CORE 0.004444
K_2246 X_NUC_25.L_CORE X_NUC_99.L_CORE 0.002429
K_2247 X_NUC_25.L_CORE X_NUC_100.L_CORE 0.004486
K_2248 X_NUC_25.L_CORE X_NUC_101.L_CORE 0.002830
K_2249 X_NUC_25.L_CORE X_NUC_102.L_CORE 0.002718
K_2250 X_NUC_25.L_CORE X_NUC_103.L_CORE 0.003275
K_2251 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_2252 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_2253 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.002975
K_2254 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.003002
K_2255 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.002970
K_2256 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.003003
K_2257 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.003975
K_2258 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.004047
K_2259 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.004015
K_2260 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.003990
K_2261 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.005891
K_2262 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.005870
K_2263 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.005768
K_2264 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.005922
K_2265 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.002658
K_2266 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.002689
K_2267 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.002662
K_2268 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.002676
K_2269 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.007256
K_2270 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.007379
K_2271 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.007277
K_2272 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.007129
K_2273 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.003227
K_2274 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.003245
K_2275 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.003202
K_2276 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.003246
K_2277 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.002967
K_2278 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.003007
K_2279 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.002976
K_2280 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.002975
K_2281 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.006574
K_2282 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.006540
K_2283 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.006390
K_2284 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.006462
K_2285 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.002625
K_2286 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.002648
K_2287 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.002617
K_2288 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.002637
K_2289 X_NUC_26.L_CORE X_NUC_65.L_CORE 0.003904
K_2290 X_NUC_26.L_CORE X_NUC_66.L_CORE 0.003953
K_2291 X_NUC_26.L_CORE X_NUC_67.L_CORE 0.003903
K_2292 X_NUC_26.L_CORE X_NUC_68.L_CORE 0.003881
K_2293 X_NUC_26.L_CORE X_NUC_69.L_CORE 0.003638
K_2294 X_NUC_26.L_CORE X_NUC_70.L_CORE 0.003647
K_2295 X_NUC_26.L_CORE X_NUC_71.L_CORE 0.003589
K_2296 X_NUC_26.L_CORE X_NUC_72.L_CORE 0.003633
K_2297 X_NUC_26.L_CORE X_NUC_73.L_CORE 0.002678
K_2298 X_NUC_26.L_CORE X_NUC_74.L_CORE 0.002705
K_2299 X_NUC_26.L_CORE X_NUC_75.L_CORE 0.002673
K_2300 X_NUC_26.L_CORE X_NUC_76.L_CORE 0.002681
K_2301 X_NUC_26.L_CORE X_NUC_77.L_CORE 0.004231
K_2302 X_NUC_26.L_CORE X_NUC_78.L_CORE 0.004255
K_2303 X_NUC_26.L_CORE X_NUC_79.L_CORE 0.004184
K_2304 X_NUC_26.L_CORE X_NUC_80.L_CORE 0.004186
K_2305 X_NUC_26.L_CORE X_NUC_81.L_CORE 0.002879
K_2306 X_NUC_26.L_CORE X_NUC_82.L_CORE 0.002898
K_2307 X_NUC_26.L_CORE X_NUC_83.L_CORE 0.002858
K_2308 X_NUC_26.L_CORE X_NUC_84.L_CORE 0.002879
K_2309 X_NUC_26.L_CORE X_NUC_85.L_CORE 0.003061
K_2310 X_NUC_26.L_CORE X_NUC_86.L_CORE 0.003087
K_2311 X_NUC_26.L_CORE X_NUC_87.L_CORE 0.003045
K_2312 X_NUC_26.L_CORE X_NUC_88.L_CORE 0.003051
K_2313 X_NUC_26.L_CORE X_NUC_89.L_CORE 0.004031
K_2314 X_NUC_26.L_CORE X_NUC_90.L_CORE 0.007316
K_2315 X_NUC_26.L_CORE X_NUC_91.L_CORE 0.002871
K_2316 X_NUC_26.L_CORE X_NUC_92.L_CORE 0.005969
K_2317 X_NUC_26.L_CORE X_NUC_93.L_CORE 0.003886
K_2318 X_NUC_26.L_CORE X_NUC_94.L_CORE 0.002730
K_2319 X_NUC_26.L_CORE X_NUC_95.L_CORE 0.015024
K_2320 X_NUC_26.L_CORE X_NUC_96.L_CORE 0.002626
K_2321 X_NUC_26.L_CORE X_NUC_97.L_CORE 0.003415
K_2322 X_NUC_26.L_CORE X_NUC_98.L_CORE 0.004464
K_2323 X_NUC_26.L_CORE X_NUC_99.L_CORE 0.002406
K_2324 X_NUC_26.L_CORE X_NUC_100.L_CORE 0.004458
K_2325 X_NUC_26.L_CORE X_NUC_101.L_CORE 0.002818
K_2326 X_NUC_26.L_CORE X_NUC_102.L_CORE 0.002693
K_2327 X_NUC_26.L_CORE X_NUC_103.L_CORE 0.003263
K_2328 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_2329 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.003007
K_2330 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.003034
K_2331 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.003002
K_2332 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.003036
K_2333 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.004005
K_2334 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.004078
K_2335 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.004047
K_2336 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.004021
K_2337 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.005998
K_2338 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.005973
K_2339 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.005870
K_2340 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.006030
K_2341 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.002685
K_2342 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.002716
K_2343 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.002689
K_2344 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.002703
K_2345 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.007354
K_2346 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.007477
K_2347 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.007379
K_2348 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.007221
K_2349 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.003270
K_2350 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.003288
K_2351 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.003245
K_2352 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.003290
K_2353 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.002997
K_2354 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.003038
K_2355 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.003007
K_2356 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.003005
K_2357 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.006734
K_2358 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.006694
K_2359 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.006540
K_2360 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.006614
K_2361 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.002657
K_2362 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.002680
K_2363 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.002648
K_2364 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.002669
K_2365 X_NUC_27.L_CORE X_NUC_65.L_CORE 0.003952
K_2366 X_NUC_27.L_CORE X_NUC_66.L_CORE 0.004002
K_2367 X_NUC_27.L_CORE X_NUC_67.L_CORE 0.003953
K_2368 X_NUC_27.L_CORE X_NUC_68.L_CORE 0.003929
K_2369 X_NUC_27.L_CORE X_NUC_69.L_CORE 0.003697
K_2370 X_NUC_27.L_CORE X_NUC_70.L_CORE 0.003706
K_2371 X_NUC_27.L_CORE X_NUC_71.L_CORE 0.003647
K_2372 X_NUC_27.L_CORE X_NUC_72.L_CORE 0.003692
K_2373 X_NUC_27.L_CORE X_NUC_73.L_CORE 0.002709
K_2374 X_NUC_27.L_CORE X_NUC_74.L_CORE 0.002738
K_2375 X_NUC_27.L_CORE X_NUC_75.L_CORE 0.002705
K_2376 X_NUC_27.L_CORE X_NUC_76.L_CORE 0.002713
K_2377 X_NUC_27.L_CORE X_NUC_77.L_CORE 0.004304
K_2378 X_NUC_27.L_CORE X_NUC_78.L_CORE 0.004328
K_2379 X_NUC_27.L_CORE X_NUC_79.L_CORE 0.004255
K_2380 X_NUC_27.L_CORE X_NUC_80.L_CORE 0.004256
K_2381 X_NUC_27.L_CORE X_NUC_81.L_CORE 0.002919
K_2382 X_NUC_27.L_CORE X_NUC_82.L_CORE 0.002939
K_2383 X_NUC_27.L_CORE X_NUC_83.L_CORE 0.002898
K_2384 X_NUC_27.L_CORE X_NUC_84.L_CORE 0.002919
K_2385 X_NUC_27.L_CORE X_NUC_85.L_CORE 0.003103
K_2386 X_NUC_27.L_CORE X_NUC_86.L_CORE 0.003130
K_2387 X_NUC_27.L_CORE X_NUC_87.L_CORE 0.003087
K_2388 X_NUC_27.L_CORE X_NUC_88.L_CORE 0.003093
K_2389 X_NUC_27.L_CORE X_NUC_89.L_CORE 0.004040
K_2390 X_NUC_27.L_CORE X_NUC_90.L_CORE 0.007289
K_2391 X_NUC_27.L_CORE X_NUC_91.L_CORE 0.002893
K_2392 X_NUC_27.L_CORE X_NUC_92.L_CORE 0.005955
K_2393 X_NUC_27.L_CORE X_NUC_93.L_CORE 0.003925
K_2394 X_NUC_27.L_CORE X_NUC_94.L_CORE 0.002752
K_2395 X_NUC_27.L_CORE X_NUC_95.L_CORE 0.015081
K_2396 X_NUC_27.L_CORE X_NUC_96.L_CORE 0.002654
K_2397 X_NUC_27.L_CORE X_NUC_97.L_CORE 0.003443
K_2398 X_NUC_27.L_CORE X_NUC_98.L_CORE 0.004534
K_2399 X_NUC_27.L_CORE X_NUC_99.L_CORE 0.002431
K_2400 X_NUC_27.L_CORE X_NUC_100.L_CORE 0.004516
K_2401 X_NUC_27.L_CORE X_NUC_101.L_CORE 0.002855
K_2402 X_NUC_27.L_CORE X_NUC_102.L_CORE 0.002723
K_2403 X_NUC_27.L_CORE X_NUC_103.L_CORE 0.003310
K_2404 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.002973
K_2405 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.003000
K_2406 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.002968
K_2407 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.003002
K_2408 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.004031
K_2409 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.004105
K_2410 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.004073
K_2411 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.004047
K_2412 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.005838
K_2413 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.005815
K_2414 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.005718
K_2415 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.005870
K_2416 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.002671
K_2417 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.002702
K_2418 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.002674
K_2419 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.002689
K_2420 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.007517
K_2421 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.007648
K_2422 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.007539
K_2423 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.007379
K_2424 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.003226
K_2425 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.003243
K_2426 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.003201
K_2427 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.003245
K_2428 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.002999
K_2429 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.003039
K_2430 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.003008
K_2431 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.003007
K_2432 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.006653
K_2433 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.006615
K_2434 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.006463
K_2435 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.006540
K_2436 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.002636
K_2437 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.002660
K_2438 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.002628
K_2439 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.002648
K_2440 X_NUC_28.L_CORE X_NUC_65.L_CORE 0.003976
K_2441 X_NUC_28.L_CORE X_NUC_66.L_CORE 0.004027
K_2442 X_NUC_28.L_CORE X_NUC_67.L_CORE 0.003975
K_2443 X_NUC_28.L_CORE X_NUC_68.L_CORE 0.003953
K_2444 X_NUC_28.L_CORE X_NUC_69.L_CORE 0.003651
K_2445 X_NUC_28.L_CORE X_NUC_70.L_CORE 0.003660
K_2446 X_NUC_28.L_CORE X_NUC_71.L_CORE 0.003602
K_2447 X_NUC_28.L_CORE X_NUC_72.L_CORE 0.003647
K_2448 X_NUC_28.L_CORE X_NUC_73.L_CORE 0.002701
K_2449 X_NUC_28.L_CORE X_NUC_74.L_CORE 0.002729
K_2450 X_NUC_28.L_CORE X_NUC_75.L_CORE 0.002697
K_2451 X_NUC_28.L_CORE X_NUC_76.L_CORE 0.002705
K_2452 X_NUC_28.L_CORE X_NUC_77.L_CORE 0.004302
K_2453 X_NUC_28.L_CORE X_NUC_78.L_CORE 0.004325
K_2454 X_NUC_28.L_CORE X_NUC_79.L_CORE 0.004252
K_2455 X_NUC_28.L_CORE X_NUC_80.L_CORE 0.004255
K_2456 X_NUC_28.L_CORE X_NUC_81.L_CORE 0.002898
K_2457 X_NUC_28.L_CORE X_NUC_82.L_CORE 0.002916
K_2458 X_NUC_28.L_CORE X_NUC_83.L_CORE 0.002876
K_2459 X_NUC_28.L_CORE X_NUC_84.L_CORE 0.002898
K_2460 X_NUC_28.L_CORE X_NUC_85.L_CORE 0.003097
K_2461 X_NUC_28.L_CORE X_NUC_86.L_CORE 0.003124
K_2462 X_NUC_28.L_CORE X_NUC_87.L_CORE 0.003081
K_2463 X_NUC_28.L_CORE X_NUC_88.L_CORE 0.003087
K_2464 X_NUC_28.L_CORE X_NUC_89.L_CORE 0.004031
K_2465 X_NUC_28.L_CORE X_NUC_90.L_CORE 0.007121
K_2466 X_NUC_28.L_CORE X_NUC_91.L_CORE 0.002871
K_2467 X_NUC_28.L_CORE X_NUC_92.L_CORE 0.006058
K_2468 X_NUC_28.L_CORE X_NUC_93.L_CORE 0.003853
K_2469 X_NUC_28.L_CORE X_NUC_94.L_CORE 0.002748
K_2470 X_NUC_28.L_CORE X_NUC_95.L_CORE 0.015470
K_2471 X_NUC_28.L_CORE X_NUC_96.L_CORE 0.002627
K_2472 X_NUC_28.L_CORE X_NUC_97.L_CORE 0.003465
K_2473 X_NUC_28.L_CORE X_NUC_98.L_CORE 0.004460
K_2474 X_NUC_28.L_CORE X_NUC_99.L_CORE 0.002420
K_2475 X_NUC_28.L_CORE X_NUC_100.L_CORE 0.004551
K_2476 X_NUC_28.L_CORE X_NUC_101.L_CORE 0.002828
K_2477 X_NUC_28.L_CORE X_NUC_102.L_CORE 0.002722
K_2478 X_NUC_28.L_CORE X_NUC_103.L_CORE 0.003297
K_2479 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_2480 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_2481 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_2482 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.002906
K_2483 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.002909
K_2484 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.002926
K_2485 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.002886
K_2486 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.003941
K_2487 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.003875
K_2488 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.003915
K_2489 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.003886
K_2490 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.005761
K_2491 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.005878
K_2492 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.005834
K_2493 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.005733
K_2494 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.002641
K_2495 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.002629
K_2496 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.002646
K_2497 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.002616
K_2498 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.007358
K_2499 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.007162
K_2500 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.007136
K_2501 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.007154
K_2502 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.003218
K_2503 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.003234
K_2504 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.003236
K_2505 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.003192
K_2506 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.002994
K_2507 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.002964
K_2508 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.002981
K_2509 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.002955
K_2510 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.006540
K_2511 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.006608
K_2512 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.006464
K_2513 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.006419
K_2514 X_NUC_29.L_CORE X_NUC_65.L_CORE 0.002661
K_2515 X_NUC_29.L_CORE X_NUC_66.L_CORE 0.002658
K_2516 X_NUC_29.L_CORE X_NUC_67.L_CORE 0.002665
K_2517 X_NUC_29.L_CORE X_NUC_68.L_CORE 0.002634
K_2518 X_NUC_29.L_CORE X_NUC_69.L_CORE 0.003966
K_2519 X_NUC_29.L_CORE X_NUC_70.L_CORE 0.003915
K_2520 X_NUC_29.L_CORE X_NUC_71.L_CORE 0.003914
K_2521 X_NUC_29.L_CORE X_NUC_72.L_CORE 0.003894
K_2522 X_NUC_29.L_CORE X_NUC_73.L_CORE 0.003669
K_2523 X_NUC_29.L_CORE X_NUC_74.L_CORE 0.003689
K_2524 X_NUC_29.L_CORE X_NUC_75.L_CORE 0.003667
K_2525 X_NUC_29.L_CORE X_NUC_76.L_CORE 0.003626
K_2526 X_NUC_29.L_CORE X_NUC_77.L_CORE 0.002773
K_2527 X_NUC_29.L_CORE X_NUC_78.L_CORE 0.002758
K_2528 X_NUC_29.L_CORE X_NUC_79.L_CORE 0.002763
K_2529 X_NUC_29.L_CORE X_NUC_80.L_CORE 0.002738
K_2530 X_NUC_29.L_CORE X_NUC_81.L_CORE 0.004100
K_2531 X_NUC_29.L_CORE X_NUC_82.L_CORE 0.004084
K_2532 X_NUC_29.L_CORE X_NUC_83.L_CORE 0.004052
K_2533 X_NUC_29.L_CORE X_NUC_84.L_CORE 0.004028
K_2534 X_NUC_29.L_CORE X_NUC_85.L_CORE 0.003044
K_2535 X_NUC_29.L_CORE X_NUC_86.L_CORE 0.003041
K_2536 X_NUC_29.L_CORE X_NUC_87.L_CORE 0.003034
K_2537 X_NUC_29.L_CORE X_NUC_88.L_CORE 0.003005
K_2538 X_NUC_29.L_CORE X_NUC_89.L_CORE 0.003680
K_2539 X_NUC_29.L_CORE X_NUC_90.L_CORE 0.003588
K_2540 X_NUC_29.L_CORE X_NUC_91.L_CORE 0.007748
K_2541 X_NUC_29.L_CORE X_NUC_92.L_CORE 0.002678
K_2542 X_NUC_29.L_CORE X_NUC_93.L_CORE 0.005676
K_2543 X_NUC_29.L_CORE X_NUC_94.L_CORE 0.003740
K_2544 X_NUC_29.L_CORE X_NUC_95.L_CORE 0.002644
K_2545 X_NUC_29.L_CORE X_NUC_96.L_CORE 0.013448
K_2546 X_NUC_29.L_CORE X_NUC_97.L_CORE 0.002589
K_2547 X_NUC_29.L_CORE X_NUC_98.L_CORE 0.003364
K_2548 X_NUC_29.L_CORE X_NUC_99.L_CORE 0.004390
K_2549 X_NUC_29.L_CORE X_NUC_100.L_CORE 0.002429
K_2550 X_NUC_29.L_CORE X_NUC_101.L_CORE 0.004276
K_2551 X_NUC_29.L_CORE X_NUC_102.L_CORE 0.002873
K_2552 X_NUC_29.L_CORE X_NUC_103.L_CORE 0.002811
K_2553 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_2554 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_2555 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.002903
K_2556 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.002906
K_2557 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.002923
K_2558 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.002883
K_2559 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.004010
K_2560 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.003941
K_2561 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.003983
K_2562 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.003953
K_2563 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.005647
K_2564 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.005761
K_2565 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.005717
K_2566 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.005623
K_2567 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.002654
K_2568 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.002641
K_2569 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.002659
K_2570 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.002628
K_2571 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.007560
K_2572 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.007358
K_2573 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.007325
K_2574 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.007344
K_2575 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.003201
K_2576 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.003218
K_2577 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.003219
K_2578 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.003176
K_2579 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.003024
K_2580 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.002994
K_2581 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.003011
K_2582 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.002985
K_2583 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.006468
K_2584 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.006540
K_2585 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.006398
K_2586 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.006354
K_2587 X_NUC_30.L_CORE X_NUC_65.L_CORE 0.002665
K_2588 X_NUC_30.L_CORE X_NUC_66.L_CORE 0.002661
K_2589 X_NUC_30.L_CORE X_NUC_67.L_CORE 0.002668
K_2590 X_NUC_30.L_CORE X_NUC_68.L_CORE 0.002638
K_2591 X_NUC_30.L_CORE X_NUC_69.L_CORE 0.004016
K_2592 X_NUC_30.L_CORE X_NUC_70.L_CORE 0.003966
K_2593 X_NUC_30.L_CORE X_NUC_71.L_CORE 0.003964
K_2594 X_NUC_30.L_CORE X_NUC_72.L_CORE 0.003943
K_2595 X_NUC_30.L_CORE X_NUC_73.L_CORE 0.003648
K_2596 X_NUC_30.L_CORE X_NUC_74.L_CORE 0.003669
K_2597 X_NUC_30.L_CORE X_NUC_75.L_CORE 0.003647
K_2598 X_NUC_30.L_CORE X_NUC_76.L_CORE 0.003607
K_2599 X_NUC_30.L_CORE X_NUC_77.L_CORE 0.002788
K_2600 X_NUC_30.L_CORE X_NUC_78.L_CORE 0.002773
K_2601 X_NUC_30.L_CORE X_NUC_79.L_CORE 0.002778
K_2602 X_NUC_30.L_CORE X_NUC_80.L_CORE 0.002752
K_2603 X_NUC_30.L_CORE X_NUC_81.L_CORE 0.004115
K_2604 X_NUC_30.L_CORE X_NUC_82.L_CORE 0.004100
K_2605 X_NUC_30.L_CORE X_NUC_83.L_CORE 0.004067
K_2606 X_NUC_30.L_CORE X_NUC_84.L_CORE 0.004043
K_2607 X_NUC_30.L_CORE X_NUC_85.L_CORE 0.003046
K_2608 X_NUC_30.L_CORE X_NUC_86.L_CORE 0.003044
K_2609 X_NUC_30.L_CORE X_NUC_87.L_CORE 0.003036
K_2610 X_NUC_30.L_CORE X_NUC_88.L_CORE 0.003007
K_2611 X_NUC_30.L_CORE X_NUC_89.L_CORE 0.003680
K_2612 X_NUC_30.L_CORE X_NUC_90.L_CORE 0.003630
K_2613 X_NUC_30.L_CORE X_NUC_91.L_CORE 0.007591
K_2614 X_NUC_30.L_CORE X_NUC_92.L_CORE 0.002686
K_2615 X_NUC_30.L_CORE X_NUC_93.L_CORE 0.005833
K_2616 X_NUC_30.L_CORE X_NUC_94.L_CORE 0.003702
K_2617 X_NUC_30.L_CORE X_NUC_95.L_CORE 0.002666
K_2618 X_NUC_30.L_CORE X_NUC_96.L_CORE 0.013307
K_2619 X_NUC_30.L_CORE X_NUC_97.L_CORE 0.002586
K_2620 X_NUC_30.L_CORE X_NUC_98.L_CORE 0.003412
K_2621 X_NUC_30.L_CORE X_NUC_99.L_CORE 0.004335
K_2622 X_NUC_30.L_CORE X_NUC_100.L_CORE 0.002439
K_2623 X_NUC_30.L_CORE X_NUC_101.L_CORE 0.004313
K_2624 X_NUC_30.L_CORE X_NUC_102.L_CORE 0.002866
K_2625 X_NUC_30.L_CORE X_NUC_103.L_CORE 0.002825
K_2626 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_2627 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.002886
K_2628 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.002889
K_2629 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.002906
K_2630 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.002866
K_2631 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.003967
K_2632 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.003900
K_2633 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.003941
K_2634 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.003911
K_2635 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.005687
K_2636 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.005801
K_2637 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.005761
K_2638 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.005662
K_2639 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.002637
K_2640 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.002624
K_2641 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.002641
K_2642 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.002611
K_2643 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.007591
K_2644 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.007382
K_2645 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.007358
K_2646 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.007373
K_2647 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.003199
K_2648 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.003216
K_2649 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.003218
K_2650 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.003174
K_2651 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.003007
K_2652 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.002977
K_2653 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.002994
K_2654 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.002968
K_2655 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.006613
K_2656 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.006686
K_2657 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.006540
K_2658 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.006491
K_2659 X_NUC_31.L_CORE X_NUC_65.L_CORE 0.002658
K_2660 X_NUC_31.L_CORE X_NUC_66.L_CORE 0.002654
K_2661 X_NUC_31.L_CORE X_NUC_67.L_CORE 0.002661
K_2662 X_NUC_31.L_CORE X_NUC_68.L_CORE 0.002631
K_2663 X_NUC_31.L_CORE X_NUC_69.L_CORE 0.004018
K_2664 X_NUC_31.L_CORE X_NUC_70.L_CORE 0.003966
K_2665 X_NUC_31.L_CORE X_NUC_71.L_CORE 0.003966
K_2666 X_NUC_31.L_CORE X_NUC_72.L_CORE 0.003945
K_2667 X_NUC_31.L_CORE X_NUC_73.L_CORE 0.003670
K_2668 X_NUC_31.L_CORE X_NUC_74.L_CORE 0.003690
K_2669 X_NUC_31.L_CORE X_NUC_75.L_CORE 0.003669
K_2670 X_NUC_31.L_CORE X_NUC_76.L_CORE 0.003628
K_2671 X_NUC_31.L_CORE X_NUC_77.L_CORE 0.002782
K_2672 X_NUC_31.L_CORE X_NUC_78.L_CORE 0.002768
K_2673 X_NUC_31.L_CORE X_NUC_79.L_CORE 0.002773
K_2674 X_NUC_31.L_CORE X_NUC_80.L_CORE 0.002747
K_2675 X_NUC_31.L_CORE X_NUC_81.L_CORE 0.004148
K_2676 X_NUC_31.L_CORE X_NUC_82.L_CORE 0.004133
K_2677 X_NUC_31.L_CORE X_NUC_83.L_CORE 0.004100
K_2678 X_NUC_31.L_CORE X_NUC_84.L_CORE 0.004074
K_2679 X_NUC_31.L_CORE X_NUC_85.L_CORE 0.003054
K_2680 X_NUC_31.L_CORE X_NUC_86.L_CORE 0.003051
K_2681 X_NUC_31.L_CORE X_NUC_87.L_CORE 0.003044
K_2682 X_NUC_31.L_CORE X_NUC_88.L_CORE 0.003014
K_2683 X_NUC_31.L_CORE X_NUC_89.L_CORE 0.003629
K_2684 X_NUC_31.L_CORE X_NUC_90.L_CORE 0.003572
K_2685 X_NUC_31.L_CORE X_NUC_91.L_CORE 0.007470
K_2686 X_NUC_31.L_CORE X_NUC_92.L_CORE 0.002662
K_2687 X_NUC_31.L_CORE X_NUC_93.L_CORE 0.005732
K_2688 X_NUC_31.L_CORE X_NUC_94.L_CORE 0.003694
K_2689 X_NUC_31.L_CORE X_NUC_95.L_CORE 0.002644
K_2690 X_NUC_31.L_CORE X_NUC_96.L_CORE 0.014160
K_2691 X_NUC_31.L_CORE X_NUC_97.L_CORE 0.002577
K_2692 X_NUC_31.L_CORE X_NUC_98.L_CORE 0.003395
K_2693 X_NUC_31.L_CORE X_NUC_99.L_CORE 0.004384
K_2694 X_NUC_31.L_CORE X_NUC_100.L_CORE 0.002431
K_2695 X_NUC_31.L_CORE X_NUC_101.L_CORE 0.004349
K_2696 X_NUC_31.L_CORE X_NUC_102.L_CORE 0.002875
K_2697 X_NUC_31.L_CORE X_NUC_103.L_CORE 0.002828
K_2698 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.002926
K_2699 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.002929
K_2700 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.002947
K_2701 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.002906
K_2702 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.003998
K_2703 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.003929
K_2704 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.003971
K_2705 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.003941
K_2706 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.005785
K_2707 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.005905
K_2708 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.005861
K_2709 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.005761
K_2710 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.002668
K_2711 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.002655
K_2712 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.002672
K_2713 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.002641
K_2714 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.007569
K_2715 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.007362
K_2716 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.007333
K_2717 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.007358
K_2718 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.003243
K_2719 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.003260
K_2720 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.003262
K_2721 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.003218
K_2722 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.003034
K_2723 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.003003
K_2724 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.003020
K_2725 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.002994
K_2726 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.006662
K_2727 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.006737
K_2728 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.006584
K_2729 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.006540
K_2730 X_NUC_32.L_CORE X_NUC_65.L_CORE 0.002689
K_2731 X_NUC_32.L_CORE X_NUC_66.L_CORE 0.002685
K_2732 X_NUC_32.L_CORE X_NUC_67.L_CORE 0.002692
K_2733 X_NUC_32.L_CORE X_NUC_68.L_CORE 0.002661
K_2734 X_NUC_32.L_CORE X_NUC_69.L_CORE 0.004040
K_2735 X_NUC_32.L_CORE X_NUC_70.L_CORE 0.003987
K_2736 X_NUC_32.L_CORE X_NUC_71.L_CORE 0.003986
K_2737 X_NUC_32.L_CORE X_NUC_72.L_CORE 0.003966
K_2738 X_NUC_32.L_CORE X_NUC_73.L_CORE 0.003711
K_2739 X_NUC_32.L_CORE X_NUC_74.L_CORE 0.003733
K_2740 X_NUC_32.L_CORE X_NUC_75.L_CORE 0.003710
K_2741 X_NUC_32.L_CORE X_NUC_76.L_CORE 0.003669
K_2742 X_NUC_32.L_CORE X_NUC_77.L_CORE 0.002809
K_2743 X_NUC_32.L_CORE X_NUC_78.L_CORE 0.002794
K_2744 X_NUC_32.L_CORE X_NUC_79.L_CORE 0.002799
K_2745 X_NUC_32.L_CORE X_NUC_80.L_CORE 0.002773
K_2746 X_NUC_32.L_CORE X_NUC_81.L_CORE 0.004175
K_2747 X_NUC_32.L_CORE X_NUC_82.L_CORE 0.004159
K_2748 X_NUC_32.L_CORE X_NUC_83.L_CORE 0.004125
K_2749 X_NUC_32.L_CORE X_NUC_84.L_CORE 0.004100
K_2750 X_NUC_32.L_CORE X_NUC_85.L_CORE 0.003084
K_2751 X_NUC_32.L_CORE X_NUC_86.L_CORE 0.003081
K_2752 X_NUC_32.L_CORE X_NUC_87.L_CORE 0.003074
K_2753 X_NUC_32.L_CORE X_NUC_88.L_CORE 0.003044
K_2754 X_NUC_32.L_CORE X_NUC_89.L_CORE 0.003683
K_2755 X_NUC_32.L_CORE X_NUC_90.L_CORE 0.003609
K_2756 X_NUC_32.L_CORE X_NUC_91.L_CORE 0.007608
K_2757 X_NUC_32.L_CORE X_NUC_92.L_CORE 0.002695
K_2758 X_NUC_32.L_CORE X_NUC_93.L_CORE 0.005738
K_2759 X_NUC_32.L_CORE X_NUC_94.L_CORE 0.003748
K_2760 X_NUC_32.L_CORE X_NUC_95.L_CORE 0.002669
K_2761 X_NUC_32.L_CORE X_NUC_96.L_CORE 0.013660
K_2762 X_NUC_32.L_CORE X_NUC_97.L_CORE 0.002609
K_2763 X_NUC_32.L_CORE X_NUC_98.L_CORE 0.003413
K_2764 X_NUC_32.L_CORE X_NUC_99.L_CORE 0.004427
K_2765 X_NUC_32.L_CORE X_NUC_100.L_CORE 0.002455
K_2766 X_NUC_32.L_CORE X_NUC_101.L_CORE 0.004355
K_2767 X_NUC_32.L_CORE X_NUC_102.L_CORE 0.002903
K_2768 X_NUC_32.L_CORE X_NUC_103.L_CORE 0.002849
K_2769 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_2770 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_2771 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_2772 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.002843
K_2773 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.002815
K_2774 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.002815
K_2775 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.002841
K_2776 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.003875
K_2777 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.003903
K_2778 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.003849
K_2779 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.003915
K_2780 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.005698
K_2781 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.005553
K_2782 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.005592
K_2783 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.005591
K_2784 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.002619
K_2785 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.002608
K_2786 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.002594
K_2787 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.002624
K_2788 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.007350
K_2789 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.007500
K_2790 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.007240
K_2791 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.007368
K_2792 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.003218
K_2793 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.003177
K_2794 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.003175
K_2795 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.003196
K_2796 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.003007
K_2797 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.003010
K_2798 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.002977
K_2799 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.003017
K_2800 X_NUC_33.L_CORE X_NUC_65.L_CORE 0.006501
K_2801 X_NUC_33.L_CORE X_NUC_66.L_CORE 0.006414
K_2802 X_NUC_33.L_CORE X_NUC_67.L_CORE 0.006329
K_2803 X_NUC_33.L_CORE X_NUC_68.L_CORE 0.006334
K_2804 X_NUC_33.L_CORE X_NUC_69.L_CORE 0.002702
K_2805 X_NUC_33.L_CORE X_NUC_70.L_CORE 0.002684
K_2806 X_NUC_33.L_CORE X_NUC_71.L_CORE 0.002670
K_2807 X_NUC_33.L_CORE X_NUC_72.L_CORE 0.002695
K_2808 X_NUC_33.L_CORE X_NUC_73.L_CORE 0.003991
K_2809 X_NUC_33.L_CORE X_NUC_74.L_CORE 0.004009
K_2810 X_NUC_33.L_CORE X_NUC_75.L_CORE 0.003937
K_2811 X_NUC_33.L_CORE X_NUC_76.L_CORE 0.003988
K_2812 X_NUC_33.L_CORE X_NUC_77.L_CORE 0.003703
K_2813 X_NUC_33.L_CORE X_NUC_78.L_CORE 0.003662
K_2814 X_NUC_33.L_CORE X_NUC_79.L_CORE 0.003640
K_2815 X_NUC_33.L_CORE X_NUC_80.L_CORE 0.003660
K_2816 X_NUC_33.L_CORE X_NUC_81.L_CORE 0.002895
K_2817 X_NUC_33.L_CORE X_NUC_82.L_CORE 0.002887
K_2818 X_NUC_33.L_CORE X_NUC_83.L_CORE 0.002859
K_2819 X_NUC_33.L_CORE X_NUC_84.L_CORE 0.002889
K_2820 X_NUC_33.L_CORE X_NUC_85.L_CORE 0.003815
K_2821 X_NUC_33.L_CORE X_NUC_86.L_CORE 0.003803
K_2822 X_NUC_33.L_CORE X_NUC_87.L_CORE 0.003751
K_2823 X_NUC_33.L_CORE X_NUC_88.L_CORE 0.003783
K_2824 X_NUC_33.L_CORE X_NUC_89.L_CORE 0.005018
K_2825 X_NUC_33.L_CORE X_NUC_90.L_CORE 0.003256
K_2826 X_NUC_33.L_CORE X_NUC_91.L_CORE 0.003355
K_2827 X_NUC_33.L_CORE X_NUC_92.L_CORE 0.007700
K_2828 X_NUC_33.L_CORE X_NUC_93.L_CORE 0.002545
K_2829 X_NUC_33.L_CORE X_NUC_94.L_CORE 0.005616
K_2830 X_NUC_33.L_CORE X_NUC_95.L_CORE 0.003584
K_2831 X_NUC_33.L_CORE X_NUC_96.L_CORE 0.002601
K_2832 X_NUC_33.L_CORE X_NUC_97.L_CORE 0.012228
K_2833 X_NUC_33.L_CORE X_NUC_98.L_CORE 0.002563
K_2834 X_NUC_33.L_CORE X_NUC_99.L_CORE 0.003384
K_2835 X_NUC_33.L_CORE X_NUC_100.L_CORE 0.004256
K_2836 X_NUC_33.L_CORE X_NUC_101.L_CORE 0.002489
K_2837 X_NUC_33.L_CORE X_NUC_102.L_CORE 0.004071
K_2838 X_NUC_33.L_CORE X_NUC_103.L_CORE 0.002965
K_2839 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_2840 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_2841 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.002872
K_2842 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.002843
K_2843 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.002842
K_2844 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.002870
K_2845 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.003847
K_2846 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.003875
K_2847 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.003822
K_2848 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.003886
K_2849 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.005851
K_2850 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.005698
K_2851 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.005738
K_2852 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.005738
K_2853 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.002630
K_2854 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.002619
K_2855 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.002605
K_2856 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.002635
K_2857 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.007200
K_2858 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.007350
K_2859 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.007100
K_2860 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.007222
K_2861 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.003260
K_2862 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.003218
K_2863 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.003215
K_2864 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.003238
K_2865 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.003003
K_2866 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.003007
K_2867 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.002974
K_2868 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.003014
K_2869 X_NUC_34.L_CORE X_NUC_65.L_CORE 0.006585
K_2870 X_NUC_34.L_CORE X_NUC_66.L_CORE 0.006501
K_2871 X_NUC_34.L_CORE X_NUC_67.L_CORE 0.006410
K_2872 X_NUC_34.L_CORE X_NUC_68.L_CORE 0.006414
K_2873 X_NUC_34.L_CORE X_NUC_69.L_CORE 0.002720
K_2874 X_NUC_34.L_CORE X_NUC_70.L_CORE 0.002702
K_2875 X_NUC_34.L_CORE X_NUC_71.L_CORE 0.002688
K_2876 X_NUC_34.L_CORE X_NUC_72.L_CORE 0.002714
K_2877 X_NUC_34.L_CORE X_NUC_73.L_CORE 0.003971
K_2878 X_NUC_34.L_CORE X_NUC_74.L_CORE 0.003991
K_2879 X_NUC_34.L_CORE X_NUC_75.L_CORE 0.003919
K_2880 X_NUC_34.L_CORE X_NUC_76.L_CORE 0.003969
K_2881 X_NUC_34.L_CORE X_NUC_77.L_CORE 0.003745
K_2882 X_NUC_34.L_CORE X_NUC_78.L_CORE 0.003703
K_2883 X_NUC_34.L_CORE X_NUC_79.L_CORE 0.003680
K_2884 X_NUC_34.L_CORE X_NUC_80.L_CORE 0.003701
K_2885 X_NUC_34.L_CORE X_NUC_81.L_CORE 0.002903
K_2886 X_NUC_34.L_CORE X_NUC_82.L_CORE 0.002895
K_2887 X_NUC_34.L_CORE X_NUC_83.L_CORE 0.002866
K_2888 X_NUC_34.L_CORE X_NUC_84.L_CORE 0.002897
K_2889 X_NUC_34.L_CORE X_NUC_85.L_CORE 0.003826
K_2890 X_NUC_34.L_CORE X_NUC_86.L_CORE 0.003815
K_2891 X_NUC_34.L_CORE X_NUC_87.L_CORE 0.003762
K_2892 X_NUC_34.L_CORE X_NUC_88.L_CORE 0.003794
K_2893 X_NUC_34.L_CORE X_NUC_89.L_CORE 0.005032
K_2894 X_NUC_34.L_CORE X_NUC_90.L_CORE 0.003292
K_2895 X_NUC_34.L_CORE X_NUC_91.L_CORE 0.003346
K_2896 X_NUC_34.L_CORE X_NUC_92.L_CORE 0.007937
K_2897 X_NUC_34.L_CORE X_NUC_93.L_CORE 0.002561
K_2898 X_NUC_34.L_CORE X_NUC_94.L_CORE 0.005508
K_2899 X_NUC_34.L_CORE X_NUC_95.L_CORE 0.003645
K_2900 X_NUC_34.L_CORE X_NUC_96.L_CORE 0.002602
K_2901 X_NUC_34.L_CORE X_NUC_97.L_CORE 0.012105
K_2902 X_NUC_34.L_CORE X_NUC_98.L_CORE 0.002586
K_2903 X_NUC_34.L_CORE X_NUC_99.L_CORE 0.003364
K_2904 X_NUC_34.L_CORE X_NUC_100.L_CORE 0.004319
K_2905 X_NUC_34.L_CORE X_NUC_101.L_CORE 0.002498
K_2906 X_NUC_34.L_CORE X_NUC_102.L_CORE 0.004061
K_2907 X_NUC_34.L_CORE X_NUC_103.L_CORE 0.002985
K_2908 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_2909 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.002872
K_2910 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.002844
K_2911 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.002843
K_2912 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.002870
K_2913 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.003900
K_2914 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.003930
K_2915 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.003875
K_2916 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.003942
K_2917 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.005806
K_2918 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.005655
K_2919 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.005698
K_2920 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.005695
K_2921 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.002644
K_2922 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.002633
K_2923 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.002619
K_2924 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.002650
K_2925 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.007456
K_2926 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.007618
K_2927 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.007350
K_2928 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.007480
K_2929 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.003262
K_2930 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.003220
K_2931 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.003218
K_2932 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.003240
K_2933 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.003037
K_2934 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.003040
K_2935 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.003007
K_2936 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.003048
K_2937 X_NUC_35.L_CORE X_NUC_65.L_CORE 0.006681
K_2938 X_NUC_35.L_CORE X_NUC_66.L_CORE 0.006590
K_2939 X_NUC_35.L_CORE X_NUC_67.L_CORE 0.006501
K_2940 X_NUC_35.L_CORE X_NUC_68.L_CORE 0.006503
K_2941 X_NUC_35.L_CORE X_NUC_69.L_CORE 0.002735
K_2942 X_NUC_35.L_CORE X_NUC_70.L_CORE 0.002717
K_2943 X_NUC_35.L_CORE X_NUC_71.L_CORE 0.002702
K_2944 X_NUC_35.L_CORE X_NUC_72.L_CORE 0.002728
K_2945 X_NUC_35.L_CORE X_NUC_73.L_CORE 0.004045
K_2946 X_NUC_35.L_CORE X_NUC_74.L_CORE 0.004065
K_2947 X_NUC_35.L_CORE X_NUC_75.L_CORE 0.003991
K_2948 X_NUC_35.L_CORE X_NUC_76.L_CORE 0.004043
K_2949 X_NUC_35.L_CORE X_NUC_77.L_CORE 0.003769
K_2950 X_NUC_35.L_CORE X_NUC_78.L_CORE 0.003726
K_2951 X_NUC_35.L_CORE X_NUC_79.L_CORE 0.003703
K_2952 X_NUC_35.L_CORE X_NUC_80.L_CORE 0.003724
K_2953 X_NUC_35.L_CORE X_NUC_81.L_CORE 0.002932
K_2954 X_NUC_35.L_CORE X_NUC_82.L_CORE 0.002924
K_2955 X_NUC_35.L_CORE X_NUC_83.L_CORE 0.002895
K_2956 X_NUC_35.L_CORE X_NUC_84.L_CORE 0.002926
K_2957 X_NUC_35.L_CORE X_NUC_85.L_CORE 0.003881
K_2958 X_NUC_35.L_CORE X_NUC_86.L_CORE 0.003869
K_2959 X_NUC_35.L_CORE X_NUC_87.L_CORE 0.003815
K_2960 X_NUC_35.L_CORE X_NUC_88.L_CORE 0.003848
K_2961 X_NUC_35.L_CORE X_NUC_89.L_CORE 0.004989
K_2962 X_NUC_35.L_CORE X_NUC_90.L_CORE 0.003273
K_2963 X_NUC_35.L_CORE X_NUC_91.L_CORE 0.003362
K_2964 X_NUC_35.L_CORE X_NUC_92.L_CORE 0.007678
K_2965 X_NUC_35.L_CORE X_NUC_93.L_CORE 0.002564
K_2966 X_NUC_35.L_CORE X_NUC_94.L_CORE 0.005604
K_2967 X_NUC_35.L_CORE X_NUC_95.L_CORE 0.003623
K_2968 X_NUC_35.L_CORE X_NUC_96.L_CORE 0.002621
K_2969 X_NUC_35.L_CORE X_NUC_97.L_CORE 0.012496
K_2970 X_NUC_35.L_CORE X_NUC_98.L_CORE 0.002591
K_2971 X_NUC_35.L_CORE X_NUC_99.L_CORE 0.003414
K_2972 X_NUC_35.L_CORE X_NUC_100.L_CORE 0.004332
K_2973 X_NUC_35.L_CORE X_NUC_101.L_CORE 0.002516
K_2974 X_NUC_35.L_CORE X_NUC_102.L_CORE 0.004134
K_2975 X_NUC_35.L_CORE X_NUC_103.L_CORE 0.003008
K_2976 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.002845
K_2977 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.002817
K_2978 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.002817
K_2979 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.002843
K_2980 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.003835
K_2981 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.003863
K_2982 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.003811
K_2983 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.003875
K_2984 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.005807
K_2985 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.005655
K_2986 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.005696
K_2987 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.005698
K_2988 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.002613
K_2989 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.002602
K_2990 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.002589
K_2991 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.002619
K_2992 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.007323
K_2993 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.007476
K_2994 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.007218
K_2995 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.007350
K_2996 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.003239
K_2997 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.003198
K_2998 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.003196
K_2999 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.003218
K_3000 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.002996
K_3001 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.003000
K_3002 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.002967
K_3003 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.003007
K_3004 X_NUC_36.L_CORE X_NUC_65.L_CORE 0.006675
K_3005 X_NUC_36.L_CORE X_NUC_66.L_CORE 0.006584
K_3006 X_NUC_36.L_CORE X_NUC_67.L_CORE 0.006493
K_3007 X_NUC_36.L_CORE X_NUC_68.L_CORE 0.006501
K_3008 X_NUC_36.L_CORE X_NUC_69.L_CORE 0.002709
K_3009 X_NUC_36.L_CORE X_NUC_70.L_CORE 0.002690
K_3010 X_NUC_36.L_CORE X_NUC_71.L_CORE 0.002676
K_3011 X_NUC_36.L_CORE X_NUC_72.L_CORE 0.002702
K_3012 X_NUC_36.L_CORE X_NUC_73.L_CORE 0.003992
K_3013 X_NUC_36.L_CORE X_NUC_74.L_CORE 0.004011
K_3014 X_NUC_36.L_CORE X_NUC_75.L_CORE 0.003939
K_3015 X_NUC_36.L_CORE X_NUC_76.L_CORE 0.003991
K_3016 X_NUC_36.L_CORE X_NUC_77.L_CORE 0.003746
K_3017 X_NUC_36.L_CORE X_NUC_78.L_CORE 0.003704
K_3018 X_NUC_36.L_CORE X_NUC_79.L_CORE 0.003681
K_3019 X_NUC_36.L_CORE X_NUC_80.L_CORE 0.003703
K_3020 X_NUC_36.L_CORE X_NUC_81.L_CORE 0.002901
K_3021 X_NUC_36.L_CORE X_NUC_82.L_CORE 0.002892
K_3022 X_NUC_36.L_CORE X_NUC_83.L_CORE 0.002864
K_3023 X_NUC_36.L_CORE X_NUC_84.L_CORE 0.002895
K_3024 X_NUC_36.L_CORE X_NUC_85.L_CORE 0.003847
K_3025 X_NUC_36.L_CORE X_NUC_86.L_CORE 0.003835
K_3026 X_NUC_36.L_CORE X_NUC_87.L_CORE 0.003782
K_3027 X_NUC_36.L_CORE X_NUC_88.L_CORE 0.003815
K_3028 X_NUC_36.L_CORE X_NUC_89.L_CORE 0.004923
K_3029 X_NUC_36.L_CORE X_NUC_90.L_CORE 0.003243
K_3030 X_NUC_36.L_CORE X_NUC_91.L_CORE 0.003313
K_3031 X_NUC_36.L_CORE X_NUC_92.L_CORE 0.007715
K_3032 X_NUC_36.L_CORE X_NUC_93.L_CORE 0.002537
K_3033 X_NUC_36.L_CORE X_NUC_94.L_CORE 0.005503
K_3034 X_NUC_36.L_CORE X_NUC_95.L_CORE 0.003610
K_3035 X_NUC_36.L_CORE X_NUC_96.L_CORE 0.002588
K_3036 X_NUC_36.L_CORE X_NUC_97.L_CORE 0.012792
K_3037 X_NUC_36.L_CORE X_NUC_98.L_CORE 0.002570
K_3038 X_NUC_36.L_CORE X_NUC_99.L_CORE 0.003369
K_3039 X_NUC_36.L_CORE X_NUC_100.L_CORE 0.004331
K_3040 X_NUC_36.L_CORE X_NUC_101.L_CORE 0.002491
K_3041 X_NUC_36.L_CORE X_NUC_102.L_CORE 0.004101
K_3042 X_NUC_36.L_CORE X_NUC_103.L_CORE 0.002988
K_3043 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_3044 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_3045 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_3046 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.002808
K_3047 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.002846
K_3048 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.002825
K_3049 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.002825
K_3050 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.003843
K_3051 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.003867
K_3052 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.003882
K_3053 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.003815
K_3054 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.005677
K_3055 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.005790
K_3056 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.005650
K_3057 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.005748
K_3058 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.002619
K_3059 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.002648
K_3060 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.002636
K_3061 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.002621
K_3062 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.007358
K_3063 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.007346
K_3064 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.007331
K_3065 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.007142
K_3066 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.003245
K_3067 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.003292
K_3068 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.003250
K_3069 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.003261
K_3070 X_NUC_37.L_CORE X_NUC_65.L_CORE 0.003047
K_3071 X_NUC_37.L_CORE X_NUC_66.L_CORE 0.003072
K_3072 X_NUC_37.L_CORE X_NUC_67.L_CORE 0.003064
K_3073 X_NUC_37.L_CORE X_NUC_68.L_CORE 0.003031
K_3074 X_NUC_37.L_CORE X_NUC_69.L_CORE 0.006417
K_3075 X_NUC_37.L_CORE X_NUC_70.L_CORE 0.006494
K_3076 X_NUC_37.L_CORE X_NUC_71.L_CORE 0.006311
K_3077 X_NUC_37.L_CORE X_NUC_72.L_CORE 0.006350
K_3078 X_NUC_37.L_CORE X_NUC_73.L_CORE 0.002776
K_3079 X_NUC_37.L_CORE X_NUC_74.L_CORE 0.002809
K_3080 X_NUC_37.L_CORE X_NUC_75.L_CORE 0.002784
K_3081 X_NUC_37.L_CORE X_NUC_76.L_CORE 0.002777
K_3082 X_NUC_37.L_CORE X_NUC_77.L_CORE 0.004024
K_3083 X_NUC_37.L_CORE X_NUC_78.L_CORE 0.004051
K_3084 X_NUC_37.L_CORE X_NUC_79.L_CORE 0.004023
K_3085 X_NUC_37.L_CORE X_NUC_80.L_CORE 0.003975
K_3086 X_NUC_37.L_CORE X_NUC_81.L_CORE 0.003746
K_3087 X_NUC_37.L_CORE X_NUC_82.L_CORE 0.003792
K_3088 X_NUC_37.L_CORE X_NUC_83.L_CORE 0.003731
K_3089 X_NUC_37.L_CORE X_NUC_84.L_CORE 0.003737
K_3090 X_NUC_37.L_CORE X_NUC_85.L_CORE 0.003131
K_3091 X_NUC_37.L_CORE X_NUC_86.L_CORE 0.003162
K_3092 X_NUC_37.L_CORE X_NUC_87.L_CORE 0.003133
K_3093 X_NUC_37.L_CORE X_NUC_88.L_CORE 0.003116
K_3094 X_NUC_37.L_CORE X_NUC_89.L_CORE 0.003135
K_3095 X_NUC_37.L_CORE X_NUC_90.L_CORE 0.005912
K_3096 X_NUC_37.L_CORE X_NUC_91.L_CORE 0.003076
K_3097 X_NUC_37.L_CORE X_NUC_92.L_CORE 0.003201
K_3098 X_NUC_37.L_CORE X_NUC_93.L_CORE 0.007966
K_3099 X_NUC_37.L_CORE X_NUC_94.L_CORE 0.002489
K_3100 X_NUC_37.L_CORE X_NUC_95.L_CORE 0.005438
K_3101 X_NUC_37.L_CORE X_NUC_96.L_CORE 0.003585
K_3102 X_NUC_37.L_CORE X_NUC_97.L_CORE 0.002595
K_3103 X_NUC_37.L_CORE X_NUC_98.L_CORE 0.010972
K_3104 X_NUC_37.L_CORE X_NUC_99.L_CORE 0.002611
K_3105 X_NUC_37.L_CORE X_NUC_100.L_CORE 0.003404
K_3106 X_NUC_37.L_CORE X_NUC_101.L_CORE 0.004239
K_3107 X_NUC_37.L_CORE X_NUC_102.L_CORE 0.002627
K_3108 X_NUC_37.L_CORE X_NUC_103.L_CORE 0.003730
K_3109 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_3110 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_3111 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.002770
K_3112 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.002808
K_3113 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.002788
K_3114 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.002787
K_3115 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.003819
K_3116 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.003843
K_3117 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.003857
K_3118 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.003792
K_3119 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.005567
K_3120 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.005677
K_3121 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.005543
K_3122 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.005636
K_3123 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.002590
K_3124 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.002619
K_3125 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.002607
K_3126 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.002593
K_3127 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.007360
K_3128 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.007358
K_3129 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.007338
K_3130 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.007148
K_3131 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.003199
K_3132 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.003245
K_3133 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.003204
K_3134 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.003215
K_3135 X_NUC_38.L_CORE X_NUC_65.L_CORE 0.003021
K_3136 X_NUC_38.L_CORE X_NUC_66.L_CORE 0.003047
K_3137 X_NUC_38.L_CORE X_NUC_67.L_CORE 0.003038
K_3138 X_NUC_38.L_CORE X_NUC_68.L_CORE 0.003006
K_3139 X_NUC_38.L_CORE X_NUC_69.L_CORE 0.006338
K_3140 X_NUC_38.L_CORE X_NUC_70.L_CORE 0.006417
K_3141 X_NUC_38.L_CORE X_NUC_71.L_CORE 0.006237
K_3142 X_NUC_38.L_CORE X_NUC_72.L_CORE 0.006275
K_3143 X_NUC_38.L_CORE X_NUC_73.L_CORE 0.002744
K_3144 X_NUC_38.L_CORE X_NUC_74.L_CORE 0.002776
K_3145 X_NUC_38.L_CORE X_NUC_75.L_CORE 0.002752
K_3146 X_NUC_38.L_CORE X_NUC_76.L_CORE 0.002745
K_3147 X_NUC_38.L_CORE X_NUC_77.L_CORE 0.003997
K_3148 X_NUC_38.L_CORE X_NUC_78.L_CORE 0.004024
K_3149 X_NUC_38.L_CORE X_NUC_79.L_CORE 0.003996
K_3150 X_NUC_38.L_CORE X_NUC_80.L_CORE 0.003949
K_3151 X_NUC_38.L_CORE X_NUC_81.L_CORE 0.003699
K_3152 X_NUC_38.L_CORE X_NUC_82.L_CORE 0.003746
K_3153 X_NUC_38.L_CORE X_NUC_83.L_CORE 0.003686
K_3154 X_NUC_38.L_CORE X_NUC_84.L_CORE 0.003692
K_3155 X_NUC_38.L_CORE X_NUC_85.L_CORE 0.003100
K_3156 X_NUC_38.L_CORE X_NUC_86.L_CORE 0.003131
K_3157 X_NUC_38.L_CORE X_NUC_87.L_CORE 0.003103
K_3158 X_NUC_38.L_CORE X_NUC_88.L_CORE 0.003086
K_3159 X_NUC_38.L_CORE X_NUC_89.L_CORE 0.003101
K_3160 X_NUC_38.L_CORE X_NUC_90.L_CORE 0.005870
K_3161 X_NUC_38.L_CORE X_NUC_91.L_CORE 0.003034
K_3162 X_NUC_38.L_CORE X_NUC_92.L_CORE 0.003177
K_3163 X_NUC_38.L_CORE X_NUC_93.L_CORE 0.007827
K_3164 X_NUC_38.L_CORE X_NUC_94.L_CORE 0.002461
K_3165 X_NUC_38.L_CORE X_NUC_95.L_CORE 0.005450
K_3166 X_NUC_38.L_CORE X_NUC_96.L_CORE 0.003532
K_3167 X_NUC_38.L_CORE X_NUC_97.L_CORE 0.002572
K_3168 X_NUC_38.L_CORE X_NUC_98.L_CORE 0.011118
K_3169 X_NUC_38.L_CORE X_NUC_99.L_CORE 0.002580
K_3170 X_NUC_38.L_CORE X_NUC_100.L_CORE 0.003387
K_3171 X_NUC_38.L_CORE X_NUC_101.L_CORE 0.004191
K_3172 X_NUC_38.L_CORE X_NUC_102.L_CORE 0.002603
K_3173 X_NUC_38.L_CORE X_NUC_103.L_CORE 0.003706
K_3174 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_3175 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.002789
K_3176 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.002827
K_3177 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.002808
K_3178 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.002806
K_3179 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.003805
K_3180 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.003828
K_3181 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.003843
K_3182 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.003778
K_3183 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.005701
K_3184 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.005817
K_3185 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.005677
K_3186 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.005775
K_3187 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.002601
K_3188 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.002630
K_3189 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.002619
K_3190 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.002604
K_3191 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.007375
K_3192 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.007368
K_3193 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.007358
K_3194 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.007162
K_3195 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.003239
K_3196 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.003286
K_3197 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.003245
K_3198 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.003255
K_3199 X_NUC_39.L_CORE X_NUC_65.L_CORE 0.003029
K_3200 X_NUC_39.L_CORE X_NUC_66.L_CORE 0.003055
K_3201 X_NUC_39.L_CORE X_NUC_67.L_CORE 0.003047
K_3202 X_NUC_39.L_CORE X_NUC_68.L_CORE 0.003014
K_3203 X_NUC_39.L_CORE X_NUC_69.L_CORE 0.006523
K_3204 X_NUC_39.L_CORE X_NUC_70.L_CORE 0.006607
K_3205 X_NUC_39.L_CORE X_NUC_71.L_CORE 0.006417
K_3206 X_NUC_39.L_CORE X_NUC_72.L_CORE 0.006455
K_3207 X_NUC_39.L_CORE X_NUC_73.L_CORE 0.002767
K_3208 X_NUC_39.L_CORE X_NUC_74.L_CORE 0.002800
K_3209 X_NUC_39.L_CORE X_NUC_75.L_CORE 0.002776
K_3210 X_NUC_39.L_CORE X_NUC_76.L_CORE 0.002768
K_3211 X_NUC_39.L_CORE X_NUC_77.L_CORE 0.004025
K_3212 X_NUC_39.L_CORE X_NUC_78.L_CORE 0.004052
K_3213 X_NUC_39.L_CORE X_NUC_79.L_CORE 0.004024
K_3214 X_NUC_39.L_CORE X_NUC_80.L_CORE 0.003976
K_3215 X_NUC_39.L_CORE X_NUC_81.L_CORE 0.003759
K_3216 X_NUC_39.L_CORE X_NUC_82.L_CORE 0.003807
K_3217 X_NUC_39.L_CORE X_NUC_83.L_CORE 0.003746
K_3218 X_NUC_39.L_CORE X_NUC_84.L_CORE 0.003751
K_3219 X_NUC_39.L_CORE X_NUC_85.L_CORE 0.003128
K_3220 X_NUC_39.L_CORE X_NUC_86.L_CORE 0.003160
K_3221 X_NUC_39.L_CORE X_NUC_87.L_CORE 0.003131
K_3222 X_NUC_39.L_CORE X_NUC_88.L_CORE 0.003114
K_3223 X_NUC_39.L_CORE X_NUC_89.L_CORE 0.003090
K_3224 X_NUC_39.L_CORE X_NUC_90.L_CORE 0.005757
K_3225 X_NUC_39.L_CORE X_NUC_91.L_CORE 0.003045
K_3226 X_NUC_39.L_CORE X_NUC_92.L_CORE 0.003159
K_3227 X_NUC_39.L_CORE X_NUC_93.L_CORE 0.007902
K_3228 X_NUC_39.L_CORE X_NUC_94.L_CORE 0.002468
K_3229 X_NUC_39.L_CORE X_NUC_95.L_CORE 0.005372
K_3230 X_NUC_39.L_CORE X_NUC_96.L_CORE 0.003577
K_3231 X_NUC_39.L_CORE X_NUC_97.L_CORE 0.002575
K_3232 X_NUC_39.L_CORE X_NUC_98.L_CORE 0.011492
K_3233 X_NUC_39.L_CORE X_NUC_99.L_CORE 0.002602
K_3234 X_NUC_39.L_CORE X_NUC_100.L_CORE 0.003392
K_3235 X_NUC_39.L_CORE X_NUC_101.L_CORE 0.004276
K_3236 X_NUC_39.L_CORE X_NUC_102.L_CORE 0.002621
K_3237 X_NUC_39.L_CORE X_NUC_103.L_CORE 0.003749
K_3238 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.002790
K_3239 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.002828
K_3240 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.002808
K_3241 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.002808
K_3242 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.003871
K_3243 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.003896
K_3244 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.003911
K_3245 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.003843
K_3246 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.005605
K_3247 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.005715
K_3248 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.005580
K_3249 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.005677
K_3250 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.002616
K_3251 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.002645
K_3252 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.002634
K_3253 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.002619
K_3254 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.007584
K_3255 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.007577
K_3256 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.007561
K_3257 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.007358
K_3258 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.003228
K_3259 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.003275
K_3260 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.003233
K_3261 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.003245
K_3262 X_NUC_40.L_CORE X_NUC_65.L_CORE 0.003061
K_3263 X_NUC_40.L_CORE X_NUC_66.L_CORE 0.003088
K_3264 X_NUC_40.L_CORE X_NUC_67.L_CORE 0.003079
K_3265 X_NUC_40.L_CORE X_NUC_68.L_CORE 0.003047
K_3266 X_NUC_40.L_CORE X_NUC_69.L_CORE 0.006481
K_3267 X_NUC_40.L_CORE X_NUC_70.L_CORE 0.006564
K_3268 X_NUC_40.L_CORE X_NUC_71.L_CORE 0.006374
K_3269 X_NUC_40.L_CORE X_NUC_72.L_CORE 0.006417
K_3270 X_NUC_40.L_CORE X_NUC_73.L_CORE 0.002775
K_3271 X_NUC_40.L_CORE X_NUC_74.L_CORE 0.002808
K_3272 X_NUC_40.L_CORE X_NUC_75.L_CORE 0.002783
K_3273 X_NUC_40.L_CORE X_NUC_76.L_CORE 0.002776
K_3274 X_NUC_40.L_CORE X_NUC_77.L_CORE 0.004074
K_3275 X_NUC_40.L_CORE X_NUC_78.L_CORE 0.004102
K_3276 X_NUC_40.L_CORE X_NUC_79.L_CORE 0.004073
K_3277 X_NUC_40.L_CORE X_NUC_80.L_CORE 0.004024
K_3278 X_NUC_40.L_CORE X_NUC_81.L_CORE 0.003753
K_3279 X_NUC_40.L_CORE X_NUC_82.L_CORE 0.003801
K_3280 X_NUC_40.L_CORE X_NUC_83.L_CORE 0.003739
K_3281 X_NUC_40.L_CORE X_NUC_84.L_CORE 0.003746
K_3282 X_NUC_40.L_CORE X_NUC_85.L_CORE 0.003146
K_3283 X_NUC_40.L_CORE X_NUC_86.L_CORE 0.003178
K_3284 X_NUC_40.L_CORE X_NUC_87.L_CORE 0.003148
K_3285 X_NUC_40.L_CORE X_NUC_88.L_CORE 0.003131
K_3286 X_NUC_40.L_CORE X_NUC_89.L_CORE 0.003109
K_3287 X_NUC_40.L_CORE X_NUC_90.L_CORE 0.005820
K_3288 X_NUC_40.L_CORE X_NUC_91.L_CORE 0.003041
K_3289 X_NUC_40.L_CORE X_NUC_92.L_CORE 0.003199
K_3290 X_NUC_40.L_CORE X_NUC_93.L_CORE 0.007688
K_3291 X_NUC_40.L_CORE X_NUC_94.L_CORE 0.002477
K_3292 X_NUC_40.L_CORE X_NUC_95.L_CORE 0.005514
K_3293 X_NUC_40.L_CORE X_NUC_96.L_CORE 0.003547
K_3294 X_NUC_40.L_CORE X_NUC_97.L_CORE 0.002598
K_3295 X_NUC_40.L_CORE X_NUC_98.L_CORE 0.011424
K_3296 X_NUC_40.L_CORE X_NUC_99.L_CORE 0.002602
K_3297 X_NUC_40.L_CORE X_NUC_100.L_CORE 0.003438
K_3298 X_NUC_40.L_CORE X_NUC_101.L_CORE 0.004243
K_3299 X_NUC_40.L_CORE X_NUC_102.L_CORE 0.002634
K_3300 X_NUC_40.L_CORE X_NUC_103.L_CORE 0.003771
K_3301 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_3302 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_3303 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_3304 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.002796
K_3305 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.002768
K_3306 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.002793
K_3307 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.002768
K_3308 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.003843
K_3309 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.003782
K_3310 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.003790
K_3311 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.003821
K_3312 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.005698
K_3313 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.005676
K_3314 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.005727
K_3315 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.005583
K_3316 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.002641
K_3317 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.002610
K_3318 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.002625
K_3319 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.002617
K_3320 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.007379
K_3321 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.007237
K_3322 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.007127
K_3323 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.007259
K_3324 X_NUC_41.L_CORE X_NUC_65.L_CORE 0.003300
K_3325 X_NUC_41.L_CORE X_NUC_66.L_CORE 0.003272
K_3326 X_NUC_41.L_CORE X_NUC_67.L_CORE 0.003293
K_3327 X_NUC_41.L_CORE X_NUC_68.L_CORE 0.003254
K_3328 X_NUC_41.L_CORE X_NUC_69.L_CORE 0.003117
K_3329 X_NUC_41.L_CORE X_NUC_70.L_CORE 0.003075
K_3330 X_NUC_41.L_CORE X_NUC_71.L_CORE 0.003080
K_3331 X_NUC_41.L_CORE X_NUC_72.L_CORE 0.003086
K_3332 X_NUC_41.L_CORE X_NUC_73.L_CORE 0.006279
K_3333 X_NUC_41.L_CORE X_NUC_74.L_CORE 0.006229
K_3334 X_NUC_41.L_CORE X_NUC_75.L_CORE 0.006177
K_3335 X_NUC_41.L_CORE X_NUC_76.L_CORE 0.006104
K_3336 X_NUC_41.L_CORE X_NUC_77.L_CORE 0.002895
K_3337 X_NUC_41.L_CORE X_NUC_78.L_CORE 0.002863
K_3338 X_NUC_41.L_CORE X_NUC_79.L_CORE 0.002875
K_3339 X_NUC_41.L_CORE X_NUC_80.L_CORE 0.002858
K_3340 X_NUC_41.L_CORE X_NUC_81.L_CORE 0.004056
K_3341 X_NUC_41.L_CORE X_NUC_82.L_CORE 0.004001
K_3342 X_NUC_41.L_CORE X_NUC_83.L_CORE 0.003985
K_3343 X_NUC_41.L_CORE X_NUC_84.L_CORE 0.003995
K_3344 X_NUC_41.L_CORE X_NUC_85.L_CORE 0.003773
K_3345 X_NUC_41.L_CORE X_NUC_86.L_CORE 0.003735
K_3346 X_NUC_41.L_CORE X_NUC_87.L_CORE 0.003734
K_3347 X_NUC_41.L_CORE X_NUC_88.L_CORE 0.003706
K_3348 X_NUC_41.L_CORE X_NUC_89.L_CORE 0.003790
K_3349 X_NUC_41.L_CORE X_NUC_90.L_CORE 0.002759
K_3350 X_NUC_41.L_CORE X_NUC_91.L_CORE 0.006483
K_3351 X_NUC_41.L_CORE X_NUC_92.L_CORE 0.002910
K_3352 X_NUC_41.L_CORE X_NUC_93.L_CORE 0.003069
K_3353 X_NUC_41.L_CORE X_NUC_94.L_CORE 0.008003
K_3354 X_NUC_41.L_CORE X_NUC_95.L_CORE 0.002420
K_3355 X_NUC_41.L_CORE X_NUC_96.L_CORE 0.005346
K_3356 X_NUC_41.L_CORE X_NUC_97.L_CORE 0.003536
K_3357 X_NUC_41.L_CORE X_NUC_98.L_CORE 0.002582
K_3358 X_NUC_41.L_CORE X_NUC_99.L_CORE 0.010010
K_3359 X_NUC_41.L_CORE X_NUC_100.L_CORE 0.002642
K_3360 X_NUC_41.L_CORE X_NUC_101.L_CORE 0.003431
K_3361 X_NUC_41.L_CORE X_NUC_102.L_CORE 0.004109
K_3362 X_NUC_41.L_CORE X_NUC_103.L_CORE 0.002863
K_3363 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_3364 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_3365 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.002824
K_3366 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.002796
K_3367 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.002821
K_3368 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.002796
K_3369 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.003907
K_3370 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.003843
K_3371 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.003851
K_3372 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.003884
K_3373 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.005716
K_3374 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.005698
K_3375 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.005748
K_3376 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.005602
K_3377 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.002674
K_3378 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.002641
K_3379 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.002657
K_3380 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.002649
K_3381 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.007520
K_3382 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.007379
K_3383 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.007259
K_3384 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.007397
K_3385 X_NUC_42.L_CORE X_NUC_65.L_CORE 0.003329
K_3386 X_NUC_42.L_CORE X_NUC_66.L_CORE 0.003300
K_3387 X_NUC_42.L_CORE X_NUC_67.L_CORE 0.003322
K_3388 X_NUC_42.L_CORE X_NUC_68.L_CORE 0.003282
K_3389 X_NUC_42.L_CORE X_NUC_69.L_CORE 0.003160
K_3390 X_NUC_42.L_CORE X_NUC_70.L_CORE 0.003117
K_3391 X_NUC_42.L_CORE X_NUC_71.L_CORE 0.003123
K_3392 X_NUC_42.L_CORE X_NUC_72.L_CORE 0.003128
K_3393 X_NUC_42.L_CORE X_NUC_73.L_CORE 0.006324
K_3394 X_NUC_42.L_CORE X_NUC_74.L_CORE 0.006279
K_3395 X_NUC_42.L_CORE X_NUC_75.L_CORE 0.006222
K_3396 X_NUC_42.L_CORE X_NUC_76.L_CORE 0.006148
K_3397 X_NUC_42.L_CORE X_NUC_77.L_CORE 0.002926
K_3398 X_NUC_42.L_CORE X_NUC_78.L_CORE 0.002895
K_3399 X_NUC_42.L_CORE X_NUC_79.L_CORE 0.002906
K_3400 X_NUC_42.L_CORE X_NUC_80.L_CORE 0.002889
K_3401 X_NUC_42.L_CORE X_NUC_81.L_CORE 0.004111
K_3402 X_NUC_42.L_CORE X_NUC_82.L_CORE 0.004056
K_3403 X_NUC_42.L_CORE X_NUC_83.L_CORE 0.004038
K_3404 X_NUC_42.L_CORE X_NUC_84.L_CORE 0.004048
K_3405 X_NUC_42.L_CORE X_NUC_85.L_CORE 0.003811
K_3406 X_NUC_42.L_CORE X_NUC_86.L_CORE 0.003773
K_3407 X_NUC_42.L_CORE X_NUC_87.L_CORE 0.003771
K_3408 X_NUC_42.L_CORE X_NUC_88.L_CORE 0.003742
K_3409 X_NUC_42.L_CORE X_NUC_89.L_CORE 0.003823
K_3410 X_NUC_42.L_CORE X_NUC_90.L_CORE 0.002791
K_3411 X_NUC_42.L_CORE X_NUC_91.L_CORE 0.006553
K_3412 X_NUC_42.L_CORE X_NUC_92.L_CORE 0.002935
K_3413 X_NUC_42.L_CORE X_NUC_93.L_CORE 0.003111
K_3414 X_NUC_42.L_CORE X_NUC_94.L_CORE 0.007932
K_3415 X_NUC_42.L_CORE X_NUC_95.L_CORE 0.002446
K_3416 X_NUC_42.L_CORE X_NUC_96.L_CORE 0.005431
K_3417 X_NUC_42.L_CORE X_NUC_97.L_CORE 0.003555
K_3418 X_NUC_42.L_CORE X_NUC_98.L_CORE 0.002614
K_3419 X_NUC_42.L_CORE X_NUC_99.L_CORE 0.009955
K_3420 X_NUC_42.L_CORE X_NUC_100.L_CORE 0.002666
K_3421 X_NUC_42.L_CORE X_NUC_101.L_CORE 0.003475
K_3422 X_NUC_42.L_CORE X_NUC_102.L_CORE 0.004132
K_3423 X_NUC_42.L_CORE X_NUC_103.L_CORE 0.002892
K_3424 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_3425 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.002799
K_3426 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.002771
K_3427 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.002796
K_3428 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.002771
K_3429 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.003898
K_3430 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.003834
K_3431 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.003843
K_3432 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.003875
K_3433 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.005665
K_3434 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.005646
K_3435 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.005698
K_3436 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.005554
K_3437 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.002657
K_3438 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.002626
K_3439 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.002641
K_3440 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.002633
K_3441 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.007650
K_3442 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.007497
K_3443 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.007379
K_3444 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.007521
K_3445 X_NUC_43.L_CORE X_NUC_65.L_CORE 0.003307
K_3446 X_NUC_43.L_CORE X_NUC_66.L_CORE 0.003279
K_3447 X_NUC_43.L_CORE X_NUC_67.L_CORE 0.003300
K_3448 X_NUC_43.L_CORE X_NUC_68.L_CORE 0.003261
K_3449 X_NUC_43.L_CORE X_NUC_69.L_CORE 0.003154
K_3450 X_NUC_43.L_CORE X_NUC_70.L_CORE 0.003111
K_3451 X_NUC_43.L_CORE X_NUC_71.L_CORE 0.003117
K_3452 X_NUC_43.L_CORE X_NUC_72.L_CORE 0.003122
K_3453 X_NUC_43.L_CORE X_NUC_73.L_CORE 0.006381
K_3454 X_NUC_43.L_CORE X_NUC_74.L_CORE 0.006332
K_3455 X_NUC_43.L_CORE X_NUC_75.L_CORE 0.006279
K_3456 X_NUC_43.L_CORE X_NUC_76.L_CORE 0.006200
K_3457 X_NUC_43.L_CORE X_NUC_77.L_CORE 0.002915
K_3458 X_NUC_43.L_CORE X_NUC_78.L_CORE 0.002883
K_3459 X_NUC_43.L_CORE X_NUC_79.L_CORE 0.002895
K_3460 X_NUC_43.L_CORE X_NUC_80.L_CORE 0.002877
K_3461 X_NUC_43.L_CORE X_NUC_81.L_CORE 0.004129
K_3462 X_NUC_43.L_CORE X_NUC_82.L_CORE 0.004072
K_3463 X_NUC_43.L_CORE X_NUC_83.L_CORE 0.004056
K_3464 X_NUC_43.L_CORE X_NUC_84.L_CORE 0.004065
K_3465 X_NUC_43.L_CORE X_NUC_85.L_CORE 0.003813
K_3466 X_NUC_43.L_CORE X_NUC_86.L_CORE 0.003774
K_3467 X_NUC_43.L_CORE X_NUC_87.L_CORE 0.003773
K_3468 X_NUC_43.L_CORE X_NUC_88.L_CORE 0.003744
K_3469 X_NUC_43.L_CORE X_NUC_89.L_CORE 0.003754
K_3470 X_NUC_43.L_CORE X_NUC_90.L_CORE 0.002759
K_3471 X_NUC_43.L_CORE X_NUC_91.L_CORE 0.006416
K_3472 X_NUC_43.L_CORE X_NUC_92.L_CORE 0.002898
K_3473 X_NUC_43.L_CORE X_NUC_93.L_CORE 0.003089
K_3474 X_NUC_43.L_CORE X_NUC_94.L_CORE 0.007753
K_3475 X_NUC_43.L_CORE X_NUC_95.L_CORE 0.002426
K_3476 X_NUC_43.L_CORE X_NUC_96.L_CORE 0.005449
K_3477 X_NUC_43.L_CORE X_NUC_97.L_CORE 0.003523
K_3478 X_NUC_43.L_CORE X_NUC_98.L_CORE 0.002603
K_3479 X_NUC_43.L_CORE X_NUC_99.L_CORE 0.010341
K_3480 X_NUC_43.L_CORE X_NUC_100.L_CORE 0.002652
K_3481 X_NUC_43.L_CORE X_NUC_101.L_CORE 0.003485
K_3482 X_NUC_43.L_CORE X_NUC_102.L_CORE 0.004142
K_3483 X_NUC_43.L_CORE X_NUC_103.L_CORE 0.002890
K_3484 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.002824
K_3485 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.002795
K_3486 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.002821
K_3487 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.002796
K_3488 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.003865
K_3489 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.003803
K_3490 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.003811
K_3491 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.003843
K_3492 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.005816
K_3493 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.005795
K_3494 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.005849
K_3495 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.005698
K_3496 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.002666
K_3497 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.002634
K_3498 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.002650
K_3499 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.002641
K_3500 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.007497
K_3501 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.007352
K_3502 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.007237
K_3503 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.007379
K_3504 X_NUC_44.L_CORE X_NUC_65.L_CORE 0.003348
K_3505 X_NUC_44.L_CORE X_NUC_66.L_CORE 0.003318
K_3506 X_NUC_44.L_CORE X_NUC_67.L_CORE 0.003340
K_3507 X_NUC_44.L_CORE X_NUC_68.L_CORE 0.003300
K_3508 X_NUC_44.L_CORE X_NUC_69.L_CORE 0.003148
K_3509 X_NUC_44.L_CORE X_NUC_70.L_CORE 0.003105
K_3510 X_NUC_44.L_CORE X_NUC_71.L_CORE 0.003111
K_3511 X_NUC_44.L_CORE X_NUC_72.L_CORE 0.003117
K_3512 X_NUC_44.L_CORE X_NUC_73.L_CORE 0.006464
K_3513 X_NUC_44.L_CORE X_NUC_74.L_CORE 0.006413
K_3514 X_NUC_44.L_CORE X_NUC_75.L_CORE 0.006356
K_3515 X_NUC_44.L_CORE X_NUC_76.L_CORE 0.006279
K_3516 X_NUC_44.L_CORE X_NUC_77.L_CORE 0.002932
K_3517 X_NUC_44.L_CORE X_NUC_78.L_CORE 0.002900
K_3518 X_NUC_44.L_CORE X_NUC_79.L_CORE 0.002912
K_3519 X_NUC_44.L_CORE X_NUC_80.L_CORE 0.002895
K_3520 X_NUC_44.L_CORE X_NUC_81.L_CORE 0.004119
K_3521 X_NUC_44.L_CORE X_NUC_82.L_CORE 0.004062
K_3522 X_NUC_44.L_CORE X_NUC_83.L_CORE 0.004045
K_3523 X_NUC_44.L_CORE X_NUC_84.L_CORE 0.004056
K_3524 X_NUC_44.L_CORE X_NUC_85.L_CORE 0.003842
K_3525 X_NUC_44.L_CORE X_NUC_86.L_CORE 0.003803
K_3526 X_NUC_44.L_CORE X_NUC_87.L_CORE 0.003801
K_3527 X_NUC_44.L_CORE X_NUC_88.L_CORE 0.003773
K_3528 X_NUC_44.L_CORE X_NUC_89.L_CORE 0.003785
K_3529 X_NUC_44.L_CORE X_NUC_90.L_CORE 0.002765
K_3530 X_NUC_44.L_CORE X_NUC_91.L_CORE 0.006364
K_3531 X_NUC_44.L_CORE X_NUC_92.L_CORE 0.002928
K_3532 X_NUC_44.L_CORE X_NUC_93.L_CORE 0.003074
K_3533 X_NUC_44.L_CORE X_NUC_94.L_CORE 0.008017
K_3534 X_NUC_44.L_CORE X_NUC_95.L_CORE 0.002438
K_3535 X_NUC_44.L_CORE X_NUC_96.L_CORE 0.005338
K_3536 X_NUC_44.L_CORE X_NUC_97.L_CORE 0.003580
K_3537 X_NUC_44.L_CORE X_NUC_98.L_CORE 0.002601
K_3538 X_NUC_44.L_CORE X_NUC_99.L_CORE 0.010319
K_3539 X_NUC_44.L_CORE X_NUC_100.L_CORE 0.002673
K_3540 X_NUC_44.L_CORE X_NUC_101.L_CORE 0.003466
K_3541 X_NUC_44.L_CORE X_NUC_102.L_CORE 0.004189
K_3542 X_NUC_44.L_CORE X_NUC_103.L_CORE 0.002900
K_3543 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_3544 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_3545 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_3546 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.002808
K_3547 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.002812
K_3548 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.002789
K_3549 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.002827
K_3550 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.003875
K_3551 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.003945
K_3552 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.003893
K_3553 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.003912
K_3554 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.005761
K_3555 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.005678
K_3556 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.005625
K_3557 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.005747
K_3558 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.002689
K_3559 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.002707
K_3560 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.002679
K_3561 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.002708
K_3562 X_NUC_45.L_CORE X_NUC_65.L_CORE 0.007412
K_3563 X_NUC_45.L_CORE X_NUC_66.L_CORE 0.007616
K_3564 X_NUC_45.L_CORE X_NUC_67.L_CORE 0.007383
K_3565 X_NUC_45.L_CORE X_NUC_68.L_CORE 0.007391
K_3566 X_NUC_45.L_CORE X_NUC_69.L_CORE 0.003390
K_3567 X_NUC_45.L_CORE X_NUC_70.L_CORE 0.003385
K_3568 X_NUC_45.L_CORE X_NUC_71.L_CORE 0.003348
K_3569 X_NUC_45.L_CORE X_NUC_72.L_CORE 0.003399
K_3570 X_NUC_45.L_CORE X_NUC_73.L_CORE 0.003225
K_3571 X_NUC_45.L_CORE X_NUC_74.L_CORE 0.003263
K_3572 X_NUC_45.L_CORE X_NUC_75.L_CORE 0.003216
K_3573 X_NUC_45.L_CORE X_NUC_76.L_CORE 0.003243
K_3574 X_NUC_45.L_CORE X_NUC_77.L_CORE 0.006065
K_3575 X_NUC_45.L_CORE X_NUC_78.L_CORE 0.006062
K_3576 X_NUC_45.L_CORE X_NUC_79.L_CORE 0.005915
K_3577 X_NUC_45.L_CORE X_NUC_80.L_CORE 0.006004
K_3578 X_NUC_45.L_CORE X_NUC_81.L_CORE 0.003086
K_3579 X_NUC_45.L_CORE X_NUC_82.L_CORE 0.003100
K_3580 X_NUC_45.L_CORE X_NUC_83.L_CORE 0.003059
K_3581 X_NUC_45.L_CORE X_NUC_84.L_CORE 0.003096
K_3582 X_NUC_45.L_CORE X_NUC_85.L_CORE 0.004045
K_3583 X_NUC_45.L_CORE X_NUC_86.L_CORE 0.004084
K_3584 X_NUC_45.L_CORE X_NUC_87.L_CORE 0.004005
K_3585 X_NUC_45.L_CORE X_NUC_88.L_CORE 0.004044
K_3586 X_NUC_45.L_CORE X_NUC_89.L_CORE 0.003551
K_3587 X_NUC_45.L_CORE X_NUC_90.L_CORE 0.003855
K_3588 X_NUC_45.L_CORE X_NUC_91.L_CORE 0.002617
K_3589 X_NUC_45.L_CORE X_NUC_92.L_CORE 0.007093
K_3590 X_NUC_45.L_CORE X_NUC_93.L_CORE 0.002844
K_3591 X_NUC_45.L_CORE X_NUC_94.L_CORE 0.003057
K_3592 X_NUC_45.L_CORE X_NUC_95.L_CORE 0.007937
K_3593 X_NUC_45.L_CORE X_NUC_96.L_CORE 0.002429
K_3594 X_NUC_45.L_CORE X_NUC_97.L_CORE 0.005459
K_3595 X_NUC_45.L_CORE X_NUC_98.L_CORE 0.003563
K_3596 X_NUC_45.L_CORE X_NUC_99.L_CORE 0.002660
K_3597 X_NUC_45.L_CORE X_NUC_100.L_CORE 0.008956
K_3598 X_NUC_45.L_CORE X_NUC_101.L_CORE 0.002765
K_3599 X_NUC_45.L_CORE X_NUC_102.L_CORE 0.003573
K_3600 X_NUC_45.L_CORE X_NUC_103.L_CORE 0.003932
K_3601 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_3602 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_3603 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.002803
K_3604 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.002808
K_3605 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.002785
K_3606 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.002823
K_3607 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.003808
K_3608 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.003875
K_3609 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.003825
K_3610 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.003843
K_3611 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.005844
K_3612 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.005761
K_3613 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.005704
K_3614 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.005831
K_3615 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.002671
K_3616 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.002689
K_3617 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.002661
K_3618 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.002689
K_3619 X_NUC_46.L_CORE X_NUC_65.L_CORE 0.007214
K_3620 X_NUC_46.L_CORE X_NUC_66.L_CORE 0.007412
K_3621 X_NUC_46.L_CORE X_NUC_67.L_CORE 0.007191
K_3622 X_NUC_46.L_CORE X_NUC_68.L_CORE 0.007199
K_3623 X_NUC_46.L_CORE X_NUC_69.L_CORE 0.003394
K_3624 X_NUC_46.L_CORE X_NUC_70.L_CORE 0.003390
K_3625 X_NUC_46.L_CORE X_NUC_71.L_CORE 0.003353
K_3626 X_NUC_46.L_CORE X_NUC_72.L_CORE 0.003404
K_3627 X_NUC_46.L_CORE X_NUC_73.L_CORE 0.003189
K_3628 X_NUC_46.L_CORE X_NUC_74.L_CORE 0.003225
K_3629 X_NUC_46.L_CORE X_NUC_75.L_CORE 0.003180
K_3630 X_NUC_46.L_CORE X_NUC_76.L_CORE 0.003207
K_3631 X_NUC_46.L_CORE X_NUC_77.L_CORE 0.006064
K_3632 X_NUC_46.L_CORE X_NUC_78.L_CORE 0.006065
K_3633 X_NUC_46.L_CORE X_NUC_79.L_CORE 0.005916
K_3634 X_NUC_46.L_CORE X_NUC_80.L_CORE 0.006006
K_3635 X_NUC_46.L_CORE X_NUC_81.L_CORE 0.003072
K_3636 X_NUC_46.L_CORE X_NUC_82.L_CORE 0.003086
K_3637 X_NUC_46.L_CORE X_NUC_83.L_CORE 0.003045
K_3638 X_NUC_46.L_CORE X_NUC_84.L_CORE 0.003082
K_3639 X_NUC_46.L_CORE X_NUC_85.L_CORE 0.004005
K_3640 X_NUC_46.L_CORE X_NUC_86.L_CORE 0.004045
K_3641 X_NUC_46.L_CORE X_NUC_87.L_CORE 0.003968
K_3642 X_NUC_46.L_CORE X_NUC_88.L_CORE 0.004005
K_3643 X_NUC_46.L_CORE X_NUC_89.L_CORE 0.003520
K_3644 X_NUC_46.L_CORE X_NUC_90.L_CORE 0.003867
K_3645 X_NUC_46.L_CORE X_NUC_91.L_CORE 0.002598
K_3646 X_NUC_46.L_CORE X_NUC_92.L_CORE 0.006986
K_3647 X_NUC_46.L_CORE X_NUC_93.L_CORE 0.002847
K_3648 X_NUC_46.L_CORE X_NUC_94.L_CORE 0.003017
K_3649 X_NUC_46.L_CORE X_NUC_95.L_CORE 0.008194
K_3650 X_NUC_46.L_CORE X_NUC_96.L_CORE 0.002418
K_3651 X_NUC_46.L_CORE X_NUC_97.L_CORE 0.005322
K_3652 X_NUC_46.L_CORE X_NUC_98.L_CORE 0.003587
K_3653 X_NUC_46.L_CORE X_NUC_99.L_CORE 0.002635
K_3654 X_NUC_46.L_CORE X_NUC_100.L_CORE 0.008950
K_3655 X_NUC_46.L_CORE X_NUC_101.L_CORE 0.002760
K_3656 X_NUC_46.L_CORE X_NUC_102.L_CORE 0.003530
K_3657 X_NUC_46.L_CORE X_NUC_103.L_CORE 0.003929
K_3658 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_3659 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.002825
K_3660 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.002830
K_3661 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.002808
K_3662 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.002846
K_3663 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.003857
K_3664 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.003927
K_3665 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.003875
K_3666 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.003894
K_3667 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.005903
K_3668 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.005816
K_3669 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.005761
K_3670 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.005891
K_3671 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.002699
K_3672 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.002717
K_3673 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.002689
K_3674 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.002718
K_3675 X_NUC_47.L_CORE X_NUC_65.L_CORE 0.007431
K_3676 X_NUC_47.L_CORE X_NUC_66.L_CORE 0.007643
K_3677 X_NUC_47.L_CORE X_NUC_67.L_CORE 0.007412
K_3678 X_NUC_47.L_CORE X_NUC_68.L_CORE 0.007415
K_3679 X_NUC_47.L_CORE X_NUC_69.L_CORE 0.003432
K_3680 X_NUC_47.L_CORE X_NUC_70.L_CORE 0.003427
K_3681 X_NUC_47.L_CORE X_NUC_71.L_CORE 0.003390
K_3682 X_NUC_47.L_CORE X_NUC_72.L_CORE 0.003442
K_3683 X_NUC_47.L_CORE X_NUC_73.L_CORE 0.003234
K_3684 X_NUC_47.L_CORE X_NUC_74.L_CORE 0.003272
K_3685 X_NUC_47.L_CORE X_NUC_75.L_CORE 0.003225
K_3686 X_NUC_47.L_CORE X_NUC_76.L_CORE 0.003253
K_3687 X_NUC_47.L_CORE X_NUC_77.L_CORE 0.006222
K_3688 X_NUC_47.L_CORE X_NUC_78.L_CORE 0.006221
K_3689 X_NUC_47.L_CORE X_NUC_79.L_CORE 0.006065
K_3690 X_NUC_47.L_CORE X_NUC_80.L_CORE 0.006159
K_3691 X_NUC_47.L_CORE X_NUC_81.L_CORE 0.003114
K_3692 X_NUC_47.L_CORE X_NUC_82.L_CORE 0.003128
K_3693 X_NUC_47.L_CORE X_NUC_83.L_CORE 0.003086
K_3694 X_NUC_47.L_CORE X_NUC_84.L_CORE 0.003124
K_3695 X_NUC_47.L_CORE X_NUC_85.L_CORE 0.004084
K_3696 X_NUC_47.L_CORE X_NUC_86.L_CORE 0.004125
K_3697 X_NUC_47.L_CORE X_NUC_87.L_CORE 0.004045
K_3698 X_NUC_47.L_CORE X_NUC_88.L_CORE 0.004084
K_3699 X_NUC_47.L_CORE X_NUC_89.L_CORE 0.003515
K_3700 X_NUC_47.L_CORE X_NUC_90.L_CORE 0.003849
K_3701 X_NUC_47.L_CORE X_NUC_91.L_CORE 0.002610
K_3702 X_NUC_47.L_CORE X_NUC_92.L_CORE 0.006879
K_3703 X_NUC_47.L_CORE X_NUC_93.L_CORE 0.002856
K_3704 X_NUC_47.L_CORE X_NUC_94.L_CORE 0.003039
K_3705 X_NUC_47.L_CORE X_NUC_95.L_CORE 0.008069
K_3706 X_NUC_47.L_CORE X_NUC_96.L_CORE 0.002437
K_3707 X_NUC_47.L_CORE X_NUC_97.L_CORE 0.005389
K_3708 X_NUC_47.L_CORE X_NUC_98.L_CORE 0.003611
K_3709 X_NUC_47.L_CORE X_NUC_99.L_CORE 0.002664
K_3710 X_NUC_47.L_CORE X_NUC_100.L_CORE 0.009239
K_3711 X_NUC_47.L_CORE X_NUC_101.L_CORE 0.002790
K_3712 X_NUC_47.L_CORE X_NUC_102.L_CORE 0.003588
K_3713 X_NUC_47.L_CORE X_NUC_103.L_CORE 0.003996
K_3714 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.002788
K_3715 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.002792
K_3716 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.002770
K_3717 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.002808
K_3718 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.003838
K_3719 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.003907
K_3720 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.003855
K_3721 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.003875
K_3722 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.005771
K_3723 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.005689
K_3724 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.005636
K_3725 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.005761
K_3726 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.002670
K_3727 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.002688
K_3728 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.002660
K_3729 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.002689
K_3730 X_NUC_48.L_CORE X_NUC_65.L_CORE 0.007423
K_3731 X_NUC_48.L_CORE X_NUC_66.L_CORE 0.007634
K_3732 X_NUC_48.L_CORE X_NUC_67.L_CORE 0.007398
K_3733 X_NUC_48.L_CORE X_NUC_68.L_CORE 0.007412
K_3734 X_NUC_48.L_CORE X_NUC_69.L_CORE 0.003380
K_3735 X_NUC_48.L_CORE X_NUC_70.L_CORE 0.003375
K_3736 X_NUC_48.L_CORE X_NUC_71.L_CORE 0.003339
K_3737 X_NUC_48.L_CORE X_NUC_72.L_CORE 0.003390
K_3738 X_NUC_48.L_CORE X_NUC_73.L_CORE 0.003207
K_3739 X_NUC_48.L_CORE X_NUC_74.L_CORE 0.003244
K_3740 X_NUC_48.L_CORE X_NUC_75.L_CORE 0.003198
K_3741 X_NUC_48.L_CORE X_NUC_76.L_CORE 0.003225
K_3742 X_NUC_48.L_CORE X_NUC_77.L_CORE 0.006123
K_3743 X_NUC_48.L_CORE X_NUC_78.L_CORE 0.006122
K_3744 X_NUC_48.L_CORE X_NUC_79.L_CORE 0.005971
K_3745 X_NUC_48.L_CORE X_NUC_80.L_CORE 0.006065
K_3746 X_NUC_48.L_CORE X_NUC_81.L_CORE 0.003076
K_3747 X_NUC_48.L_CORE X_NUC_82.L_CORE 0.003090
K_3748 X_NUC_48.L_CORE X_NUC_83.L_CORE 0.003049
K_3749 X_NUC_48.L_CORE X_NUC_84.L_CORE 0.003086
K_3750 X_NUC_48.L_CORE X_NUC_85.L_CORE 0.004044
K_3751 X_NUC_48.L_CORE X_NUC_86.L_CORE 0.004084
K_3752 X_NUC_48.L_CORE X_NUC_87.L_CORE 0.004005
K_3753 X_NUC_48.L_CORE X_NUC_88.L_CORE 0.004045
K_3754 X_NUC_48.L_CORE X_NUC_89.L_CORE 0.003491
K_3755 X_NUC_48.L_CORE X_NUC_90.L_CORE 0.003802
K_3756 X_NUC_48.L_CORE X_NUC_91.L_CORE 0.002586
K_3757 X_NUC_48.L_CORE X_NUC_92.L_CORE 0.006906
K_3758 X_NUC_48.L_CORE X_NUC_93.L_CORE 0.002819
K_3759 X_NUC_48.L_CORE X_NUC_94.L_CORE 0.003022
K_3760 X_NUC_48.L_CORE X_NUC_95.L_CORE 0.007922
K_3761 X_NUC_48.L_CORE X_NUC_96.L_CORE 0.002410
K_3762 X_NUC_48.L_CORE X_NUC_97.L_CORE 0.005411
K_3763 X_NUC_48.L_CORE X_NUC_98.L_CORE 0.003555
K_3764 X_NUC_48.L_CORE X_NUC_99.L_CORE 0.002642
K_3765 X_NUC_48.L_CORE X_NUC_100.L_CORE 0.009228
K_3766 X_NUC_48.L_CORE X_NUC_101.L_CORE 0.002756
K_3767 X_NUC_48.L_CORE X_NUC_102.L_CORE 0.003567
K_3768 X_NUC_48.L_CORE X_NUC_103.L_CORE 0.003949
K_3769 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_3770 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_3771 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_3772 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.002843
K_3773 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.002866
K_3774 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.002869
K_3775 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.002837
K_3776 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.003941
K_3777 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.003903
K_3778 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.003946
K_3779 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.003884
K_3780 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.005870
K_3781 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.006026
K_3782 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.005931
K_3783 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.005886
K_3784 X_NUC_49.L_CORE X_NUC_65.L_CORE 0.002765
K_3785 X_NUC_49.L_CORE X_NUC_66.L_CORE 0.002771
K_3786 X_NUC_49.L_CORE X_NUC_67.L_CORE 0.002781
K_3787 X_NUC_49.L_CORE X_NUC_68.L_CORE 0.002746
K_3788 X_NUC_49.L_CORE X_NUC_69.L_CORE 0.007445
K_3789 X_NUC_49.L_CORE X_NUC_70.L_CORE 0.007315
K_3790 X_NUC_49.L_CORE X_NUC_71.L_CORE 0.007334
K_3791 X_NUC_49.L_CORE X_NUC_72.L_CORE 0.007189
K_3792 X_NUC_49.L_CORE X_NUC_73.L_CORE 0.003522
K_3793 X_NUC_49.L_CORE X_NUC_74.L_CORE 0.003562
K_3794 X_NUC_49.L_CORE X_NUC_75.L_CORE 0.003545
K_3795 X_NUC_49.L_CORE X_NUC_76.L_CORE 0.003507
K_3796 X_NUC_49.L_CORE X_NUC_77.L_CORE 0.003387
K_3797 X_NUC_49.L_CORE X_NUC_78.L_CORE 0.003379
K_3798 X_NUC_49.L_CORE X_NUC_79.L_CORE 0.003391
K_3799 X_NUC_49.L_CORE X_NUC_80.L_CORE 0.003342
K_3800 X_NUC_49.L_CORE X_NUC_81.L_CORE 0.005734
K_3801 X_NUC_49.L_CORE X_NUC_82.L_CORE 0.005785
K_3802 X_NUC_49.L_CORE X_NUC_83.L_CORE 0.005709
K_3803 X_NUC_49.L_CORE X_NUC_84.L_CORE 0.005632
K_3804 X_NUC_49.L_CORE X_NUC_85.L_CORE 0.003448
K_3805 X_NUC_49.L_CORE X_NUC_86.L_CORE 0.003464
K_3806 X_NUC_49.L_CORE X_NUC_87.L_CORE 0.003456
K_3807 X_NUC_49.L_CORE X_NUC_88.L_CORE 0.003412
K_3808 X_NUC_49.L_CORE X_NUC_89.L_CORE 0.002862
K_3809 X_NUC_49.L_CORE X_NUC_90.L_CORE 0.003533
K_3810 X_NUC_49.L_CORE X_NUC_91.L_CORE 0.003895
K_3811 X_NUC_49.L_CORE X_NUC_92.L_CORE 0.002516
K_3812 X_NUC_49.L_CORE X_NUC_93.L_CORE 0.007434
K_3813 X_NUC_49.L_CORE X_NUC_94.L_CORE 0.002824
K_3814 X_NUC_49.L_CORE X_NUC_95.L_CORE 0.003014
K_3815 X_NUC_49.L_CORE X_NUC_96.L_CORE 0.008360
K_3816 X_NUC_49.L_CORE X_NUC_97.L_CORE 0.002450
K_3817 X_NUC_49.L_CORE X_NUC_98.L_CORE 0.005389
K_3818 X_NUC_49.L_CORE X_NUC_99.L_CORE 0.003678
K_3819 X_NUC_49.L_CORE X_NUC_100.L_CORE 0.002739
K_3820 X_NUC_49.L_CORE X_NUC_101.L_CORE 0.007931
K_3821 X_NUC_49.L_CORE X_NUC_102.L_CORE 0.002960
K_3822 X_NUC_49.L_CORE X_NUC_103.L_CORE 0.003688
K_3823 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_3824 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_3825 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.002821
K_3826 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.002843
K_3827 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.002846
K_3828 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.002815
K_3829 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.003980
K_3830 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.003941
K_3831 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.003985
K_3832 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.003921
K_3833 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.005722
K_3834 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.005870
K_3835 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.005780
K_3836 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.005739
K_3837 X_NUC_50.L_CORE X_NUC_65.L_CORE 0.002759
K_3838 X_NUC_50.L_CORE X_NUC_66.L_CORE 0.002765
K_3839 X_NUC_50.L_CORE X_NUC_67.L_CORE 0.002775
K_3840 X_NUC_50.L_CORE X_NUC_68.L_CORE 0.002739
K_3841 X_NUC_50.L_CORE X_NUC_69.L_CORE 0.007572
K_3842 X_NUC_50.L_CORE X_NUC_70.L_CORE 0.007445
K_3843 X_NUC_50.L_CORE X_NUC_71.L_CORE 0.007461
K_3844 X_NUC_50.L_CORE X_NUC_72.L_CORE 0.007308
K_3845 X_NUC_50.L_CORE X_NUC_73.L_CORE 0.003482
K_3846 X_NUC_50.L_CORE X_NUC_74.L_CORE 0.003522
K_3847 X_NUC_50.L_CORE X_NUC_75.L_CORE 0.003506
K_3848 X_NUC_50.L_CORE X_NUC_76.L_CORE 0.003468
K_3849 X_NUC_50.L_CORE X_NUC_77.L_CORE 0.003394
K_3850 X_NUC_50.L_CORE X_NUC_78.L_CORE 0.003387
K_3851 X_NUC_50.L_CORE X_NUC_79.L_CORE 0.003399
K_3852 X_NUC_50.L_CORE X_NUC_80.L_CORE 0.003350
K_3853 X_NUC_50.L_CORE X_NUC_81.L_CORE 0.005681
K_3854 X_NUC_50.L_CORE X_NUC_82.L_CORE 0.005734
K_3855 X_NUC_50.L_CORE X_NUC_83.L_CORE 0.005658
K_3856 X_NUC_50.L_CORE X_NUC_84.L_CORE 0.005583
K_3857 X_NUC_50.L_CORE X_NUC_85.L_CORE 0.003431
K_3858 X_NUC_50.L_CORE X_NUC_86.L_CORE 0.003448
K_3859 X_NUC_50.L_CORE X_NUC_87.L_CORE 0.003440
K_3860 X_NUC_50.L_CORE X_NUC_88.L_CORE 0.003396
K_3861 X_NUC_50.L_CORE X_NUC_89.L_CORE 0.002850
K_3862 X_NUC_50.L_CORE X_NUC_90.L_CORE 0.003551
K_3863 X_NUC_50.L_CORE X_NUC_91.L_CORE 0.003846
K_3864 X_NUC_50.L_CORE X_NUC_92.L_CORE 0.002514
K_3865 X_NUC_50.L_CORE X_NUC_93.L_CORE 0.007572
K_3866 X_NUC_50.L_CORE X_NUC_94.L_CORE 0.002796
K_3867 X_NUC_50.L_CORE X_NUC_95.L_CORE 0.003033
K_3868 X_NUC_50.L_CORE X_NUC_96.L_CORE 0.008052
K_3869 X_NUC_50.L_CORE X_NUC_97.L_CORE 0.002440
K_3870 X_NUC_50.L_CORE X_NUC_98.L_CORE 0.005504
K_3871 X_NUC_50.L_CORE X_NUC_99.L_CORE 0.003622
K_3872 X_NUC_50.L_CORE X_NUC_100.L_CORE 0.002742
K_3873 X_NUC_50.L_CORE X_NUC_101.L_CORE 0.007916
K_3874 X_NUC_50.L_CORE X_NUC_102.L_CORE 0.002940
K_3875 X_NUC_50.L_CORE X_NUC_103.L_CORE 0.003695
K_3876 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_3877 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.002818
K_3878 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.002840
K_3879 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.002843
K_3880 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.002812
K_3881 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.003936
K_3882 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.003898
K_3883 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.003941
K_3884 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.003879
K_3885 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.005808
K_3886 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.005960
K_3887 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.005870
K_3888 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.005825
K_3889 X_NUC_51.L_CORE X_NUC_65.L_CORE 0.002749
K_3890 X_NUC_51.L_CORE X_NUC_66.L_CORE 0.002756
K_3891 X_NUC_51.L_CORE X_NUC_67.L_CORE 0.002765
K_3892 X_NUC_51.L_CORE X_NUC_68.L_CORE 0.002730
K_3893 X_NUC_51.L_CORE X_NUC_69.L_CORE 0.007551
K_3894 X_NUC_51.L_CORE X_NUC_70.L_CORE 0.007420
K_3895 X_NUC_51.L_CORE X_NUC_71.L_CORE 0.007445
K_3896 X_NUC_51.L_CORE X_NUC_72.L_CORE 0.007289
K_3897 X_NUC_51.L_CORE X_NUC_73.L_CORE 0.003498
K_3898 X_NUC_51.L_CORE X_NUC_74.L_CORE 0.003538
K_3899 X_NUC_51.L_CORE X_NUC_75.L_CORE 0.003522
K_3900 X_NUC_51.L_CORE X_NUC_76.L_CORE 0.003484
K_3901 X_NUC_51.L_CORE X_NUC_77.L_CORE 0.003381
K_3902 X_NUC_51.L_CORE X_NUC_78.L_CORE 0.003374
K_3903 X_NUC_51.L_CORE X_NUC_79.L_CORE 0.003387
K_3904 X_NUC_51.L_CORE X_NUC_80.L_CORE 0.003338
K_3905 X_NUC_51.L_CORE X_NUC_81.L_CORE 0.005756
K_3906 X_NUC_51.L_CORE X_NUC_82.L_CORE 0.005810
K_3907 X_NUC_51.L_CORE X_NUC_83.L_CORE 0.005734
K_3908 X_NUC_51.L_CORE X_NUC_84.L_CORE 0.005655
K_3909 X_NUC_51.L_CORE X_NUC_85.L_CORE 0.003439
K_3910 X_NUC_51.L_CORE X_NUC_86.L_CORE 0.003455
K_3911 X_NUC_51.L_CORE X_NUC_87.L_CORE 0.003448
K_3912 X_NUC_51.L_CORE X_NUC_88.L_CORE 0.003403
K_3913 X_NUC_51.L_CORE X_NUC_89.L_CORE 0.002824
K_3914 X_NUC_51.L_CORE X_NUC_90.L_CORE 0.003493
K_3915 X_NUC_51.L_CORE X_NUC_91.L_CORE 0.003826
K_3916 X_NUC_51.L_CORE X_NUC_92.L_CORE 0.002493
K_3917 X_NUC_51.L_CORE X_NUC_93.L_CORE 0.007326
K_3918 X_NUC_51.L_CORE X_NUC_94.L_CORE 0.002791
K_3919 X_NUC_51.L_CORE X_NUC_95.L_CORE 0.002999
K_3920 X_NUC_51.L_CORE X_NUC_96.L_CORE 0.008191
K_3921 X_NUC_51.L_CORE X_NUC_97.L_CORE 0.002432
K_3922 X_NUC_51.L_CORE X_NUC_98.L_CORE 0.005425
K_3923 X_NUC_51.L_CORE X_NUC_99.L_CORE 0.003647
K_3924 X_NUC_51.L_CORE X_NUC_100.L_CORE 0.002730
K_3925 X_NUC_51.L_CORE X_NUC_101.L_CORE 0.008108
K_3926 X_NUC_51.L_CORE X_NUC_102.L_CORE 0.002947
K_3927 X_NUC_51.L_CORE X_NUC_103.L_CORE 0.003698
K_3928 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.002849
K_3929 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.002872
K_3930 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.002875
K_3931 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.002843
K_3932 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.004000
K_3933 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.003961
K_3934 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.004006
K_3935 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.003941
K_3936 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.005850
K_3937 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.006006
K_3938 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.005912
K_3939 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.005870
K_3940 X_NUC_52.L_CORE X_NUC_65.L_CORE 0.002785
K_3941 X_NUC_52.L_CORE X_NUC_66.L_CORE 0.002791
K_3942 X_NUC_52.L_CORE X_NUC_67.L_CORE 0.002801
K_3943 X_NUC_52.L_CORE X_NUC_68.L_CORE 0.002765
K_3944 X_NUC_52.L_CORE X_NUC_69.L_CORE 0.007720
K_3945 X_NUC_52.L_CORE X_NUC_70.L_CORE 0.007580
K_3946 X_NUC_52.L_CORE X_NUC_71.L_CORE 0.007602
K_3947 X_NUC_52.L_CORE X_NUC_72.L_CORE 0.007445
K_3948 X_NUC_52.L_CORE X_NUC_73.L_CORE 0.003537
K_3949 X_NUC_52.L_CORE X_NUC_74.L_CORE 0.003578
K_3950 X_NUC_52.L_CORE X_NUC_75.L_CORE 0.003561
K_3951 X_NUC_52.L_CORE X_NUC_76.L_CORE 0.003522
K_3952 X_NUC_52.L_CORE X_NUC_77.L_CORE 0.003432
K_3953 X_NUC_52.L_CORE X_NUC_78.L_CORE 0.003424
K_3954 X_NUC_52.L_CORE X_NUC_79.L_CORE 0.003437
K_3955 X_NUC_52.L_CORE X_NUC_80.L_CORE 0.003387
K_3956 X_NUC_52.L_CORE X_NUC_81.L_CORE 0.005838
K_3957 X_NUC_52.L_CORE X_NUC_82.L_CORE 0.005894
K_3958 X_NUC_52.L_CORE X_NUC_83.L_CORE 0.005813
K_3959 X_NUC_52.L_CORE X_NUC_84.L_CORE 0.005734
K_3960 X_NUC_52.L_CORE X_NUC_85.L_CORE 0.003484
K_3961 X_NUC_52.L_CORE X_NUC_86.L_CORE 0.003501
K_3962 X_NUC_52.L_CORE X_NUC_87.L_CORE 0.003493
K_3963 X_NUC_52.L_CORE X_NUC_88.L_CORE 0.003448
K_3964 X_NUC_52.L_CORE X_NUC_89.L_CORE 0.002851
K_3965 X_NUC_52.L_CORE X_NUC_90.L_CORE 0.003530
K_3966 X_NUC_52.L_CORE X_NUC_91.L_CORE 0.003847
K_3967 X_NUC_52.L_CORE X_NUC_92.L_CORE 0.002521
K_3968 X_NUC_52.L_CORE X_NUC_93.L_CORE 0.007358
K_3969 X_NUC_52.L_CORE X_NUC_94.L_CORE 0.002816
K_3970 X_NUC_52.L_CORE X_NUC_95.L_CORE 0.003038
K_3971 X_NUC_52.L_CORE X_NUC_96.L_CORE 0.008117
K_3972 X_NUC_52.L_CORE X_NUC_97.L_CORE 0.002459
K_3973 X_NUC_52.L_CORE X_NUC_98.L_CORE 0.005504
K_3974 X_NUC_52.L_CORE X_NUC_99.L_CORE 0.003674
K_3975 X_NUC_52.L_CORE X_NUC_100.L_CORE 0.002765
K_3976 X_NUC_52.L_CORE X_NUC_101.L_CORE 0.008169
K_3977 X_NUC_52.L_CORE X_NUC_102.L_CORE 0.002979
K_3978 X_NUC_52.L_CORE X_NUC_103.L_CORE 0.003747
K_3979 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_3980 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_3981 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_3982 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.002906
K_3983 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.002867
K_3984 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.002881
K_3985 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.002889
K_3986 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.004047
K_3987 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.004031
K_3988 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.003994
K_3989 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.004069
K_3990 X_NUC_53.L_CORE X_NUC_65.L_CORE 0.006033
K_3991 X_NUC_53.L_CORE X_NUC_66.L_CORE 0.005885
K_3992 X_NUC_53.L_CORE X_NUC_67.L_CORE 0.005952
K_3993 X_NUC_53.L_CORE X_NUC_68.L_CORE 0.005887
K_3994 X_NUC_53.L_CORE X_NUC_69.L_CORE 0.002879
K_3995 X_NUC_53.L_CORE X_NUC_70.L_CORE 0.002848
K_3996 X_NUC_53.L_CORE X_NUC_71.L_CORE 0.002846
K_3997 X_NUC_53.L_CORE X_NUC_72.L_CORE 0.002869
K_3998 X_NUC_53.L_CORE X_NUC_73.L_CORE 0.007462
K_3999 X_NUC_53.L_CORE X_NUC_74.L_CORE 0.007424
K_4000 X_NUC_53.L_CORE X_NUC_75.L_CORE 0.007228
K_4001 X_NUC_53.L_CORE X_NUC_76.L_CORE 0.007418
K_4002 X_NUC_53.L_CORE X_NUC_77.L_CORE 0.003714
K_4003 X_NUC_53.L_CORE X_NUC_78.L_CORE 0.003654
K_4004 X_NUC_53.L_CORE X_NUC_79.L_CORE 0.003664
K_4005 X_NUC_53.L_CORE X_NUC_80.L_CORE 0.003668
K_4006 X_NUC_53.L_CORE X_NUC_81.L_CORE 0.003632
K_4007 X_NUC_53.L_CORE X_NUC_82.L_CORE 0.003597
K_4008 X_NUC_53.L_CORE X_NUC_83.L_CORE 0.003573
K_4009 X_NUC_53.L_CORE X_NUC_84.L_CORE 0.003617
K_4010 X_NUC_53.L_CORE X_NUC_85.L_CORE 0.005159
K_4011 X_NUC_53.L_CORE X_NUC_86.L_CORE 0.005078
K_4012 X_NUC_53.L_CORE X_NUC_87.L_CORE 0.005038
K_4013 X_NUC_53.L_CORE X_NUC_88.L_CORE 0.005072
K_4014 X_NUC_53.L_CORE X_NUC_89.L_CORE 0.003654
K_4015 X_NUC_53.L_CORE X_NUC_90.L_CORE 0.002621
K_4016 X_NUC_53.L_CORE X_NUC_91.L_CORE 0.003532
K_4017 X_NUC_53.L_CORE X_NUC_92.L_CORE 0.003859
K_4018 X_NUC_53.L_CORE X_NUC_93.L_CORE 0.002459
K_4019 X_NUC_53.L_CORE X_NUC_94.L_CORE 0.008001
K_4020 X_NUC_53.L_CORE X_NUC_95.L_CORE 0.002792
K_4021 X_NUC_53.L_CORE X_NUC_96.L_CORE 0.003041
K_4022 X_NUC_53.L_CORE X_NUC_97.L_CORE 0.008314
K_4023 X_NUC_53.L_CORE X_NUC_98.L_CORE 0.002486
K_4024 X_NUC_53.L_CORE X_NUC_99.L_CORE 0.005575
K_4025 X_NUC_53.L_CORE X_NUC_100.L_CORE 0.003747
K_4026 X_NUC_53.L_CORE X_NUC_101.L_CORE 0.002882
K_4027 X_NUC_53.L_CORE X_NUC_102.L_CORE 0.006807
K_4028 X_NUC_53.L_CORE X_NUC_103.L_CORE 0.003299
K_4029 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_4030 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_4031 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.002947
K_4032 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.002906
K_4033 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.002920
K_4034 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.002929
K_4035 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.004063
K_4036 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.004047
K_4037 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.004009
K_4038 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.004085
K_4039 X_NUC_54.L_CORE X_NUC_65.L_CORE 0.006188
K_4040 X_NUC_54.L_CORE X_NUC_66.L_CORE 0.006033
K_4041 X_NUC_54.L_CORE X_NUC_67.L_CORE 0.006103
K_4042 X_NUC_54.L_CORE X_NUC_68.L_CORE 0.006033
K_4043 X_NUC_54.L_CORE X_NUC_69.L_CORE 0.002910
K_4044 X_NUC_54.L_CORE X_NUC_70.L_CORE 0.002879
K_4045 X_NUC_54.L_CORE X_NUC_71.L_CORE 0.002877
K_4046 X_NUC_54.L_CORE X_NUC_72.L_CORE 0.002900
K_4047 X_NUC_54.L_CORE X_NUC_73.L_CORE 0.007492
K_4048 X_NUC_54.L_CORE X_NUC_74.L_CORE 0.007462
K_4049 X_NUC_54.L_CORE X_NUC_75.L_CORE 0.007260
K_4050 X_NUC_54.L_CORE X_NUC_76.L_CORE 0.007451
K_4051 X_NUC_54.L_CORE X_NUC_77.L_CORE 0.003776
K_4052 X_NUC_54.L_CORE X_NUC_78.L_CORE 0.003714
K_4053 X_NUC_54.L_CORE X_NUC_79.L_CORE 0.003723
K_4054 X_NUC_54.L_CORE X_NUC_80.L_CORE 0.003728
K_4055 X_NUC_54.L_CORE X_NUC_81.L_CORE 0.003666
K_4056 X_NUC_54.L_CORE X_NUC_82.L_CORE 0.003632
K_4057 X_NUC_54.L_CORE X_NUC_83.L_CORE 0.003606
K_4058 X_NUC_54.L_CORE X_NUC_84.L_CORE 0.003651
K_4059 X_NUC_54.L_CORE X_NUC_85.L_CORE 0.005240
K_4060 X_NUC_54.L_CORE X_NUC_86.L_CORE 0.005159
K_4061 X_NUC_54.L_CORE X_NUC_87.L_CORE 0.005115
K_4062 X_NUC_54.L_CORE X_NUC_88.L_CORE 0.005151
K_4063 X_NUC_54.L_CORE X_NUC_89.L_CORE 0.003678
K_4064 X_NUC_54.L_CORE X_NUC_90.L_CORE 0.002646
K_4065 X_NUC_54.L_CORE X_NUC_91.L_CORE 0.003538
K_4066 X_NUC_54.L_CORE X_NUC_92.L_CORE 0.003910
K_4067 X_NUC_54.L_CORE X_NUC_93.L_CORE 0.002479
K_4068 X_NUC_54.L_CORE X_NUC_94.L_CORE 0.007876
K_4069 X_NUC_54.L_CORE X_NUC_95.L_CORE 0.002829
K_4070 X_NUC_54.L_CORE X_NUC_96.L_CORE 0.003053
K_4071 X_NUC_54.L_CORE X_NUC_97.L_CORE 0.008498
K_4072 X_NUC_54.L_CORE X_NUC_98.L_CORE 0.002513
K_4073 X_NUC_54.L_CORE X_NUC_99.L_CORE 0.005547
K_4074 X_NUC_54.L_CORE X_NUC_100.L_CORE 0.003810
K_4075 X_NUC_54.L_CORE X_NUC_101.L_CORE 0.002906
K_4076 X_NUC_54.L_CORE X_NUC_102.L_CORE 0.006877
K_4077 X_NUC_54.L_CORE X_NUC_103.L_CORE 0.003340
K_4078 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_4079 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.002932
K_4080 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.002892
K_4081 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.002906
K_4082 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.002914
K_4083 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.004102
K_4084 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.004085
K_4085 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.004047
K_4086 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.004125
K_4087 X_NUC_55.L_CORE X_NUC_65.L_CORE 0.006113
K_4088 X_NUC_55.L_CORE X_NUC_66.L_CORE 0.005961
K_4089 X_NUC_55.L_CORE X_NUC_67.L_CORE 0.006033
K_4090 X_NUC_55.L_CORE X_NUC_68.L_CORE 0.005963
K_4091 X_NUC_55.L_CORE X_NUC_69.L_CORE 0.002912
K_4092 X_NUC_55.L_CORE X_NUC_70.L_CORE 0.002880
K_4093 X_NUC_55.L_CORE X_NUC_71.L_CORE 0.002879
K_4094 X_NUC_55.L_CORE X_NUC_72.L_CORE 0.002902
K_4095 X_NUC_55.L_CORE X_NUC_73.L_CORE 0.007710
K_4096 X_NUC_55.L_CORE X_NUC_74.L_CORE 0.007672
K_4097 X_NUC_55.L_CORE X_NUC_75.L_CORE 0.007462
K_4098 X_NUC_55.L_CORE X_NUC_76.L_CORE 0.007666
K_4099 X_NUC_55.L_CORE X_NUC_77.L_CORE 0.003766
K_4100 X_NUC_55.L_CORE X_NUC_78.L_CORE 0.003704
K_4101 X_NUC_55.L_CORE X_NUC_79.L_CORE 0.003714
K_4102 X_NUC_55.L_CORE X_NUC_80.L_CORE 0.003718
K_4103 X_NUC_55.L_CORE X_NUC_81.L_CORE 0.003692
K_4104 X_NUC_55.L_CORE X_NUC_82.L_CORE 0.003657
K_4105 X_NUC_55.L_CORE X_NUC_83.L_CORE 0.003632
K_4106 X_NUC_55.L_CORE X_NUC_84.L_CORE 0.003677
K_4107 X_NUC_55.L_CORE X_NUC_85.L_CORE 0.005286
K_4108 X_NUC_55.L_CORE X_NUC_86.L_CORE 0.005201
K_4109 X_NUC_55.L_CORE X_NUC_87.L_CORE 0.005159
K_4110 X_NUC_55.L_CORE X_NUC_88.L_CORE 0.005194
K_4111 X_NUC_55.L_CORE X_NUC_89.L_CORE 0.003630
K_4112 X_NUC_55.L_CORE X_NUC_90.L_CORE 0.002624
K_4113 X_NUC_55.L_CORE X_NUC_91.L_CORE 0.003528
K_4114 X_NUC_55.L_CORE X_NUC_92.L_CORE 0.003840
K_4115 X_NUC_55.L_CORE X_NUC_93.L_CORE 0.002472
K_4116 X_NUC_55.L_CORE X_NUC_94.L_CORE 0.007830
K_4117 X_NUC_55.L_CORE X_NUC_95.L_CORE 0.002804
K_4118 X_NUC_55.L_CORE X_NUC_96.L_CORE 0.003064
K_4119 X_NUC_55.L_CORE X_NUC_97.L_CORE 0.008240
K_4120 X_NUC_55.L_CORE X_NUC_98.L_CORE 0.002507
K_4121 X_NUC_55.L_CORE X_NUC_99.L_CORE 0.005660
K_4122 X_NUC_55.L_CORE X_NUC_100.L_CORE 0.003783
K_4123 X_NUC_55.L_CORE X_NUC_101.L_CORE 0.002918
K_4124 X_NUC_55.L_CORE X_NUC_102.L_CORE 0.007017
K_4125 X_NUC_55.L_CORE X_NUC_103.L_CORE 0.003348
K_4126 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.002923
K_4127 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.002884
K_4128 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.002898
K_4129 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.002906
K_4130 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.004025
K_4131 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.004009
K_4132 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.003972
K_4133 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.004047
K_4134 X_NUC_56.L_CORE X_NUC_65.L_CORE 0.006185
K_4135 X_NUC_56.L_CORE X_NUC_66.L_CORE 0.006028
K_4136 X_NUC_56.L_CORE X_NUC_67.L_CORE 0.006100
K_4137 X_NUC_56.L_CORE X_NUC_68.L_CORE 0.006033
K_4138 X_NUC_56.L_CORE X_NUC_69.L_CORE 0.002888
K_4139 X_NUC_56.L_CORE X_NUC_70.L_CORE 0.002857
K_4140 X_NUC_56.L_CORE X_NUC_71.L_CORE 0.002855
K_4141 X_NUC_56.L_CORE X_NUC_72.L_CORE 0.002879
K_4142 X_NUC_56.L_CORE X_NUC_73.L_CORE 0.007498
K_4143 X_NUC_56.L_CORE X_NUC_74.L_CORE 0.007463
K_4144 X_NUC_56.L_CORE X_NUC_75.L_CORE 0.007265
K_4145 X_NUC_56.L_CORE X_NUC_76.L_CORE 0.007462
K_4146 X_NUC_56.L_CORE X_NUC_77.L_CORE 0.003761
K_4147 X_NUC_56.L_CORE X_NUC_78.L_CORE 0.003699
K_4148 X_NUC_56.L_CORE X_NUC_79.L_CORE 0.003709
K_4149 X_NUC_56.L_CORE X_NUC_80.L_CORE 0.003714
K_4150 X_NUC_56.L_CORE X_NUC_81.L_CORE 0.003646
K_4151 X_NUC_56.L_CORE X_NUC_82.L_CORE 0.003611
K_4152 X_NUC_56.L_CORE X_NUC_83.L_CORE 0.003587
K_4153 X_NUC_56.L_CORE X_NUC_84.L_CORE 0.003632
K_4154 X_NUC_56.L_CORE X_NUC_85.L_CORE 0.005247
K_4155 X_NUC_56.L_CORE X_NUC_86.L_CORE 0.005164
K_4156 X_NUC_56.L_CORE X_NUC_87.L_CORE 0.005122
K_4157 X_NUC_56.L_CORE X_NUC_88.L_CORE 0.005159
K_4158 X_NUC_56.L_CORE X_NUC_89.L_CORE 0.003620
K_4159 X_NUC_56.L_CORE X_NUC_90.L_CORE 0.002615
K_4160 X_NUC_56.L_CORE X_NUC_91.L_CORE 0.003485
K_4161 X_NUC_56.L_CORE X_NUC_92.L_CORE 0.003864
K_4162 X_NUC_56.L_CORE X_NUC_93.L_CORE 0.002453
K_4163 X_NUC_56.L_CORE X_NUC_94.L_CORE 0.007708
K_4164 X_NUC_56.L_CORE X_NUC_95.L_CORE 0.002805
K_4165 X_NUC_56.L_CORE X_NUC_96.L_CORE 0.003022
K_4166 X_NUC_56.L_CORE X_NUC_97.L_CORE 0.008520
K_4167 X_NUC_56.L_CORE X_NUC_98.L_CORE 0.002494
K_4168 X_NUC_56.L_CORE X_NUC_99.L_CORE 0.005517
K_4169 X_NUC_56.L_CORE X_NUC_100.L_CORE 0.003801
K_4170 X_NUC_56.L_CORE X_NUC_101.L_CORE 0.002887
K_4171 X_NUC_56.L_CORE X_NUC_102.L_CORE 0.006969
K_4172 X_NUC_56.L_CORE X_NUC_103.L_CORE 0.003332
K_4173 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.207973
K_4174 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.207973
K_4175 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.207973
K_4176 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.003002
K_4177 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.003039
K_4178 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.003007
K_4179 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.003030
K_4180 X_NUC_57.L_CORE X_NUC_65.L_CORE 0.004203
K_4181 X_NUC_57.L_CORE X_NUC_66.L_CORE 0.004273
K_4182 X_NUC_57.L_CORE X_NUC_67.L_CORE 0.004252
K_4183 X_NUC_57.L_CORE X_NUC_68.L_CORE 0.004204
K_4184 X_NUC_57.L_CORE X_NUC_69.L_CORE 0.006260
K_4185 X_NUC_57.L_CORE X_NUC_70.L_CORE 0.006336
K_4186 X_NUC_57.L_CORE X_NUC_71.L_CORE 0.006174
K_4187 X_NUC_57.L_CORE X_NUC_72.L_CORE 0.006334
K_4188 X_NUC_57.L_CORE X_NUC_73.L_CORE 0.003044
K_4189 X_NUC_57.L_CORE X_NUC_74.L_CORE 0.003088
K_4190 X_NUC_57.L_CORE X_NUC_75.L_CORE 0.003057
K_4191 X_NUC_57.L_CORE X_NUC_76.L_CORE 0.003061
K_4192 X_NUC_57.L_CORE X_NUC_77.L_CORE 0.007425
K_4193 X_NUC_57.L_CORE X_NUC_78.L_CORE 0.007602
K_4194 X_NUC_57.L_CORE X_NUC_79.L_CORE 0.007437
K_4195 X_NUC_57.L_CORE X_NUC_80.L_CORE 0.007338
K_4196 X_NUC_57.L_CORE X_NUC_81.L_CORE 0.004000
K_4197 X_NUC_57.L_CORE X_NUC_82.L_CORE 0.004058
K_4198 X_NUC_57.L_CORE X_NUC_83.L_CORE 0.003985
K_4199 X_NUC_57.L_CORE X_NUC_84.L_CORE 0.004025
K_4200 X_NUC_57.L_CORE X_NUC_85.L_CORE 0.004054
K_4201 X_NUC_57.L_CORE X_NUC_86.L_CORE 0.004124
K_4202 X_NUC_57.L_CORE X_NUC_87.L_CORE 0.004062
K_4203 X_NUC_57.L_CORE X_NUC_88.L_CORE 0.004058
K_4204 X_NUC_57.L_CORE X_NUC_89.L_CORE 0.002814
K_4205 X_NUC_57.L_CORE X_NUC_90.L_CORE 0.004097
K_4206 X_NUC_57.L_CORE X_NUC_91.L_CORE 0.002545
K_4207 X_NUC_57.L_CORE X_NUC_92.L_CORE 0.003559
K_4208 X_NUC_57.L_CORE X_NUC_93.L_CORE 0.003925
K_4209 X_NUC_57.L_CORE X_NUC_94.L_CORE 0.002474
K_4210 X_NUC_57.L_CORE X_NUC_95.L_CORE 0.008351
K_4211 X_NUC_57.L_CORE X_NUC_96.L_CORE 0.002861
K_4212 X_NUC_57.L_CORE X_NUC_97.L_CORE 0.003130
K_4213 X_NUC_57.L_CORE X_NUC_98.L_CORE 0.008659
K_4214 X_NUC_57.L_CORE X_NUC_99.L_CORE 0.002610
K_4215 X_NUC_57.L_CORE X_NUC_100.L_CORE 0.005781
K_4216 X_NUC_57.L_CORE X_NUC_101.L_CORE 0.003998
K_4217 X_NUC_57.L_CORE X_NUC_102.L_CORE 0.003172
K_4218 X_NUC_57.L_CORE X_NUC_103.L_CORE 0.005598
K_4219 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.207973
K_4220 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.207973
K_4221 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.002965
K_4222 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.003002
K_4223 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.002971
K_4224 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.002992
K_4225 X_NUC_58.L_CORE X_NUC_65.L_CORE 0.004135
K_4226 X_NUC_58.L_CORE X_NUC_66.L_CORE 0.004203
K_4227 X_NUC_58.L_CORE X_NUC_67.L_CORE 0.004183
K_4228 X_NUC_58.L_CORE X_NUC_68.L_CORE 0.004136
K_4229 X_NUC_58.L_CORE X_NUC_69.L_CORE 0.006182
K_4230 X_NUC_58.L_CORE X_NUC_70.L_CORE 0.006260
K_4231 X_NUC_58.L_CORE X_NUC_71.L_CORE 0.006101
K_4232 X_NUC_58.L_CORE X_NUC_72.L_CORE 0.006256
K_4233 X_NUC_58.L_CORE X_NUC_73.L_CORE 0.003001
K_4234 X_NUC_58.L_CORE X_NUC_74.L_CORE 0.003044
K_4235 X_NUC_58.L_CORE X_NUC_75.L_CORE 0.003014
K_4236 X_NUC_58.L_CORE X_NUC_76.L_CORE 0.003018
K_4237 X_NUC_58.L_CORE X_NUC_77.L_CORE 0.007251
K_4238 X_NUC_58.L_CORE X_NUC_78.L_CORE 0.007425
K_4239 X_NUC_58.L_CORE X_NUC_79.L_CORE 0.007267
K_4240 X_NUC_58.L_CORE X_NUC_80.L_CORE 0.007175
K_4241 X_NUC_58.L_CORE X_NUC_81.L_CORE 0.003942
K_4242 X_NUC_58.L_CORE X_NUC_82.L_CORE 0.004000
K_4243 X_NUC_58.L_CORE X_NUC_83.L_CORE 0.003929
K_4244 X_NUC_58.L_CORE X_NUC_84.L_CORE 0.003967
K_4245 X_NUC_58.L_CORE X_NUC_85.L_CORE 0.003987
K_4246 X_NUC_58.L_CORE X_NUC_86.L_CORE 0.004054
K_4247 X_NUC_58.L_CORE X_NUC_87.L_CORE 0.003995
K_4248 X_NUC_58.L_CORE X_NUC_88.L_CORE 0.003991
K_4249 X_NUC_58.L_CORE X_NUC_89.L_CORE 0.002789
K_4250 X_NUC_58.L_CORE X_NUC_90.L_CORE 0.004082
K_4251 X_NUC_58.L_CORE X_NUC_91.L_CORE 0.002521
K_4252 X_NUC_58.L_CORE X_NUC_92.L_CORE 0.003526
K_4253 X_NUC_58.L_CORE X_NUC_93.L_CORE 0.003907
K_4254 X_NUC_58.L_CORE X_NUC_94.L_CORE 0.002446
K_4255 X_NUC_58.L_CORE X_NUC_95.L_CORE 0.008385
K_4256 X_NUC_58.L_CORE X_NUC_96.L_CORE 0.002833
K_4257 X_NUC_58.L_CORE X_NUC_97.L_CORE 0.003091
K_4258 X_NUC_58.L_CORE X_NUC_98.L_CORE 0.008718
K_4259 X_NUC_58.L_CORE X_NUC_99.L_CORE 0.002579
K_4260 X_NUC_58.L_CORE X_NUC_100.L_CORE 0.005698
K_4261 X_NUC_58.L_CORE X_NUC_101.L_CORE 0.003957
K_4262 X_NUC_58.L_CORE X_NUC_102.L_CORE 0.003129
K_4263 X_NUC_58.L_CORE X_NUC_103.L_CORE 0.005515
K_4264 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.207973
K_4265 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.002996
K_4266 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.003033
K_4267 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.003002
K_4268 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.003024
K_4269 X_NUC_59.L_CORE X_NUC_65.L_CORE 0.004153
K_4270 X_NUC_59.L_CORE X_NUC_66.L_CORE 0.004221
K_4271 X_NUC_59.L_CORE X_NUC_67.L_CORE 0.004203
K_4272 X_NUC_59.L_CORE X_NUC_68.L_CORE 0.004155
K_4273 X_NUC_59.L_CORE X_NUC_69.L_CORE 0.006344
K_4274 X_NUC_59.L_CORE X_NUC_70.L_CORE 0.006426
K_4275 X_NUC_59.L_CORE X_NUC_71.L_CORE 0.006260
K_4276 X_NUC_59.L_CORE X_NUC_72.L_CORE 0.006424
K_4277 X_NUC_59.L_CORE X_NUC_73.L_CORE 0.003031
K_4278 X_NUC_59.L_CORE X_NUC_74.L_CORE 0.003075
K_4279 X_NUC_59.L_CORE X_NUC_75.L_CORE 0.003044
K_4280 X_NUC_59.L_CORE X_NUC_76.L_CORE 0.003048
K_4281 X_NUC_59.L_CORE X_NUC_77.L_CORE 0.007404
K_4282 X_NUC_59.L_CORE X_NUC_78.L_CORE 0.007585
K_4283 X_NUC_59.L_CORE X_NUC_79.L_CORE 0.007425
K_4284 X_NUC_59.L_CORE X_NUC_80.L_CORE 0.007323
K_4285 X_NUC_59.L_CORE X_NUC_81.L_CORE 0.004012
K_4286 X_NUC_59.L_CORE X_NUC_82.L_CORE 0.004072
K_4287 X_NUC_59.L_CORE X_NUC_83.L_CORE 0.004000
K_4288 X_NUC_59.L_CORE X_NUC_84.L_CORE 0.004039
K_4289 X_NUC_59.L_CORE X_NUC_85.L_CORE 0.004045
K_4290 X_NUC_59.L_CORE X_NUC_86.L_CORE 0.004114
K_4291 X_NUC_59.L_CORE X_NUC_87.L_CORE 0.004054
K_4292 X_NUC_59.L_CORE X_NUC_88.L_CORE 0.004049
K_4293 X_NUC_59.L_CORE X_NUC_89.L_CORE 0.002780
K_4294 X_NUC_59.L_CORE X_NUC_90.L_CORE 0.004041
K_4295 X_NUC_59.L_CORE X_NUC_91.L_CORE 0.002527
K_4296 X_NUC_59.L_CORE X_NUC_92.L_CORE 0.003500
K_4297 X_NUC_59.L_CORE X_NUC_93.L_CORE 0.003914
K_4298 X_NUC_59.L_CORE X_NUC_94.L_CORE 0.002454
K_4299 X_NUC_59.L_CORE X_NUC_95.L_CORE 0.008090
K_4300 X_NUC_59.L_CORE X_NUC_96.L_CORE 0.002856
K_4301 X_NUC_59.L_CORE X_NUC_97.L_CORE 0.003095
K_4302 X_NUC_59.L_CORE X_NUC_98.L_CORE 0.008869
K_4303 X_NUC_59.L_CORE X_NUC_99.L_CORE 0.002600
K_4304 X_NUC_59.L_CORE X_NUC_100.L_CORE 0.005715
K_4305 X_NUC_59.L_CORE X_NUC_101.L_CORE 0.004026
K_4306 X_NUC_59.L_CORE X_NUC_102.L_CORE 0.003160
K_4307 X_NUC_59.L_CORE X_NUC_103.L_CORE 0.005651
K_4308 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.002974
K_4309 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.003011
K_4310 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.002980
K_4311 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.003002
K_4312 X_NUC_60.L_CORE X_NUC_65.L_CORE 0.004200
K_4313 X_NUC_60.L_CORE X_NUC_66.L_CORE 0.004271
K_4314 X_NUC_60.L_CORE X_NUC_67.L_CORE 0.004251
K_4315 X_NUC_60.L_CORE X_NUC_68.L_CORE 0.004203
K_4316 X_NUC_60.L_CORE X_NUC_69.L_CORE 0.006184
K_4317 X_NUC_60.L_CORE X_NUC_70.L_CORE 0.006259
K_4318 X_NUC_60.L_CORE X_NUC_71.L_CORE 0.006103
K_4319 X_NUC_60.L_CORE X_NUC_72.L_CORE 0.006260
K_4320 X_NUC_60.L_CORE X_NUC_73.L_CORE 0.003027
K_4321 X_NUC_60.L_CORE X_NUC_74.L_CORE 0.003070
K_4322 X_NUC_60.L_CORE X_NUC_75.L_CORE 0.003040
K_4323 X_NUC_60.L_CORE X_NUC_76.L_CORE 0.003044
K_4324 X_NUC_60.L_CORE X_NUC_77.L_CORE 0.007505
K_4325 X_NUC_60.L_CORE X_NUC_78.L_CORE 0.007694
K_4326 X_NUC_60.L_CORE X_NUC_79.L_CORE 0.007522
K_4327 X_NUC_60.L_CORE X_NUC_80.L_CORE 0.007425
K_4328 X_NUC_60.L_CORE X_NUC_81.L_CORE 0.003973
K_4329 X_NUC_60.L_CORE X_NUC_82.L_CORE 0.004031
K_4330 X_NUC_60.L_CORE X_NUC_83.L_CORE 0.003960
K_4331 X_NUC_60.L_CORE X_NUC_84.L_CORE 0.004000
K_4332 X_NUC_60.L_CORE X_NUC_85.L_CORE 0.004049
K_4333 X_NUC_60.L_CORE X_NUC_86.L_CORE 0.004119
K_4334 X_NUC_60.L_CORE X_NUC_87.L_CORE 0.004058
K_4335 X_NUC_60.L_CORE X_NUC_88.L_CORE 0.004054
K_4336 X_NUC_60.L_CORE X_NUC_89.L_CORE 0.002783
K_4337 X_NUC_60.L_CORE X_NUC_90.L_CORE 0.004029
K_4338 X_NUC_60.L_CORE X_NUC_91.L_CORE 0.002516
K_4339 X_NUC_60.L_CORE X_NUC_92.L_CORE 0.003532
K_4340 X_NUC_60.L_CORE X_NUC_93.L_CORE 0.003858
K_4341 X_NUC_60.L_CORE X_NUC_94.L_CORE 0.002455
K_4342 X_NUC_60.L_CORE X_NUC_95.L_CORE 0.008299
K_4343 X_NUC_60.L_CORE X_NUC_96.L_CORE 0.002829
K_4344 X_NUC_60.L_CORE X_NUC_97.L_CORE 0.003119
K_4345 X_NUC_60.L_CORE X_NUC_98.L_CORE 0.008511
K_4346 X_NUC_60.L_CORE X_NUC_99.L_CORE 0.002592
K_4347 X_NUC_60.L_CORE X_NUC_100.L_CORE 0.005840
K_4348 X_NUC_60.L_CORE X_NUC_101.L_CORE 0.003967
K_4349 X_NUC_60.L_CORE X_NUC_102.L_CORE 0.003166
K_4350 X_NUC_60.L_CORE X_NUC_103.L_CORE 0.005636
K_4351 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.207973
K_4352 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.207973
K_4353 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.207973
K_4354 X_NUC_61.L_CORE X_NUC_65.L_CORE 0.003140
K_4355 X_NUC_61.L_CORE X_NUC_66.L_CORE 0.003126
K_4356 X_NUC_61.L_CORE X_NUC_67.L_CORE 0.003153
K_4357 X_NUC_61.L_CORE X_NUC_68.L_CORE 0.003108
K_4358 X_NUC_61.L_CORE X_NUC_69.L_CORE 0.004425
K_4359 X_NUC_61.L_CORE X_NUC_70.L_CORE 0.004335
K_4360 X_NUC_61.L_CORE X_NUC_71.L_CORE 0.004375
K_4361 X_NUC_61.L_CORE X_NUC_72.L_CORE 0.004362
K_4362 X_NUC_61.L_CORE X_NUC_73.L_CORE 0.006568
K_4363 X_NUC_61.L_CORE X_NUC_74.L_CORE 0.006611
K_4364 X_NUC_61.L_CORE X_NUC_75.L_CORE 0.006633
K_4365 X_NUC_61.L_CORE X_NUC_76.L_CORE 0.006446
K_4366 X_NUC_61.L_CORE X_NUC_77.L_CORE 0.003291
K_4367 X_NUC_61.L_CORE X_NUC_78.L_CORE 0.003258
K_4368 X_NUC_61.L_CORE X_NUC_79.L_CORE 0.003284
K_4369 X_NUC_61.L_CORE X_NUC_80.L_CORE 0.003247
K_4370 X_NUC_61.L_CORE X_NUC_81.L_CORE 0.007249
K_4371 X_NUC_61.L_CORE X_NUC_82.L_CORE 0.007071
K_4372 X_NUC_61.L_CORE X_NUC_83.L_CORE 0.007086
K_4373 X_NUC_61.L_CORE X_NUC_84.L_CORE 0.007014
K_4374 X_NUC_61.L_CORE X_NUC_85.L_CORE 0.004469
K_4375 X_NUC_61.L_CORE X_NUC_86.L_CORE 0.004438
K_4376 X_NUC_61.L_CORE X_NUC_87.L_CORE 0.004461
K_4377 X_NUC_61.L_CORE X_NUC_88.L_CORE 0.004384
K_4378 X_NUC_61.L_CORE X_NUC_89.L_CORE 0.002866
K_4379 X_NUC_61.L_CORE X_NUC_90.L_CORE 0.002659
K_4380 X_NUC_61.L_CORE X_NUC_91.L_CORE 0.004385
K_4381 X_NUC_61.L_CORE X_NUC_92.L_CORE 0.002485
K_4382 X_NUC_61.L_CORE X_NUC_93.L_CORE 0.003549
K_4383 X_NUC_61.L_CORE X_NUC_94.L_CORE 0.003989
K_4384 X_NUC_61.L_CORE X_NUC_95.L_CORE 0.002474
K_4385 X_NUC_61.L_CORE X_NUC_96.L_CORE 0.008749
K_4386 X_NUC_61.L_CORE X_NUC_97.L_CORE 0.002922
K_4387 X_NUC_61.L_CORE X_NUC_98.L_CORE 0.003196
K_4388 X_NUC_61.L_CORE X_NUC_99.L_CORE 0.009233
K_4389 X_NUC_61.L_CORE X_NUC_100.L_CORE 0.002736
K_4390 X_NUC_61.L_CORE X_NUC_101.L_CORE 0.005907
K_4391 X_NUC_61.L_CORE X_NUC_102.L_CORE 0.004280
K_4392 X_NUC_61.L_CORE X_NUC_103.L_CORE 0.003636
K_4393 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.207973
K_4394 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.207973
K_4395 X_NUC_62.L_CORE X_NUC_65.L_CORE 0.003153
K_4396 X_NUC_62.L_CORE X_NUC_66.L_CORE 0.003140
K_4397 X_NUC_62.L_CORE X_NUC_67.L_CORE 0.003167
K_4398 X_NUC_62.L_CORE X_NUC_68.L_CORE 0.003122
K_4399 X_NUC_62.L_CORE X_NUC_69.L_CORE 0.004519
K_4400 X_NUC_62.L_CORE X_NUC_70.L_CORE 0.004425
K_4401 X_NUC_62.L_CORE X_NUC_71.L_CORE 0.004467
K_4402 X_NUC_62.L_CORE X_NUC_72.L_CORE 0.004453
K_4403 X_NUC_62.L_CORE X_NUC_73.L_CORE 0.006519
K_4404 X_NUC_62.L_CORE X_NUC_74.L_CORE 0.006568
K_4405 X_NUC_62.L_CORE X_NUC_75.L_CORE 0.006586
K_4406 X_NUC_62.L_CORE X_NUC_76.L_CORE 0.006403
K_4407 X_NUC_62.L_CORE X_NUC_77.L_CORE 0.003325
K_4408 X_NUC_62.L_CORE X_NUC_78.L_CORE 0.003291
K_4409 X_NUC_62.L_CORE X_NUC_79.L_CORE 0.003318
K_4410 X_NUC_62.L_CORE X_NUC_80.L_CORE 0.003280
K_4411 X_NUC_62.L_CORE X_NUC_81.L_CORE 0.007431
K_4412 X_NUC_62.L_CORE X_NUC_82.L_CORE 0.007249
K_4413 X_NUC_62.L_CORE X_NUC_83.L_CORE 0.007260
K_4414 X_NUC_62.L_CORE X_NUC_84.L_CORE 0.007183
K_4415 X_NUC_62.L_CORE X_NUC_85.L_CORE 0.004500
K_4416 X_NUC_62.L_CORE X_NUC_86.L_CORE 0.004469
K_4417 X_NUC_62.L_CORE X_NUC_87.L_CORE 0.004492
K_4418 X_NUC_62.L_CORE X_NUC_88.L_CORE 0.004414
K_4419 X_NUC_62.L_CORE X_NUC_89.L_CORE 0.002872
K_4420 X_NUC_62.L_CORE X_NUC_90.L_CORE 0.002681
K_4421 X_NUC_62.L_CORE X_NUC_91.L_CORE 0.004377
K_4422 X_NUC_62.L_CORE X_NUC_92.L_CORE 0.002495
K_4423 X_NUC_62.L_CORE X_NUC_93.L_CORE 0.003598
K_4424 X_NUC_62.L_CORE X_NUC_94.L_CORE 0.003959
K_4425 X_NUC_62.L_CORE X_NUC_95.L_CORE 0.002496
K_4426 X_NUC_62.L_CORE X_NUC_96.L_CORE 0.008880
K_4427 X_NUC_62.L_CORE X_NUC_97.L_CORE 0.002924
K_4428 X_NUC_62.L_CORE X_NUC_98.L_CORE 0.003245
K_4429 X_NUC_62.L_CORE X_NUC_99.L_CORE 0.008928
K_4430 X_NUC_62.L_CORE X_NUC_100.L_CORE 0.002755
K_4431 X_NUC_62.L_CORE X_NUC_101.L_CORE 0.006062
K_4432 X_NUC_62.L_CORE X_NUC_102.L_CORE 0.004278
K_4433 X_NUC_62.L_CORE X_NUC_103.L_CORE 0.003679
K_4434 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.207973
K_4435 X_NUC_63.L_CORE X_NUC_65.L_CORE 0.003126
K_4436 X_NUC_63.L_CORE X_NUC_66.L_CORE 0.003112
K_4437 X_NUC_63.L_CORE X_NUC_67.L_CORE 0.003140
K_4438 X_NUC_63.L_CORE X_NUC_68.L_CORE 0.003095
K_4439 X_NUC_63.L_CORE X_NUC_69.L_CORE 0.004474
K_4440 X_NUC_63.L_CORE X_NUC_70.L_CORE 0.004382
K_4441 X_NUC_63.L_CORE X_NUC_71.L_CORE 0.004425
K_4442 X_NUC_63.L_CORE X_NUC_72.L_CORE 0.004410
K_4443 X_NUC_63.L_CORE X_NUC_73.L_CORE 0.006499
K_4444 X_NUC_63.L_CORE X_NUC_74.L_CORE 0.006543
K_4445 X_NUC_63.L_CORE X_NUC_75.L_CORE 0.006568
K_4446 X_NUC_63.L_CORE X_NUC_76.L_CORE 0.006383
K_4447 X_NUC_63.L_CORE X_NUC_77.L_CORE 0.003297
K_4448 X_NUC_63.L_CORE X_NUC_78.L_CORE 0.003264
K_4449 X_NUC_63.L_CORE X_NUC_79.L_CORE 0.003291
K_4450 X_NUC_63.L_CORE X_NUC_80.L_CORE 0.003254
K_4451 X_NUC_63.L_CORE X_NUC_81.L_CORE 0.007414
K_4452 X_NUC_63.L_CORE X_NUC_82.L_CORE 0.007228
K_4453 X_NUC_63.L_CORE X_NUC_83.L_CORE 0.007249
K_4454 X_NUC_63.L_CORE X_NUC_84.L_CORE 0.007168
K_4455 X_NUC_63.L_CORE X_NUC_85.L_CORE 0.004476
K_4456 X_NUC_63.L_CORE X_NUC_86.L_CORE 0.004445
K_4457 X_NUC_63.L_CORE X_NUC_87.L_CORE 0.004469
K_4458 X_NUC_63.L_CORE X_NUC_88.L_CORE 0.004391
K_4459 X_NUC_63.L_CORE X_NUC_89.L_CORE 0.002835
K_4460 X_NUC_63.L_CORE X_NUC_90.L_CORE 0.002648
K_4461 X_NUC_63.L_CORE X_NUC_91.L_CORE 0.004311
K_4462 X_NUC_63.L_CORE X_NUC_92.L_CORE 0.002468
K_4463 X_NUC_63.L_CORE X_NUC_93.L_CORE 0.003550
K_4464 X_NUC_63.L_CORE X_NUC_94.L_CORE 0.003918
K_4465 X_NUC_63.L_CORE X_NUC_95.L_CORE 0.002470
K_4466 X_NUC_63.L_CORE X_NUC_96.L_CORE 0.008753
K_4467 X_NUC_63.L_CORE X_NUC_97.L_CORE 0.002899
K_4468 X_NUC_63.L_CORE X_NUC_98.L_CORE 0.003214
K_4469 X_NUC_63.L_CORE X_NUC_99.L_CORE 0.008981
K_4470 X_NUC_63.L_CORE X_NUC_100.L_CORE 0.002733
K_4471 X_NUC_63.L_CORE X_NUC_101.L_CORE 0.006046
K_4472 X_NUC_63.L_CORE X_NUC_102.L_CORE 0.004266
K_4473 X_NUC_63.L_CORE X_NUC_103.L_CORE 0.003661
K_4474 X_NUC_64.L_CORE X_NUC_65.L_CORE 0.003171
K_4475 X_NUC_64.L_CORE X_NUC_66.L_CORE 0.003157
K_4476 X_NUC_64.L_CORE X_NUC_67.L_CORE 0.003186
K_4477 X_NUC_64.L_CORE X_NUC_68.L_CORE 0.003140
K_4478 X_NUC_64.L_CORE X_NUC_69.L_CORE 0.004488
K_4479 X_NUC_64.L_CORE X_NUC_70.L_CORE 0.004395
K_4480 X_NUC_64.L_CORE X_NUC_71.L_CORE 0.004438
K_4481 X_NUC_64.L_CORE X_NUC_72.L_CORE 0.004425
K_4482 X_NUC_64.L_CORE X_NUC_73.L_CORE 0.006690
K_4483 X_NUC_64.L_CORE X_NUC_74.L_CORE 0.006739
K_4484 X_NUC_64.L_CORE X_NUC_75.L_CORE 0.006762
K_4485 X_NUC_64.L_CORE X_NUC_76.L_CORE 0.006568
K_4486 X_NUC_64.L_CORE X_NUC_77.L_CORE 0.003336
K_4487 X_NUC_64.L_CORE X_NUC_78.L_CORE 0.003301
K_4488 X_NUC_64.L_CORE X_NUC_79.L_CORE 0.003329
K_4489 X_NUC_64.L_CORE X_NUC_80.L_CORE 0.003291
K_4490 X_NUC_64.L_CORE X_NUC_81.L_CORE 0.007498
K_4491 X_NUC_64.L_CORE X_NUC_82.L_CORE 0.007307
K_4492 X_NUC_64.L_CORE X_NUC_83.L_CORE 0.007323
K_4493 X_NUC_64.L_CORE X_NUC_84.L_CORE 0.007249
K_4494 X_NUC_64.L_CORE X_NUC_85.L_CORE 0.004558
K_4495 X_NUC_64.L_CORE X_NUC_86.L_CORE 0.004525
K_4496 X_NUC_64.L_CORE X_NUC_87.L_CORE 0.004549
K_4497 X_NUC_64.L_CORE X_NUC_88.L_CORE 0.004469
K_4498 X_NUC_64.L_CORE X_NUC_89.L_CORE 0.002857
K_4499 X_NUC_64.L_CORE X_NUC_90.L_CORE 0.002660
K_4500 X_NUC_64.L_CORE X_NUC_91.L_CORE 0.004324
K_4501 X_NUC_64.L_CORE X_NUC_92.L_CORE 0.002492
K_4502 X_NUC_64.L_CORE X_NUC_93.L_CORE 0.003544
K_4503 X_NUC_64.L_CORE X_NUC_94.L_CORE 0.003972
K_4504 X_NUC_64.L_CORE X_NUC_95.L_CORE 0.002489
K_4505 X_NUC_64.L_CORE X_NUC_96.L_CORE 0.008525
K_4506 X_NUC_64.L_CORE X_NUC_97.L_CORE 0.002939
K_4507 X_NUC_64.L_CORE X_NUC_98.L_CORE 0.003223
K_4508 X_NUC_64.L_CORE X_NUC_99.L_CORE 0.009232
K_4509 X_NUC_64.L_CORE X_NUC_100.L_CORE 0.002764
K_4510 X_NUC_64.L_CORE X_NUC_101.L_CORE 0.006023
K_4511 X_NUC_64.L_CORE X_NUC_102.L_CORE 0.004347
K_4512 X_NUC_64.L_CORE X_NUC_103.L_CORE 0.003697
K_4513 X_NUC_65.L_CORE X_NUC_66.L_CORE 0.207973
K_4514 X_NUC_65.L_CORE X_NUC_67.L_CORE 0.207973
K_4515 X_NUC_65.L_CORE X_NUC_68.L_CORE 0.207973
K_4516 X_NUC_65.L_CORE X_NUC_69.L_CORE 0.003337
K_4517 X_NUC_65.L_CORE X_NUC_70.L_CORE 0.003314
K_4518 X_NUC_65.L_CORE X_NUC_71.L_CORE 0.003300
K_4519 X_NUC_65.L_CORE X_NUC_72.L_CORE 0.003348
K_4520 X_NUC_65.L_CORE X_NUC_73.L_CORE 0.004744
K_4521 X_NUC_65.L_CORE X_NUC_74.L_CORE 0.004809
K_4522 X_NUC_65.L_CORE X_NUC_75.L_CORE 0.004720
K_4523 X_NUC_65.L_CORE X_NUC_76.L_CORE 0.004806
K_4524 X_NUC_65.L_CORE X_NUC_77.L_CORE 0.006976
K_4525 X_NUC_65.L_CORE X_NUC_78.L_CORE 0.006808
K_4526 X_NUC_65.L_CORE X_NUC_79.L_CORE 0.006768
K_4527 X_NUC_65.L_CORE X_NUC_80.L_CORE 0.006896
K_4528 X_NUC_65.L_CORE X_NUC_81.L_CORE 0.003689
K_4529 X_NUC_65.L_CORE X_NUC_82.L_CORE 0.003687
K_4530 X_NUC_65.L_CORE X_NUC_83.L_CORE 0.003645
K_4531 X_NUC_65.L_CORE X_NUC_84.L_CORE 0.003708
K_4532 X_NUC_65.L_CORE X_NUC_85.L_CORE 0.006675
K_4533 X_NUC_65.L_CORE X_NUC_86.L_CORE 0.006701
K_4534 X_NUC_65.L_CORE X_NUC_87.L_CORE 0.006518
K_4535 X_NUC_65.L_CORE X_NUC_88.L_CORE 0.006684
K_4536 X_NUC_65.L_CORE X_NUC_89.L_CORE 0.003092
K_4537 X_NUC_65.L_CORE X_NUC_90.L_CORE 0.002818
K_4538 X_NUC_65.L_CORE X_NUC_91.L_CORE 0.002626
K_4539 X_NUC_65.L_CORE X_NUC_92.L_CORE 0.004591
K_4540 X_NUC_65.L_CORE X_NUC_93.L_CORE 0.002485
K_4541 X_NUC_65.L_CORE X_NUC_94.L_CORE 0.003654
K_4542 X_NUC_65.L_CORE X_NUC_95.L_CORE 0.004033
K_4543 X_NUC_65.L_CORE X_NUC_96.L_CORE 0.002548
K_4544 X_NUC_65.L_CORE X_NUC_97.L_CORE 0.009453
K_4545 X_NUC_65.L_CORE X_NUC_98.L_CORE 0.003034
K_4546 X_NUC_65.L_CORE X_NUC_99.L_CORE 0.003411
K_4547 X_NUC_65.L_CORE X_NUC_100.L_CORE 0.009389
K_4548 X_NUC_65.L_CORE X_NUC_101.L_CORE 0.002981
K_4549 X_NUC_65.L_CORE X_NUC_102.L_CORE 0.006327
K_4550 X_NUC_65.L_CORE X_NUC_103.L_CORE 0.004716
K_4551 X_NUC_66.L_CORE X_NUC_67.L_CORE 0.207973
K_4552 X_NUC_66.L_CORE X_NUC_68.L_CORE 0.207973
K_4553 X_NUC_66.L_CORE X_NUC_69.L_CORE 0.003360
K_4554 X_NUC_66.L_CORE X_NUC_70.L_CORE 0.003337
K_4555 X_NUC_66.L_CORE X_NUC_71.L_CORE 0.003322
K_4556 X_NUC_66.L_CORE X_NUC_72.L_CORE 0.003371
K_4557 X_NUC_66.L_CORE X_NUC_73.L_CORE 0.004679
K_4558 X_NUC_66.L_CORE X_NUC_74.L_CORE 0.004744
K_4559 X_NUC_66.L_CORE X_NUC_75.L_CORE 0.004657
K_4560 X_NUC_66.L_CORE X_NUC_76.L_CORE 0.004740
K_4561 X_NUC_66.L_CORE X_NUC_77.L_CORE 0.007148
K_4562 X_NUC_66.L_CORE X_NUC_78.L_CORE 0.006976
K_4563 X_NUC_66.L_CORE X_NUC_79.L_CORE 0.006929
K_4564 X_NUC_66.L_CORE X_NUC_80.L_CORE 0.007066
K_4565 X_NUC_66.L_CORE X_NUC_81.L_CORE 0.003690
K_4566 X_NUC_66.L_CORE X_NUC_82.L_CORE 0.003689
K_4567 X_NUC_66.L_CORE X_NUC_83.L_CORE 0.003647
K_4568 X_NUC_66.L_CORE X_NUC_84.L_CORE 0.003709
K_4569 X_NUC_66.L_CORE X_NUC_85.L_CORE 0.006642
K_4570 X_NUC_66.L_CORE X_NUC_86.L_CORE 0.006675
K_4571 X_NUC_66.L_CORE X_NUC_87.L_CORE 0.006491
K_4572 X_NUC_66.L_CORE X_NUC_88.L_CORE 0.006654
K_4573 X_NUC_66.L_CORE X_NUC_89.L_CORE 0.003086
K_4574 X_NUC_66.L_CORE X_NUC_90.L_CORE 0.002834
K_4575 X_NUC_66.L_CORE X_NUC_91.L_CORE 0.002616
K_4576 X_NUC_66.L_CORE X_NUC_92.L_CORE 0.004609
K_4577 X_NUC_66.L_CORE X_NUC_93.L_CORE 0.002494
K_4578 X_NUC_66.L_CORE X_NUC_94.L_CORE 0.003609
K_4579 X_NUC_66.L_CORE X_NUC_95.L_CORE 0.004099
K_4580 X_NUC_66.L_CORE X_NUC_96.L_CORE 0.002544
K_4581 X_NUC_66.L_CORE X_NUC_97.L_CORE 0.009148
K_4582 X_NUC_66.L_CORE X_NUC_98.L_CORE 0.003063
K_4583 X_NUC_66.L_CORE X_NUC_99.L_CORE 0.003378
K_4584 X_NUC_66.L_CORE X_NUC_100.L_CORE 0.009820
K_4585 X_NUC_66.L_CORE X_NUC_101.L_CORE 0.002988
K_4586 X_NUC_66.L_CORE X_NUC_102.L_CORE 0.006211
K_4587 X_NUC_66.L_CORE X_NUC_103.L_CORE 0.004763
K_4588 X_NUC_67.L_CORE X_NUC_68.L_CORE 0.207973
K_4589 X_NUC_67.L_CORE X_NUC_69.L_CORE 0.003375
K_4590 X_NUC_67.L_CORE X_NUC_70.L_CORE 0.003352
K_4591 X_NUC_67.L_CORE X_NUC_71.L_CORE 0.003337
K_4592 X_NUC_67.L_CORE X_NUC_72.L_CORE 0.003386
K_4593 X_NUC_67.L_CORE X_NUC_73.L_CORE 0.004765
K_4594 X_NUC_67.L_CORE X_NUC_74.L_CORE 0.004832
K_4595 X_NUC_67.L_CORE X_NUC_75.L_CORE 0.004744
K_4596 X_NUC_67.L_CORE X_NUC_76.L_CORE 0.004830
K_4597 X_NUC_67.L_CORE X_NUC_77.L_CORE 0.007195
K_4598 X_NUC_67.L_CORE X_NUC_78.L_CORE 0.007016
K_4599 X_NUC_67.L_CORE X_NUC_79.L_CORE 0.006976
K_4600 X_NUC_67.L_CORE X_NUC_80.L_CORE 0.007112
K_4601 X_NUC_67.L_CORE X_NUC_81.L_CORE 0.003734
K_4602 X_NUC_67.L_CORE X_NUC_82.L_CORE 0.003732
K_4603 X_NUC_67.L_CORE X_NUC_83.L_CORE 0.003689
K_4604 X_NUC_67.L_CORE X_NUC_84.L_CORE 0.003754
K_4605 X_NUC_67.L_CORE X_NUC_85.L_CORE 0.006836
K_4606 X_NUC_67.L_CORE X_NUC_86.L_CORE 0.006868
K_4607 X_NUC_67.L_CORE X_NUC_87.L_CORE 0.006675
K_4608 X_NUC_67.L_CORE X_NUC_88.L_CORE 0.006850
K_4609 X_NUC_67.L_CORE X_NUC_89.L_CORE 0.003067
K_4610 X_NUC_67.L_CORE X_NUC_90.L_CORE 0.002814
K_4611 X_NUC_67.L_CORE X_NUC_91.L_CORE 0.002618
K_4612 X_NUC_67.L_CORE X_NUC_92.L_CORE 0.004526
K_4613 X_NUC_67.L_CORE X_NUC_93.L_CORE 0.002492
K_4614 X_NUC_67.L_CORE X_NUC_94.L_CORE 0.003620
K_4615 X_NUC_67.L_CORE X_NUC_95.L_CORE 0.004046
K_4616 X_NUC_67.L_CORE X_NUC_96.L_CORE 0.002555
K_4617 X_NUC_67.L_CORE X_NUC_97.L_CORE 0.009059
K_4618 X_NUC_67.L_CORE X_NUC_98.L_CORE 0.003062
K_4619 X_NUC_67.L_CORE X_NUC_99.L_CORE 0.003416
K_4620 X_NUC_67.L_CORE X_NUC_100.L_CORE 0.009664
K_4621 X_NUC_67.L_CORE X_NUC_101.L_CORE 0.003010
K_4622 X_NUC_67.L_CORE X_NUC_102.L_CORE 0.006396
K_4623 X_NUC_67.L_CORE X_NUC_103.L_CORE 0.004820
K_4624 X_NUC_68.L_CORE X_NUC_69.L_CORE 0.003326
K_4625 X_NUC_68.L_CORE X_NUC_70.L_CORE 0.003304
K_4626 X_NUC_68.L_CORE X_NUC_71.L_CORE 0.003290
K_4627 X_NUC_68.L_CORE X_NUC_72.L_CORE 0.003337
K_4628 X_NUC_68.L_CORE X_NUC_73.L_CORE 0.004682
K_4629 X_NUC_68.L_CORE X_NUC_74.L_CORE 0.004745
K_4630 X_NUC_68.L_CORE X_NUC_75.L_CORE 0.004660
K_4631 X_NUC_68.L_CORE X_NUC_76.L_CORE 0.004744
K_4632 X_NUC_68.L_CORE X_NUC_77.L_CORE 0.007050
K_4633 X_NUC_68.L_CORE X_NUC_78.L_CORE 0.006881
K_4634 X_NUC_68.L_CORE X_NUC_79.L_CORE 0.006840
K_4635 X_NUC_68.L_CORE X_NUC_80.L_CORE 0.006976
K_4636 X_NUC_68.L_CORE X_NUC_81.L_CORE 0.003670
K_4637 X_NUC_68.L_CORE X_NUC_82.L_CORE 0.003669
K_4638 X_NUC_68.L_CORE X_NUC_83.L_CORE 0.003627
K_4639 X_NUC_68.L_CORE X_NUC_84.L_CORE 0.003689
K_4640 X_NUC_68.L_CORE X_NUC_85.L_CORE 0.006659
K_4641 X_NUC_68.L_CORE X_NUC_86.L_CORE 0.006688
K_4642 X_NUC_68.L_CORE X_NUC_87.L_CORE 0.006506
K_4643 X_NUC_68.L_CORE X_NUC_88.L_CORE 0.006675
K_4644 X_NUC_68.L_CORE X_NUC_89.L_CORE 0.003052
K_4645 X_NUC_68.L_CORE X_NUC_90.L_CORE 0.002796
K_4646 X_NUC_68.L_CORE X_NUC_91.L_CORE 0.002594
K_4647 X_NUC_68.L_CORE X_NUC_92.L_CORE 0.004535
K_4648 X_NUC_68.L_CORE X_NUC_93.L_CORE 0.002468
K_4649 X_NUC_68.L_CORE X_NUC_94.L_CORE 0.003593
K_4650 X_NUC_68.L_CORE X_NUC_95.L_CORE 0.004028
K_4651 X_NUC_68.L_CORE X_NUC_96.L_CORE 0.002526
K_4652 X_NUC_68.L_CORE X_NUC_97.L_CORE 0.009184
K_4653 X_NUC_68.L_CORE X_NUC_98.L_CORE 0.003028
K_4654 X_NUC_68.L_CORE X_NUC_99.L_CORE 0.003372
K_4655 X_NUC_68.L_CORE X_NUC_100.L_CORE 0.009669
K_4656 X_NUC_68.L_CORE X_NUC_101.L_CORE 0.002968
K_4657 X_NUC_68.L_CORE X_NUC_102.L_CORE 0.006282
K_4658 X_NUC_68.L_CORE X_NUC_103.L_CORE 0.004741
K_4659 X_NUC_69.L_CORE X_NUC_70.L_CORE 0.207973
K_4660 X_NUC_69.L_CORE X_NUC_71.L_CORE 0.207973
K_4661 X_NUC_69.L_CORE X_NUC_72.L_CORE 0.207973
K_4662 X_NUC_69.L_CORE X_NUC_73.L_CORE 0.003628
K_4663 X_NUC_69.L_CORE X_NUC_74.L_CORE 0.003687
K_4664 X_NUC_69.L_CORE X_NUC_75.L_CORE 0.003666
K_4665 X_NUC_69.L_CORE X_NUC_76.L_CORE 0.003642
K_4666 X_NUC_69.L_CORE X_NUC_77.L_CORE 0.005220
K_4667 X_NUC_69.L_CORE X_NUC_78.L_CORE 0.005234
K_4668 X_NUC_69.L_CORE X_NUC_79.L_CORE 0.005274
K_4669 X_NUC_69.L_CORE X_NUC_80.L_CORE 0.005147
K_4670 X_NUC_69.L_CORE X_NUC_81.L_CORE 0.007489
K_4671 X_NUC_69.L_CORE X_NUC_82.L_CORE 0.007744
K_4672 X_NUC_69.L_CORE X_NUC_83.L_CORE 0.007542
K_4673 X_NUC_69.L_CORE X_NUC_84.L_CORE 0.007525
K_4674 X_NUC_69.L_CORE X_NUC_85.L_CORE 0.004494
K_4675 X_NUC_69.L_CORE X_NUC_86.L_CORE 0.004559
K_4676 X_NUC_69.L_CORE X_NUC_87.L_CORE 0.004537
K_4677 X_NUC_69.L_CORE X_NUC_88.L_CORE 0.004471
K_4678 X_NUC_69.L_CORE X_NUC_89.L_CORE 0.002531
K_4679 X_NUC_69.L_CORE X_NUC_90.L_CORE 0.003259
K_4680 X_NUC_69.L_CORE X_NUC_91.L_CORE 0.002834
K_4681 X_NUC_69.L_CORE X_NUC_92.L_CORE 0.002622
K_4682 X_NUC_69.L_CORE X_NUC_93.L_CORE 0.004759
K_4683 X_NUC_69.L_CORE X_NUC_94.L_CORE 0.002540
K_4684 X_NUC_69.L_CORE X_NUC_95.L_CORE 0.003714
K_4685 X_NUC_69.L_CORE X_NUC_96.L_CORE 0.004231
K_4686 X_NUC_69.L_CORE X_NUC_97.L_CORE 0.002660
K_4687 X_NUC_69.L_CORE X_NUC_98.L_CORE 0.009653
K_4688 X_NUC_69.L_CORE X_NUC_99.L_CORE 0.003268
K_4689 X_NUC_69.L_CORE X_NUC_100.L_CORE 0.003666
K_4690 X_NUC_69.L_CORE X_NUC_101.L_CORE 0.010457
K_4691 X_NUC_69.L_CORE X_NUC_102.L_CORE 0.003415
K_4692 X_NUC_69.L_CORE X_NUC_103.L_CORE 0.006411
K_4693 X_NUC_70.L_CORE X_NUC_71.L_CORE 0.207973
K_4694 X_NUC_70.L_CORE X_NUC_72.L_CORE 0.207973
K_4695 X_NUC_70.L_CORE X_NUC_73.L_CORE 0.003570
K_4696 X_NUC_70.L_CORE X_NUC_74.L_CORE 0.003628
K_4697 X_NUC_70.L_CORE X_NUC_75.L_CORE 0.003607
K_4698 X_NUC_70.L_CORE X_NUC_76.L_CORE 0.003584
K_4699 X_NUC_70.L_CORE X_NUC_77.L_CORE 0.005202
K_4700 X_NUC_70.L_CORE X_NUC_78.L_CORE 0.005220
K_4701 X_NUC_70.L_CORE X_NUC_79.L_CORE 0.005257
K_4702 X_NUC_70.L_CORE X_NUC_80.L_CORE 0.005131
K_4703 X_NUC_70.L_CORE X_NUC_81.L_CORE 0.007249
K_4704 X_NUC_70.L_CORE X_NUC_82.L_CORE 0.007489
K_4705 X_NUC_70.L_CORE X_NUC_83.L_CORE 0.007302
K_4706 X_NUC_70.L_CORE X_NUC_84.L_CORE 0.007286
K_4707 X_NUC_70.L_CORE X_NUC_85.L_CORE 0.004429
K_4708 X_NUC_70.L_CORE X_NUC_86.L_CORE 0.004494
K_4709 X_NUC_70.L_CORE X_NUC_87.L_CORE 0.004472
K_4710 X_NUC_70.L_CORE X_NUC_88.L_CORE 0.004409
K_4711 X_NUC_70.L_CORE X_NUC_89.L_CORE 0.002517
K_4712 X_NUC_70.L_CORE X_NUC_90.L_CORE 0.003262
K_4713 X_NUC_70.L_CORE X_NUC_91.L_CORE 0.002808
K_4714 X_NUC_70.L_CORE X_NUC_92.L_CORE 0.002614
K_4715 X_NUC_70.L_CORE X_NUC_93.L_CORE 0.004760
K_4716 X_NUC_70.L_CORE X_NUC_94.L_CORE 0.002515
K_4717 X_NUC_70.L_CORE X_NUC_95.L_CORE 0.003734
K_4718 X_NUC_70.L_CORE X_NUC_96.L_CORE 0.004167
K_4719 X_NUC_70.L_CORE X_NUC_97.L_CORE 0.002641
K_4720 X_NUC_70.L_CORE X_NUC_98.L_CORE 0.010039
K_4721 X_NUC_70.L_CORE X_NUC_99.L_CORE 0.003218
K_4722 X_NUC_70.L_CORE X_NUC_100.L_CORE 0.003660
K_4723 X_NUC_70.L_CORE X_NUC_101.L_CORE 0.010086
K_4724 X_NUC_70.L_CORE X_NUC_102.L_CORE 0.003372
K_4725 X_NUC_70.L_CORE X_NUC_103.L_CORE 0.006366
K_4726 X_NUC_71.L_CORE X_NUC_72.L_CORE 0.207973
K_4727 X_NUC_71.L_CORE X_NUC_73.L_CORE 0.003589
K_4728 X_NUC_71.L_CORE X_NUC_74.L_CORE 0.003647
K_4729 X_NUC_71.L_CORE X_NUC_75.L_CORE 0.003628
K_4730 X_NUC_71.L_CORE X_NUC_76.L_CORE 0.003603
K_4731 X_NUC_71.L_CORE X_NUC_77.L_CORE 0.005164
K_4732 X_NUC_71.L_CORE X_NUC_78.L_CORE 0.005180
K_4733 X_NUC_71.L_CORE X_NUC_79.L_CORE 0.005220
K_4734 X_NUC_71.L_CORE X_NUC_80.L_CORE 0.005095
K_4735 X_NUC_71.L_CORE X_NUC_81.L_CORE 0.007427
K_4736 X_NUC_71.L_CORE X_NUC_82.L_CORE 0.007681
K_4737 X_NUC_71.L_CORE X_NUC_83.L_CORE 0.007489
K_4738 X_NUC_71.L_CORE X_NUC_84.L_CORE 0.007467
K_4739 X_NUC_71.L_CORE X_NUC_85.L_CORE 0.004450
K_4740 X_NUC_71.L_CORE X_NUC_86.L_CORE 0.004514
K_4741 X_NUC_71.L_CORE X_NUC_87.L_CORE 0.004494
K_4742 X_NUC_71.L_CORE X_NUC_88.L_CORE 0.004429
K_4743 X_NUC_71.L_CORE X_NUC_89.L_CORE 0.002501
K_4744 X_NUC_71.L_CORE X_NUC_90.L_CORE 0.003219
K_4745 X_NUC_71.L_CORE X_NUC_91.L_CORE 0.002802
K_4746 X_NUC_71.L_CORE X_NUC_92.L_CORE 0.002592
K_4747 X_NUC_71.L_CORE X_NUC_93.L_CORE 0.004702
K_4748 X_NUC_71.L_CORE X_NUC_94.L_CORE 0.002512
K_4749 X_NUC_71.L_CORE X_NUC_95.L_CORE 0.003673
K_4750 X_NUC_71.L_CORE X_NUC_96.L_CORE 0.004189
K_4751 X_NUC_71.L_CORE X_NUC_97.L_CORE 0.002632
K_4752 X_NUC_71.L_CORE X_NUC_98.L_CORE 0.009621
K_4753 X_NUC_71.L_CORE X_NUC_99.L_CORE 0.003237
K_4754 X_NUC_71.L_CORE X_NUC_100.L_CORE 0.003632
K_4755 X_NUC_71.L_CORE X_NUC_101.L_CORE 0.010550
K_4756 X_NUC_71.L_CORE X_NUC_102.L_CORE 0.003385
K_4757 X_NUC_71.L_CORE X_NUC_103.L_CORE 0.006398
K_4758 X_NUC_72.L_CORE X_NUC_73.L_CORE 0.003613
K_4759 X_NUC_72.L_CORE X_NUC_74.L_CORE 0.003672
K_4760 X_NUC_72.L_CORE X_NUC_75.L_CORE 0.003652
K_4761 X_NUC_72.L_CORE X_NUC_76.L_CORE 0.003628
K_4762 X_NUC_72.L_CORE X_NUC_77.L_CORE 0.005292
K_4763 X_NUC_72.L_CORE X_NUC_78.L_CORE 0.005309
K_4764 X_NUC_72.L_CORE X_NUC_79.L_CORE 0.005351
K_4765 X_NUC_72.L_CORE X_NUC_80.L_CORE 0.005220
K_4766 X_NUC_72.L_CORE X_NUC_81.L_CORE 0.007444
K_4767 X_NUC_72.L_CORE X_NUC_82.L_CORE 0.007700
K_4768 X_NUC_72.L_CORE X_NUC_83.L_CORE 0.007501
K_4769 X_NUC_72.L_CORE X_NUC_84.L_CORE 0.007489
K_4770 X_NUC_72.L_CORE X_NUC_85.L_CORE 0.004515
K_4771 X_NUC_72.L_CORE X_NUC_86.L_CORE 0.004582
K_4772 X_NUC_72.L_CORE X_NUC_87.L_CORE 0.004560
K_4773 X_NUC_72.L_CORE X_NUC_88.L_CORE 0.004494
K_4774 X_NUC_72.L_CORE X_NUC_89.L_CORE 0.002513
K_4775 X_NUC_72.L_CORE X_NUC_90.L_CORE 0.003235
K_4776 X_NUC_72.L_CORE X_NUC_91.L_CORE 0.002802
K_4777 X_NUC_72.L_CORE X_NUC_92.L_CORE 0.002616
K_4778 X_NUC_72.L_CORE X_NUC_93.L_CORE 0.004672
K_4779 X_NUC_72.L_CORE X_NUC_94.L_CORE 0.002524
K_4780 X_NUC_72.L_CORE X_NUC_95.L_CORE 0.003726
K_4781 X_NUC_72.L_CORE X_NUC_96.L_CORE 0.004152
K_4782 X_NUC_72.L_CORE X_NUC_97.L_CORE 0.002659
K_4783 X_NUC_72.L_CORE X_NUC_98.L_CORE 0.009719
K_4784 X_NUC_72.L_CORE X_NUC_99.L_CORE 0.003242
K_4785 X_NUC_72.L_CORE X_NUC_100.L_CORE 0.003696
K_4786 X_NUC_72.L_CORE X_NUC_101.L_CORE 0.010251
K_4787 X_NUC_72.L_CORE X_NUC_102.L_CORE 0.003419
K_4788 X_NUC_72.L_CORE X_NUC_103.L_CORE 0.006552
K_4789 X_NUC_73.L_CORE X_NUC_74.L_CORE 0.207973
K_4790 X_NUC_73.L_CORE X_NUC_75.L_CORE 0.207973
K_4791 X_NUC_73.L_CORE X_NUC_76.L_CORE 0.207973
K_4792 X_NUC_73.L_CORE X_NUC_77.L_CORE 0.004081
K_4793 X_NUC_73.L_CORE X_NUC_78.L_CORE 0.004007
K_4794 X_NUC_73.L_CORE X_NUC_79.L_CORE 0.004053
K_4795 X_NUC_73.L_CORE X_NUC_80.L_CORE 0.004027
K_4796 X_NUC_73.L_CORE X_NUC_81.L_CORE 0.005988
K_4797 X_NUC_73.L_CORE X_NUC_82.L_CORE 0.005854
K_4798 X_NUC_73.L_CORE X_NUC_83.L_CORE 0.005847
K_4799 X_NUC_73.L_CORE X_NUC_84.L_CORE 0.005942
K_4800 X_NUC_73.L_CORE X_NUC_85.L_CORE 0.007921
K_4801 X_NUC_73.L_CORE X_NUC_86.L_CORE 0.007675
K_4802 X_NUC_73.L_CORE X_NUC_87.L_CORE 0.007760
K_4803 X_NUC_73.L_CORE X_NUC_88.L_CORE 0.007660
K_4804 X_NUC_73.L_CORE X_NUC_89.L_CORE 0.002840
K_4805 X_NUC_73.L_CORE X_NUC_90.L_CORE 0.002421
K_4806 X_NUC_73.L_CORE X_NUC_91.L_CORE 0.003359
K_4807 X_NUC_73.L_CORE X_NUC_92.L_CORE 0.002839
K_4808 X_NUC_73.L_CORE X_NUC_93.L_CORE 0.002645
K_4809 X_NUC_73.L_CORE X_NUC_94.L_CORE 0.004876
K_4810 X_NUC_73.L_CORE X_NUC_95.L_CORE 0.002594
K_4811 X_NUC_73.L_CORE X_NUC_96.L_CORE 0.003849
K_4812 X_NUC_73.L_CORE X_NUC_97.L_CORE 0.004377
K_4813 X_NUC_73.L_CORE X_NUC_98.L_CORE 0.002797
K_4814 X_NUC_73.L_CORE X_NUC_99.L_CORE 0.010613
K_4815 X_NUC_73.L_CORE X_NUC_100.L_CORE 0.003521
K_4816 X_NUC_73.L_CORE X_NUC_101.L_CORE 0.004065
K_4817 X_NUC_73.L_CORE X_NUC_102.L_CORE 0.010894
K_4818 X_NUC_73.L_CORE X_NUC_103.L_CORE 0.004250
K_4819 X_NUC_74.L_CORE X_NUC_75.L_CORE 0.207973
K_4820 X_NUC_74.L_CORE X_NUC_76.L_CORE 0.207973
K_4821 X_NUC_74.L_CORE X_NUC_77.L_CORE 0.004158
K_4822 X_NUC_74.L_CORE X_NUC_78.L_CORE 0.004081
K_4823 X_NUC_74.L_CORE X_NUC_79.L_CORE 0.004128
K_4824 X_NUC_74.L_CORE X_NUC_80.L_CORE 0.004101
K_4825 X_NUC_74.L_CORE X_NUC_81.L_CORE 0.006126
K_4826 X_NUC_74.L_CORE X_NUC_82.L_CORE 0.005988
K_4827 X_NUC_74.L_CORE X_NUC_83.L_CORE 0.005978
K_4828 X_NUC_74.L_CORE X_NUC_84.L_CORE 0.006080
K_4829 X_NUC_74.L_CORE X_NUC_85.L_CORE 0.008180
K_4830 X_NUC_74.L_CORE X_NUC_86.L_CORE 0.007921
K_4831 X_NUC_74.L_CORE X_NUC_87.L_CORE 0.008009
K_4832 X_NUC_74.L_CORE X_NUC_88.L_CORE 0.007900
K_4833 X_NUC_74.L_CORE X_NUC_89.L_CORE 0.002849
K_4834 X_NUC_74.L_CORE X_NUC_90.L_CORE 0.002440
K_4835 X_NUC_74.L_CORE X_NUC_91.L_CORE 0.003362
K_4836 X_NUC_74.L_CORE X_NUC_92.L_CORE 0.002857
K_4837 X_NUC_74.L_CORE X_NUC_93.L_CORE 0.002668
K_4838 X_NUC_74.L_CORE X_NUC_94.L_CORE 0.004838
K_4839 X_NUC_74.L_CORE X_NUC_95.L_CORE 0.002622
K_4840 X_NUC_74.L_CORE X_NUC_96.L_CORE 0.003869
K_4841 X_NUC_74.L_CORE X_NUC_97.L_CORE 0.004396
K_4842 X_NUC_74.L_CORE X_NUC_98.L_CORE 0.002834
K_4843 X_NUC_74.L_CORE X_NUC_99.L_CORE 0.010330
K_4844 X_NUC_74.L_CORE X_NUC_100.L_CORE 0.003570
K_4845 X_NUC_74.L_CORE X_NUC_101.L_CORE 0.004125
K_4846 X_NUC_74.L_CORE X_NUC_102.L_CORE 0.011071
K_4847 X_NUC_74.L_CORE X_NUC_103.L_CORE 0.004333
K_4848 X_NUC_75.L_CORE X_NUC_76.L_CORE 0.207973
K_4849 X_NUC_75.L_CORE X_NUC_77.L_CORE 0.004109
K_4850 X_NUC_75.L_CORE X_NUC_78.L_CORE 0.004035
K_4851 X_NUC_75.L_CORE X_NUC_79.L_CORE 0.004081
K_4852 X_NUC_75.L_CORE X_NUC_80.L_CORE 0.004054
K_4853 X_NUC_75.L_CORE X_NUC_81.L_CORE 0.006134
K_4854 X_NUC_75.L_CORE X_NUC_82.L_CORE 0.005993
K_4855 X_NUC_75.L_CORE X_NUC_83.L_CORE 0.005988
K_4856 X_NUC_75.L_CORE X_NUC_84.L_CORE 0.006087
K_4857 X_NUC_75.L_CORE X_NUC_85.L_CORE 0.008081
K_4858 X_NUC_75.L_CORE X_NUC_86.L_CORE 0.007826
K_4859 X_NUC_75.L_CORE X_NUC_87.L_CORE 0.007921
K_4860 X_NUC_75.L_CORE X_NUC_88.L_CORE 0.007810
K_4861 X_NUC_75.L_CORE X_NUC_89.L_CORE 0.002816
K_4862 X_NUC_75.L_CORE X_NUC_90.L_CORE 0.002416
K_4863 X_NUC_75.L_CORE X_NUC_91.L_CORE 0.003334
K_4864 X_NUC_75.L_CORE X_NUC_92.L_CORE 0.002819
K_4865 X_NUC_75.L_CORE X_NUC_93.L_CORE 0.002650
K_4866 X_NUC_75.L_CORE X_NUC_94.L_CORE 0.004772
K_4867 X_NUC_75.L_CORE X_NUC_95.L_CORE 0.002594
K_4868 X_NUC_75.L_CORE X_NUC_96.L_CORE 0.003862
K_4869 X_NUC_75.L_CORE X_NUC_97.L_CORE 0.004319
K_4870 X_NUC_75.L_CORE X_NUC_98.L_CORE 0.002814
K_4871 X_NUC_75.L_CORE X_NUC_99.L_CORE 0.010498
K_4872 X_NUC_75.L_CORE X_NUC_100.L_CORE 0.003526
K_4873 X_NUC_75.L_CORE X_NUC_101.L_CORE 0.004126
K_4874 X_NUC_75.L_CORE X_NUC_102.L_CORE 0.010966
K_4875 X_NUC_75.L_CORE X_NUC_103.L_CORE 0.004309
K_4876 X_NUC_76.L_CORE X_NUC_77.L_CORE 0.004137
K_4877 X_NUC_76.L_CORE X_NUC_78.L_CORE 0.004061
K_4878 X_NUC_76.L_CORE X_NUC_79.L_CORE 0.004108
K_4879 X_NUC_76.L_CORE X_NUC_80.L_CORE 0.004081
K_4880 X_NUC_76.L_CORE X_NUC_81.L_CORE 0.006029
K_4881 X_NUC_76.L_CORE X_NUC_82.L_CORE 0.005895
K_4882 X_NUC_76.L_CORE X_NUC_83.L_CORE 0.005888
K_4883 X_NUC_76.L_CORE X_NUC_84.L_CORE 0.005988
K_4884 X_NUC_76.L_CORE X_NUC_85.L_CORE 0.008198
K_4885 X_NUC_76.L_CORE X_NUC_86.L_CORE 0.007932
K_4886 X_NUC_76.L_CORE X_NUC_87.L_CORE 0.008025
K_4887 X_NUC_76.L_CORE X_NUC_88.L_CORE 0.007921
K_4888 X_NUC_76.L_CORE X_NUC_89.L_CORE 0.002822
K_4889 X_NUC_76.L_CORE X_NUC_90.L_CORE 0.002416
K_4890 X_NUC_76.L_CORE X_NUC_91.L_CORE 0.003316
K_4891 X_NUC_76.L_CORE X_NUC_92.L_CORE 0.002839
K_4892 X_NUC_76.L_CORE X_NUC_93.L_CORE 0.002635
K_4893 X_NUC_76.L_CORE X_NUC_94.L_CORE 0.004796
K_4894 X_NUC_76.L_CORE X_NUC_95.L_CORE 0.002603
K_4895 X_NUC_76.L_CORE X_NUC_96.L_CORE 0.003805
K_4896 X_NUC_76.L_CORE X_NUC_97.L_CORE 0.004398
K_4897 X_NUC_76.L_CORE X_NUC_98.L_CORE 0.002806
K_4898 X_NUC_76.L_CORE X_NUC_99.L_CORE 0.010130
K_4899 X_NUC_76.L_CORE X_NUC_100.L_CORE 0.003561
K_4900 X_NUC_76.L_CORE X_NUC_101.L_CORE 0.004073
K_4901 X_NUC_76.L_CORE X_NUC_102.L_CORE 0.011450
K_4902 X_NUC_76.L_CORE X_NUC_103.L_CORE 0.004314
K_4903 X_NUC_77.L_CORE X_NUC_78.L_CORE 0.207973
K_4904 X_NUC_77.L_CORE X_NUC_79.L_CORE 0.207973
K_4905 X_NUC_77.L_CORE X_NUC_80.L_CORE 0.207973
K_4906 X_NUC_77.L_CORE X_NUC_81.L_CORE 0.004888
K_4907 X_NUC_77.L_CORE X_NUC_82.L_CORE 0.004943
K_4908 X_NUC_77.L_CORE X_NUC_83.L_CORE 0.004858
K_4909 X_NUC_77.L_CORE X_NUC_84.L_CORE 0.004959
K_4910 X_NUC_77.L_CORE X_NUC_85.L_CORE 0.007434
K_4911 X_NUC_77.L_CORE X_NUC_86.L_CORE 0.007687
K_4912 X_NUC_77.L_CORE X_NUC_87.L_CORE 0.007467
K_4913 X_NUC_77.L_CORE X_NUC_88.L_CORE 0.007542
K_4914 X_NUC_77.L_CORE X_NUC_89.L_CORE 0.002610
K_4915 X_NUC_77.L_CORE X_NUC_90.L_CORE 0.002947
K_4916 X_NUC_77.L_CORE X_NUC_91.L_CORE 0.002436
K_4917 X_NUC_77.L_CORE X_NUC_92.L_CORE 0.003426
K_4918 X_NUC_77.L_CORE X_NUC_93.L_CORE 0.002906
K_4919 X_NUC_77.L_CORE X_NUC_94.L_CORE 0.002755
K_4920 X_NUC_77.L_CORE X_NUC_95.L_CORE 0.004849
K_4921 X_NUC_77.L_CORE X_NUC_96.L_CORE 0.002753
K_4922 X_NUC_77.L_CORE X_NUC_97.L_CORE 0.004077
K_4923 X_NUC_77.L_CORE X_NUC_98.L_CORE 0.004623
K_4924 X_NUC_77.L_CORE X_NUC_99.L_CORE 0.003097
K_4925 X_NUC_77.L_CORE X_NUC_100.L_CORE 0.011208
K_4926 X_NUC_77.L_CORE X_NUC_101.L_CORE 0.004059
K_4927 X_NUC_77.L_CORE X_NUC_102.L_CORE 0.004933
K_4928 X_NUC_77.L_CORE X_NUC_103.L_CORE 0.010862
K_4929 X_NUC_78.L_CORE X_NUC_79.L_CORE 0.207973
K_4930 X_NUC_78.L_CORE X_NUC_80.L_CORE 0.207973
K_4931 X_NUC_78.L_CORE X_NUC_81.L_CORE 0.004832
K_4932 X_NUC_78.L_CORE X_NUC_82.L_CORE 0.004888
K_4933 X_NUC_78.L_CORE X_NUC_83.L_CORE 0.004804
K_4934 X_NUC_78.L_CORE X_NUC_84.L_CORE 0.004902
K_4935 X_NUC_78.L_CORE X_NUC_85.L_CORE 0.007195
K_4936 X_NUC_78.L_CORE X_NUC_86.L_CORE 0.007434
K_4937 X_NUC_78.L_CORE X_NUC_87.L_CORE 0.007230
K_4938 X_NUC_78.L_CORE X_NUC_88.L_CORE 0.007297
K_4939 X_NUC_78.L_CORE X_NUC_89.L_CORE 0.002597
K_4940 X_NUC_78.L_CORE X_NUC_90.L_CORE 0.002953
K_4941 X_NUC_78.L_CORE X_NUC_91.L_CORE 0.002421
K_4942 X_NUC_78.L_CORE X_NUC_92.L_CORE 0.003413
K_4943 X_NUC_78.L_CORE X_NUC_93.L_CORE 0.002910
K_4944 X_NUC_78.L_CORE X_NUC_94.L_CORE 0.002725
K_4945 X_NUC_78.L_CORE X_NUC_95.L_CORE 0.004905
K_4946 X_NUC_78.L_CORE X_NUC_96.L_CORE 0.002738
K_4947 X_NUC_78.L_CORE X_NUC_97.L_CORE 0.004019
K_4948 X_NUC_78.L_CORE X_NUC_98.L_CORE 0.004675
K_4949 X_NUC_78.L_CORE X_NUC_99.L_CORE 0.003058
K_4950 X_NUC_78.L_CORE X_NUC_100.L_CORE 0.011189
K_4951 X_NUC_78.L_CORE X_NUC_101.L_CORE 0.004043
K_4952 X_NUC_78.L_CORE X_NUC_102.L_CORE 0.004820
K_4953 X_NUC_78.L_CORE X_NUC_103.L_CORE 0.010792
K_4954 X_NUC_79.L_CORE X_NUC_80.L_CORE 0.207973
K_4955 X_NUC_79.L_CORE X_NUC_81.L_CORE 0.004916
K_4956 X_NUC_79.L_CORE X_NUC_82.L_CORE 0.004974
K_4957 X_NUC_79.L_CORE X_NUC_83.L_CORE 0.004888
K_4958 X_NUC_79.L_CORE X_NUC_84.L_CORE 0.004990
K_4959 X_NUC_79.L_CORE X_NUC_85.L_CORE 0.007391
K_4960 X_NUC_79.L_CORE X_NUC_86.L_CORE 0.007645
K_4961 X_NUC_79.L_CORE X_NUC_87.L_CORE 0.007434
K_4962 X_NUC_79.L_CORE X_NUC_88.L_CORE 0.007502
K_4963 X_NUC_79.L_CORE X_NUC_89.L_CORE 0.002583
K_4964 X_NUC_79.L_CORE X_NUC_90.L_CORE 0.002927
K_4965 X_NUC_79.L_CORE X_NUC_91.L_CORE 0.002420
K_4966 X_NUC_79.L_CORE X_NUC_92.L_CORE 0.003374
K_4967 X_NUC_79.L_CORE X_NUC_93.L_CORE 0.002903
K_4968 X_NUC_79.L_CORE X_NUC_94.L_CORE 0.002727
K_4969 X_NUC_79.L_CORE X_NUC_95.L_CORE 0.004801
K_4970 X_NUC_79.L_CORE X_NUC_96.L_CORE 0.002750
K_4971 X_NUC_79.L_CORE X_NUC_97.L_CORE 0.004003
K_4972 X_NUC_79.L_CORE X_NUC_98.L_CORE 0.004658
K_4973 X_NUC_79.L_CORE X_NUC_99.L_CORE 0.003082
K_4974 X_NUC_79.L_CORE X_NUC_100.L_CORE 0.010794
K_4975 X_NUC_79.L_CORE X_NUC_101.L_CORE 0.004090
K_4976 X_NUC_79.L_CORE X_NUC_102.L_CORE 0.004890
K_4977 X_NUC_79.L_CORE X_NUC_103.L_CORE 0.011324
K_4978 X_NUC_80.L_CORE X_NUC_81.L_CORE 0.004817
K_4979 X_NUC_80.L_CORE X_NUC_82.L_CORE 0.004871
K_4980 X_NUC_80.L_CORE X_NUC_83.L_CORE 0.004790
K_4981 X_NUC_80.L_CORE X_NUC_84.L_CORE 0.004888
K_4982 X_NUC_80.L_CORE X_NUC_85.L_CORE 0.007321
K_4983 X_NUC_80.L_CORE X_NUC_86.L_CORE 0.007568
K_4984 X_NUC_80.L_CORE X_NUC_87.L_CORE 0.007358
K_4985 X_NUC_80.L_CORE X_NUC_88.L_CORE 0.007434
K_4986 X_NUC_80.L_CORE X_NUC_89.L_CORE 0.002581
K_4987 X_NUC_80.L_CORE X_NUC_90.L_CORE 0.002917
K_4988 X_NUC_80.L_CORE X_NUC_91.L_CORE 0.002408
K_4989 X_NUC_80.L_CORE X_NUC_92.L_CORE 0.003394
K_4990 X_NUC_80.L_CORE X_NUC_93.L_CORE 0.002874
K_4991 X_NUC_80.L_CORE X_NUC_94.L_CORE 0.002724
K_4992 X_NUC_80.L_CORE X_NUC_95.L_CORE 0.004816
K_4993 X_NUC_80.L_CORE X_NUC_96.L_CORE 0.002721
K_4994 X_NUC_80.L_CORE X_NUC_97.L_CORE 0.004040
K_4995 X_NUC_80.L_CORE X_NUC_98.L_CORE 0.004580
K_4996 X_NUC_80.L_CORE X_NUC_99.L_CORE 0.003061
K_4997 X_NUC_80.L_CORE X_NUC_100.L_CORE 0.011346
K_4998 X_NUC_80.L_CORE X_NUC_101.L_CORE 0.004013
K_4999 X_NUC_80.L_CORE X_NUC_102.L_CORE 0.004884
K_5000 X_NUC_80.L_CORE X_NUC_103.L_CORE 0.010875
K_5001 X_NUC_81.L_CORE X_NUC_82.L_CORE 0.207973
K_5002 X_NUC_81.L_CORE X_NUC_83.L_CORE 0.207973
K_5003 X_NUC_81.L_CORE X_NUC_84.L_CORE 0.207973
K_5004 X_NUC_81.L_CORE X_NUC_85.L_CORE 0.006887
K_5005 X_NUC_81.L_CORE X_NUC_86.L_CORE 0.006924
K_5006 X_NUC_81.L_CORE X_NUC_87.L_CORE 0.006998
K_5007 X_NUC_81.L_CORE X_NUC_88.L_CORE 0.006776
K_5008 X_NUC_81.L_CORE X_NUC_89.L_CORE 0.002473
K_5009 X_NUC_81.L_CORE X_NUC_90.L_CORE 0.002617
K_5010 X_NUC_81.L_CORE X_NUC_91.L_CORE 0.003001
K_5011 X_NUC_81.L_CORE X_NUC_92.L_CORE 0.002491
K_5012 X_NUC_81.L_CORE X_NUC_93.L_CORE 0.003423
K_5013 X_NUC_81.L_CORE X_NUC_94.L_CORE 0.003021
K_5014 X_NUC_81.L_CORE X_NUC_95.L_CORE 0.002875
K_5015 X_NUC_81.L_CORE X_NUC_96.L_CORE 0.004799
K_5016 X_NUC_81.L_CORE X_NUC_97.L_CORE 0.002982
K_5017 X_NUC_81.L_CORE X_NUC_98.L_CORE 0.004269
K_5018 X_NUC_81.L_CORE X_NUC_99.L_CORE 0.005067
K_5019 X_NUC_81.L_CORE X_NUC_100.L_CORE 0.003515
K_5020 X_NUC_81.L_CORE X_NUC_101.L_CORE 0.011770
K_5021 X_NUC_81.L_CORE X_NUC_102.L_CORE 0.005079
K_5022 X_NUC_81.L_CORE X_NUC_103.L_CORE 0.006731
K_5023 X_NUC_82.L_CORE X_NUC_83.L_CORE 0.207973
K_5024 X_NUC_82.L_CORE X_NUC_84.L_CORE 0.207973
K_5025 X_NUC_82.L_CORE X_NUC_85.L_CORE 0.006843
K_5026 X_NUC_82.L_CORE X_NUC_86.L_CORE 0.006887
K_5027 X_NUC_82.L_CORE X_NUC_87.L_CORE 0.006956
K_5028 X_NUC_82.L_CORE X_NUC_88.L_CORE 0.006737
K_5029 X_NUC_82.L_CORE X_NUC_89.L_CORE 0.002470
K_5030 X_NUC_82.L_CORE X_NUC_90.L_CORE 0.002630
K_5031 X_NUC_82.L_CORE X_NUC_91.L_CORE 0.002985
K_5032 X_NUC_82.L_CORE X_NUC_92.L_CORE 0.002493
K_5033 X_NUC_82.L_CORE X_NUC_93.L_CORE 0.003447
K_5034 X_NUC_82.L_CORE X_NUC_94.L_CORE 0.002995
K_5035 X_NUC_82.L_CORE X_NUC_95.L_CORE 0.002899
K_5036 X_NUC_82.L_CORE X_NUC_96.L_CORE 0.004768
K_5037 X_NUC_82.L_CORE X_NUC_97.L_CORE 0.002971
K_5038 X_NUC_82.L_CORE X_NUC_98.L_CORE 0.004349
K_5039 X_NUC_82.L_CORE X_NUC_99.L_CORE 0.004956
K_5040 X_NUC_82.L_CORE X_NUC_100.L_CORE 0.003535
K_5041 X_NUC_82.L_CORE X_NUC_101.L_CORE 0.012195
K_5042 X_NUC_82.L_CORE X_NUC_102.L_CORE 0.005015
K_5043 X_NUC_82.L_CORE X_NUC_103.L_CORE 0.006863
K_5044 X_NUC_83.L_CORE X_NUC_84.L_CORE 0.207973
K_5045 X_NUC_83.L_CORE X_NUC_85.L_CORE 0.006774
K_5046 X_NUC_83.L_CORE X_NUC_86.L_CORE 0.006813
K_5047 X_NUC_83.L_CORE X_NUC_87.L_CORE 0.006887
K_5048 X_NUC_83.L_CORE X_NUC_88.L_CORE 0.006671
K_5049 X_NUC_83.L_CORE X_NUC_89.L_CORE 0.002447
K_5050 X_NUC_83.L_CORE X_NUC_90.L_CORE 0.002599
K_5051 X_NUC_83.L_CORE X_NUC_91.L_CORE 0.002965
K_5052 X_NUC_83.L_CORE X_NUC_92.L_CORE 0.002467
K_5053 X_NUC_83.L_CORE X_NUC_93.L_CORE 0.003407
K_5054 X_NUC_83.L_CORE X_NUC_94.L_CORE 0.002978
K_5055 X_NUC_83.L_CORE X_NUC_95.L_CORE 0.002859
K_5056 X_NUC_83.L_CORE X_NUC_96.L_CORE 0.004752
K_5057 X_NUC_83.L_CORE X_NUC_97.L_CORE 0.002946
K_5058 X_NUC_83.L_CORE X_NUC_98.L_CORE 0.004277
K_5059 X_NUC_83.L_CORE X_NUC_99.L_CORE 0.004970
K_5060 X_NUC_83.L_CORE X_NUC_100.L_CORE 0.003491
K_5061 X_NUC_83.L_CORE X_NUC_101.L_CORE 0.012143
K_5062 X_NUC_83.L_CORE X_NUC_102.L_CORE 0.005001
K_5063 X_NUC_83.L_CORE X_NUC_103.L_CORE 0.006758
K_5064 X_NUC_84.L_CORE X_NUC_85.L_CORE 0.006996
K_5065 X_NUC_84.L_CORE X_NUC_86.L_CORE 0.007039
K_5066 X_NUC_84.L_CORE X_NUC_87.L_CORE 0.007117
K_5067 X_NUC_84.L_CORE X_NUC_88.L_CORE 0.006887
K_5068 X_NUC_84.L_CORE X_NUC_89.L_CORE 0.002458
K_5069 X_NUC_84.L_CORE X_NUC_90.L_CORE 0.002607
K_5070 X_NUC_84.L_CORE X_NUC_91.L_CORE 0.002964
K_5071 X_NUC_84.L_CORE X_NUC_92.L_CORE 0.002488
K_5072 X_NUC_84.L_CORE X_NUC_93.L_CORE 0.003394
K_5073 X_NUC_84.L_CORE X_NUC_94.L_CORE 0.002997
K_5074 X_NUC_84.L_CORE X_NUC_95.L_CORE 0.002883
K_5075 X_NUC_84.L_CORE X_NUC_96.L_CORE 0.004694
K_5076 X_NUC_84.L_CORE X_NUC_97.L_CORE 0.002983
K_5077 X_NUC_84.L_CORE X_NUC_98.L_CORE 0.004283
K_5078 X_NUC_84.L_CORE X_NUC_99.L_CORE 0.004986
K_5079 X_NUC_84.L_CORE X_NUC_100.L_CORE 0.003546
K_5080 X_NUC_84.L_CORE X_NUC_101.L_CORE 0.011627
K_5081 X_NUC_84.L_CORE X_NUC_102.L_CORE 0.005105
K_5082 X_NUC_84.L_CORE X_NUC_103.L_CORE 0.006928
K_5083 X_NUC_85.L_CORE X_NUC_86.L_CORE 0.207973
K_5084 X_NUC_85.L_CORE X_NUC_87.L_CORE 0.207973
K_5085 X_NUC_85.L_CORE X_NUC_88.L_CORE 0.207973
K_5086 X_NUC_85.L_CORE X_NUC_89.L_CORE 0.002566
K_5087 X_NUC_85.L_CORE X_NUC_90.L_CORE 0.002494
K_5088 X_NUC_85.L_CORE X_NUC_91.L_CORE 0.002673
K_5089 X_NUC_85.L_CORE X_NUC_92.L_CORE 0.002965
K_5090 X_NUC_85.L_CORE X_NUC_93.L_CORE 0.002654
K_5091 X_NUC_85.L_CORE X_NUC_94.L_CORE 0.003379
K_5092 X_NUC_85.L_CORE X_NUC_95.L_CORE 0.003150
K_5093 X_NUC_85.L_CORE X_NUC_96.L_CORE 0.003160
K_5094 X_NUC_85.L_CORE X_NUC_97.L_CORE 0.004472
K_5095 X_NUC_85.L_CORE X_NUC_98.L_CORE 0.003400
K_5096 X_NUC_85.L_CORE X_NUC_99.L_CORE 0.004680
K_5097 X_NUC_85.L_CORE X_NUC_100.L_CORE 0.005416
K_5098 X_NUC_85.L_CORE X_NUC_101.L_CORE 0.004483
K_5099 X_NUC_85.L_CORE X_NUC_102.L_CORE 0.012510
K_5100 X_NUC_85.L_CORE X_NUC_103.L_CORE 0.008140
K_5101 X_NUC_86.L_CORE X_NUC_87.L_CORE 0.207973
K_5102 X_NUC_86.L_CORE X_NUC_88.L_CORE 0.207973
K_5103 X_NUC_86.L_CORE X_NUC_89.L_CORE 0.002564
K_5104 X_NUC_86.L_CORE X_NUC_90.L_CORE 0.002506
K_5105 X_NUC_86.L_CORE X_NUC_91.L_CORE 0.002665
K_5106 X_NUC_86.L_CORE X_NUC_92.L_CORE 0.002972
K_5107 X_NUC_86.L_CORE X_NUC_93.L_CORE 0.002668
K_5108 X_NUC_86.L_CORE X_NUC_94.L_CORE 0.003347
K_5109 X_NUC_86.L_CORE X_NUC_95.L_CORE 0.003185
K_5110 X_NUC_86.L_CORE X_NUC_96.L_CORE 0.003155
K_5111 X_NUC_86.L_CORE X_NUC_97.L_CORE 0.004447
K_5112 X_NUC_86.L_CORE X_NUC_98.L_CORE 0.003445
K_5113 X_NUC_86.L_CORE X_NUC_99.L_CORE 0.004605
K_5114 X_NUC_86.L_CORE X_NUC_100.L_CORE 0.005512
K_5115 X_NUC_86.L_CORE X_NUC_101.L_CORE 0.004517
K_5116 X_NUC_86.L_CORE X_NUC_102.L_CORE 0.011837
K_5117 X_NUC_86.L_CORE X_NUC_103.L_CORE 0.008450
K_5118 X_NUC_87.L_CORE X_NUC_88.L_CORE 0.207973
K_5119 X_NUC_87.L_CORE X_NUC_89.L_CORE 0.002543
K_5120 X_NUC_87.L_CORE X_NUC_90.L_CORE 0.002483
K_5121 X_NUC_87.L_CORE X_NUC_91.L_CORE 0.002655
K_5122 X_NUC_87.L_CORE X_NUC_92.L_CORE 0.002934
K_5123 X_NUC_87.L_CORE X_NUC_93.L_CORE 0.002653
K_5124 X_NUC_87.L_CORE X_NUC_94.L_CORE 0.003331
K_5125 X_NUC_87.L_CORE X_NUC_95.L_CORE 0.003140
K_5126 X_NUC_87.L_CORE X_NUC_96.L_CORE 0.003157
K_5127 X_NUC_87.L_CORE X_NUC_97.L_CORE 0.004382
K_5128 X_NUC_87.L_CORE X_NUC_98.L_CORE 0.003418
K_5129 X_NUC_87.L_CORE X_NUC_99.L_CORE 0.004638
K_5130 X_NUC_87.L_CORE X_NUC_100.L_CORE 0.005382
K_5131 X_NUC_87.L_CORE X_NUC_101.L_CORE 0.004534
K_5132 X_NUC_87.L_CORE X_NUC_102.L_CORE 0.012016
K_5133 X_NUC_87.L_CORE X_NUC_103.L_CORE 0.008383
K_5134 X_NUC_88.L_CORE X_NUC_89.L_CORE 0.002544
K_5135 X_NUC_88.L_CORE X_NUC_90.L_CORE 0.002479
K_5136 X_NUC_88.L_CORE X_NUC_91.L_CORE 0.002641
K_5137 X_NUC_88.L_CORE X_NUC_92.L_CORE 0.002951
K_5138 X_NUC_88.L_CORE X_NUC_93.L_CORE 0.002634
K_5139 X_NUC_88.L_CORE X_NUC_94.L_CORE 0.003332
K_5140 X_NUC_88.L_CORE X_NUC_95.L_CORE 0.003150
K_5141 X_NUC_88.L_CORE X_NUC_96.L_CORE 0.003119
K_5142 X_NUC_88.L_CORE X_NUC_97.L_CORE 0.004446
K_5143 X_NUC_88.L_CORE X_NUC_98.L_CORE 0.003394
K_5144 X_NUC_88.L_CORE X_NUC_99.L_CORE 0.004583
K_5145 X_NUC_88.L_CORE X_NUC_100.L_CORE 0.005475
K_5146 X_NUC_88.L_CORE X_NUC_101.L_CORE 0.004445
K_5147 X_NUC_88.L_CORE X_NUC_102.L_CORE 0.012243
K_5148 X_NUC_88.L_CORE X_NUC_103.L_CORE 0.008295
K_5149 X_NUC_89.L_CORE X_NUC_90.L_CORE 0.004951
K_5150 X_NUC_89.L_CORE X_NUC_91.L_CORE 0.005340
K_5151 X_NUC_89.L_CORE X_NUC_92.L_CORE 0.005642
K_5152 X_NUC_89.L_CORE X_NUC_93.L_CORE 0.003260
K_5153 X_NUC_89.L_CORE X_NUC_94.L_CORE 0.004691
K_5154 X_NUC_89.L_CORE X_NUC_95.L_CORE 0.003231
K_5155 X_NUC_89.L_CORE X_NUC_96.L_CORE 0.002945
K_5156 X_NUC_89.L_CORE X_NUC_97.L_CORE 0.003576
K_5157 X_NUC_89.L_CORE X_NUC_98.L_CORE 0.002538
K_5158 X_NUC_89.L_CORE X_NUC_99.L_CORE 0.002862
K_5159 X_NUC_89.L_CORE X_NUC_100.L_CORE 0.002680
K_5160 X_NUC_89.L_CORE X_NUC_101.L_CORE 0.002335
K_5161 X_NUC_89.L_CORE X_NUC_102.L_CORE 0.002565
K_5162 X_NUC_89.L_CORE X_NUC_103.L_CORE 0.002279
K_5163 X_NUC_90.L_CORE X_NUC_91.L_CORE 0.003562
K_5164 X_NUC_90.L_CORE X_NUC_92.L_CORE 0.004371
K_5165 X_NUC_90.L_CORE X_NUC_93.L_CORE 0.005409
K_5166 X_NUC_90.L_CORE X_NUC_94.L_CORE 0.002730
K_5167 X_NUC_90.L_CORE X_NUC_95.L_CORE 0.005080
K_5168 X_NUC_90.L_CORE X_NUC_96.L_CORE 0.002957
K_5169 X_NUC_90.L_CORE X_NUC_97.L_CORE 0.002705
K_5170 X_NUC_90.L_CORE X_NUC_98.L_CORE 0.003883
K_5171 X_NUC_90.L_CORE X_NUC_99.L_CORE 0.002351
K_5172 X_NUC_90.L_CORE X_NUC_100.L_CORE 0.002888
K_5173 X_NUC_90.L_CORE X_NUC_101.L_CORE 0.002687
K_5174 X_NUC_90.L_CORE X_NUC_102.L_CORE 0.002276
K_5175 X_NUC_90.L_CORE X_NUC_103.L_CORE 0.002565
K_5176 X_NUC_91.L_CORE X_NUC_92.L_CORE 0.003018
K_5177 X_NUC_91.L_CORE X_NUC_93.L_CORE 0.003873
K_5178 X_NUC_91.L_CORE X_NUC_94.L_CORE 0.005122
K_5179 X_NUC_91.L_CORE X_NUC_95.L_CORE 0.002483
K_5180 X_NUC_91.L_CORE X_NUC_96.L_CORE 0.005218
K_5181 X_NUC_91.L_CORE X_NUC_97.L_CORE 0.002809
K_5182 X_NUC_91.L_CORE X_NUC_98.L_CORE 0.002588
K_5183 X_NUC_91.L_CORE X_NUC_99.L_CORE 0.004021
K_5184 X_NUC_91.L_CORE X_NUC_100.L_CORE 0.002283
K_5185 X_NUC_91.L_CORE X_NUC_101.L_CORE 0.002891
K_5186 X_NUC_91.L_CORE X_NUC_102.L_CORE 0.002687
K_5187 X_NUC_91.L_CORE X_NUC_103.L_CORE 0.002335
K_5188 X_NUC_92.L_CORE X_NUC_93.L_CORE 0.002727
K_5189 X_NUC_92.L_CORE X_NUC_94.L_CORE 0.003584
K_5190 X_NUC_92.L_CORE X_NUC_95.L_CORE 0.004912
K_5191 X_NUC_92.L_CORE X_NUC_96.L_CORE 0.002348
K_5192 X_NUC_92.L_CORE X_NUC_97.L_CORE 0.005271
K_5193 X_NUC_92.L_CORE X_NUC_98.L_CORE 0.002732
K_5194 X_NUC_92.L_CORE X_NUC_99.L_CORE 0.002536
K_5195 X_NUC_92.L_CORE X_NUC_100.L_CORE 0.004062
K_5196 X_NUC_92.L_CORE X_NUC_101.L_CORE 0.002283
K_5197 X_NUC_92.L_CORE X_NUC_102.L_CORE 0.002888
K_5198 X_NUC_92.L_CORE X_NUC_103.L_CORE 0.002680
K_5199 X_NUC_93.L_CORE X_NUC_94.L_CORE 0.002558
K_5200 X_NUC_93.L_CORE X_NUC_95.L_CORE 0.003413
K_5201 X_NUC_93.L_CORE X_NUC_96.L_CORE 0.004779
K_5202 X_NUC_93.L_CORE X_NUC_97.L_CORE 0.002278
K_5203 X_NUC_93.L_CORE X_NUC_98.L_CORE 0.005288
K_5204 X_NUC_93.L_CORE X_NUC_99.L_CORE 0.002708
K_5205 X_NUC_93.L_CORE X_NUC_100.L_CORE 0.002536
K_5206 X_NUC_93.L_CORE X_NUC_101.L_CORE 0.004021
K_5207 X_NUC_93.L_CORE X_NUC_102.L_CORE 0.002351
K_5208 X_NUC_93.L_CORE X_NUC_103.L_CORE 0.002862
K_5209 X_NUC_94.L_CORE X_NUC_95.L_CORE 0.002461
K_5210 X_NUC_94.L_CORE X_NUC_96.L_CORE 0.003322
K_5211 X_NUC_94.L_CORE X_NUC_97.L_CORE 0.004716
K_5212 X_NUC_94.L_CORE X_NUC_98.L_CORE 0.002256
K_5213 X_NUC_94.L_CORE X_NUC_99.L_CORE 0.005288
K_5214 X_NUC_94.L_CORE X_NUC_100.L_CORE 0.002732
K_5215 X_NUC_94.L_CORE X_NUC_101.L_CORE 0.002588
K_5216 X_NUC_94.L_CORE X_NUC_102.L_CORE 0.003883
K_5217 X_NUC_94.L_CORE X_NUC_103.L_CORE 0.002538
K_5218 X_NUC_95.L_CORE X_NUC_96.L_CORE 0.002416
K_5219 X_NUC_95.L_CORE X_NUC_97.L_CORE 0.003293
K_5220 X_NUC_95.L_CORE X_NUC_98.L_CORE 0.004716
K_5221 X_NUC_95.L_CORE X_NUC_99.L_CORE 0.002278
K_5222 X_NUC_95.L_CORE X_NUC_100.L_CORE 0.005271
K_5223 X_NUC_95.L_CORE X_NUC_101.L_CORE 0.002809
K_5224 X_NUC_95.L_CORE X_NUC_102.L_CORE 0.002705
K_5225 X_NUC_95.L_CORE X_NUC_103.L_CORE 0.003576
K_5226 X_NUC_96.L_CORE X_NUC_97.L_CORE 0.002416
K_5227 X_NUC_96.L_CORE X_NUC_98.L_CORE 0.003322
K_5228 X_NUC_96.L_CORE X_NUC_99.L_CORE 0.004779
K_5229 X_NUC_96.L_CORE X_NUC_100.L_CORE 0.002348
K_5230 X_NUC_96.L_CORE X_NUC_101.L_CORE 0.005218
K_5231 X_NUC_96.L_CORE X_NUC_102.L_CORE 0.002957
K_5232 X_NUC_96.L_CORE X_NUC_103.L_CORE 0.002945
K_5233 X_NUC_97.L_CORE X_NUC_98.L_CORE 0.002461
K_5234 X_NUC_97.L_CORE X_NUC_99.L_CORE 0.003413
K_5235 X_NUC_97.L_CORE X_NUC_100.L_CORE 0.004912
K_5236 X_NUC_97.L_CORE X_NUC_101.L_CORE 0.002483
K_5237 X_NUC_97.L_CORE X_NUC_102.L_CORE 0.005080
K_5238 X_NUC_97.L_CORE X_NUC_103.L_CORE 0.003231
K_5239 X_NUC_98.L_CORE X_NUC_99.L_CORE 0.002558
K_5240 X_NUC_98.L_CORE X_NUC_100.L_CORE 0.003584
K_5241 X_NUC_98.L_CORE X_NUC_101.L_CORE 0.005122
K_5242 X_NUC_98.L_CORE X_NUC_102.L_CORE 0.002730
K_5243 X_NUC_98.L_CORE X_NUC_103.L_CORE 0.004691
K_5244 X_NUC_99.L_CORE X_NUC_100.L_CORE 0.002727
K_5245 X_NUC_99.L_CORE X_NUC_101.L_CORE 0.003873
K_5246 X_NUC_99.L_CORE X_NUC_102.L_CORE 0.005409
K_5247 X_NUC_99.L_CORE X_NUC_103.L_CORE 0.003260
K_5248 X_NUC_100.L_CORE X_NUC_101.L_CORE 0.003018
K_5249 X_NUC_100.L_CORE X_NUC_102.L_CORE 0.004371
K_5250 X_NUC_100.L_CORE X_NUC_103.L_CORE 0.005642
K_5251 X_NUC_101.L_CORE X_NUC_102.L_CORE 0.003562
K_5252 X_NUC_101.L_CORE X_NUC_103.L_CORE 0.005340
K_5253 X_NUC_102.L_CORE X_NUC_103.L_CORE 0.004951

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
