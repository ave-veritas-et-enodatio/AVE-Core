* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Cerium-140 (Z=58, A=140)
* Auto-generated topological mutual impedance array
* Nodes: 140

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON
X_NUC_65 NODE_65 0 NUCLEON
X_NUC_66 NODE_66 0 NUCLEON
X_NUC_67 NODE_67 0 NUCLEON
X_NUC_68 NODE_68 0 NUCLEON
X_NUC_69 NODE_69 0 NUCLEON
X_NUC_70 NODE_70 0 NUCLEON
X_NUC_71 NODE_71 0 NUCLEON
X_NUC_72 NODE_72 0 NUCLEON
X_NUC_73 NODE_73 0 NUCLEON
X_NUC_74 NODE_74 0 NUCLEON
X_NUC_75 NODE_75 0 NUCLEON
X_NUC_76 NODE_76 0 NUCLEON
X_NUC_77 NODE_77 0 NUCLEON
X_NUC_78 NODE_78 0 NUCLEON
X_NUC_79 NODE_79 0 NUCLEON
X_NUC_80 NODE_80 0 NUCLEON
X_NUC_81 NODE_81 0 NUCLEON
X_NUC_82 NODE_82 0 NUCLEON
X_NUC_83 NODE_83 0 NUCLEON
X_NUC_84 NODE_84 0 NUCLEON
X_NUC_85 NODE_85 0 NUCLEON
X_NUC_86 NODE_86 0 NUCLEON
X_NUC_87 NODE_87 0 NUCLEON
X_NUC_88 NODE_88 0 NUCLEON
X_NUC_89 NODE_89 0 NUCLEON
X_NUC_90 NODE_90 0 NUCLEON
X_NUC_91 NODE_91 0 NUCLEON
X_NUC_92 NODE_92 0 NUCLEON
X_NUC_93 NODE_93 0 NUCLEON
X_NUC_94 NODE_94 0 NUCLEON
X_NUC_95 NODE_95 0 NUCLEON
X_NUC_96 NODE_96 0 NUCLEON
X_NUC_97 NODE_97 0 NUCLEON
X_NUC_98 NODE_98 0 NUCLEON
X_NUC_99 NODE_99 0 NUCLEON
X_NUC_100 NODE_100 0 NUCLEON
X_NUC_101 NODE_101 0 NUCLEON
X_NUC_102 NODE_102 0 NUCLEON
X_NUC_103 NODE_103 0 NUCLEON
X_NUC_104 NODE_104 0 NUCLEON
X_NUC_105 NODE_105 0 NUCLEON
X_NUC_106 NODE_106 0 NUCLEON
X_NUC_107 NODE_107 0 NUCLEON
X_NUC_108 NODE_108 0 NUCLEON
X_NUC_109 NODE_109 0 NUCLEON
X_NUC_110 NODE_110 0 NUCLEON
X_NUC_111 NODE_111 0 NUCLEON
X_NUC_112 NODE_112 0 NUCLEON
X_NUC_113 NODE_113 0 NUCLEON
X_NUC_114 NODE_114 0 NUCLEON
X_NUC_115 NODE_115 0 NUCLEON
X_NUC_116 NODE_116 0 NUCLEON
X_NUC_117 NODE_117 0 NUCLEON
X_NUC_118 NODE_118 0 NUCLEON
X_NUC_119 NODE_119 0 NUCLEON
X_NUC_120 NODE_120 0 NUCLEON
X_NUC_121 NODE_121 0 NUCLEON
X_NUC_122 NODE_122 0 NUCLEON
X_NUC_123 NODE_123 0 NUCLEON
X_NUC_124 NODE_124 0 NUCLEON
X_NUC_125 NODE_125 0 NUCLEON
X_NUC_126 NODE_126 0 NUCLEON
X_NUC_127 NODE_127 0 NUCLEON
X_NUC_128 NODE_128 0 NUCLEON
X_NUC_129 NODE_129 0 NUCLEON
X_NUC_130 NODE_130 0 NUCLEON
X_NUC_131 NODE_131 0 NUCLEON
X_NUC_132 NODE_132 0 NUCLEON
X_NUC_133 NODE_133 0 NUCLEON
X_NUC_134 NODE_134 0 NUCLEON
X_NUC_135 NODE_135 0 NUCLEON
X_NUC_136 NODE_136 0 NUCLEON
X_NUC_137 NODE_137 0 NUCLEON
X_NUC_138 NODE_138 0 NUCLEON
X_NUC_139 NODE_139 0 NUCLEON
X_NUC_140 NODE_140 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.006000
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.005841
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.005880
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.005931
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.006479
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.006558
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.006396
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.006576
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.006933
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.006823
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.006909
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.006732
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.003898
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.003855
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.003836
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.003890
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.005880
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.006025
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.005887
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.005890
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.003884
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.003820
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.003839
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.003823
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.003516
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.003520
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.003474
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.003526
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.004572
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.004594
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.004574
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.004502
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.002974
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.002941
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.002935
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.002952
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.003548
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.003587
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.003527
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.003554
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.003303
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.003275
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.003280
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.003252
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.002692
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.002681
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.002660
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.002686
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.003409
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.003440
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.003402
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.003385
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.002621
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.002596
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.002594
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.002594
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.002680
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.002689
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.002656
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.002679
K_64 X_NUC_1.L_CORE X_NUC_65.L_CORE 0.002905
K_65 X_NUC_1.L_CORE X_NUC_66.L_CORE 0.002902
K_66 X_NUC_1.L_CORE X_NUC_67.L_CORE 0.002892
K_67 X_NUC_1.L_CORE X_NUC_68.L_CORE 0.002869
K_68 X_NUC_1.L_CORE X_NUC_69.L_CORE 0.002331
K_69 X_NUC_1.L_CORE X_NUC_70.L_CORE 0.002317
K_70 X_NUC_1.L_CORE X_NUC_71.L_CORE 0.002305
K_71 X_NUC_1.L_CORE X_NUC_72.L_CORE 0.002317
K_72 X_NUC_1.L_CORE X_NUC_73.L_CORE 0.002693
K_73 X_NUC_1.L_CORE X_NUC_74.L_CORE 0.002712
K_74 X_NUC_1.L_CORE X_NUC_75.L_CORE 0.002679
K_75 X_NUC_1.L_CORE X_NUC_76.L_CORE 0.002684
K_76 X_NUC_1.L_CORE X_NUC_77.L_CORE 0.002424
K_77 X_NUC_1.L_CORE X_NUC_78.L_CORE 0.002409
K_78 X_NUC_1.L_CORE X_NUC_79.L_CORE 0.002404
K_79 X_NUC_1.L_CORE X_NUC_80.L_CORE 0.002397
K_80 X_NUC_1.L_CORE X_NUC_81.L_CORE 0.002256
K_81 X_NUC_1.L_CORE X_NUC_82.L_CORE 0.002255
K_82 X_NUC_1.L_CORE X_NUC_83.L_CORE 0.002235
K_83 X_NUC_1.L_CORE X_NUC_84.L_CORE 0.002250
K_84 X_NUC_1.L_CORE X_NUC_85.L_CORE 0.002524
K_85 X_NUC_1.L_CORE X_NUC_86.L_CORE 0.002530
K_86 X_NUC_1.L_CORE X_NUC_87.L_CORE 0.002512
K_87 X_NUC_1.L_CORE X_NUC_88.L_CORE 0.002502
K_88 X_NUC_1.L_CORE X_NUC_89.L_CORE 0.002149
K_89 X_NUC_1.L_CORE X_NUC_90.L_CORE 0.002137
K_90 X_NUC_1.L_CORE X_NUC_91.L_CORE 0.002128
K_91 X_NUC_1.L_CORE X_NUC_92.L_CORE 0.002132
K_92 X_NUC_1.L_CORE X_NUC_93.L_CORE 0.002254
K_93 X_NUC_1.L_CORE X_NUC_94.L_CORE 0.002261
K_94 X_NUC_1.L_CORE X_NUC_95.L_CORE 0.002238
K_95 X_NUC_1.L_CORE X_NUC_96.L_CORE 0.002246
K_96 X_NUC_1.L_CORE X_NUC_97.L_CORE 0.002241
K_97 X_NUC_1.L_CORE X_NUC_98.L_CORE 0.002236
K_98 X_NUC_1.L_CORE X_NUC_99.L_CORE 0.002226
K_99 X_NUC_1.L_CORE X_NUC_100.L_CORE 0.002220
K_100 X_NUC_1.L_CORE X_NUC_101.L_CORE 0.002042
K_101 X_NUC_1.L_CORE X_NUC_102.L_CORE 0.002037
K_102 X_NUC_1.L_CORE X_NUC_103.L_CORE 0.002023
K_103 X_NUC_1.L_CORE X_NUC_104.L_CORE 0.002031
K_104 X_NUC_1.L_CORE X_NUC_105.L_CORE 0.002177
K_105 X_NUC_1.L_CORE X_NUC_106.L_CORE 0.002181
K_106 X_NUC_1.L_CORE X_NUC_107.L_CORE 0.002164
K_107 X_NUC_1.L_CORE X_NUC_108.L_CORE 0.002163
K_108 X_NUC_1.L_CORE X_NUC_109.L_CORE 0.002033
K_109 X_NUC_1.L_CORE X_NUC_110.L_CORE 0.002027
K_110 X_NUC_1.L_CORE X_NUC_111.L_CORE 0.002017
K_111 X_NUC_1.L_CORE X_NUC_112.L_CORE 0.002017
K_112 X_NUC_1.L_CORE X_NUC_113.L_CORE 0.002010
K_113 X_NUC_1.L_CORE X_NUC_114.L_CORE 0.002009
K_114 X_NUC_1.L_CORE X_NUC_115.L_CORE 0.001994
K_115 X_NUC_1.L_CORE X_NUC_116.L_CORE 0.001998
K_116 X_NUC_1.L_CORE X_NUC_117.L_CORE 0.034315
K_117 X_NUC_1.L_CORE X_NUC_118.L_CORE 0.005196
K_118 X_NUC_1.L_CORE X_NUC_119.L_CORE 0.005583
K_119 X_NUC_1.L_CORE X_NUC_120.L_CORE 0.005731
K_120 X_NUC_1.L_CORE X_NUC_121.L_CORE 0.003396
K_121 X_NUC_1.L_CORE X_NUC_122.L_CORE 0.004887
K_122 X_NUC_1.L_CORE X_NUC_123.L_CORE 0.003328
K_123 X_NUC_1.L_CORE X_NUC_124.L_CORE 0.003048
K_124 X_NUC_1.L_CORE X_NUC_125.L_CORE 0.003781
K_125 X_NUC_1.L_CORE X_NUC_126.L_CORE 0.002583
K_126 X_NUC_1.L_CORE X_NUC_127.L_CORE 0.003016
K_127 X_NUC_1.L_CORE X_NUC_128.L_CORE 0.002797
K_128 X_NUC_1.L_CORE X_NUC_129.L_CORE 0.002344
K_129 X_NUC_1.L_CORE X_NUC_130.L_CORE 0.002836
K_130 X_NUC_1.L_CORE X_NUC_131.L_CORE 0.002265
K_131 X_NUC_1.L_CORE X_NUC_132.L_CORE 0.002306
K_132 X_NUC_1.L_CORE X_NUC_133.L_CORE 0.002429
K_133 X_NUC_1.L_CORE X_NUC_134.L_CORE 0.002037
K_134 X_NUC_1.L_CORE X_NUC_135.L_CORE 0.002261
K_135 X_NUC_1.L_CORE X_NUC_136.L_CORE 0.002074
K_136 X_NUC_1.L_CORE X_NUC_137.L_CORE 0.001967
K_137 X_NUC_1.L_CORE X_NUC_138.L_CORE 0.002083
K_138 X_NUC_1.L_CORE X_NUC_139.L_CORE 0.001889
K_139 X_NUC_1.L_CORE X_NUC_140.L_CORE 0.001912
K_140 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_141 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_142 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.006168
K_143 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.006000
K_144 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.006041
K_145 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.006096
K_146 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.006396
K_147 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.006479
K_148 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.006320
K_149 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.006493
K_150 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.007040
K_151 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.006933
K_152 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.007019
K_153 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.006833
K_154 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.003941
K_155 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.003898
K_156 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.003877
K_157 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.003933
K_158 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.005739
K_159 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.005880
K_160 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.005749
K_161 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.005752
K_162 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.003949
K_163 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.003884
K_164 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.003903
K_165 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.003886
K_166 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.003511
K_167 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.003516
K_168 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.003469
K_169 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.003522
K_170 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.004548
K_171 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.004572
K_172 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.004552
K_173 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.004480
K_174 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.003008
K_175 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.002974
K_176 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.002968
K_177 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.002985
K_178 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.003509
K_179 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.003548
K_180 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.003489
K_181 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.003516
K_182 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.003331
K_183 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.003303
K_184 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.003308
K_185 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.003278
K_186 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.002702
K_187 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.002692
K_188 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.002670
K_189 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.002697
K_190 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.003377
K_191 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.003409
K_192 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.003371
K_193 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.003355
K_194 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.002647
K_195 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.002621
K_196 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.002619
K_197 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.002619
K_198 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.002670
K_199 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.002680
K_200 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.002647
K_201 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.002669
K_202 X_NUC_2.L_CORE X_NUC_65.L_CORE 0.002908
K_203 X_NUC_2.L_CORE X_NUC_66.L_CORE 0.002905
K_204 X_NUC_2.L_CORE X_NUC_67.L_CORE 0.002895
K_205 X_NUC_2.L_CORE X_NUC_68.L_CORE 0.002872
K_206 X_NUC_2.L_CORE X_NUC_69.L_CORE 0.002344
K_207 X_NUC_2.L_CORE X_NUC_70.L_CORE 0.002331
K_208 X_NUC_2.L_CORE X_NUC_71.L_CORE 0.002318
K_209 X_NUC_2.L_CORE X_NUC_72.L_CORE 0.002331
K_210 X_NUC_2.L_CORE X_NUC_73.L_CORE 0.002675
K_211 X_NUC_2.L_CORE X_NUC_74.L_CORE 0.002693
K_212 X_NUC_2.L_CORE X_NUC_75.L_CORE 0.002661
K_213 X_NUC_2.L_CORE X_NUC_76.L_CORE 0.002666
K_214 X_NUC_2.L_CORE X_NUC_77.L_CORE 0.002439
K_215 X_NUC_2.L_CORE X_NUC_78.L_CORE 0.002424
K_216 X_NUC_2.L_CORE X_NUC_79.L_CORE 0.002419
K_217 X_NUC_2.L_CORE X_NUC_80.L_CORE 0.002412
K_218 X_NUC_2.L_CORE X_NUC_81.L_CORE 0.002258
K_219 X_NUC_2.L_CORE X_NUC_82.L_CORE 0.002256
K_220 X_NUC_2.L_CORE X_NUC_83.L_CORE 0.002236
K_221 X_NUC_2.L_CORE X_NUC_84.L_CORE 0.002251
K_222 X_NUC_2.L_CORE X_NUC_85.L_CORE 0.002517
K_223 X_NUC_2.L_CORE X_NUC_86.L_CORE 0.002524
K_224 X_NUC_2.L_CORE X_NUC_87.L_CORE 0.002505
K_225 X_NUC_2.L_CORE X_NUC_88.L_CORE 0.002496
K_226 X_NUC_2.L_CORE X_NUC_89.L_CORE 0.002161
K_227 X_NUC_2.L_CORE X_NUC_90.L_CORE 0.002149
K_228 X_NUC_2.L_CORE X_NUC_91.L_CORE 0.002140
K_229 X_NUC_2.L_CORE X_NUC_92.L_CORE 0.002144
K_230 X_NUC_2.L_CORE X_NUC_93.L_CORE 0.002247
K_231 X_NUC_2.L_CORE X_NUC_94.L_CORE 0.002254
K_232 X_NUC_2.L_CORE X_NUC_95.L_CORE 0.002231
K_233 X_NUC_2.L_CORE X_NUC_96.L_CORE 0.002239
K_234 X_NUC_2.L_CORE X_NUC_97.L_CORE 0.002246
K_235 X_NUC_2.L_CORE X_NUC_98.L_CORE 0.002241
K_236 X_NUC_2.L_CORE X_NUC_99.L_CORE 0.002231
K_237 X_NUC_2.L_CORE X_NUC_100.L_CORE 0.002225
K_238 X_NUC_2.L_CORE X_NUC_101.L_CORE 0.002047
K_239 X_NUC_2.L_CORE X_NUC_102.L_CORE 0.002042
K_240 X_NUC_2.L_CORE X_NUC_103.L_CORE 0.002028
K_241 X_NUC_2.L_CORE X_NUC_104.L_CORE 0.002036
K_242 X_NUC_2.L_CORE X_NUC_105.L_CORE 0.002173
K_243 X_NUC_2.L_CORE X_NUC_106.L_CORE 0.002177
K_244 X_NUC_2.L_CORE X_NUC_107.L_CORE 0.002159
K_245 X_NUC_2.L_CORE X_NUC_108.L_CORE 0.002159
K_246 X_NUC_2.L_CORE X_NUC_109.L_CORE 0.002039
K_247 X_NUC_2.L_CORE X_NUC_110.L_CORE 0.002033
K_248 X_NUC_2.L_CORE X_NUC_111.L_CORE 0.002023
K_249 X_NUC_2.L_CORE X_NUC_112.L_CORE 0.002023
K_250 X_NUC_2.L_CORE X_NUC_113.L_CORE 0.002011
K_251 X_NUC_2.L_CORE X_NUC_114.L_CORE 0.002010
K_252 X_NUC_2.L_CORE X_NUC_115.L_CORE 0.001995
K_253 X_NUC_2.L_CORE X_NUC_116.L_CORE 0.001999
K_254 X_NUC_2.L_CORE X_NUC_117.L_CORE 0.032410
K_255 X_NUC_2.L_CORE X_NUC_118.L_CORE 0.005324
K_256 X_NUC_2.L_CORE X_NUC_119.L_CORE 0.005512
K_257 X_NUC_2.L_CORE X_NUC_120.L_CORE 0.005798
K_258 X_NUC_2.L_CORE X_NUC_121.L_CORE 0.003429
K_259 X_NUC_2.L_CORE X_NUC_122.L_CORE 0.004786
K_260 X_NUC_2.L_CORE X_NUC_123.L_CORE 0.003376
K_261 X_NUC_2.L_CORE X_NUC_124.L_CORE 0.003044
K_262 X_NUC_2.L_CORE X_NUC_125.L_CORE 0.003763
K_263 X_NUC_2.L_CORE X_NUC_126.L_CORE 0.002608
K_264 X_NUC_2.L_CORE X_NUC_127.L_CORE 0.002988
K_265 X_NUC_2.L_CORE X_NUC_128.L_CORE 0.002816
K_266 X_NUC_2.L_CORE X_NUC_129.L_CORE 0.002351
K_267 X_NUC_2.L_CORE X_NUC_130.L_CORE 0.002816
K_268 X_NUC_2.L_CORE X_NUC_131.L_CORE 0.002283
K_269 X_NUC_2.L_CORE X_NUC_132.L_CORE 0.002299
K_270 X_NUC_2.L_CORE X_NUC_133.L_CORE 0.002431
K_271 X_NUC_2.L_CORE X_NUC_134.L_CORE 0.002046
K_272 X_NUC_2.L_CORE X_NUC_135.L_CORE 0.002250
K_273 X_NUC_2.L_CORE X_NUC_136.L_CORE 0.002083
K_274 X_NUC_2.L_CORE X_NUC_137.L_CORE 0.001968
K_275 X_NUC_2.L_CORE X_NUC_138.L_CORE 0.002081
K_276 X_NUC_2.L_CORE X_NUC_139.L_CORE 0.001895
K_277 X_NUC_2.L_CORE X_NUC_140.L_CORE 0.001911
K_278 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_279 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.006123
K_280 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.005956
K_281 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.006000
K_282 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.006051
K_283 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.006558
K_284 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.006644
K_285 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.006479
K_286 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.006662
K_287 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.006949
K_288 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.006842
K_289 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.006933
K_290 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.006750
K_291 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.003962
K_292 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.003918
K_293 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.003898
K_294 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.003954
K_295 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.005867
K_296 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.006015
K_297 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.005880
K_298 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.005881
K_299 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.003928
K_300 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.003864
K_301 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.003884
K_302 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.003867
K_303 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.003559
K_304 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.003563
K_305 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.003516
K_306 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.003570
K_307 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.004567
K_308 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.004591
K_309 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.004572
K_310 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.004499
K_311 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.003014
K_312 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.002980
K_313 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.002974
K_314 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.002991
K_315 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.003568
K_316 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.003608
K_317 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.003548
K_318 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.003575
K_319 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.003325
K_320 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.003297
K_321 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.003303
K_322 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.003273
K_323 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.002725
K_324 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.002714
K_325 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.002692
K_326 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.002719
K_327 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.003415
K_328 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.003447
K_329 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.003409
K_330 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.003392
K_331 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.002649
K_332 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.002623
K_333 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.002621
K_334 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.002621
K_335 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.002703
K_336 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.002713
K_337 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.002680
K_338 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.002702
K_339 X_NUC_3.L_CORE X_NUC_65.L_CORE 0.002917
K_340 X_NUC_3.L_CORE X_NUC_66.L_CORE 0.002914
K_341 X_NUC_3.L_CORE X_NUC_67.L_CORE 0.002905
K_342 X_NUC_3.L_CORE X_NUC_68.L_CORE 0.002881
K_343 X_NUC_3.L_CORE X_NUC_69.L_CORE 0.002357
K_344 X_NUC_3.L_CORE X_NUC_70.L_CORE 0.002343
K_345 X_NUC_3.L_CORE X_NUC_71.L_CORE 0.002331
K_346 X_NUC_3.L_CORE X_NUC_72.L_CORE 0.002343
K_347 X_NUC_3.L_CORE X_NUC_73.L_CORE 0.002707
K_348 X_NUC_3.L_CORE X_NUC_74.L_CORE 0.002726
K_349 X_NUC_3.L_CORE X_NUC_75.L_CORE 0.002693
K_350 X_NUC_3.L_CORE X_NUC_76.L_CORE 0.002697
K_351 X_NUC_3.L_CORE X_NUC_77.L_CORE 0.002444
K_352 X_NUC_3.L_CORE X_NUC_78.L_CORE 0.002428
K_353 X_NUC_3.L_CORE X_NUC_79.L_CORE 0.002424
K_354 X_NUC_3.L_CORE X_NUC_80.L_CORE 0.002416
K_355 X_NUC_3.L_CORE X_NUC_81.L_CORE 0.002278
K_356 X_NUC_3.L_CORE X_NUC_82.L_CORE 0.002277
K_357 X_NUC_3.L_CORE X_NUC_83.L_CORE 0.002256
K_358 X_NUC_3.L_CORE X_NUC_84.L_CORE 0.002272
K_359 X_NUC_3.L_CORE X_NUC_85.L_CORE 0.002535
K_360 X_NUC_3.L_CORE X_NUC_86.L_CORE 0.002542
K_361 X_NUC_3.L_CORE X_NUC_87.L_CORE 0.002524
K_362 X_NUC_3.L_CORE X_NUC_88.L_CORE 0.002514
K_363 X_NUC_3.L_CORE X_NUC_89.L_CORE 0.002170
K_364 X_NUC_3.L_CORE X_NUC_90.L_CORE 0.002157
K_365 X_NUC_3.L_CORE X_NUC_91.L_CORE 0.002149
K_366 X_NUC_3.L_CORE X_NUC_92.L_CORE 0.002152
K_367 X_NUC_3.L_CORE X_NUC_93.L_CORE 0.002271
K_368 X_NUC_3.L_CORE X_NUC_94.L_CORE 0.002277
K_369 X_NUC_3.L_CORE X_NUC_95.L_CORE 0.002254
K_370 X_NUC_3.L_CORE X_NUC_96.L_CORE 0.002262
K_371 X_NUC_3.L_CORE X_NUC_97.L_CORE 0.002256
K_372 X_NUC_3.L_CORE X_NUC_98.L_CORE 0.002251
K_373 X_NUC_3.L_CORE X_NUC_99.L_CORE 0.002241
K_374 X_NUC_3.L_CORE X_NUC_100.L_CORE 0.002234
K_375 X_NUC_3.L_CORE X_NUC_101.L_CORE 0.002061
K_376 X_NUC_3.L_CORE X_NUC_102.L_CORE 0.002056
K_377 X_NUC_3.L_CORE X_NUC_103.L_CORE 0.002042
K_378 X_NUC_3.L_CORE X_NUC_104.L_CORE 0.002050
K_379 X_NUC_3.L_CORE X_NUC_105.L_CORE 0.002191
K_380 X_NUC_3.L_CORE X_NUC_106.L_CORE 0.002195
K_381 X_NUC_3.L_CORE X_NUC_107.L_CORE 0.002177
K_382 X_NUC_3.L_CORE X_NUC_108.L_CORE 0.002177
K_383 X_NUC_3.L_CORE X_NUC_109.L_CORE 0.002050
K_384 X_NUC_3.L_CORE X_NUC_110.L_CORE 0.002044
K_385 X_NUC_3.L_CORE X_NUC_111.L_CORE 0.002033
K_386 X_NUC_3.L_CORE X_NUC_112.L_CORE 0.002034
K_387 X_NUC_3.L_CORE X_NUC_113.L_CORE 0.002026
K_388 X_NUC_3.L_CORE X_NUC_114.L_CORE 0.002025
K_389 X_NUC_3.L_CORE X_NUC_115.L_CORE 0.002010
K_390 X_NUC_3.L_CORE X_NUC_116.L_CORE 0.002014
K_391 X_NUC_3.L_CORE X_NUC_117.L_CORE 0.029629
K_392 X_NUC_3.L_CORE X_NUC_118.L_CORE 0.005275
K_393 X_NUC_3.L_CORE X_NUC_119.L_CORE 0.005625
K_394 X_NUC_3.L_CORE X_NUC_120.L_CORE 0.005723
K_395 X_NUC_3.L_CORE X_NUC_121.L_CORE 0.003443
K_396 X_NUC_3.L_CORE X_NUC_122.L_CORE 0.004869
K_397 X_NUC_3.L_CORE X_NUC_123.L_CORE 0.003359
K_398 X_NUC_3.L_CORE X_NUC_124.L_CORE 0.003080
K_399 X_NUC_3.L_CORE X_NUC_125.L_CORE 0.003776
K_400 X_NUC_3.L_CORE X_NUC_126.L_CORE 0.002613
K_401 X_NUC_3.L_CORE X_NUC_127.L_CORE 0.003031
K_402 X_NUC_3.L_CORE X_NUC_128.L_CORE 0.002813
K_403 X_NUC_3.L_CORE X_NUC_129.L_CORE 0.002369
K_404 X_NUC_3.L_CORE X_NUC_130.L_CORE 0.002842
K_405 X_NUC_3.L_CORE X_NUC_131.L_CORE 0.002286
K_406 X_NUC_3.L_CORE X_NUC_132.L_CORE 0.002324
K_407 X_NUC_3.L_CORE X_NUC_133.L_CORE 0.002440
K_408 X_NUC_3.L_CORE X_NUC_134.L_CORE 0.002057
K_409 X_NUC_3.L_CORE X_NUC_135.L_CORE 0.002273
K_410 X_NUC_3.L_CORE X_NUC_136.L_CORE 0.002090
K_411 X_NUC_3.L_CORE X_NUC_137.L_CORE 0.001984
K_412 X_NUC_3.L_CORE X_NUC_138.L_CORE 0.002094
K_413 X_NUC_3.L_CORE X_NUC_139.L_CORE 0.001905
K_414 X_NUC_3.L_CORE X_NUC_140.L_CORE 0.001925
K_415 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.006067
K_416 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.005904
K_417 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.005945
K_418 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.006000
K_419 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.006380
K_420 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.006459
K_421 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.006304
K_422 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.006479
K_423 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.007145
K_424 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.007029
K_425 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.007123
K_426 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.006933
K_427 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.003905
K_428 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.003863
K_429 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.003843
K_430 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.003898
K_431 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.005864
K_432 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.006011
K_433 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.005874
K_434 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.005880
K_435 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.003946
K_436 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.003880
K_437 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.003900
K_438 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.003884
K_439 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.003504
K_440 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.003509
K_441 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.003463
K_442 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.003516
K_443 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.004643
K_444 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.004668
K_445 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.004647
K_446 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.004572
K_447 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.002996
K_448 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.002962
K_449 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.002957
K_450 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.002974
K_451 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.003540
K_452 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.003579
K_453 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.003520
K_454 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.003548
K_455 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.003356
K_456 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.003327
K_457 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.003333
K_458 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.003303
K_459 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.002697
K_460 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.002687
K_461 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.002665
K_462 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.002692
K_463 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.003432
K_464 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.003464
K_465 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.003425
K_466 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.003409
K_467 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.002649
K_468 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.002623
K_469 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.002621
K_470 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.002621
K_471 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.002680
K_472 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.002690
K_473 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.002657
K_474 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.002680
K_475 X_NUC_4.L_CORE X_NUC_65.L_CORE 0.002942
K_476 X_NUC_4.L_CORE X_NUC_66.L_CORE 0.002939
K_477 X_NUC_4.L_CORE X_NUC_67.L_CORE 0.002929
K_478 X_NUC_4.L_CORE X_NUC_68.L_CORE 0.002905
K_479 X_NUC_4.L_CORE X_NUC_69.L_CORE 0.002344
K_480 X_NUC_4.L_CORE X_NUC_70.L_CORE 0.002330
K_481 X_NUC_4.L_CORE X_NUC_71.L_CORE 0.002318
K_482 X_NUC_4.L_CORE X_NUC_72.L_CORE 0.002331
K_483 X_NUC_4.L_CORE X_NUC_73.L_CORE 0.002702
K_484 X_NUC_4.L_CORE X_NUC_74.L_CORE 0.002721
K_485 X_NUC_4.L_CORE X_NUC_75.L_CORE 0.002689
K_486 X_NUC_4.L_CORE X_NUC_76.L_CORE 0.002693
K_487 X_NUC_4.L_CORE X_NUC_77.L_CORE 0.002452
K_488 X_NUC_4.L_CORE X_NUC_78.L_CORE 0.002436
K_489 X_NUC_4.L_CORE X_NUC_79.L_CORE 0.002432
K_490 X_NUC_4.L_CORE X_NUC_80.L_CORE 0.002424
K_491 X_NUC_4.L_CORE X_NUC_81.L_CORE 0.002263
K_492 X_NUC_4.L_CORE X_NUC_82.L_CORE 0.002262
K_493 X_NUC_4.L_CORE X_NUC_83.L_CORE 0.002241
K_494 X_NUC_4.L_CORE X_NUC_84.L_CORE 0.002256
K_495 X_NUC_4.L_CORE X_NUC_85.L_CORE 0.002545
K_496 X_NUC_4.L_CORE X_NUC_86.L_CORE 0.002552
K_497 X_NUC_4.L_CORE X_NUC_87.L_CORE 0.002534
K_498 X_NUC_4.L_CORE X_NUC_88.L_CORE 0.002524
K_499 X_NUC_4.L_CORE X_NUC_89.L_CORE 0.002166
K_500 X_NUC_4.L_CORE X_NUC_90.L_CORE 0.002153
K_501 X_NUC_4.L_CORE X_NUC_91.L_CORE 0.002145
K_502 X_NUC_4.L_CORE X_NUC_92.L_CORE 0.002149
K_503 X_NUC_4.L_CORE X_NUC_93.L_CORE 0.002262
K_504 X_NUC_4.L_CORE X_NUC_94.L_CORE 0.002269
K_505 X_NUC_4.L_CORE X_NUC_95.L_CORE 0.002246
K_506 X_NUC_4.L_CORE X_NUC_96.L_CORE 0.002254
K_507 X_NUC_4.L_CORE X_NUC_97.L_CORE 0.002264
K_508 X_NUC_4.L_CORE X_NUC_98.L_CORE 0.002258
K_509 X_NUC_4.L_CORE X_NUC_99.L_CORE 0.002248
K_510 X_NUC_4.L_CORE X_NUC_100.L_CORE 0.002241
K_511 X_NUC_4.L_CORE X_NUC_101.L_CORE 0.002053
K_512 X_NUC_4.L_CORE X_NUC_102.L_CORE 0.002048
K_513 X_NUC_4.L_CORE X_NUC_103.L_CORE 0.002034
K_514 X_NUC_4.L_CORE X_NUC_104.L_CORE 0.002042
K_515 X_NUC_4.L_CORE X_NUC_105.L_CORE 0.002191
K_516 X_NUC_4.L_CORE X_NUC_106.L_CORE 0.002195
K_517 X_NUC_4.L_CORE X_NUC_107.L_CORE 0.002177
K_518 X_NUC_4.L_CORE X_NUC_108.L_CORE 0.002177
K_519 X_NUC_4.L_CORE X_NUC_109.L_CORE 0.002050
K_520 X_NUC_4.L_CORE X_NUC_110.L_CORE 0.002044
K_521 X_NUC_4.L_CORE X_NUC_111.L_CORE 0.002033
K_522 X_NUC_4.L_CORE X_NUC_112.L_CORE 0.002033
K_523 X_NUC_4.L_CORE X_NUC_113.L_CORE 0.002022
K_524 X_NUC_4.L_CORE X_NUC_114.L_CORE 0.002021
K_525 X_NUC_4.L_CORE X_NUC_115.L_CORE 0.002006
K_526 X_NUC_4.L_CORE X_NUC_116.L_CORE 0.002010
K_527 X_NUC_4.L_CORE X_NUC_117.L_CORE 0.031063
K_528 X_NUC_4.L_CORE X_NUC_118.L_CORE 0.005238
K_529 X_NUC_4.L_CORE X_NUC_119.L_CORE 0.005495
K_530 X_NUC_4.L_CORE X_NUC_120.L_CORE 0.005864
K_531 X_NUC_4.L_CORE X_NUC_121.L_CORE 0.003399
K_532 X_NUC_4.L_CORE X_NUC_122.L_CORE 0.004872
K_533 X_NUC_4.L_CORE X_NUC_123.L_CORE 0.003373
K_534 X_NUC_4.L_CORE X_NUC_124.L_CORE 0.003039
K_535 X_NUC_4.L_CORE X_NUC_125.L_CORE 0.003828
K_536 X_NUC_4.L_CORE X_NUC_126.L_CORE 0.002600
K_537 X_NUC_4.L_CORE X_NUC_127.L_CORE 0.003012
K_538 X_NUC_4.L_CORE X_NUC_128.L_CORE 0.002835
K_539 X_NUC_4.L_CORE X_NUC_129.L_CORE 0.002349
K_540 X_NUC_4.L_CORE X_NUC_130.L_CORE 0.002853
K_541 X_NUC_4.L_CORE X_NUC_131.L_CORE 0.002286
K_542 X_NUC_4.L_CORE X_NUC_132.L_CORE 0.002309
K_543 X_NUC_4.L_CORE X_NUC_133.L_CORE 0.002455
K_544 X_NUC_4.L_CORE X_NUC_134.L_CORE 0.002048
K_545 X_NUC_4.L_CORE X_NUC_135.L_CORE 0.002270
K_546 X_NUC_4.L_CORE X_NUC_136.L_CORE 0.002094
K_547 X_NUC_4.L_CORE X_NUC_137.L_CORE 0.001975
K_548 X_NUC_4.L_CORE X_NUC_138.L_CORE 0.002098
K_549 X_NUC_4.L_CORE X_NUC_139.L_CORE 0.001903
K_550 X_NUC_4.L_CORE X_NUC_140.L_CORE 0.001922
K_551 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_552 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_553 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_554 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.004230
K_555 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.004312
K_556 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.004249
K_557 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.004282
K_558 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.005178
K_559 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.005237
K_560 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.005247
K_561 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.005134
K_562 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.006507
K_563 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.006513
K_564 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.006369
K_565 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.006556
K_566 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.003171
K_567 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.003218
K_568 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.003190
K_569 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.003183
K_570 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.006387
K_571 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.006297
K_572 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.006332
K_573 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.006202
K_574 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.003439
K_575 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.003474
K_576 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.003422
K_577 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.003462
K_578 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.003113
K_579 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.003144
K_580 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.003131
K_581 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.003100
K_582 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.005129
K_583 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.005059
K_584 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.005005
K_585 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.005058
K_586 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.002625
K_587 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.002655
K_588 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.002627
K_589 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.002633
K_590 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.003538
K_591 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.003537
K_592 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.003535
K_593 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.003489
K_594 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.003256
K_595 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.003263
K_596 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.003218
K_597 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.003257
K_598 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.002446
K_599 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.002469
K_600 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.002451
K_601 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.002442
K_602 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.003731
K_603 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.003697
K_604 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.003681
K_605 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.003669
K_606 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.002450
K_607 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.002469
K_608 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.002440
K_609 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.002454
K_610 X_NUC_5.L_CORE X_NUC_65.L_CORE 0.002587
K_611 X_NUC_5.L_CORE X_NUC_66.L_CORE 0.002598
K_612 X_NUC_5.L_CORE X_NUC_67.L_CORE 0.002588
K_613 X_NUC_5.L_CORE X_NUC_68.L_CORE 0.002567
K_614 X_NUC_5.L_CORE X_NUC_69.L_CORE 0.003041
K_615 X_NUC_5.L_CORE X_NUC_70.L_CORE 0.003031
K_616 X_NUC_5.L_CORE X_NUC_71.L_CORE 0.002999
K_617 X_NUC_5.L_CORE X_NUC_72.L_CORE 0.003021
K_618 X_NUC_5.L_CORE X_NUC_73.L_CORE 0.002173
K_619 X_NUC_5.L_CORE X_NUC_74.L_CORE 0.002191
K_620 X_NUC_5.L_CORE X_NUC_75.L_CORE 0.002171
K_621 X_NUC_5.L_CORE X_NUC_76.L_CORE 0.002171
K_622 X_NUC_5.L_CORE X_NUC_77.L_CORE 0.002790
K_623 X_NUC_5.L_CORE X_NUC_78.L_CORE 0.002784
K_624 X_NUC_5.L_CORE X_NUC_79.L_CORE 0.002772
K_625 X_NUC_5.L_CORE X_NUC_80.L_CORE 0.002756
K_626 X_NUC_5.L_CORE X_NUC_81.L_CORE 0.002384
K_627 X_NUC_5.L_CORE X_NUC_82.L_CORE 0.002393
K_628 X_NUC_5.L_CORE X_NUC_83.L_CORE 0.002366
K_629 X_NUC_5.L_CORE X_NUC_84.L_CORE 0.002380
K_630 X_NUC_5.L_CORE X_NUC_85.L_CORE 0.002167
K_631 X_NUC_5.L_CORE X_NUC_86.L_CORE 0.002179
K_632 X_NUC_5.L_CORE X_NUC_87.L_CORE 0.002166
K_633 X_NUC_5.L_CORE X_NUC_88.L_CORE 0.002157
K_634 X_NUC_5.L_CORE X_NUC_89.L_CORE 0.002646
K_635 X_NUC_5.L_CORE X_NUC_90.L_CORE 0.002637
K_636 X_NUC_5.L_CORE X_NUC_91.L_CORE 0.002617
K_637 X_NUC_5.L_CORE X_NUC_92.L_CORE 0.002620
K_638 X_NUC_5.L_CORE X_NUC_93.L_CORE 0.002071
K_639 X_NUC_5.L_CORE X_NUC_94.L_CORE 0.002083
K_640 X_NUC_5.L_CORE X_NUC_95.L_CORE 0.002063
K_641 X_NUC_5.L_CORE X_NUC_96.L_CORE 0.002067
K_642 X_NUC_5.L_CORE X_NUC_97.L_CORE 0.002259
K_643 X_NUC_5.L_CORE X_NUC_98.L_CORE 0.002262
K_644 X_NUC_5.L_CORE X_NUC_99.L_CORE 0.002250
K_645 X_NUC_5.L_CORE X_NUC_100.L_CORE 0.002240
K_646 X_NUC_5.L_CORE X_NUC_101.L_CORE 0.002267
K_647 X_NUC_5.L_CORE X_NUC_102.L_CORE 0.002269
K_648 X_NUC_5.L_CORE X_NUC_103.L_CORE 0.002248
K_649 X_NUC_5.L_CORE X_NUC_104.L_CORE 0.002256
K_650 X_NUC_5.L_CORE X_NUC_105.L_CORE 0.001998
K_651 X_NUC_5.L_CORE X_NUC_106.L_CORE 0.002007
K_652 X_NUC_5.L_CORE X_NUC_107.L_CORE 0.001992
K_653 X_NUC_5.L_CORE X_NUC_108.L_CORE 0.001990
K_654 X_NUC_5.L_CORE X_NUC_109.L_CORE 0.002204
K_655 X_NUC_5.L_CORE X_NUC_110.L_CORE 0.002205
K_656 X_NUC_5.L_CORE X_NUC_111.L_CORE 0.002189
K_657 X_NUC_5.L_CORE X_NUC_112.L_CORE 0.002187
K_658 X_NUC_5.L_CORE X_NUC_113.L_CORE 0.002033
K_659 X_NUC_5.L_CORE X_NUC_114.L_CORE 0.002039
K_660 X_NUC_5.L_CORE X_NUC_115.L_CORE 0.002022
K_661 X_NUC_5.L_CORE X_NUC_116.L_CORE 0.002024
K_662 X_NUC_5.L_CORE X_NUC_117.L_CORE 0.005486
K_663 X_NUC_5.L_CORE X_NUC_118.L_CORE 0.029530
K_664 X_NUC_5.L_CORE X_NUC_119.L_CORE 0.003798
K_665 X_NUC_5.L_CORE X_NUC_120.L_CORE 0.004538
K_666 X_NUC_5.L_CORE X_NUC_121.L_CORE 0.005444
K_667 X_NUC_5.L_CORE X_NUC_122.L_CORE 0.002832
K_668 X_NUC_5.L_CORE X_NUC_123.L_CORE 0.005112
K_669 X_NUC_5.L_CORE X_NUC_124.L_CORE 0.003017
K_670 X_NUC_5.L_CORE X_NUC_125.L_CORE 0.002743
K_671 X_NUC_5.L_CORE X_NUC_126.L_CORE 0.004086
K_672 X_NUC_5.L_CORE X_NUC_127.L_CORE 0.002334
K_673 X_NUC_5.L_CORE X_NUC_128.L_CORE 0.002990
K_674 X_NUC_5.L_CORE X_NUC_129.L_CORE 0.002773
K_675 X_NUC_5.L_CORE X_NUC_130.L_CORE 0.002171
K_676 X_NUC_5.L_CORE X_NUC_131.L_CORE 0.003000
K_677 X_NUC_5.L_CORE X_NUC_132.L_CORE 0.002160
K_678 X_NUC_5.L_CORE X_NUC_133.L_CORE 0.002244
K_679 X_NUC_5.L_CORE X_NUC_134.L_CORE 0.002499
K_680 X_NUC_5.L_CORE X_NUC_135.L_CORE 0.001945
K_681 X_NUC_5.L_CORE X_NUC_136.L_CORE 0.002298
K_682 X_NUC_5.L_CORE X_NUC_137.L_CORE 0.002058
K_683 X_NUC_5.L_CORE X_NUC_138.L_CORE 0.001929
K_684 X_NUC_5.L_CORE X_NUC_139.L_CORE 0.002104
K_685 X_NUC_5.L_CORE X_NUC_140.L_CORE 0.001888
K_686 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_687 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_688 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.004152
K_689 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.004230
K_690 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.004171
K_691 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.004201
K_692 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.005117
K_693 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.005178
K_694 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.005186
K_695 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.005077
K_696 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.006495
K_697 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.006507
K_698 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.006360
K_699 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.006547
K_700 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.003125
K_701 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.003171
K_702 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.003144
K_703 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.003137
K_704 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.006474
K_705 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.006387
K_706 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.006420
K_707 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.006285
K_708 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.003404
K_709 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.003439
K_710 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.003388
K_711 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.003427
K_712 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.003083
K_713 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.003113
K_714 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.003101
K_715 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.003071
K_716 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.005198
K_717 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.005129
K_718 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.005071
K_719 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.005126
K_720 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.002596
K_721 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.002625
K_722 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.002598
K_723 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.002604
K_724 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.003539
K_725 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.003538
K_726 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.003536
K_727 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.003489
K_728 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.003248
K_729 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.003256
K_730 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.003211
K_731 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.003249
K_732 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.002423
K_733 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.002446
K_734 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.002429
K_735 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.002419
K_736 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.003765
K_737 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.003731
K_738 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.003714
K_739 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.003702
K_740 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.002431
K_741 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.002450
K_742 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.002422
K_743 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.002435
K_744 X_NUC_6.L_CORE X_NUC_65.L_CORE 0.002576
K_745 X_NUC_6.L_CORE X_NUC_66.L_CORE 0.002587
K_746 X_NUC_6.L_CORE X_NUC_67.L_CORE 0.002577
K_747 X_NUC_6.L_CORE X_NUC_68.L_CORE 0.002556
K_748 X_NUC_6.L_CORE X_NUC_69.L_CORE 0.003050
K_749 X_NUC_6.L_CORE X_NUC_70.L_CORE 0.003041
K_750 X_NUC_6.L_CORE X_NUC_71.L_CORE 0.003008
K_751 X_NUC_6.L_CORE X_NUC_72.L_CORE 0.003030
K_752 X_NUC_6.L_CORE X_NUC_73.L_CORE 0.002156
K_753 X_NUC_6.L_CORE X_NUC_74.L_CORE 0.002173
K_754 X_NUC_6.L_CORE X_NUC_75.L_CORE 0.002154
K_755 X_NUC_6.L_CORE X_NUC_76.L_CORE 0.002154
K_756 X_NUC_6.L_CORE X_NUC_77.L_CORE 0.002797
K_757 X_NUC_6.L_CORE X_NUC_78.L_CORE 0.002790
K_758 X_NUC_6.L_CORE X_NUC_79.L_CORE 0.002779
K_759 X_NUC_6.L_CORE X_NUC_80.L_CORE 0.002762
K_760 X_NUC_6.L_CORE X_NUC_81.L_CORE 0.002375
K_761 X_NUC_6.L_CORE X_NUC_82.L_CORE 0.002384
K_762 X_NUC_6.L_CORE X_NUC_83.L_CORE 0.002358
K_763 X_NUC_6.L_CORE X_NUC_84.L_CORE 0.002372
K_764 X_NUC_6.L_CORE X_NUC_85.L_CORE 0.002155
K_765 X_NUC_6.L_CORE X_NUC_86.L_CORE 0.002167
K_766 X_NUC_6.L_CORE X_NUC_87.L_CORE 0.002154
K_767 X_NUC_6.L_CORE X_NUC_88.L_CORE 0.002145
K_768 X_NUC_6.L_CORE X_NUC_89.L_CORE 0.002654
K_769 X_NUC_6.L_CORE X_NUC_90.L_CORE 0.002646
K_770 X_NUC_6.L_CORE X_NUC_91.L_CORE 0.002625
K_771 X_NUC_6.L_CORE X_NUC_92.L_CORE 0.002628
K_772 X_NUC_6.L_CORE X_NUC_93.L_CORE 0.002059
K_773 X_NUC_6.L_CORE X_NUC_94.L_CORE 0.002071
K_774 X_NUC_6.L_CORE X_NUC_95.L_CORE 0.002052
K_775 X_NUC_6.L_CORE X_NUC_96.L_CORE 0.002056
K_776 X_NUC_6.L_CORE X_NUC_97.L_CORE 0.002255
K_777 X_NUC_6.L_CORE X_NUC_98.L_CORE 0.002259
K_778 X_NUC_6.L_CORE X_NUC_99.L_CORE 0.002246
K_779 X_NUC_6.L_CORE X_NUC_100.L_CORE 0.002237
K_780 X_NUC_6.L_CORE X_NUC_101.L_CORE 0.002265
K_781 X_NUC_6.L_CORE X_NUC_102.L_CORE 0.002267
K_782 X_NUC_6.L_CORE X_NUC_103.L_CORE 0.002246
K_783 X_NUC_6.L_CORE X_NUC_104.L_CORE 0.002254
K_784 X_NUC_6.L_CORE X_NUC_105.L_CORE 0.001988
K_785 X_NUC_6.L_CORE X_NUC_106.L_CORE 0.001998
K_786 X_NUC_6.L_CORE X_NUC_107.L_CORE 0.001983
K_787 X_NUC_6.L_CORE X_NUC_108.L_CORE 0.001981
K_788 X_NUC_6.L_CORE X_NUC_109.L_CORE 0.002204
K_789 X_NUC_6.L_CORE X_NUC_110.L_CORE 0.002204
K_790 X_NUC_6.L_CORE X_NUC_111.L_CORE 0.002189
K_791 X_NUC_6.L_CORE X_NUC_112.L_CORE 0.002186
K_792 X_NUC_6.L_CORE X_NUC_113.L_CORE 0.002028
K_793 X_NUC_6.L_CORE X_NUC_114.L_CORE 0.002033
K_794 X_NUC_6.L_CORE X_NUC_115.L_CORE 0.002016
K_795 X_NUC_6.L_CORE X_NUC_116.L_CORE 0.002018
K_796 X_NUC_6.L_CORE X_NUC_117.L_CORE 0.005357
K_797 X_NUC_6.L_CORE X_NUC_118.L_CORE 0.033243
K_798 X_NUC_6.L_CORE X_NUC_119.L_CORE 0.003735
K_799 X_NUC_6.L_CORE X_NUC_120.L_CORE 0.004500
K_800 X_NUC_6.L_CORE X_NUC_121.L_CORE 0.005456
K_801 X_NUC_6.L_CORE X_NUC_122.L_CORE 0.002796
K_802 X_NUC_6.L_CORE X_NUC_123.L_CORE 0.005182
K_803 X_NUC_6.L_CORE X_NUC_124.L_CORE 0.002993
K_804 X_NUC_6.L_CORE X_NUC_125.L_CORE 0.002720
K_805 X_NUC_6.L_CORE X_NUC_126.L_CORE 0.004134
K_806 X_NUC_6.L_CORE X_NUC_127.L_CORE 0.002311
K_807 X_NUC_6.L_CORE X_NUC_128.L_CORE 0.002993
K_808 X_NUC_6.L_CORE X_NUC_129.L_CORE 0.002769
K_809 X_NUC_6.L_CORE X_NUC_130.L_CORE 0.002155
K_810 X_NUC_6.L_CORE X_NUC_131.L_CORE 0.003021
K_811 X_NUC_6.L_CORE X_NUC_132.L_CORE 0.002146
K_812 X_NUC_6.L_CORE X_NUC_133.L_CORE 0.002236
K_813 X_NUC_6.L_CORE X_NUC_134.L_CORE 0.002505
K_814 X_NUC_6.L_CORE X_NUC_135.L_CORE 0.001933
K_815 X_NUC_6.L_CORE X_NUC_136.L_CORE 0.002301
K_816 X_NUC_6.L_CORE X_NUC_137.L_CORE 0.002053
K_817 X_NUC_6.L_CORE X_NUC_138.L_CORE 0.001921
K_818 X_NUC_6.L_CORE X_NUC_139.L_CORE 0.002105
K_819 X_NUC_6.L_CORE X_NUC_140.L_CORE 0.001882
K_820 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_821 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.004210
K_822 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.004291
K_823 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.004230
K_824 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.004261
K_825 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.005108
K_826 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.005167
K_827 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.005178
K_828 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.005068
K_829 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.006648
K_830 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.006658
K_831 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.006507
K_832 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.006704
K_833 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.003151
K_834 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.003198
K_835 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.003171
K_836 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.003163
K_837 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.006436
K_838 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.006348
K_839 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.006387
K_840 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.006251
K_841 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.003456
K_842 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.003491
K_843 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.003439
K_844 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.003479
K_845 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.003095
K_846 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.003125
K_847 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.003113
K_848 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.003083
K_849 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.005258
K_850 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.005185
K_851 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.005129
K_852 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.005184
K_853 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.002623
K_854 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.002653
K_855 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.002625
K_856 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.002632
K_857 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.003541
K_858 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.003540
K_859 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.003538
K_860 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.003491
K_861 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.003294
K_862 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.003302
K_863 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.003256
K_864 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.003295
K_865 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.002440
K_866 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.002463
K_867 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.002446
K_868 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.002436
K_869 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.003782
K_870 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.003747
K_871 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.003731
K_872 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.003719
K_873 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.002459
K_874 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.002479
K_875 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.002450
K_876 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.002464
K_877 X_NUC_7.L_CORE X_NUC_65.L_CORE 0.002586
K_878 X_NUC_7.L_CORE X_NUC_66.L_CORE 0.002597
K_879 X_NUC_7.L_CORE X_NUC_67.L_CORE 0.002587
K_880 X_NUC_7.L_CORE X_NUC_68.L_CORE 0.002566
K_881 X_NUC_7.L_CORE X_NUC_69.L_CORE 0.003084
K_882 X_NUC_7.L_CORE X_NUC_70.L_CORE 0.003074
K_883 X_NUC_7.L_CORE X_NUC_71.L_CORE 0.003041
K_884 X_NUC_7.L_CORE X_NUC_72.L_CORE 0.003063
K_885 X_NUC_7.L_CORE X_NUC_73.L_CORE 0.002174
K_886 X_NUC_7.L_CORE X_NUC_74.L_CORE 0.002192
K_887 X_NUC_7.L_CORE X_NUC_75.L_CORE 0.002173
K_888 X_NUC_7.L_CORE X_NUC_76.L_CORE 0.002173
K_889 X_NUC_7.L_CORE X_NUC_77.L_CORE 0.002808
K_890 X_NUC_7.L_CORE X_NUC_78.L_CORE 0.002801
K_891 X_NUC_7.L_CORE X_NUC_79.L_CORE 0.002790
K_892 X_NUC_7.L_CORE X_NUC_80.L_CORE 0.002773
K_893 X_NUC_7.L_CORE X_NUC_81.L_CORE 0.002402
K_894 X_NUC_7.L_CORE X_NUC_82.L_CORE 0.002411
K_895 X_NUC_7.L_CORE X_NUC_83.L_CORE 0.002384
K_896 X_NUC_7.L_CORE X_NUC_84.L_CORE 0.002399
K_897 X_NUC_7.L_CORE X_NUC_85.L_CORE 0.002169
K_898 X_NUC_7.L_CORE X_NUC_86.L_CORE 0.002181
K_899 X_NUC_7.L_CORE X_NUC_87.L_CORE 0.002167
K_900 X_NUC_7.L_CORE X_NUC_88.L_CORE 0.002159
K_901 X_NUC_7.L_CORE X_NUC_89.L_CORE 0.002674
K_902 X_NUC_7.L_CORE X_NUC_90.L_CORE 0.002666
K_903 X_NUC_7.L_CORE X_NUC_91.L_CORE 0.002646
K_904 X_NUC_7.L_CORE X_NUC_92.L_CORE 0.002648
K_905 X_NUC_7.L_CORE X_NUC_93.L_CORE 0.002079
K_906 X_NUC_7.L_CORE X_NUC_94.L_CORE 0.002091
K_907 X_NUC_7.L_CORE X_NUC_95.L_CORE 0.002071
K_908 X_NUC_7.L_CORE X_NUC_96.L_CORE 0.002075
K_909 X_NUC_7.L_CORE X_NUC_97.L_CORE 0.002268
K_910 X_NUC_7.L_CORE X_NUC_98.L_CORE 0.002271
K_911 X_NUC_7.L_CORE X_NUC_99.L_CORE 0.002259
K_912 X_NUC_7.L_CORE X_NUC_100.L_CORE 0.002249
K_913 X_NUC_7.L_CORE X_NUC_101.L_CORE 0.002287
K_914 X_NUC_7.L_CORE X_NUC_102.L_CORE 0.002289
K_915 X_NUC_7.L_CORE X_NUC_103.L_CORE 0.002267
K_916 X_NUC_7.L_CORE X_NUC_104.L_CORE 0.002275
K_917 X_NUC_7.L_CORE X_NUC_105.L_CORE 0.002004
K_918 X_NUC_7.L_CORE X_NUC_106.L_CORE 0.002013
K_919 X_NUC_7.L_CORE X_NUC_107.L_CORE 0.001998
K_920 X_NUC_7.L_CORE X_NUC_108.L_CORE 0.001996
K_921 X_NUC_7.L_CORE X_NUC_109.L_CORE 0.002219
K_922 X_NUC_7.L_CORE X_NUC_110.L_CORE 0.002220
K_923 X_NUC_7.L_CORE X_NUC_111.L_CORE 0.002204
K_924 X_NUC_7.L_CORE X_NUC_112.L_CORE 0.002202
K_925 X_NUC_7.L_CORE X_NUC_113.L_CORE 0.002045
K_926 X_NUC_7.L_CORE X_NUC_114.L_CORE 0.002051
K_927 X_NUC_7.L_CORE X_NUC_115.L_CORE 0.002033
K_928 X_NUC_7.L_CORE X_NUC_116.L_CORE 0.002036
K_929 X_NUC_7.L_CORE X_NUC_117.L_CORE 0.005373
K_930 X_NUC_7.L_CORE X_NUC_118.L_CORE 0.029289
K_931 X_NUC_7.L_CORE X_NUC_119.L_CORE 0.003780
K_932 X_NUC_7.L_CORE X_NUC_120.L_CORE 0.004482
K_933 X_NUC_7.L_CORE X_NUC_121.L_CORE 0.005548
K_934 X_NUC_7.L_CORE X_NUC_122.L_CORE 0.002816
K_935 X_NUC_7.L_CORE X_NUC_123.L_CORE 0.005148
K_936 X_NUC_7.L_CORE X_NUC_124.L_CORE 0.003032
K_937 X_NUC_7.L_CORE X_NUC_125.L_CORE 0.002729
K_938 X_NUC_7.L_CORE X_NUC_126.L_CORE 0.004167
K_939 X_NUC_7.L_CORE X_NUC_127.L_CORE 0.002334
K_940 X_NUC_7.L_CORE X_NUC_128.L_CORE 0.002995
K_941 X_NUC_7.L_CORE X_NUC_129.L_CORE 0.002802
K_942 X_NUC_7.L_CORE X_NUC_130.L_CORE 0.002168
K_943 X_NUC_7.L_CORE X_NUC_131.L_CORE 0.003033
K_944 X_NUC_7.L_CORE X_NUC_132.L_CORE 0.002169
K_945 X_NUC_7.L_CORE X_NUC_133.L_CORE 0.002245
K_946 X_NUC_7.L_CORE X_NUC_134.L_CORE 0.002527
K_947 X_NUC_7.L_CORE X_NUC_135.L_CORE 0.001948
K_948 X_NUC_7.L_CORE X_NUC_136.L_CORE 0.002312
K_949 X_NUC_7.L_CORE X_NUC_137.L_CORE 0.002073
K_950 X_NUC_7.L_CORE X_NUC_138.L_CORE 0.001933
K_951 X_NUC_7.L_CORE X_NUC_139.L_CORE 0.002120
K_952 X_NUC_7.L_CORE X_NUC_140.L_CORE 0.001897
K_953 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.004179
K_954 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.004259
K_955 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.004199
K_956 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.004230
K_957 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.005219
K_958 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.005281
K_959 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.005291
K_960 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.005178
K_961 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.006453
K_962 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.006462
K_963 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.006321
K_964 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.006507
K_965 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.003159
K_966 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.003206
K_967 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.003178
K_968 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.003171
K_969 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.006582
K_970 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.006487
K_971 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.006525
K_972 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.006387
K_973 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.003416
K_974 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.003450
K_975 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.003399
K_976 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.003439
K_977 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.003126
K_978 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.003157
K_979 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.003144
K_980 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.003113
K_981 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.005199
K_982 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.005128
K_983 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.005072
K_984 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.005129
K_985 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.002616
K_986 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.002646
K_987 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.002618
K_988 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.002625
K_989 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.003589
K_990 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.003589
K_991 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.003586
K_992 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.003538
K_993 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.003255
K_994 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.003262
K_995 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.003217
K_996 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.003256
K_997 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.002449
K_998 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.002473
K_999 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.002455
K_1000 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.002446
K_1001 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.003795
K_1002 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.003760
K_1003 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.003743
K_1004 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.003731
K_1005 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.002446
K_1006 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.002465
K_1007 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.002436
K_1008 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.002450
K_1009 X_NUC_8.L_CORE X_NUC_65.L_CORE 0.002608
K_1010 X_NUC_8.L_CORE X_NUC_66.L_CORE 0.002619
K_1011 X_NUC_8.L_CORE X_NUC_67.L_CORE 0.002608
K_1012 X_NUC_8.L_CORE X_NUC_68.L_CORE 0.002587
K_1013 X_NUC_8.L_CORE X_NUC_69.L_CORE 0.003061
K_1014 X_NUC_8.L_CORE X_NUC_70.L_CORE 0.003052
K_1015 X_NUC_8.L_CORE X_NUC_71.L_CORE 0.003019
K_1016 X_NUC_8.L_CORE X_NUC_72.L_CORE 0.003041
K_1017 X_NUC_8.L_CORE X_NUC_73.L_CORE 0.002175
K_1018 X_NUC_8.L_CORE X_NUC_74.L_CORE 0.002192
K_1019 X_NUC_8.L_CORE X_NUC_75.L_CORE 0.002173
K_1020 X_NUC_8.L_CORE X_NUC_76.L_CORE 0.002173
K_1021 X_NUC_8.L_CORE X_NUC_77.L_CORE 0.002826
K_1022 X_NUC_8.L_CORE X_NUC_78.L_CORE 0.002819
K_1023 X_NUC_8.L_CORE X_NUC_79.L_CORE 0.002807
K_1024 X_NUC_8.L_CORE X_NUC_80.L_CORE 0.002790
K_1025 X_NUC_8.L_CORE X_NUC_81.L_CORE 0.002388
K_1026 X_NUC_8.L_CORE X_NUC_82.L_CORE 0.002396
K_1027 X_NUC_8.L_CORE X_NUC_83.L_CORE 0.002370
K_1028 X_NUC_8.L_CORE X_NUC_84.L_CORE 0.002384
K_1029 X_NUC_8.L_CORE X_NUC_85.L_CORE 0.002178
K_1030 X_NUC_8.L_CORE X_NUC_86.L_CORE 0.002190
K_1031 X_NUC_8.L_CORE X_NUC_87.L_CORE 0.002176
K_1032 X_NUC_8.L_CORE X_NUC_88.L_CORE 0.002167
K_1033 X_NUC_8.L_CORE X_NUC_89.L_CORE 0.002671
K_1034 X_NUC_8.L_CORE X_NUC_90.L_CORE 0.002663
K_1035 X_NUC_8.L_CORE X_NUC_91.L_CORE 0.002642
K_1036 X_NUC_8.L_CORE X_NUC_92.L_CORE 0.002646
K_1037 X_NUC_8.L_CORE X_NUC_93.L_CORE 0.002074
K_1038 X_NUC_8.L_CORE X_NUC_94.L_CORE 0.002086
K_1039 X_NUC_8.L_CORE X_NUC_95.L_CORE 0.002067
K_1040 X_NUC_8.L_CORE X_NUC_96.L_CORE 0.002071
K_1041 X_NUC_8.L_CORE X_NUC_97.L_CORE 0.002278
K_1042 X_NUC_8.L_CORE X_NUC_98.L_CORE 0.002282
K_1043 X_NUC_8.L_CORE X_NUC_99.L_CORE 0.002269
K_1044 X_NUC_8.L_CORE X_NUC_100.L_CORE 0.002259
K_1045 X_NUC_8.L_CORE X_NUC_101.L_CORE 0.002279
K_1046 X_NUC_8.L_CORE X_NUC_102.L_CORE 0.002281
K_1047 X_NUC_8.L_CORE X_NUC_103.L_CORE 0.002259
K_1048 X_NUC_8.L_CORE X_NUC_104.L_CORE 0.002267
K_1049 X_NUC_8.L_CORE X_NUC_105.L_CORE 0.002006
K_1050 X_NUC_8.L_CORE X_NUC_106.L_CORE 0.002015
K_1051 X_NUC_8.L_CORE X_NUC_107.L_CORE 0.002000
K_1052 X_NUC_8.L_CORE X_NUC_108.L_CORE 0.001998
K_1053 X_NUC_8.L_CORE X_NUC_109.L_CORE 0.002222
K_1054 X_NUC_8.L_CORE X_NUC_110.L_CORE 0.002222
K_1055 X_NUC_8.L_CORE X_NUC_111.L_CORE 0.002207
K_1056 X_NUC_8.L_CORE X_NUC_112.L_CORE 0.002204
K_1057 X_NUC_8.L_CORE X_NUC_113.L_CORE 0.002043
K_1058 X_NUC_8.L_CORE X_NUC_114.L_CORE 0.002049
K_1059 X_NUC_8.L_CORE X_NUC_115.L_CORE 0.002031
K_1060 X_NUC_8.L_CORE X_NUC_116.L_CORE 0.002033
K_1061 X_NUC_8.L_CORE X_NUC_117.L_CORE 0.005420
K_1062 X_NUC_8.L_CORE X_NUC_118.L_CORE 0.029156
K_1063 X_NUC_8.L_CORE X_NUC_119.L_CORE 0.003753
K_1064 X_NUC_8.L_CORE X_NUC_120.L_CORE 0.004573
K_1065 X_NUC_8.L_CORE X_NUC_121.L_CORE 0.005409
K_1066 X_NUC_8.L_CORE X_NUC_122.L_CORE 0.002822
K_1067 X_NUC_8.L_CORE X_NUC_123.L_CORE 0.005236
K_1068 X_NUC_8.L_CORE X_NUC_124.L_CORE 0.003000
K_1069 X_NUC_8.L_CORE X_NUC_125.L_CORE 0.002754
K_1070 X_NUC_8.L_CORE X_NUC_126.L_CORE 0.004132
K_1071 X_NUC_8.L_CORE X_NUC_127.L_CORE 0.002328
K_1072 X_NUC_8.L_CORE X_NUC_128.L_CORE 0.003028
K_1073 X_NUC_8.L_CORE X_NUC_129.L_CORE 0.002774
K_1074 X_NUC_8.L_CORE X_NUC_130.L_CORE 0.002176
K_1075 X_NUC_8.L_CORE X_NUC_131.L_CORE 0.003041
K_1076 X_NUC_8.L_CORE X_NUC_132.L_CORE 0.002158
K_1077 X_NUC_8.L_CORE X_NUC_133.L_CORE 0.002260
K_1078 X_NUC_8.L_CORE X_NUC_134.L_CORE 0.002515
K_1079 X_NUC_8.L_CORE X_NUC_135.L_CORE 0.001948
K_1080 X_NUC_8.L_CORE X_NUC_136.L_CORE 0.002321
K_1081 X_NUC_8.L_CORE X_NUC_137.L_CORE 0.002064
K_1082 X_NUC_8.L_CORE X_NUC_138.L_CORE 0.001938
K_1083 X_NUC_8.L_CORE X_NUC_139.L_CORE 0.002119
K_1084 X_NUC_8.L_CORE X_NUC_140.L_CORE 0.001896
K_1085 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_1086 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_1087 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_1088 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.003508
K_1089 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.003481
K_1090 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.003518
K_1091 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.003466
K_1092 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.004479
K_1093 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.004389
K_1094 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.004410
K_1095 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.004435
K_1096 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.006012
K_1097 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.006099
K_1098 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.006086
K_1099 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.005946
K_1100 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.002804
K_1101 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.002774
K_1102 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.002794
K_1103 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.002774
K_1104 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.006522
K_1105 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.006464
K_1106 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.006338
K_1107 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.006489
K_1108 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.003162
K_1109 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.003159
K_1110 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.003172
K_1111 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.003127
K_1112 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.002872
K_1113 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.002835
K_1114 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.002844
K_1115 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.002844
K_1116 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.005461
K_1117 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.005554
K_1118 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.005432
K_1119 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.005426
K_1120 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.002431
K_1121 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.002416
K_1122 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.002426
K_1123 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.002405
K_1124 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.003485
K_1125 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.003450
K_1126 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.003429
K_1127 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.003458
K_1128 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.003192
K_1129 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.003208
K_1130 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.003196
K_1131 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.003161
K_1132 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.002306
K_1133 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.002285
K_1134 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.002291
K_1135 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.002283
K_1136 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.003935
K_1137 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.003947
K_1138 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.003879
K_1139 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.003910
K_1140 X_NUC_9.L_CORE X_NUC_65.L_CORE 0.002347
K_1141 X_NUC_9.L_CORE X_NUC_66.L_CORE 0.002341
K_1142 X_NUC_9.L_CORE X_NUC_67.L_CORE 0.002344
K_1143 X_NUC_9.L_CORE X_NUC_68.L_CORE 0.002323
K_1144 X_NUC_9.L_CORE X_NUC_69.L_CORE 0.002522
K_1145 X_NUC_9.L_CORE X_NUC_70.L_CORE 0.002500
K_1146 X_NUC_9.L_CORE X_NUC_71.L_CORE 0.002494
K_1147 X_NUC_9.L_CORE X_NUC_72.L_CORE 0.002500
K_1148 X_NUC_9.L_CORE X_NUC_73.L_CORE 0.003112
K_1149 X_NUC_9.L_CORE X_NUC_74.L_CORE 0.003131
K_1150 X_NUC_9.L_CORE X_NUC_75.L_CORE 0.003099
K_1151 X_NUC_9.L_CORE X_NUC_76.L_CORE 0.003086
K_1152 X_NUC_9.L_CORE X_NUC_77.L_CORE 0.002088
K_1153 X_NUC_9.L_CORE X_NUC_78.L_CORE 0.002076
K_1154 X_NUC_9.L_CORE X_NUC_79.L_CORE 0.002078
K_1155 X_NUC_9.L_CORE X_NUC_80.L_CORE 0.002067
K_1156 X_NUC_9.L_CORE X_NUC_81.L_CORE 0.002839
K_1157 X_NUC_9.L_CORE X_NUC_82.L_CORE 0.002829
K_1158 X_NUC_9.L_CORE X_NUC_83.L_CORE 0.002802
K_1159 X_NUC_9.L_CORE X_NUC_84.L_CORE 0.002817
K_1160 X_NUC_9.L_CORE X_NUC_85.L_CORE 0.002357
K_1161 X_NUC_9.L_CORE X_NUC_86.L_CORE 0.002358
K_1162 X_NUC_9.L_CORE X_NUC_87.L_CORE 0.002351
K_1163 X_NUC_9.L_CORE X_NUC_88.L_CORE 0.002335
K_1164 X_NUC_9.L_CORE X_NUC_89.L_CORE 0.002121
K_1165 X_NUC_9.L_CORE X_NUC_90.L_CORE 0.002106
K_1166 X_NUC_9.L_CORE X_NUC_91.L_CORE 0.002103
K_1167 X_NUC_9.L_CORE X_NUC_92.L_CORE 0.002101
K_1168 X_NUC_9.L_CORE X_NUC_93.L_CORE 0.002708
K_1169 X_NUC_9.L_CORE X_NUC_94.L_CORE 0.002713
K_1170 X_NUC_9.L_CORE X_NUC_95.L_CORE 0.002685
K_1171 X_NUC_9.L_CORE X_NUC_96.L_CORE 0.002686
K_1172 X_NUC_9.L_CORE X_NUC_97.L_CORE 0.002037
K_1173 X_NUC_9.L_CORE X_NUC_98.L_CORE 0.002030
K_1174 X_NUC_9.L_CORE X_NUC_99.L_CORE 0.002028
K_1175 X_NUC_9.L_CORE X_NUC_100.L_CORE 0.002017
K_1176 X_NUC_9.L_CORE X_NUC_101.L_CORE 0.002259
K_1177 X_NUC_9.L_CORE X_NUC_102.L_CORE 0.002249
K_1178 X_NUC_9.L_CORE X_NUC_103.L_CORE 0.002237
K_1179 X_NUC_9.L_CORE X_NUC_104.L_CORE 0.002240
K_1180 X_NUC_9.L_CORE X_NUC_105.L_CORE 0.002273
K_1181 X_NUC_9.L_CORE X_NUC_106.L_CORE 0.002275
K_1182 X_NUC_9.L_CORE X_NUC_107.L_CORE 0.002261
K_1183 X_NUC_9.L_CORE X_NUC_108.L_CORE 0.002254
K_1184 X_NUC_9.L_CORE X_NUC_109.L_CORE 0.001998
K_1185 X_NUC_9.L_CORE X_NUC_110.L_CORE 0.001990
K_1186 X_NUC_9.L_CORE X_NUC_111.L_CORE 0.001985
K_1187 X_NUC_9.L_CORE X_NUC_112.L_CORE 0.001980
K_1188 X_NUC_9.L_CORE X_NUC_113.L_CORE 0.002177
K_1189 X_NUC_9.L_CORE X_NUC_114.L_CORE 0.002173
K_1190 X_NUC_9.L_CORE X_NUC_115.L_CORE 0.002160
K_1191 X_NUC_9.L_CORE X_NUC_116.L_CORE 0.002159
K_1192 X_NUC_9.L_CORE X_NUC_117.L_CORE 0.005937
K_1193 X_NUC_9.L_CORE X_NUC_118.L_CORE 0.003790
K_1194 X_NUC_9.L_CORE X_NUC_119.L_CORE 0.030936
K_1195 X_NUC_9.L_CORE X_NUC_120.L_CORE 0.003133
K_1196 X_NUC_9.L_CORE X_NUC_121.L_CORE 0.003913
K_1197 X_NUC_9.L_CORE X_NUC_122.L_CORE 0.005122
K_1198 X_NUC_9.L_CORE X_NUC_123.L_CORE 0.002495
K_1199 X_NUC_9.L_CORE X_NUC_124.L_CORE 0.005197
K_1200 X_NUC_9.L_CORE X_NUC_125.L_CORE 0.002786
K_1201 X_NUC_9.L_CORE X_NUC_126.L_CORE 0.002527
K_1202 X_NUC_9.L_CORE X_NUC_127.L_CORE 0.004311
K_1203 X_NUC_9.L_CORE X_NUC_128.L_CORE 0.002164
K_1204 X_NUC_9.L_CORE X_NUC_129.L_CORE 0.002940
K_1205 X_NUC_9.L_CORE X_NUC_130.L_CORE 0.002730
K_1206 X_NUC_9.L_CORE X_NUC_131.L_CORE 0.002051
K_1207 X_NUC_9.L_CORE X_NUC_132.L_CORE 0.003109
K_1208 X_NUC_9.L_CORE X_NUC_133.L_CORE 0.002081
K_1209 X_NUC_9.L_CORE X_NUC_134.L_CORE 0.002190
K_1210 X_NUC_9.L_CORE X_NUC_135.L_CORE 0.002532
K_1211 X_NUC_9.L_CORE X_NUC_136.L_CORE 0.001886
K_1212 X_NUC_9.L_CORE X_NUC_137.L_CORE 0.002306
K_1213 X_NUC_9.L_CORE X_NUC_138.L_CORE 0.002042
K_1214 X_NUC_9.L_CORE X_NUC_139.L_CORE 0.001913
K_1215 X_NUC_9.L_CORE X_NUC_140.L_CORE 0.002064
K_1216 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_1217 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_1218 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.003535
K_1219 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.003508
K_1220 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.003545
K_1221 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.003492
K_1222 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.004573
K_1223 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.004479
K_1224 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.004501
K_1225 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.004527
K_1226 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.005923
K_1227 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.006012
K_1228 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.005997
K_1229 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.005863
K_1230 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.002835
K_1231 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.002804
K_1232 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.002825
K_1233 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.002804
K_1234 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.006575
K_1235 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.006522
K_1236 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.006389
K_1237 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.006544
K_1238 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.003163
K_1239 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.003162
K_1240 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.003174
K_1241 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.003129
K_1242 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.002910
K_1243 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.002872
K_1244 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.002881
K_1245 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.002881
K_1246 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.005368
K_1247 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.005461
K_1248 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.005343
K_1249 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.005336
K_1250 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.002446
K_1251 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.002431
K_1252 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.002442
K_1253 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.002420
K_1254 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.003520
K_1255 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.003485
K_1256 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.003462
K_1257 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.003493
K_1258 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.003175
K_1259 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.003192
K_1260 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.003180
K_1261 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.003146
K_1262 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.002327
K_1263 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.002306
K_1264 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.002311
K_1265 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.002303
K_1266 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.003921
K_1267 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.003935
K_1268 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.003867
K_1269 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.003897
K_1270 X_NUC_10.L_CORE X_NUC_65.L_CORE 0.002352
K_1271 X_NUC_10.L_CORE X_NUC_66.L_CORE 0.002347
K_1272 X_NUC_10.L_CORE X_NUC_67.L_CORE 0.002349
K_1273 X_NUC_10.L_CORE X_NUC_68.L_CORE 0.002329
K_1274 X_NUC_10.L_CORE X_NUC_69.L_CORE 0.002544
K_1275 X_NUC_10.L_CORE X_NUC_70.L_CORE 0.002522
K_1276 X_NUC_10.L_CORE X_NUC_71.L_CORE 0.002516
K_1277 X_NUC_10.L_CORE X_NUC_72.L_CORE 0.002522
K_1278 X_NUC_10.L_CORE X_NUC_73.L_CORE 0.003092
K_1279 X_NUC_10.L_CORE X_NUC_74.L_CORE 0.003112
K_1280 X_NUC_10.L_CORE X_NUC_75.L_CORE 0.003080
K_1281 X_NUC_10.L_CORE X_NUC_76.L_CORE 0.003068
K_1282 X_NUC_10.L_CORE X_NUC_77.L_CORE 0.002100
K_1283 X_NUC_10.L_CORE X_NUC_78.L_CORE 0.002088
K_1284 X_NUC_10.L_CORE X_NUC_79.L_CORE 0.002090
K_1285 X_NUC_10.L_CORE X_NUC_80.L_CORE 0.002079
K_1286 X_NUC_10.L_CORE X_NUC_81.L_CORE 0.002848
K_1287 X_NUC_10.L_CORE X_NUC_82.L_CORE 0.002839
K_1288 X_NUC_10.L_CORE X_NUC_83.L_CORE 0.002812
K_1289 X_NUC_10.L_CORE X_NUC_84.L_CORE 0.002827
K_1290 X_NUC_10.L_CORE X_NUC_85.L_CORE 0.002355
K_1291 X_NUC_10.L_CORE X_NUC_86.L_CORE 0.002357
K_1292 X_NUC_10.L_CORE X_NUC_87.L_CORE 0.002349
K_1293 X_NUC_10.L_CORE X_NUC_88.L_CORE 0.002333
K_1294 X_NUC_10.L_CORE X_NUC_89.L_CORE 0.002135
K_1295 X_NUC_10.L_CORE X_NUC_90.L_CORE 0.002121
K_1296 X_NUC_10.L_CORE X_NUC_91.L_CORE 0.002118
K_1297 X_NUC_10.L_CORE X_NUC_92.L_CORE 0.002115
K_1298 X_NUC_10.L_CORE X_NUC_93.L_CORE 0.002702
K_1299 X_NUC_10.L_CORE X_NUC_94.L_CORE 0.002708
K_1300 X_NUC_10.L_CORE X_NUC_95.L_CORE 0.002680
K_1301 X_NUC_10.L_CORE X_NUC_96.L_CORE 0.002681
K_1302 X_NUC_10.L_CORE X_NUC_97.L_CORE 0.002043
K_1303 X_NUC_10.L_CORE X_NUC_98.L_CORE 0.002037
K_1304 X_NUC_10.L_CORE X_NUC_99.L_CORE 0.002034
K_1305 X_NUC_10.L_CORE X_NUC_100.L_CORE 0.002023
K_1306 X_NUC_10.L_CORE X_NUC_101.L_CORE 0.002269
K_1307 X_NUC_10.L_CORE X_NUC_102.L_CORE 0.002259
K_1308 X_NUC_10.L_CORE X_NUC_103.L_CORE 0.002247
K_1309 X_NUC_10.L_CORE X_NUC_104.L_CORE 0.002250
K_1310 X_NUC_10.L_CORE X_NUC_105.L_CORE 0.002272
K_1311 X_NUC_10.L_CORE X_NUC_106.L_CORE 0.002273
K_1312 X_NUC_10.L_CORE X_NUC_107.L_CORE 0.002260
K_1313 X_NUC_10.L_CORE X_NUC_108.L_CORE 0.002252
K_1314 X_NUC_10.L_CORE X_NUC_109.L_CORE 0.002006
K_1315 X_NUC_10.L_CORE X_NUC_110.L_CORE 0.001998
K_1316 X_NUC_10.L_CORE X_NUC_111.L_CORE 0.001993
K_1317 X_NUC_10.L_CORE X_NUC_112.L_CORE 0.001988
K_1318 X_NUC_10.L_CORE X_NUC_113.L_CORE 0.002181
K_1319 X_NUC_10.L_CORE X_NUC_114.L_CORE 0.002177
K_1320 X_NUC_10.L_CORE X_NUC_115.L_CORE 0.002164
K_1321 X_NUC_10.L_CORE X_NUC_116.L_CORE 0.002163
K_1322 X_NUC_10.L_CORE X_NUC_117.L_CORE 0.005989
K_1323 X_NUC_10.L_CORE X_NUC_118.L_CORE 0.003856
K_1324 X_NUC_10.L_CORE X_NUC_119.L_CORE 0.028010
K_1325 X_NUC_10.L_CORE X_NUC_120.L_CORE 0.003153
K_1326 X_NUC_10.L_CORE X_NUC_121.L_CORE 0.003983
K_1327 X_NUC_10.L_CORE X_NUC_122.L_CORE 0.005044
K_1328 X_NUC_10.L_CORE X_NUC_123.L_CORE 0.002519
K_1329 X_NUC_10.L_CORE X_NUC_124.L_CORE 0.005217
K_1330 X_NUC_10.L_CORE X_NUC_125.L_CORE 0.002785
K_1331 X_NUC_10.L_CORE X_NUC_126.L_CORE 0.002555
K_1332 X_NUC_10.L_CORE X_NUC_127.L_CORE 0.004252
K_1333 X_NUC_10.L_CORE X_NUC_128.L_CORE 0.002176
K_1334 X_NUC_10.L_CORE X_NUC_129.L_CORE 0.002962
K_1335 X_NUC_10.L_CORE X_NUC_130.L_CORE 0.002718
K_1336 X_NUC_10.L_CORE X_NUC_131.L_CORE 0.002067
K_1337 X_NUC_10.L_CORE X_NUC_132.L_CORE 0.003101
K_1338 X_NUC_10.L_CORE X_NUC_133.L_CORE 0.002084
K_1339 X_NUC_10.L_CORE X_NUC_134.L_CORE 0.002205
K_1340 X_NUC_10.L_CORE X_NUC_135.L_CORE 0.002522
K_1341 X_NUC_10.L_CORE X_NUC_136.L_CORE 0.001895
K_1342 X_NUC_10.L_CORE X_NUC_137.L_CORE 0.002311
K_1343 X_NUC_10.L_CORE X_NUC_138.L_CORE 0.002043
K_1344 X_NUC_10.L_CORE X_NUC_139.L_CORE 0.001921
K_1345 X_NUC_10.L_CORE X_NUC_140.L_CORE 0.002065
K_1346 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_1347 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.003497
K_1348 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.003471
K_1349 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.003508
K_1350 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.003456
K_1351 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.004549
K_1352 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.004455
K_1353 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.004479
K_1354 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.004503
K_1355 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.005935
K_1356 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.006022
K_1357 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.006012
K_1358 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.005875
K_1359 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.002814
K_1360 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.002784
K_1361 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.002804
K_1362 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.002784
K_1363 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.006716
K_1364 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.006656
K_1365 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.006522
K_1366 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.006684
K_1367 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.003151
K_1368 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.003149
K_1369 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.003162
K_1370 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.003117
K_1371 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.002901
K_1372 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.002863
K_1373 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.002872
K_1374 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.002872
K_1375 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.005486
K_1376 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.005583
K_1377 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.005461
K_1378 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.005452
K_1379 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.002436
K_1380 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.002420
K_1381 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.002431
K_1382 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.002410
K_1383 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.003544
K_1384 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.003508
K_1385 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.003485
K_1386 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.003516
K_1387 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.003187
K_1388 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.003203
K_1389 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.003192
K_1390 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.003157
K_1391 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.002321
K_1392 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.002300
K_1393 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.002306
K_1394 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.002298
K_1395 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.003991
K_1396 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.004005
K_1397 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.003935
K_1398 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.003966
K_1399 X_NUC_11.L_CORE X_NUC_65.L_CORE 0.002350
K_1400 X_NUC_11.L_CORE X_NUC_66.L_CORE 0.002344
K_1401 X_NUC_11.L_CORE X_NUC_67.L_CORE 0.002347
K_1402 X_NUC_11.L_CORE X_NUC_68.L_CORE 0.002326
K_1403 X_NUC_11.L_CORE X_NUC_69.L_CORE 0.002551
K_1404 X_NUC_11.L_CORE X_NUC_70.L_CORE 0.002528
K_1405 X_NUC_11.L_CORE X_NUC_71.L_CORE 0.002522
K_1406 X_NUC_11.L_CORE X_NUC_72.L_CORE 0.002528
K_1407 X_NUC_11.L_CORE X_NUC_73.L_CORE 0.003124
K_1408 X_NUC_11.L_CORE X_NUC_74.L_CORE 0.003143
K_1409 X_NUC_11.L_CORE X_NUC_75.L_CORE 0.003112
K_1410 X_NUC_11.L_CORE X_NUC_76.L_CORE 0.003098
K_1411 X_NUC_11.L_CORE X_NUC_77.L_CORE 0.002098
K_1412 X_NUC_11.L_CORE X_NUC_78.L_CORE 0.002085
K_1413 X_NUC_11.L_CORE X_NUC_79.L_CORE 0.002088
K_1414 X_NUC_11.L_CORE X_NUC_80.L_CORE 0.002077
K_1415 X_NUC_11.L_CORE X_NUC_81.L_CORE 0.002876
K_1416 X_NUC_11.L_CORE X_NUC_82.L_CORE 0.002866
K_1417 X_NUC_11.L_CORE X_NUC_83.L_CORE 0.002839
K_1418 X_NUC_11.L_CORE X_NUC_84.L_CORE 0.002854
K_1419 X_NUC_11.L_CORE X_NUC_85.L_CORE 0.002362
K_1420 X_NUC_11.L_CORE X_NUC_86.L_CORE 0.002364
K_1421 X_NUC_11.L_CORE X_NUC_87.L_CORE 0.002357
K_1422 X_NUC_11.L_CORE X_NUC_88.L_CORE 0.002340
K_1423 X_NUC_11.L_CORE X_NUC_89.L_CORE 0.002138
K_1424 X_NUC_11.L_CORE X_NUC_90.L_CORE 0.002123
K_1425 X_NUC_11.L_CORE X_NUC_91.L_CORE 0.002121
K_1426 X_NUC_11.L_CORE X_NUC_92.L_CORE 0.002118
K_1427 X_NUC_11.L_CORE X_NUC_93.L_CORE 0.002730
K_1428 X_NUC_11.L_CORE X_NUC_94.L_CORE 0.002736
K_1429 X_NUC_11.L_CORE X_NUC_95.L_CORE 0.002708
K_1430 X_NUC_11.L_CORE X_NUC_96.L_CORE 0.002709
K_1431 X_NUC_11.L_CORE X_NUC_97.L_CORE 0.002045
K_1432 X_NUC_11.L_CORE X_NUC_98.L_CORE 0.002039
K_1433 X_NUC_11.L_CORE X_NUC_99.L_CORE 0.002037
K_1434 X_NUC_11.L_CORE X_NUC_100.L_CORE 0.002026
K_1435 X_NUC_11.L_CORE X_NUC_101.L_CORE 0.002282
K_1436 X_NUC_11.L_CORE X_NUC_102.L_CORE 0.002271
K_1437 X_NUC_11.L_CORE X_NUC_103.L_CORE 0.002259
K_1438 X_NUC_11.L_CORE X_NUC_104.L_CORE 0.002262
K_1439 X_NUC_11.L_CORE X_NUC_105.L_CORE 0.002285
K_1440 X_NUC_11.L_CORE X_NUC_106.L_CORE 0.002287
K_1441 X_NUC_11.L_CORE X_NUC_107.L_CORE 0.002273
K_1442 X_NUC_11.L_CORE X_NUC_108.L_CORE 0.002265
K_1443 X_NUC_11.L_CORE X_NUC_109.L_CORE 0.002011
K_1444 X_NUC_11.L_CORE X_NUC_110.L_CORE 0.002003
K_1445 X_NUC_11.L_CORE X_NUC_111.L_CORE 0.001998
K_1446 X_NUC_11.L_CORE X_NUC_112.L_CORE 0.001993
K_1447 X_NUC_11.L_CORE X_NUC_113.L_CORE 0.002194
K_1448 X_NUC_11.L_CORE X_NUC_114.L_CORE 0.002190
K_1449 X_NUC_11.L_CORE X_NUC_115.L_CORE 0.002177
K_1450 X_NUC_11.L_CORE X_NUC_116.L_CORE 0.002175
K_1451 X_NUC_11.L_CORE X_NUC_117.L_CORE 0.005846
K_1452 X_NUC_11.L_CORE X_NUC_118.L_CORE 0.003804
K_1453 X_NUC_11.L_CORE X_NUC_119.L_CORE 0.029276
K_1454 X_NUC_11.L_CORE X_NUC_120.L_CORE 0.003123
K_1455 X_NUC_11.L_CORE X_NUC_121.L_CORE 0.003968
K_1456 X_NUC_11.L_CORE X_NUC_122.L_CORE 0.005062
K_1457 X_NUC_11.L_CORE X_NUC_123.L_CORE 0.002503
K_1458 X_NUC_11.L_CORE X_NUC_124.L_CORE 0.005314
K_1459 X_NUC_11.L_CORE X_NUC_125.L_CORE 0.002777
K_1460 X_NUC_11.L_CORE X_NUC_126.L_CORE 0.002550
K_1461 X_NUC_11.L_CORE X_NUC_127.L_CORE 0.004329
K_1462 X_NUC_11.L_CORE X_NUC_128.L_CORE 0.002169
K_1463 X_NUC_11.L_CORE X_NUC_129.L_CORE 0.002982
K_1464 X_NUC_11.L_CORE X_NUC_130.L_CORE 0.002729
K_1465 X_NUC_11.L_CORE X_NUC_131.L_CORE 0.002064
K_1466 X_NUC_11.L_CORE X_NUC_132.L_CORE 0.003144
K_1467 X_NUC_11.L_CORE X_NUC_133.L_CORE 0.002085
K_1468 X_NUC_11.L_CORE X_NUC_134.L_CORE 0.002212
K_1469 X_NUC_11.L_CORE X_NUC_135.L_CORE 0.002543
K_1470 X_NUC_11.L_CORE X_NUC_136.L_CORE 0.001895
K_1471 X_NUC_11.L_CORE X_NUC_137.L_CORE 0.002329
K_1472 X_NUC_11.L_CORE X_NUC_138.L_CORE 0.002050
K_1473 X_NUC_11.L_CORE X_NUC_139.L_CORE 0.001927
K_1474 X_NUC_11.L_CORE X_NUC_140.L_CORE 0.002078
K_1475 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.003551
K_1476 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.003523
K_1477 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.003561
K_1478 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.003508
K_1479 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.004523
K_1480 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.004431
K_1481 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.004453
K_1482 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.004479
K_1483 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.006075
K_1484 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.006168
K_1485 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.006154
K_1486 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.006012
K_1487 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.002835
K_1488 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.002804
K_1489 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.002825
K_1490 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.002804
K_1491 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.006549
K_1492 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.006493
K_1493 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.006365
K_1494 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.006522
K_1495 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.003197
K_1496 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.003195
K_1497 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.003208
K_1498 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.003162
K_1499 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.002901
K_1500 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.002863
K_1501 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.002872
K_1502 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.002872
K_1503 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.005493
K_1504 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.005590
K_1505 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.005465
K_1506 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.005461
K_1507 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.002457
K_1508 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.002442
K_1509 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.002453
K_1510 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.002431
K_1511 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.003512
K_1512 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.003477
K_1513 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.003455
K_1514 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.003485
K_1515 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.003223
K_1516 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.003239
K_1517 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.003227
K_1518 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.003192
K_1519 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.002329
K_1520 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.002308
K_1521 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.002314
K_1522 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.002306
K_1523 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.003959
K_1524 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.003972
K_1525 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.003903
K_1526 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.003935
K_1527 X_NUC_12.L_CORE X_NUC_65.L_CORE 0.002371
K_1528 X_NUC_12.L_CORE X_NUC_66.L_CORE 0.002366
K_1529 X_NUC_12.L_CORE X_NUC_67.L_CORE 0.002368
K_1530 X_NUC_12.L_CORE X_NUC_68.L_CORE 0.002347
K_1531 X_NUC_12.L_CORE X_NUC_69.L_CORE 0.002545
K_1532 X_NUC_12.L_CORE X_NUC_70.L_CORE 0.002522
K_1533 X_NUC_12.L_CORE X_NUC_71.L_CORE 0.002516
K_1534 X_NUC_12.L_CORE X_NUC_72.L_CORE 0.002522
K_1535 X_NUC_12.L_CORE X_NUC_73.L_CORE 0.003137
K_1536 X_NUC_12.L_CORE X_NUC_74.L_CORE 0.003157
K_1537 X_NUC_12.L_CORE X_NUC_75.L_CORE 0.003125
K_1538 X_NUC_12.L_CORE X_NUC_76.L_CORE 0.003112
K_1539 X_NUC_12.L_CORE X_NUC_77.L_CORE 0.002109
K_1540 X_NUC_12.L_CORE X_NUC_78.L_CORE 0.002096
K_1541 X_NUC_12.L_CORE X_NUC_79.L_CORE 0.002099
K_1542 X_NUC_12.L_CORE X_NUC_80.L_CORE 0.002088
K_1543 X_NUC_12.L_CORE X_NUC_81.L_CORE 0.002860
K_1544 X_NUC_12.L_CORE X_NUC_82.L_CORE 0.002850
K_1545 X_NUC_12.L_CORE X_NUC_83.L_CORE 0.002823
K_1546 X_NUC_12.L_CORE X_NUC_84.L_CORE 0.002839
K_1547 X_NUC_12.L_CORE X_NUC_85.L_CORE 0.002379
K_1548 X_NUC_12.L_CORE X_NUC_86.L_CORE 0.002381
K_1549 X_NUC_12.L_CORE X_NUC_87.L_CORE 0.002373
K_1550 X_NUC_12.L_CORE X_NUC_88.L_CORE 0.002357
K_1551 X_NUC_12.L_CORE X_NUC_89.L_CORE 0.002140
K_1552 X_NUC_12.L_CORE X_NUC_90.L_CORE 0.002126
K_1553 X_NUC_12.L_CORE X_NUC_91.L_CORE 0.002123
K_1554 X_NUC_12.L_CORE X_NUC_92.L_CORE 0.002121
K_1555 X_NUC_12.L_CORE X_NUC_93.L_CORE 0.002729
K_1556 X_NUC_12.L_CORE X_NUC_94.L_CORE 0.002734
K_1557 X_NUC_12.L_CORE X_NUC_95.L_CORE 0.002706
K_1558 X_NUC_12.L_CORE X_NUC_96.L_CORE 0.002708
K_1559 X_NUC_12.L_CORE X_NUC_97.L_CORE 0.002056
K_1560 X_NUC_12.L_CORE X_NUC_98.L_CORE 0.002050
K_1561 X_NUC_12.L_CORE X_NUC_99.L_CORE 0.002047
K_1562 X_NUC_12.L_CORE X_NUC_100.L_CORE 0.002037
K_1563 X_NUC_12.L_CORE X_NUC_101.L_CORE 0.002279
K_1564 X_NUC_12.L_CORE X_NUC_102.L_CORE 0.002268
K_1565 X_NUC_12.L_CORE X_NUC_103.L_CORE 0.002256
K_1566 X_NUC_12.L_CORE X_NUC_104.L_CORE 0.002259
K_1567 X_NUC_12.L_CORE X_NUC_105.L_CORE 0.002293
K_1568 X_NUC_12.L_CORE X_NUC_106.L_CORE 0.002295
K_1569 X_NUC_12.L_CORE X_NUC_107.L_CORE 0.002281
K_1570 X_NUC_12.L_CORE X_NUC_108.L_CORE 0.002273
K_1571 X_NUC_12.L_CORE X_NUC_109.L_CORE 0.002016
K_1572 X_NUC_12.L_CORE X_NUC_110.L_CORE 0.002008
K_1573 X_NUC_12.L_CORE X_NUC_111.L_CORE 0.002003
K_1574 X_NUC_12.L_CORE X_NUC_112.L_CORE 0.001998
K_1575 X_NUC_12.L_CORE X_NUC_113.L_CORE 0.002196
K_1576 X_NUC_12.L_CORE X_NUC_114.L_CORE 0.002192
K_1577 X_NUC_12.L_CORE X_NUC_115.L_CORE 0.002179
K_1578 X_NUC_12.L_CORE X_NUC_116.L_CORE 0.002177
K_1579 X_NUC_12.L_CORE X_NUC_117.L_CORE 0.005994
K_1580 X_NUC_12.L_CORE X_NUC_118.L_CORE 0.003826
K_1581 X_NUC_12.L_CORE X_NUC_119.L_CORE 0.027122
K_1582 X_NUC_12.L_CORE X_NUC_120.L_CORE 0.003166
K_1583 X_NUC_12.L_CORE X_NUC_121.L_CORE 0.003941
K_1584 X_NUC_12.L_CORE X_NUC_122.L_CORE 0.005154
K_1585 X_NUC_12.L_CORE X_NUC_123.L_CORE 0.002519
K_1586 X_NUC_12.L_CORE X_NUC_124.L_CORE 0.005203
K_1587 X_NUC_12.L_CORE X_NUC_125.L_CORE 0.002812
K_1588 X_NUC_12.L_CORE X_NUC_126.L_CORE 0.002549
K_1589 X_NUC_12.L_CORE X_NUC_127.L_CORE 0.004327
K_1590 X_NUC_12.L_CORE X_NUC_128.L_CORE 0.002185
K_1591 X_NUC_12.L_CORE X_NUC_129.L_CORE 0.002959
K_1592 X_NUC_12.L_CORE X_NUC_130.L_CORE 0.002753
K_1593 X_NUC_12.L_CORE X_NUC_131.L_CORE 0.002070
K_1594 X_NUC_12.L_CORE X_NUC_132.L_CORE 0.003126
K_1595 X_NUC_12.L_CORE X_NUC_133.L_CORE 0.002100
K_1596 X_NUC_12.L_CORE X_NUC_134.L_CORE 0.002208
K_1597 X_NUC_12.L_CORE X_NUC_135.L_CORE 0.002551
K_1598 X_NUC_12.L_CORE X_NUC_136.L_CORE 0.001903
K_1599 X_NUC_12.L_CORE X_NUC_137.L_CORE 0.002322
K_1600 X_NUC_12.L_CORE X_NUC_138.L_CORE 0.002060
K_1601 X_NUC_12.L_CORE X_NUC_139.L_CORE 0.001929
K_1602 X_NUC_12.L_CORE X_NUC_140.L_CORE 0.002080
K_1603 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_1604 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_1605 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_1606 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.003095
K_1607 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.003083
K_1608 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.003065
K_1609 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.003109
K_1610 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.004038
K_1611 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.004106
K_1612 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.004044
K_1613 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.004083
K_1614 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.005612
K_1615 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.005478
K_1616 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.005490
K_1617 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.005536
K_1618 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.002570
K_1619 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.002577
K_1620 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.002555
K_1621 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.002585
K_1622 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.006523
K_1623 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.006683
K_1624 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.006547
K_1625 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.006487
K_1626 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.002967
K_1627 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.002942
K_1628 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.002930
K_1629 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.002961
K_1630 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.002705
K_1631 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.002729
K_1632 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.002697
K_1633 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.002720
K_1634 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.005686
K_1635 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.005604
K_1636 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.005584
K_1637 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.005538
K_1638 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.002301
K_1639 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.002298
K_1640 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.002282
K_1641 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.002305
K_1642 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.003428
K_1643 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.003473
K_1644 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.003424
K_1645 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.003429
K_1646 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.003132
K_1647 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.003099
K_1648 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.003088
K_1649 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.003105
K_1650 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.002212
K_1651 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.002221
K_1652 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.002199
K_1653 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.002218
K_1654 X_NUC_13.L_CORE X_NUC_65.L_CORE 0.004080
K_1655 X_NUC_13.L_CORE X_NUC_66.L_CORE 0.004094
K_1656 X_NUC_13.L_CORE X_NUC_67.L_CORE 0.004049
K_1657 X_NUC_13.L_CORE X_NUC_68.L_CORE 0.004022
K_1658 X_NUC_13.L_CORE X_NUC_69.L_CORE 0.002277
K_1659 X_NUC_13.L_CORE X_NUC_70.L_CORE 0.002268
K_1660 X_NUC_13.L_CORE X_NUC_71.L_CORE 0.002254
K_1661 X_NUC_13.L_CORE X_NUC_72.L_CORE 0.002272
K_1662 X_NUC_13.L_CORE X_NUC_73.L_CORE 0.002475
K_1663 X_NUC_13.L_CORE X_NUC_74.L_CORE 0.002494
K_1664 X_NUC_13.L_CORE X_NUC_75.L_CORE 0.002465
K_1665 X_NUC_13.L_CORE X_NUC_76.L_CORE 0.002477
K_1666 X_NUC_13.L_CORE X_NUC_77.L_CORE 0.003154
K_1667 X_NUC_13.L_CORE X_NUC_78.L_CORE 0.003131
K_1668 X_NUC_13.L_CORE X_NUC_79.L_CORE 0.003113
K_1669 X_NUC_13.L_CORE X_NUC_80.L_CORE 0.003114
K_1670 X_NUC_13.L_CORE X_NUC_81.L_CORE 0.002035
K_1671 X_NUC_13.L_CORE X_NUC_82.L_CORE 0.002037
K_1672 X_NUC_13.L_CORE X_NUC_83.L_CORE 0.002020
K_1673 X_NUC_13.L_CORE X_NUC_84.L_CORE 0.002036
K_1674 X_NUC_13.L_CORE X_NUC_85.L_CORE 0.002866
K_1675 X_NUC_13.L_CORE X_NUC_86.L_CORE 0.002883
K_1676 X_NUC_13.L_CORE X_NUC_87.L_CORE 0.002850
K_1677 X_NUC_13.L_CORE X_NUC_88.L_CORE 0.002849
K_1678 X_NUC_13.L_CORE X_NUC_89.L_CORE 0.002339
K_1679 X_NUC_13.L_CORE X_NUC_90.L_CORE 0.002328
K_1680 X_NUC_13.L_CORE X_NUC_91.L_CORE 0.002313
K_1681 X_NUC_13.L_CORE X_NUC_92.L_CORE 0.002325
K_1682 X_NUC_13.L_CORE X_NUC_93.L_CORE 0.002096
K_1683 X_NUC_13.L_CORE X_NUC_94.L_CORE 0.002104
K_1684 X_NUC_13.L_CORE X_NUC_95.L_CORE 0.002083
K_1685 X_NUC_13.L_CORE X_NUC_96.L_CORE 0.002095
K_1686 X_NUC_13.L_CORE X_NUC_97.L_CORE 0.002735
K_1687 X_NUC_13.L_CORE X_NUC_98.L_CORE 0.002733
K_1688 X_NUC_13.L_CORE X_NUC_99.L_CORE 0.002710
K_1689 X_NUC_13.L_CORE X_NUC_100.L_CORE 0.002708
K_1690 X_NUC_13.L_CORE X_NUC_101.L_CORE 0.002026
K_1691 X_NUC_13.L_CORE X_NUC_102.L_CORE 0.002024
K_1692 X_NUC_13.L_CORE X_NUC_103.L_CORE 0.002008
K_1693 X_NUC_13.L_CORE X_NUC_104.L_CORE 0.002020
K_1694 X_NUC_13.L_CORE X_NUC_105.L_CORE 0.002259
K_1695 X_NUC_13.L_CORE X_NUC_106.L_CORE 0.002268
K_1696 X_NUC_13.L_CORE X_NUC_107.L_CORE 0.002245
K_1697 X_NUC_13.L_CORE X_NUC_108.L_CORE 0.002251
K_1698 X_NUC_13.L_CORE X_NUC_109.L_CORE 0.002267
K_1699 X_NUC_13.L_CORE X_NUC_110.L_CORE 0.002262
K_1700 X_NUC_13.L_CORE X_NUC_111.L_CORE 0.002245
K_1701 X_NUC_13.L_CORE X_NUC_112.L_CORE 0.002252
K_1702 X_NUC_13.L_CORE X_NUC_113.L_CORE 0.002042
K_1703 X_NUC_13.L_CORE X_NUC_114.L_CORE 0.002044
K_1704 X_NUC_13.L_CORE X_NUC_115.L_CORE 0.002026
K_1705 X_NUC_13.L_CORE X_NUC_116.L_CORE 0.002035
K_1706 X_NUC_13.L_CORE X_NUC_117.L_CORE 0.006596
K_1707 X_NUC_13.L_CORE X_NUC_118.L_CORE 0.004707
K_1708 X_NUC_13.L_CORE X_NUC_119.L_CORE 0.003186
K_1709 X_NUC_13.L_CORE X_NUC_120.L_CORE 0.027464
K_1710 X_NUC_13.L_CORE X_NUC_121.L_CORE 0.002780
K_1711 X_NUC_13.L_CORE X_NUC_122.L_CORE 0.003611
K_1712 X_NUC_13.L_CORE X_NUC_123.L_CORE 0.004730
K_1713 X_NUC_13.L_CORE X_NUC_124.L_CORE 0.002314
K_1714 X_NUC_13.L_CORE X_NUC_125.L_CORE 0.005229
K_1715 X_NUC_13.L_CORE X_NUC_126.L_CORE 0.002621
K_1716 X_NUC_13.L_CORE X_NUC_127.L_CORE 0.002419
K_1717 X_NUC_13.L_CORE X_NUC_128.L_CORE 0.004353
K_1718 X_NUC_13.L_CORE X_NUC_129.L_CORE 0.002068
K_1719 X_NUC_13.L_CORE X_NUC_130.L_CORE 0.002923
K_1720 X_NUC_13.L_CORE X_NUC_131.L_CORE 0.002669
K_1721 X_NUC_13.L_CORE X_NUC_132.L_CORE 0.001996
K_1722 X_NUC_13.L_CORE X_NUC_133.L_CORE 0.003156
K_1723 X_NUC_13.L_CORE X_NUC_134.L_CORE 0.002035
K_1724 X_NUC_13.L_CORE X_NUC_135.L_CORE 0.002176
K_1725 X_NUC_13.L_CORE X_NUC_136.L_CORE 0.002524
K_1726 X_NUC_13.L_CORE X_NUC_137.L_CORE 0.001871
K_1727 X_NUC_13.L_CORE X_NUC_138.L_CORE 0.002300
K_1728 X_NUC_13.L_CORE X_NUC_139.L_CORE 0.002036
K_1729 X_NUC_13.L_CORE X_NUC_140.L_CORE 0.001945
K_1730 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_1731 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_1732 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.003106
K_1733 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.003095
K_1734 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.003077
K_1735 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.003121
K_1736 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.003971
K_1737 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.004038
K_1738 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.003978
K_1739 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.004015
K_1740 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.005751
K_1741 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.005612
K_1742 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.005622
K_1743 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.005672
K_1744 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.002563
K_1745 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.002570
K_1746 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.002548
K_1747 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.002578
K_1748 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.006368
K_1749 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.006523
K_1750 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.006393
K_1751 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.006337
K_1752 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.002992
K_1753 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.002967
K_1754 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.002954
K_1755 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.002986
K_1756 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.002682
K_1757 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.002705
K_1758 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.002674
K_1759 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.002697
K_1760 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.005768
K_1761 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.005686
K_1762 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.005663
K_1763 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.005615
K_1764 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.002303
K_1765 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.002301
K_1766 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.002284
K_1767 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.002307
K_1768 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.003383
K_1769 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.003428
K_1770 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.003380
K_1771 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.003385
K_1772 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.003166
K_1773 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.003132
K_1774 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.003120
K_1775 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.003138
K_1776 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.002203
K_1777 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.002212
K_1778 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.002190
K_1779 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.002209
K_1780 X_NUC_14.L_CORE X_NUC_65.L_CORE 0.004066
K_1781 X_NUC_14.L_CORE X_NUC_66.L_CORE 0.004080
K_1782 X_NUC_14.L_CORE X_NUC_67.L_CORE 0.004035
K_1783 X_NUC_14.L_CORE X_NUC_68.L_CORE 0.004009
K_1784 X_NUC_14.L_CORE X_NUC_69.L_CORE 0.002286
K_1785 X_NUC_14.L_CORE X_NUC_70.L_CORE 0.002277
K_1786 X_NUC_14.L_CORE X_NUC_71.L_CORE 0.002262
K_1787 X_NUC_14.L_CORE X_NUC_72.L_CORE 0.002281
K_1788 X_NUC_14.L_CORE X_NUC_73.L_CORE 0.002456
K_1789 X_NUC_14.L_CORE X_NUC_74.L_CORE 0.002475
K_1790 X_NUC_14.L_CORE X_NUC_75.L_CORE 0.002446
K_1791 X_NUC_14.L_CORE X_NUC_76.L_CORE 0.002458
K_1792 X_NUC_14.L_CORE X_NUC_77.L_CORE 0.003177
K_1793 X_NUC_14.L_CORE X_NUC_78.L_CORE 0.003154
K_1794 X_NUC_14.L_CORE X_NUC_79.L_CORE 0.003136
K_1795 X_NUC_14.L_CORE X_NUC_80.L_CORE 0.003136
K_1796 X_NUC_14.L_CORE X_NUC_81.L_CORE 0.002034
K_1797 X_NUC_14.L_CORE X_NUC_82.L_CORE 0.002035
K_1798 X_NUC_14.L_CORE X_NUC_83.L_CORE 0.002018
K_1799 X_NUC_14.L_CORE X_NUC_84.L_CORE 0.002034
K_1800 X_NUC_14.L_CORE X_NUC_85.L_CORE 0.002848
K_1801 X_NUC_14.L_CORE X_NUC_86.L_CORE 0.002866
K_1802 X_NUC_14.L_CORE X_NUC_87.L_CORE 0.002833
K_1803 X_NUC_14.L_CORE X_NUC_88.L_CORE 0.002832
K_1804 X_NUC_14.L_CORE X_NUC_89.L_CORE 0.002350
K_1805 X_NUC_14.L_CORE X_NUC_90.L_CORE 0.002339
K_1806 X_NUC_14.L_CORE X_NUC_91.L_CORE 0.002324
K_1807 X_NUC_14.L_CORE X_NUC_92.L_CORE 0.002336
K_1808 X_NUC_14.L_CORE X_NUC_93.L_CORE 0.002087
K_1809 X_NUC_14.L_CORE X_NUC_94.L_CORE 0.002096
K_1810 X_NUC_14.L_CORE X_NUC_95.L_CORE 0.002075
K_1811 X_NUC_14.L_CORE X_NUC_96.L_CORE 0.002087
K_1812 X_NUC_14.L_CORE X_NUC_97.L_CORE 0.002738
K_1813 X_NUC_14.L_CORE X_NUC_98.L_CORE 0.002735
K_1814 X_NUC_14.L_CORE X_NUC_99.L_CORE 0.002712
K_1815 X_NUC_14.L_CORE X_NUC_100.L_CORE 0.002711
K_1816 X_NUC_14.L_CORE X_NUC_101.L_CORE 0.002028
K_1817 X_NUC_14.L_CORE X_NUC_102.L_CORE 0.002026
K_1818 X_NUC_14.L_CORE X_NUC_103.L_CORE 0.002010
K_1819 X_NUC_14.L_CORE X_NUC_104.L_CORE 0.002023
K_1820 X_NUC_14.L_CORE X_NUC_105.L_CORE 0.002251
K_1821 X_NUC_14.L_CORE X_NUC_106.L_CORE 0.002259
K_1822 X_NUC_14.L_CORE X_NUC_107.L_CORE 0.002236
K_1823 X_NUC_14.L_CORE X_NUC_108.L_CORE 0.002242
K_1824 X_NUC_14.L_CORE X_NUC_109.L_CORE 0.002272
K_1825 X_NUC_14.L_CORE X_NUC_110.L_CORE 0.002267
K_1826 X_NUC_14.L_CORE X_NUC_111.L_CORE 0.002250
K_1827 X_NUC_14.L_CORE X_NUC_112.L_CORE 0.002256
K_1828 X_NUC_14.L_CORE X_NUC_113.L_CORE 0.002040
K_1829 X_NUC_14.L_CORE X_NUC_114.L_CORE 0.002042
K_1830 X_NUC_14.L_CORE X_NUC_115.L_CORE 0.002024
K_1831 X_NUC_14.L_CORE X_NUC_116.L_CORE 0.002033
K_1832 X_NUC_14.L_CORE X_NUC_117.L_CORE 0.006491
K_1833 X_NUC_14.L_CORE X_NUC_118.L_CORE 0.004766
K_1834 X_NUC_14.L_CORE X_NUC_119.L_CORE 0.003163
K_1835 X_NUC_14.L_CORE X_NUC_120.L_CORE 0.027936
K_1836 X_NUC_14.L_CORE X_NUC_121.L_CORE 0.002791
K_1837 X_NUC_14.L_CORE X_NUC_122.L_CORE 0.003555
K_1838 X_NUC_14.L_CORE X_NUC_123.L_CORE 0.004833
K_1839 X_NUC_14.L_CORE X_NUC_124.L_CORE 0.002308
K_1840 X_NUC_14.L_CORE X_NUC_125.L_CORE 0.005138
K_1841 X_NUC_14.L_CORE X_NUC_126.L_CORE 0.002641
K_1842 X_NUC_14.L_CORE X_NUC_127.L_CORE 0.002399
K_1843 X_NUC_14.L_CORE X_NUC_128.L_CORE 0.004397
K_1844 X_NUC_14.L_CORE X_NUC_129.L_CORE 0.002070
K_1845 X_NUC_14.L_CORE X_NUC_130.L_CORE 0.002893
K_1846 X_NUC_14.L_CORE X_NUC_131.L_CORE 0.002692
K_1847 X_NUC_14.L_CORE X_NUC_132.L_CORE 0.001989
K_1848 X_NUC_14.L_CORE X_NUC_133.L_CORE 0.003150
K_1849 X_NUC_14.L_CORE X_NUC_134.L_CORE 0.002042
K_1850 X_NUC_14.L_CORE X_NUC_135.L_CORE 0.002163
K_1851 X_NUC_14.L_CORE X_NUC_136.L_CORE 0.002535
K_1852 X_NUC_14.L_CORE X_NUC_137.L_CORE 0.001870
K_1853 X_NUC_14.L_CORE X_NUC_138.L_CORE 0.002293
K_1854 X_NUC_14.L_CORE X_NUC_139.L_CORE 0.002040
K_1855 X_NUC_14.L_CORE X_NUC_140.L_CORE 0.001942
K_1856 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_1857 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.003125
K_1858 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.003113
K_1859 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.003095
K_1860 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.003140
K_1861 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.004030
K_1862 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.004099
K_1863 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.004038
K_1864 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.004075
K_1865 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.005738
K_1866 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.005597
K_1867 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.005612
K_1868 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.005659
K_1869 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.002586
K_1870 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.002593
K_1871 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.002570
K_1872 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.002601
K_1873 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.006493
K_1874 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.006654
K_1875 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.006523
K_1876 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.006461
K_1877 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.003005
K_1878 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.002980
K_1879 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.002967
K_1880 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.002999
K_1881 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.002713
K_1882 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.002737
K_1883 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.002705
K_1884 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.002729
K_1885 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.005790
K_1886 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.005705
K_1887 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.005686
K_1888 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.005636
K_1889 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.002321
K_1890 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.002318
K_1891 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.002301
K_1892 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.002325
K_1893 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.003431
K_1894 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.003477
K_1895 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.003428
K_1896 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.003433
K_1897 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.003179
K_1898 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.003144
K_1899 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.003132
K_1900 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.003150
K_1901 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.002224
K_1902 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.002234
K_1903 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.002212
K_1904 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.002231
K_1905 X_NUC_15.L_CORE X_NUC_65.L_CORE 0.004111
K_1906 X_NUC_15.L_CORE X_NUC_66.L_CORE 0.004125
K_1907 X_NUC_15.L_CORE X_NUC_67.L_CORE 0.004080
K_1908 X_NUC_15.L_CORE X_NUC_68.L_CORE 0.004052
K_1909 X_NUC_15.L_CORE X_NUC_69.L_CORE 0.002301
K_1910 X_NUC_15.L_CORE X_NUC_70.L_CORE 0.002291
K_1911 X_NUC_15.L_CORE X_NUC_71.L_CORE 0.002277
K_1912 X_NUC_15.L_CORE X_NUC_72.L_CORE 0.002296
K_1913 X_NUC_15.L_CORE X_NUC_73.L_CORE 0.002484
K_1914 X_NUC_15.L_CORE X_NUC_74.L_CORE 0.002504
K_1915 X_NUC_15.L_CORE X_NUC_75.L_CORE 0.002475
K_1916 X_NUC_15.L_CORE X_NUC_76.L_CORE 0.002486
K_1917 X_NUC_15.L_CORE X_NUC_77.L_CORE 0.003196
K_1918 X_NUC_15.L_CORE X_NUC_78.L_CORE 0.003172
K_1919 X_NUC_15.L_CORE X_NUC_79.L_CORE 0.003154
K_1920 X_NUC_15.L_CORE X_NUC_80.L_CORE 0.003154
K_1921 X_NUC_15.L_CORE X_NUC_81.L_CORE 0.002051
K_1922 X_NUC_15.L_CORE X_NUC_82.L_CORE 0.002053
K_1923 X_NUC_15.L_CORE X_NUC_83.L_CORE 0.002035
K_1924 X_NUC_15.L_CORE X_NUC_84.L_CORE 0.002051
K_1925 X_NUC_15.L_CORE X_NUC_85.L_CORE 0.002881
K_1926 X_NUC_15.L_CORE X_NUC_86.L_CORE 0.002899
K_1927 X_NUC_15.L_CORE X_NUC_87.L_CORE 0.002866
K_1928 X_NUC_15.L_CORE X_NUC_88.L_CORE 0.002864
K_1929 X_NUC_15.L_CORE X_NUC_89.L_CORE 0.002366
K_1930 X_NUC_15.L_CORE X_NUC_90.L_CORE 0.002354
K_1931 X_NUC_15.L_CORE X_NUC_91.L_CORE 0.002339
K_1932 X_NUC_15.L_CORE X_NUC_92.L_CORE 0.002351
K_1933 X_NUC_15.L_CORE X_NUC_93.L_CORE 0.002108
K_1934 X_NUC_15.L_CORE X_NUC_94.L_CORE 0.002117
K_1935 X_NUC_15.L_CORE X_NUC_95.L_CORE 0.002096
K_1936 X_NUC_15.L_CORE X_NUC_96.L_CORE 0.002108
K_1937 X_NUC_15.L_CORE X_NUC_97.L_CORE 0.002762
K_1938 X_NUC_15.L_CORE X_NUC_98.L_CORE 0.002759
K_1939 X_NUC_15.L_CORE X_NUC_99.L_CORE 0.002735
K_1940 X_NUC_15.L_CORE X_NUC_100.L_CORE 0.002734
K_1941 X_NUC_15.L_CORE X_NUC_101.L_CORE 0.002044
K_1942 X_NUC_15.L_CORE X_NUC_102.L_CORE 0.002042
K_1943 X_NUC_15.L_CORE X_NUC_103.L_CORE 0.002026
K_1944 X_NUC_15.L_CORE X_NUC_104.L_CORE 0.002039
K_1945 X_NUC_15.L_CORE X_NUC_105.L_CORE 0.002274
K_1946 X_NUC_15.L_CORE X_NUC_106.L_CORE 0.002282
K_1947 X_NUC_15.L_CORE X_NUC_107.L_CORE 0.002259
K_1948 X_NUC_15.L_CORE X_NUC_108.L_CORE 0.002265
K_1949 X_NUC_15.L_CORE X_NUC_109.L_CORE 0.002290
K_1950 X_NUC_15.L_CORE X_NUC_110.L_CORE 0.002285
K_1951 X_NUC_15.L_CORE X_NUC_111.L_CORE 0.002267
K_1952 X_NUC_15.L_CORE X_NUC_112.L_CORE 0.002274
K_1953 X_NUC_15.L_CORE X_NUC_113.L_CORE 0.002058
K_1954 X_NUC_15.L_CORE X_NUC_114.L_CORE 0.002060
K_1955 X_NUC_15.L_CORE X_NUC_115.L_CORE 0.002042
K_1956 X_NUC_15.L_CORE X_NUC_116.L_CORE 0.002051
K_1957 X_NUC_15.L_CORE X_NUC_117.L_CORE 0.006538
K_1958 X_NUC_15.L_CORE X_NUC_118.L_CORE 0.004759
K_1959 X_NUC_15.L_CORE X_NUC_119.L_CORE 0.003192
K_1960 X_NUC_15.L_CORE X_NUC_120.L_CORE 0.025540
K_1961 X_NUC_15.L_CORE X_NUC_121.L_CORE 0.002804
K_1962 X_NUC_15.L_CORE X_NUC_122.L_CORE 0.003601
K_1963 X_NUC_15.L_CORE X_NUC_123.L_CORE 0.004814
K_1964 X_NUC_15.L_CORE X_NUC_124.L_CORE 0.002327
K_1965 X_NUC_15.L_CORE X_NUC_125.L_CORE 0.005207
K_1966 X_NUC_15.L_CORE X_NUC_126.L_CORE 0.002651
K_1967 X_NUC_15.L_CORE X_NUC_127.L_CORE 0.002425
K_1968 X_NUC_15.L_CORE X_NUC_128.L_CORE 0.004409
K_1969 X_NUC_15.L_CORE X_NUC_129.L_CORE 0.002085
K_1970 X_NUC_15.L_CORE X_NUC_130.L_CORE 0.002928
K_1971 X_NUC_15.L_CORE X_NUC_131.L_CORE 0.002703
K_1972 X_NUC_15.L_CORE X_NUC_132.L_CORE 0.002007
K_1973 X_NUC_15.L_CORE X_NUC_133.L_CORE 0.003178
K_1974 X_NUC_15.L_CORE X_NUC_134.L_CORE 0.002054
K_1975 X_NUC_15.L_CORE X_NUC_135.L_CORE 0.002186
K_1976 X_NUC_15.L_CORE X_NUC_136.L_CORE 0.002550
K_1977 X_NUC_15.L_CORE X_NUC_137.L_CORE 0.001885
K_1978 X_NUC_15.L_CORE X_NUC_138.L_CORE 0.002315
K_1979 X_NUC_15.L_CORE X_NUC_139.L_CORE 0.002055
K_1980 X_NUC_15.L_CORE X_NUC_140.L_CORE 0.001959
K_1981 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.003080
K_1982 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.003068
K_1983 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.003051
K_1984 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.003095
K_1985 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.003993
K_1986 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.004060
K_1987 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.004000
K_1988 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.004038
K_1989 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.005686
K_1990 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.005549
K_1991 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.005561
K_1992 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.005612
K_1993 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.002555
K_1994 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.002562
K_1995 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.002540
K_1996 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.002570
K_1997 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.006553
K_1998 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.006719
K_1999 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.006581
K_2000 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.006523
K_2001 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.002973
K_2002 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.002948
K_2003 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.002936
K_2004 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.002967
K_2005 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.002690
K_2006 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.002713
K_2007 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.002682
K_2008 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.002705
K_2009 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.005843
K_2010 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.005756
K_2011 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.005734
K_2012 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.005686
K_2013 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.002297
K_2014 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.002294
K_2015 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.002278
K_2016 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.002301
K_2017 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.003426
K_2018 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.003472
K_2019 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.003422
K_2020 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.003428
K_2021 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.003160
K_2022 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.003126
K_2023 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.003115
K_2024 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.003132
K_2025 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.002205
K_2026 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.002214
K_2027 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.002193
K_2028 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.002212
K_2029 X_NUC_16.L_CORE X_NUC_65.L_CORE 0.004140
K_2030 X_NUC_16.L_CORE X_NUC_66.L_CORE 0.004155
K_2031 X_NUC_16.L_CORE X_NUC_67.L_CORE 0.004108
K_2032 X_NUC_16.L_CORE X_NUC_68.L_CORE 0.004080
K_2033 X_NUC_16.L_CORE X_NUC_69.L_CORE 0.002282
K_2034 X_NUC_16.L_CORE X_NUC_70.L_CORE 0.002273
K_2035 X_NUC_16.L_CORE X_NUC_71.L_CORE 0.002258
K_2036 X_NUC_16.L_CORE X_NUC_72.L_CORE 0.002277
K_2037 X_NUC_16.L_CORE X_NUC_73.L_CORE 0.002472
K_2038 X_NUC_16.L_CORE X_NUC_74.L_CORE 0.002492
K_2039 X_NUC_16.L_CORE X_NUC_75.L_CORE 0.002463
K_2040 X_NUC_16.L_CORE X_NUC_76.L_CORE 0.002475
K_2041 X_NUC_16.L_CORE X_NUC_77.L_CORE 0.003195
K_2042 X_NUC_16.L_CORE X_NUC_78.L_CORE 0.003172
K_2043 X_NUC_16.L_CORE X_NUC_79.L_CORE 0.003153
K_2044 X_NUC_16.L_CORE X_NUC_80.L_CORE 0.003154
K_2045 X_NUC_16.L_CORE X_NUC_81.L_CORE 0.002035
K_2046 X_NUC_16.L_CORE X_NUC_82.L_CORE 0.002037
K_2047 X_NUC_16.L_CORE X_NUC_83.L_CORE 0.002020
K_2048 X_NUC_16.L_CORE X_NUC_84.L_CORE 0.002035
K_2049 X_NUC_16.L_CORE X_NUC_85.L_CORE 0.002883
K_2050 X_NUC_16.L_CORE X_NUC_86.L_CORE 0.002901
K_2051 X_NUC_16.L_CORE X_NUC_87.L_CORE 0.002867
K_2052 X_NUC_16.L_CORE X_NUC_88.L_CORE 0.002866
K_2053 X_NUC_16.L_CORE X_NUC_89.L_CORE 0.002353
K_2054 X_NUC_16.L_CORE X_NUC_90.L_CORE 0.002341
K_2055 X_NUC_16.L_CORE X_NUC_91.L_CORE 0.002327
K_2056 X_NUC_16.L_CORE X_NUC_92.L_CORE 0.002339
K_2057 X_NUC_16.L_CORE X_NUC_93.L_CORE 0.002097
K_2058 X_NUC_16.L_CORE X_NUC_94.L_CORE 0.002105
K_2059 X_NUC_16.L_CORE X_NUC_95.L_CORE 0.002084
K_2060 X_NUC_16.L_CORE X_NUC_96.L_CORE 0.002096
K_2061 X_NUC_16.L_CORE X_NUC_97.L_CORE 0.002763
K_2062 X_NUC_16.L_CORE X_NUC_98.L_CORE 0.002760
K_2063 X_NUC_16.L_CORE X_NUC_99.L_CORE 0.002736
K_2064 X_NUC_16.L_CORE X_NUC_100.L_CORE 0.002735
K_2065 X_NUC_16.L_CORE X_NUC_101.L_CORE 0.002032
K_2066 X_NUC_16.L_CORE X_NUC_102.L_CORE 0.002030
K_2067 X_NUC_16.L_CORE X_NUC_103.L_CORE 0.002014
K_2068 X_NUC_16.L_CORE X_NUC_104.L_CORE 0.002026
K_2069 X_NUC_16.L_CORE X_NUC_105.L_CORE 0.002267
K_2070 X_NUC_16.L_CORE X_NUC_106.L_CORE 0.002276
K_2071 X_NUC_16.L_CORE X_NUC_107.L_CORE 0.002253
K_2072 X_NUC_16.L_CORE X_NUC_108.L_CORE 0.002259
K_2073 X_NUC_16.L_CORE X_NUC_109.L_CORE 0.002283
K_2074 X_NUC_16.L_CORE X_NUC_110.L_CORE 0.002278
K_2075 X_NUC_16.L_CORE X_NUC_111.L_CORE 0.002260
K_2076 X_NUC_16.L_CORE X_NUC_112.L_CORE 0.002267
K_2077 X_NUC_16.L_CORE X_NUC_113.L_CORE 0.002049
K_2078 X_NUC_16.L_CORE X_NUC_114.L_CORE 0.002051
K_2079 X_NUC_16.L_CORE X_NUC_115.L_CORE 0.002033
K_2080 X_NUC_16.L_CORE X_NUC_116.L_CORE 0.002042
K_2081 X_NUC_16.L_CORE X_NUC_117.L_CORE 0.006401
K_2082 X_NUC_16.L_CORE X_NUC_118.L_CORE 0.004674
K_2083 X_NUC_16.L_CORE X_NUC_119.L_CORE 0.003150
K_2084 X_NUC_16.L_CORE X_NUC_120.L_CORE 0.028906
K_2085 X_NUC_16.L_CORE X_NUC_121.L_CORE 0.002768
K_2086 X_NUC_16.L_CORE X_NUC_122.L_CORE 0.003576
K_2087 X_NUC_16.L_CORE X_NUC_123.L_CORE 0.004794
K_2088 X_NUC_16.L_CORE X_NUC_124.L_CORE 0.002302
K_2089 X_NUC_16.L_CORE X_NUC_125.L_CORE 0.005264
K_2090 X_NUC_16.L_CORE X_NUC_126.L_CORE 0.002628
K_2091 X_NUC_16.L_CORE X_NUC_127.L_CORE 0.002408
K_2092 X_NUC_16.L_CORE X_NUC_128.L_CORE 0.004446
K_2093 X_NUC_16.L_CORE X_NUC_129.L_CORE 0.002066
K_2094 X_NUC_16.L_CORE X_NUC_130.L_CORE 0.002926
K_2095 X_NUC_16.L_CORE X_NUC_131.L_CORE 0.002692
K_2096 X_NUC_16.L_CORE X_NUC_132.L_CORE 0.001993
K_2097 X_NUC_16.L_CORE X_NUC_133.L_CORE 0.003193
K_2098 X_NUC_16.L_CORE X_NUC_134.L_CORE 0.002041
K_2099 X_NUC_16.L_CORE X_NUC_135.L_CORE 0.002177
K_2100 X_NUC_16.L_CORE X_NUC_136.L_CORE 0.002549
K_2101 X_NUC_16.L_CORE X_NUC_137.L_CORE 0.001873
K_2102 X_NUC_16.L_CORE X_NUC_138.L_CORE 0.002313
K_2103 X_NUC_16.L_CORE X_NUC_139.L_CORE 0.002047
K_2104 X_NUC_16.L_CORE X_NUC_140.L_CORE 0.001952
K_2105 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_2106 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_2107 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_2108 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.002824
K_2109 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.002856
K_2110 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.002849
K_2111 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.002828
K_2112 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.003733
K_2113 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.003714
K_2114 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.003749
K_2115 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.003686
K_2116 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.005300
K_2117 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.005425
K_2118 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.005311
K_2119 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.005355
K_2120 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.002407
K_2121 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.002420
K_2122 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.002422
K_2123 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.002398
K_2124 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.006470
K_2125 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.006324
K_2126 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.006355
K_2127 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.006283
K_2128 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.002824
K_2129 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.002860
K_2130 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.002837
K_2131 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.002830
K_2132 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.002583
K_2133 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.002582
K_2134 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.002591
K_2135 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.002560
K_2136 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.005845
K_2137 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.005882
K_2138 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.005728
K_2139 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.005812
K_2140 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.002208
K_2141 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.002224
K_2142 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.002218
K_2143 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.002203
K_2144 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.003376
K_2145 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.003349
K_2146 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.003357
K_2147 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.003323
K_2148 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.003082
K_2149 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.003119
K_2150 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.003078
K_2151 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.003085
K_2152 X_NUC_17.L_CORE X_NUC_65.L_CORE 0.002146
K_2153 X_NUC_17.L_CORE X_NUC_66.L_CORE 0.002152
K_2154 X_NUC_17.L_CORE X_NUC_67.L_CORE 0.002151
K_2155 X_NUC_17.L_CORE X_NUC_68.L_CORE 0.002132
K_2156 X_NUC_17.L_CORE X_NUC_69.L_CORE 0.004186
K_2157 X_NUC_17.L_CORE X_NUC_70.L_CORE 0.004158
K_2158 X_NUC_17.L_CORE X_NUC_71.L_CORE 0.004114
K_2159 X_NUC_17.L_CORE X_NUC_72.L_CORE 0.004120
K_2160 X_NUC_17.L_CORE X_NUC_73.L_CORE 0.002228
K_2161 X_NUC_17.L_CORE X_NUC_74.L_CORE 0.002247
K_2162 X_NUC_17.L_CORE X_NUC_75.L_CORE 0.002232
K_2163 X_NUC_17.L_CORE X_NUC_76.L_CORE 0.002224
K_2164 X_NUC_17.L_CORE X_NUC_77.L_CORE 0.002441
K_2165 X_NUC_17.L_CORE X_NUC_78.L_CORE 0.002436
K_2166 X_NUC_17.L_CORE X_NUC_79.L_CORE 0.002437
K_2167 X_NUC_17.L_CORE X_NUC_80.L_CORE 0.002416
K_2168 X_NUC_17.L_CORE X_NUC_81.L_CORE 0.003180
K_2169 X_NUC_17.L_CORE X_NUC_82.L_CORE 0.003199
K_2170 X_NUC_17.L_CORE X_NUC_83.L_CORE 0.003153
K_2171 X_NUC_17.L_CORE X_NUC_84.L_CORE 0.003165
K_2172 X_NUC_17.L_CORE X_NUC_85.L_CORE 0.002004
K_2173 X_NUC_17.L_CORE X_NUC_86.L_CORE 0.002013
K_2174 X_NUC_17.L_CORE X_NUC_87.L_CORE 0.002007
K_2175 X_NUC_17.L_CORE X_NUC_88.L_CORE 0.001994
K_2176 X_NUC_17.L_CORE X_NUC_89.L_CORE 0.002880
K_2177 X_NUC_17.L_CORE X_NUC_90.L_CORE 0.002868
K_2178 X_NUC_17.L_CORE X_NUC_91.L_CORE 0.002855
K_2179 X_NUC_17.L_CORE X_NUC_92.L_CORE 0.002843
K_2180 X_NUC_17.L_CORE X_NUC_93.L_CORE 0.002331
K_2181 X_NUC_17.L_CORE X_NUC_94.L_CORE 0.002347
K_2182 X_NUC_17.L_CORE X_NUC_95.L_CORE 0.002326
K_2183 X_NUC_17.L_CORE X_NUC_96.L_CORE 0.002323
K_2184 X_NUC_17.L_CORE X_NUC_97.L_CORE 0.002088
K_2185 X_NUC_17.L_CORE X_NUC_98.L_CORE 0.002090
K_2186 X_NUC_17.L_CORE X_NUC_99.L_CORE 0.002086
K_2187 X_NUC_17.L_CORE X_NUC_100.L_CORE 0.002072
K_2188 X_NUC_17.L_CORE X_NUC_101.L_CORE 0.002735
K_2189 X_NUC_17.L_CORE X_NUC_102.L_CORE 0.002738
K_2190 X_NUC_17.L_CORE X_NUC_103.L_CORE 0.002712
K_2191 X_NUC_17.L_CORE X_NUC_104.L_CORE 0.002711
K_2192 X_NUC_17.L_CORE X_NUC_105.L_CORE 0.002037
K_2193 X_NUC_17.L_CORE X_NUC_106.L_CORE 0.002046
K_2194 X_NUC_17.L_CORE X_NUC_107.L_CORE 0.002034
K_2195 X_NUC_17.L_CORE X_NUC_108.L_CORE 0.002026
K_2196 X_NUC_17.L_CORE X_NUC_109.L_CORE 0.002259
K_2197 X_NUC_17.L_CORE X_NUC_110.L_CORE 0.002259
K_2198 X_NUC_17.L_CORE X_NUC_111.L_CORE 0.002249
K_2199 X_NUC_17.L_CORE X_NUC_112.L_CORE 0.002238
K_2200 X_NUC_17.L_CORE X_NUC_113.L_CORE 0.002241
K_2201 X_NUC_17.L_CORE X_NUC_114.L_CORE 0.002249
K_2202 X_NUC_17.L_CORE X_NUC_115.L_CORE 0.002231
K_2203 X_NUC_17.L_CORE X_NUC_116.L_CORE 0.002227
K_2204 X_NUC_17.L_CORE X_NUC_117.L_CORE 0.003606
K_2205 X_NUC_17.L_CORE X_NUC_118.L_CORE 0.006100
K_2206 X_NUC_17.L_CORE X_NUC_119.L_CORE 0.004130
K_2207 X_NUC_17.L_CORE X_NUC_120.L_CORE 0.002810
K_2208 X_NUC_17.L_CORE X_NUC_121.L_CORE 0.025289
K_2209 X_NUC_17.L_CORE X_NUC_122.L_CORE 0.002564
K_2210 X_NUC_17.L_CORE X_NUC_123.L_CORE 0.003319
K_2211 X_NUC_17.L_CORE X_NUC_124.L_CORE 0.004585
K_2212 X_NUC_17.L_CORE X_NUC_125.L_CORE 0.002180
K_2213 X_NUC_17.L_CORE X_NUC_126.L_CORE 0.005077
K_2214 X_NUC_17.L_CORE X_NUC_127.L_CORE 0.002533
K_2215 X_NUC_17.L_CORE X_NUC_128.L_CORE 0.002313
K_2216 X_NUC_17.L_CORE X_NUC_129.L_CORE 0.004428
K_2217 X_NUC_17.L_CORE X_NUC_130.L_CORE 0.002006
K_2218 X_NUC_17.L_CORE X_NUC_131.L_CORE 0.002859
K_2219 X_NUC_17.L_CORE X_NUC_132.L_CORE 0.002657
K_2220 X_NUC_17.L_CORE X_NUC_133.L_CORE 0.001952
K_2221 X_NUC_17.L_CORE X_NUC_134.L_CORE 0.003162
K_2222 X_NUC_17.L_CORE X_NUC_135.L_CORE 0.002020
K_2223 X_NUC_17.L_CORE X_NUC_136.L_CORE 0.002152
K_2224 X_NUC_17.L_CORE X_NUC_137.L_CORE 0.002520
K_2225 X_NUC_17.L_CORE X_NUC_138.L_CORE 0.001878
K_2226 X_NUC_17.L_CORE X_NUC_139.L_CORE 0.002265
K_2227 X_NUC_17.L_CORE X_NUC_140.L_CORE 0.002046
K_2228 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_2229 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_2230 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.002792
K_2231 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.002824
K_2232 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.002817
K_2233 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.002796
K_2234 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.003752
K_2235 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.003733
K_2236 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.003769
K_2237 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.003705
K_2238 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.005180
K_2239 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.005300
K_2240 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.005192
K_2241 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.005234
K_2242 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.002393
K_2243 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.002407
K_2244 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.002408
K_2245 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.002385
K_2246 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.006620
K_2247 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.006470
K_2248 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.006500
K_2249 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.006424
K_2250 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.002788
K_2251 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.002824
K_2252 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.002802
K_2253 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.002795
K_2254 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.002584
K_2255 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.002583
K_2256 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.002591
K_2257 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.002561
K_2258 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.005805
K_2259 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.005845
K_2260 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.005692
K_2261 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.005775
K_2262 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.002192
K_2263 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.002208
K_2264 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.002201
K_2265 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.002187
K_2266 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.003402
K_2267 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.003376
K_2268 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.003384
K_2269 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.003349
K_2270 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.003046
K_2271 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.003082
K_2272 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.003042
K_2273 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.003049
K_2274 X_NUC_18.L_CORE X_NUC_65.L_CORE 0.002140
K_2275 X_NUC_18.L_CORE X_NUC_66.L_CORE 0.002146
K_2276 X_NUC_18.L_CORE X_NUC_67.L_CORE 0.002145
K_2277 X_NUC_18.L_CORE X_NUC_68.L_CORE 0.002126
K_2278 X_NUC_18.L_CORE X_NUC_69.L_CORE 0.004213
K_2279 X_NUC_18.L_CORE X_NUC_70.L_CORE 0.004186
K_2280 X_NUC_18.L_CORE X_NUC_71.L_CORE 0.004140
K_2281 X_NUC_18.L_CORE X_NUC_72.L_CORE 0.004146
K_2282 X_NUC_18.L_CORE X_NUC_73.L_CORE 0.002210
K_2283 X_NUC_18.L_CORE X_NUC_74.L_CORE 0.002228
K_2284 X_NUC_18.L_CORE X_NUC_75.L_CORE 0.002214
K_2285 X_NUC_18.L_CORE X_NUC_76.L_CORE 0.002206
K_2286 X_NUC_18.L_CORE X_NUC_77.L_CORE 0.002446
K_2287 X_NUC_18.L_CORE X_NUC_78.L_CORE 0.002441
K_2288 X_NUC_18.L_CORE X_NUC_79.L_CORE 0.002442
K_2289 X_NUC_18.L_CORE X_NUC_80.L_CORE 0.002420
K_2290 X_NUC_18.L_CORE X_NUC_81.L_CORE 0.003160
K_2291 X_NUC_18.L_CORE X_NUC_82.L_CORE 0.003180
K_2292 X_NUC_18.L_CORE X_NUC_83.L_CORE 0.003134
K_2293 X_NUC_18.L_CORE X_NUC_84.L_CORE 0.003146
K_2294 X_NUC_18.L_CORE X_NUC_85.L_CORE 0.001995
K_2295 X_NUC_18.L_CORE X_NUC_86.L_CORE 0.002004
K_2296 X_NUC_18.L_CORE X_NUC_87.L_CORE 0.001998
K_2297 X_NUC_18.L_CORE X_NUC_88.L_CORE 0.001985
K_2298 X_NUC_18.L_CORE X_NUC_89.L_CORE 0.002891
K_2299 X_NUC_18.L_CORE X_NUC_90.L_CORE 0.002880
K_2300 X_NUC_18.L_CORE X_NUC_91.L_CORE 0.002867
K_2301 X_NUC_18.L_CORE X_NUC_92.L_CORE 0.002854
K_2302 X_NUC_18.L_CORE X_NUC_93.L_CORE 0.002314
K_2303 X_NUC_18.L_CORE X_NUC_94.L_CORE 0.002331
K_2304 X_NUC_18.L_CORE X_NUC_95.L_CORE 0.002310
K_2305 X_NUC_18.L_CORE X_NUC_96.L_CORE 0.002307
K_2306 X_NUC_18.L_CORE X_NUC_97.L_CORE 0.002085
K_2307 X_NUC_18.L_CORE X_NUC_98.L_CORE 0.002088
K_2308 X_NUC_18.L_CORE X_NUC_99.L_CORE 0.002083
K_2309 X_NUC_18.L_CORE X_NUC_100.L_CORE 0.002069
K_2310 X_NUC_18.L_CORE X_NUC_101.L_CORE 0.002732
K_2311 X_NUC_18.L_CORE X_NUC_102.L_CORE 0.002735
K_2312 X_NUC_18.L_CORE X_NUC_103.L_CORE 0.002709
K_2313 X_NUC_18.L_CORE X_NUC_104.L_CORE 0.002709
K_2314 X_NUC_18.L_CORE X_NUC_105.L_CORE 0.002027
K_2315 X_NUC_18.L_CORE X_NUC_106.L_CORE 0.002037
K_2316 X_NUC_18.L_CORE X_NUC_107.L_CORE 0.002025
K_2317 X_NUC_18.L_CORE X_NUC_108.L_CORE 0.002017
K_2318 X_NUC_18.L_CORE X_NUC_109.L_CORE 0.002259
K_2319 X_NUC_18.L_CORE X_NUC_110.L_CORE 0.002259
K_2320 X_NUC_18.L_CORE X_NUC_111.L_CORE 0.002248
K_2321 X_NUC_18.L_CORE X_NUC_112.L_CORE 0.002238
K_2322 X_NUC_18.L_CORE X_NUC_113.L_CORE 0.002234
K_2323 X_NUC_18.L_CORE X_NUC_114.L_CORE 0.002241
K_2324 X_NUC_18.L_CORE X_NUC_115.L_CORE 0.002224
K_2325 X_NUC_18.L_CORE X_NUC_116.L_CORE 0.002220
K_2326 X_NUC_18.L_CORE X_NUC_117.L_CORE 0.003570
K_2327 X_NUC_18.L_CORE X_NUC_118.L_CORE 0.006136
K_2328 X_NUC_18.L_CORE X_NUC_119.L_CORE 0.004052
K_2329 X_NUC_18.L_CORE X_NUC_120.L_CORE 0.002802
K_2330 X_NUC_18.L_CORE X_NUC_121.L_CORE 0.027180
K_2331 X_NUC_18.L_CORE X_NUC_122.L_CORE 0.002537
K_2332 X_NUC_18.L_CORE X_NUC_123.L_CORE 0.003339
K_2333 X_NUC_18.L_CORE X_NUC_124.L_CORE 0.004502
K_2334 X_NUC_18.L_CORE X_NUC_125.L_CORE 0.002169
K_2335 X_NUC_18.L_CORE X_NUC_126.L_CORE 0.005174
K_2336 X_NUC_18.L_CORE X_NUC_127.L_CORE 0.002504
K_2337 X_NUC_18.L_CORE X_NUC_128.L_CORE 0.002315
K_2338 X_NUC_18.L_CORE X_NUC_129.L_CORE 0.004415
K_2339 X_NUC_18.L_CORE X_NUC_130.L_CORE 0.001993
K_2340 X_NUC_18.L_CORE X_NUC_131.L_CORE 0.002878
K_2341 X_NUC_18.L_CORE X_NUC_132.L_CORE 0.002633
K_2342 X_NUC_18.L_CORE X_NUC_133.L_CORE 0.001947
K_2343 X_NUC_18.L_CORE X_NUC_134.L_CORE 0.003175
K_2344 X_NUC_18.L_CORE X_NUC_135.L_CORE 0.002006
K_2345 X_NUC_18.L_CORE X_NUC_136.L_CORE 0.002155
K_2346 X_NUC_18.L_CORE X_NUC_137.L_CORE 0.002510
K_2347 X_NUC_18.L_CORE X_NUC_138.L_CORE 0.001871
K_2348 X_NUC_18.L_CORE X_NUC_139.L_CORE 0.002267
K_2349 X_NUC_18.L_CORE X_NUC_140.L_CORE 0.002039
K_2350 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_2351 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.002799
K_2352 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.002831
K_2353 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.002824
K_2354 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.002803
K_2355 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.003717
K_2356 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.003698
K_2357 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.003733
K_2358 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.003671
K_2359 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.005285
K_2360 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.005411
K_2361 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.005300
K_2362 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.005342
K_2363 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.002391
K_2364 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.002404
K_2365 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.002407
K_2366 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.002383
K_2367 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.006586
K_2368 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.006435
K_2369 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.006470
K_2370 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.006392
K_2371 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.002810
K_2372 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.002846
K_2373 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.002824
K_2374 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.002816
K_2375 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.002575
K_2376 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.002574
K_2377 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.002583
K_2378 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.002553
K_2379 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.005965
K_2380 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006007
K_2381 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.005845
K_2382 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.005933
K_2383 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.002198
K_2384 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.002214
K_2385 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.002208
K_2386 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.002193
K_2387 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.003394
K_2388 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.003367
K_2389 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.003376
K_2390 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.003340
K_2391 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.003086
K_2392 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.003123
K_2393 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.003082
K_2394 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.003089
K_2395 X_NUC_19.L_CORE X_NUC_65.L_CORE 0.002140
K_2396 X_NUC_19.L_CORE X_NUC_66.L_CORE 0.002146
K_2397 X_NUC_19.L_CORE X_NUC_67.L_CORE 0.002146
K_2398 X_NUC_19.L_CORE X_NUC_68.L_CORE 0.002127
K_2399 X_NUC_19.L_CORE X_NUC_69.L_CORE 0.004260
K_2400 X_NUC_19.L_CORE X_NUC_70.L_CORE 0.004232
K_2401 X_NUC_19.L_CORE X_NUC_71.L_CORE 0.004186
K_2402 X_NUC_19.L_CORE X_NUC_72.L_CORE 0.004191
K_2403 X_NUC_19.L_CORE X_NUC_73.L_CORE 0.002224
K_2404 X_NUC_19.L_CORE X_NUC_74.L_CORE 0.002243
K_2405 X_NUC_19.L_CORE X_NUC_75.L_CORE 0.002228
K_2406 X_NUC_19.L_CORE X_NUC_76.L_CORE 0.002220
K_2407 X_NUC_19.L_CORE X_NUC_77.L_CORE 0.002446
K_2408 X_NUC_19.L_CORE X_NUC_78.L_CORE 0.002441
K_2409 X_NUC_19.L_CORE X_NUC_79.L_CORE 0.002441
K_2410 X_NUC_19.L_CORE X_NUC_80.L_CORE 0.002420
K_2411 X_NUC_19.L_CORE X_NUC_81.L_CORE 0.003206
K_2412 X_NUC_19.L_CORE X_NUC_82.L_CORE 0.003226
K_2413 X_NUC_19.L_CORE X_NUC_83.L_CORE 0.003180
K_2414 X_NUC_19.L_CORE X_NUC_84.L_CORE 0.003191
K_2415 X_NUC_19.L_CORE X_NUC_85.L_CORE 0.002001
K_2416 X_NUC_19.L_CORE X_NUC_86.L_CORE 0.002010
K_2417 X_NUC_19.L_CORE X_NUC_87.L_CORE 0.002004
K_2418 X_NUC_19.L_CORE X_NUC_88.L_CORE 0.001992
K_2419 X_NUC_19.L_CORE X_NUC_89.L_CORE 0.002905
K_2420 X_NUC_19.L_CORE X_NUC_90.L_CORE 0.002893
K_2421 X_NUC_19.L_CORE X_NUC_91.L_CORE 0.002880
K_2422 X_NUC_19.L_CORE X_NUC_92.L_CORE 0.002867
K_2423 X_NUC_19.L_CORE X_NUC_93.L_CORE 0.002335
K_2424 X_NUC_19.L_CORE X_NUC_94.L_CORE 0.002352
K_2425 X_NUC_19.L_CORE X_NUC_95.L_CORE 0.002331
K_2426 X_NUC_19.L_CORE X_NUC_96.L_CORE 0.002328
K_2427 X_NUC_19.L_CORE X_NUC_97.L_CORE 0.002090
K_2428 X_NUC_19.L_CORE X_NUC_98.L_CORE 0.002093
K_2429 X_NUC_19.L_CORE X_NUC_99.L_CORE 0.002088
K_2430 X_NUC_19.L_CORE X_NUC_100.L_CORE 0.002074
K_2431 X_NUC_19.L_CORE X_NUC_101.L_CORE 0.002759
K_2432 X_NUC_19.L_CORE X_NUC_102.L_CORE 0.002762
K_2433 X_NUC_19.L_CORE X_NUC_103.L_CORE 0.002735
K_2434 X_NUC_19.L_CORE X_NUC_104.L_CORE 0.002735
K_2435 X_NUC_19.L_CORE X_NUC_105.L_CORE 0.002039
K_2436 X_NUC_19.L_CORE X_NUC_106.L_CORE 0.002048
K_2437 X_NUC_19.L_CORE X_NUC_107.L_CORE 0.002037
K_2438 X_NUC_19.L_CORE X_NUC_108.L_CORE 0.002028
K_2439 X_NUC_19.L_CORE X_NUC_109.L_CORE 0.002269
K_2440 X_NUC_19.L_CORE X_NUC_110.L_CORE 0.002269
K_2441 X_NUC_19.L_CORE X_NUC_111.L_CORE 0.002259
K_2442 X_NUC_19.L_CORE X_NUC_112.L_CORE 0.002248
K_2443 X_NUC_19.L_CORE X_NUC_113.L_CORE 0.002251
K_2444 X_NUC_19.L_CORE X_NUC_114.L_CORE 0.002259
K_2445 X_NUC_19.L_CORE X_NUC_115.L_CORE 0.002241
K_2446 X_NUC_19.L_CORE X_NUC_116.L_CORE 0.002236
K_2447 X_NUC_19.L_CORE X_NUC_117.L_CORE 0.003550
K_2448 X_NUC_19.L_CORE X_NUC_118.L_CORE 0.005986
K_2449 X_NUC_19.L_CORE X_NUC_119.L_CORE 0.004073
K_2450 X_NUC_19.L_CORE X_NUC_120.L_CORE 0.002786
K_2451 X_NUC_19.L_CORE X_NUC_121.L_CORE 0.027441
K_2452 X_NUC_19.L_CORE X_NUC_122.L_CORE 0.002544
K_2453 X_NUC_19.L_CORE X_NUC_123.L_CORE 0.003311
K_2454 X_NUC_19.L_CORE X_NUC_124.L_CORE 0.004588
K_2455 X_NUC_19.L_CORE X_NUC_125.L_CORE 0.002168
K_2456 X_NUC_19.L_CORE X_NUC_126.L_CORE 0.005164
K_2457 X_NUC_19.L_CORE X_NUC_127.L_CORE 0.002524
K_2458 X_NUC_19.L_CORE X_NUC_128.L_CORE 0.002309
K_2459 X_NUC_19.L_CORE X_NUC_129.L_CORE 0.004504
K_2460 X_NUC_19.L_CORE X_NUC_130.L_CORE 0.001999
K_2461 X_NUC_19.L_CORE X_NUC_131.L_CORE 0.002876
K_2462 X_NUC_19.L_CORE X_NUC_132.L_CORE 0.002664
K_2463 X_NUC_19.L_CORE X_NUC_133.L_CORE 0.001949
K_2464 X_NUC_19.L_CORE X_NUC_134.L_CORE 0.003203
K_2465 X_NUC_19.L_CORE X_NUC_135.L_CORE 0.002019
K_2466 X_NUC_19.L_CORE X_NUC_136.L_CORE 0.002158
K_2467 X_NUC_19.L_CORE X_NUC_137.L_CORE 0.002537
K_2468 X_NUC_19.L_CORE X_NUC_138.L_CORE 0.001879
K_2469 X_NUC_19.L_CORE X_NUC_139.L_CORE 0.002279
K_2470 X_NUC_19.L_CORE X_NUC_140.L_CORE 0.002053
K_2471 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.002819
K_2472 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.002852
K_2473 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.002845
K_2474 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.002824
K_2475 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.003781
K_2476 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.003761
K_2477 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.003798
K_2478 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.003733
K_2479 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.005242
K_2480 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.005365
K_2481 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.005255
K_2482 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.005300
K_2483 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.002415
K_2484 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.002429
K_2485 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.002431
K_2486 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.002407
K_2487 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.006668
K_2488 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.006512
K_2489 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.006545
K_2490 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.006470
K_2491 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.002817
K_2492 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.002854
K_2493 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.002831
K_2494 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.002824
K_2495 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.002606
K_2496 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.002605
K_2497 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.002614
K_2498 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.002583
K_2499 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.005874
K_2500 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.005914
K_2501 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.005757
K_2502 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.005845
K_2503 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.002213
K_2504 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.002229
K_2505 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.002223
K_2506 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.002208
K_2507 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.003430
K_2508 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.003403
K_2509 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.003412
K_2510 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.003376
K_2511 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.003079
K_2512 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.003116
K_2513 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.003075
K_2514 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.003082
K_2515 X_NUC_20.L_CORE X_NUC_65.L_CORE 0.002159
K_2516 X_NUC_20.L_CORE X_NUC_66.L_CORE 0.002165
K_2517 X_NUC_20.L_CORE X_NUC_67.L_CORE 0.002165
K_2518 X_NUC_20.L_CORE X_NUC_68.L_CORE 0.002146
K_2519 X_NUC_20.L_CORE X_NUC_69.L_CORE 0.004254
K_2520 X_NUC_20.L_CORE X_NUC_70.L_CORE 0.004225
K_2521 X_NUC_20.L_CORE X_NUC_71.L_CORE 0.004179
K_2522 X_NUC_20.L_CORE X_NUC_72.L_CORE 0.004186
K_2523 X_NUC_20.L_CORE X_NUC_73.L_CORE 0.002232
K_2524 X_NUC_20.L_CORE X_NUC_74.L_CORE 0.002251
K_2525 X_NUC_20.L_CORE X_NUC_75.L_CORE 0.002236
K_2526 X_NUC_20.L_CORE X_NUC_76.L_CORE 0.002228
K_2527 X_NUC_20.L_CORE X_NUC_77.L_CORE 0.002468
K_2528 X_NUC_20.L_CORE X_NUC_78.L_CORE 0.002463
K_2529 X_NUC_20.L_CORE X_NUC_79.L_CORE 0.002463
K_2530 X_NUC_20.L_CORE X_NUC_80.L_CORE 0.002441
K_2531 X_NUC_20.L_CORE X_NUC_81.L_CORE 0.003194
K_2532 X_NUC_20.L_CORE X_NUC_82.L_CORE 0.003214
K_2533 X_NUC_20.L_CORE X_NUC_83.L_CORE 0.003167
K_2534 X_NUC_20.L_CORE X_NUC_84.L_CORE 0.003180
K_2535 X_NUC_20.L_CORE X_NUC_85.L_CORE 0.002014
K_2536 X_NUC_20.L_CORE X_NUC_86.L_CORE 0.002023
K_2537 X_NUC_20.L_CORE X_NUC_87.L_CORE 0.002017
K_2538 X_NUC_20.L_CORE X_NUC_88.L_CORE 0.002004
K_2539 X_NUC_20.L_CORE X_NUC_89.L_CORE 0.002918
K_2540 X_NUC_20.L_CORE X_NUC_90.L_CORE 0.002906
K_2541 X_NUC_20.L_CORE X_NUC_91.L_CORE 0.002893
K_2542 X_NUC_20.L_CORE X_NUC_92.L_CORE 0.002880
K_2543 X_NUC_20.L_CORE X_NUC_93.L_CORE 0.002338
K_2544 X_NUC_20.L_CORE X_NUC_94.L_CORE 0.002354
K_2545 X_NUC_20.L_CORE X_NUC_95.L_CORE 0.002333
K_2546 X_NUC_20.L_CORE X_NUC_96.L_CORE 0.002331
K_2547 X_NUC_20.L_CORE X_NUC_97.L_CORE 0.002105
K_2548 X_NUC_20.L_CORE X_NUC_98.L_CORE 0.002107
K_2549 X_NUC_20.L_CORE X_NUC_99.L_CORE 0.002102
K_2550 X_NUC_20.L_CORE X_NUC_100.L_CORE 0.002088
K_2551 X_NUC_20.L_CORE X_NUC_101.L_CORE 0.002760
K_2552 X_NUC_20.L_CORE X_NUC_102.L_CORE 0.002763
K_2553 X_NUC_20.L_CORE X_NUC_103.L_CORE 0.002736
K_2554 X_NUC_20.L_CORE X_NUC_104.L_CORE 0.002735
K_2555 X_NUC_20.L_CORE X_NUC_105.L_CORE 0.002047
K_2556 X_NUC_20.L_CORE X_NUC_106.L_CORE 0.002057
K_2557 X_NUC_20.L_CORE X_NUC_107.L_CORE 0.002045
K_2558 X_NUC_20.L_CORE X_NUC_108.L_CORE 0.002037
K_2559 X_NUC_20.L_CORE X_NUC_109.L_CORE 0.002280
K_2560 X_NUC_20.L_CORE X_NUC_110.L_CORE 0.002280
K_2561 X_NUC_20.L_CORE X_NUC_111.L_CORE 0.002269
K_2562 X_NUC_20.L_CORE X_NUC_112.L_CORE 0.002259
K_2563 X_NUC_20.L_CORE X_NUC_113.L_CORE 0.002256
K_2564 X_NUC_20.L_CORE X_NUC_114.L_CORE 0.002264
K_2565 X_NUC_20.L_CORE X_NUC_115.L_CORE 0.002246
K_2566 X_NUC_20.L_CORE X_NUC_116.L_CORE 0.002241
K_2567 X_NUC_20.L_CORE X_NUC_117.L_CORE 0.003595
K_2568 X_NUC_20.L_CORE X_NUC_118.L_CORE 0.006140
K_2569 X_NUC_20.L_CORE X_NUC_119.L_CORE 0.004086
K_2570 X_NUC_20.L_CORE X_NUC_120.L_CORE 0.002823
K_2571 X_NUC_20.L_CORE X_NUC_121.L_CORE 0.024782
K_2572 X_NUC_20.L_CORE X_NUC_122.L_CORE 0.002560
K_2573 X_NUC_20.L_CORE X_NUC_123.L_CORE 0.003360
K_2574 X_NUC_20.L_CORE X_NUC_124.L_CORE 0.004542
K_2575 X_NUC_20.L_CORE X_NUC_125.L_CORE 0.002187
K_2576 X_NUC_20.L_CORE X_NUC_126.L_CORE 0.005193
K_2577 X_NUC_20.L_CORE X_NUC_127.L_CORE 0.002528
K_2578 X_NUC_20.L_CORE X_NUC_128.L_CORE 0.002333
K_2579 X_NUC_20.L_CORE X_NUC_129.L_CORE 0.004451
K_2580 X_NUC_20.L_CORE X_NUC_130.L_CORE 0.002011
K_2581 X_NUC_20.L_CORE X_NUC_131.L_CORE 0.002899
K_2582 X_NUC_20.L_CORE X_NUC_132.L_CORE 0.002658
K_2583 X_NUC_20.L_CORE X_NUC_133.L_CORE 0.001964
K_2584 X_NUC_20.L_CORE X_NUC_134.L_CORE 0.003200
K_2585 X_NUC_20.L_CORE X_NUC_135.L_CORE 0.002025
K_2586 X_NUC_20.L_CORE X_NUC_136.L_CORE 0.002173
K_2587 X_NUC_20.L_CORE X_NUC_137.L_CORE 0.002534
K_2588 X_NUC_20.L_CORE X_NUC_138.L_CORE 0.001888
K_2589 X_NUC_20.L_CORE X_NUC_139.L_CORE 0.002286
K_2590 X_NUC_20.L_CORE X_NUC_140.L_CORE 0.002058
K_2591 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_2592 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_2593 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_2594 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.002633
K_2595 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.002600
K_2596 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.002618
K_2597 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.002612
K_2598 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.003512
K_2599 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.003486
K_2600 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.003468
K_2601 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.003520
K_2602 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.005057
K_2603 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.004997
K_2604 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.005054
K_2605 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.004955
K_2606 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.002287
K_2607 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.002263
K_2608 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.002268
K_2609 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.002276
K_2610 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.006399
K_2611 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.006440
K_2612 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.006266
K_2613 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.006420
K_2614 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.002716
K_2615 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.002687
K_2616 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.002702
K_2617 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.002686
K_2618 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.002492
K_2619 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.002473
K_2620 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.002465
K_2621 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.002486
K_2622 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.005959
K_2623 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.005975
K_2624 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.005913
K_2625 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.005824
K_2626 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.002140
K_2627 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.002119
K_2628 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.002124
K_2629 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.002124
K_2630 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.003332
K_2631 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.003325
K_2632 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.003286
K_2633 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.003328
K_2634 X_NUC_21.L_CORE X_NUC_65.L_CORE 0.003043
K_2635 X_NUC_21.L_CORE X_NUC_66.L_CORE 0.003019
K_2636 X_NUC_21.L_CORE X_NUC_67.L_CORE 0.003026
K_2637 X_NUC_21.L_CORE X_NUC_68.L_CORE 0.002999
K_2638 X_NUC_21.L_CORE X_NUC_69.L_CORE 0.002099
K_2639 X_NUC_21.L_CORE X_NUC_70.L_CORE 0.002083
K_2640 X_NUC_21.L_CORE X_NUC_71.L_CORE 0.002080
K_2641 X_NUC_21.L_CORE X_NUC_72.L_CORE 0.002089
K_2642 X_NUC_21.L_CORE X_NUC_73.L_CORE 0.004260
K_2643 X_NUC_21.L_CORE X_NUC_74.L_CORE 0.004278
K_2644 X_NUC_21.L_CORE X_NUC_75.L_CORE 0.004203
K_2645 X_NUC_21.L_CORE X_NUC_76.L_CORE 0.004218
K_2646 X_NUC_21.L_CORE X_NUC_77.L_CORE 0.002196
K_2647 X_NUC_21.L_CORE X_NUC_78.L_CORE 0.002178
K_2648 X_NUC_21.L_CORE X_NUC_79.L_CORE 0.002181
K_2649 X_NUC_21.L_CORE X_NUC_80.L_CORE 0.002176
K_2650 X_NUC_21.L_CORE X_NUC_81.L_CORE 0.002420
K_2651 X_NUC_21.L_CORE X_NUC_82.L_CORE 0.002408
K_2652 X_NUC_21.L_CORE X_NUC_83.L_CORE 0.002393
K_2653 X_NUC_21.L_CORE X_NUC_84.L_CORE 0.002411
K_2654 X_NUC_21.L_CORE X_NUC_85.L_CORE 0.003193
K_2655 X_NUC_21.L_CORE X_NUC_86.L_CORE 0.003184
K_2656 X_NUC_21.L_CORE X_NUC_87.L_CORE 0.003168
K_2657 X_NUC_21.L_CORE X_NUC_88.L_CORE 0.003148
K_2658 X_NUC_21.L_CORE X_NUC_89.L_CORE 0.001989
K_2659 X_NUC_21.L_CORE X_NUC_90.L_CORE 0.001974
K_2660 X_NUC_21.L_CORE X_NUC_91.L_CORE 0.001973
K_2661 X_NUC_21.L_CORE X_NUC_92.L_CORE 0.001975
K_2662 X_NUC_21.L_CORE X_NUC_93.L_CORE 0.002884
K_2663 X_NUC_21.L_CORE X_NUC_94.L_CORE 0.002881
K_2664 X_NUC_21.L_CORE X_NUC_95.L_CORE 0.002849
K_2665 X_NUC_21.L_CORE X_NUC_96.L_CORE 0.002866
K_2666 X_NUC_21.L_CORE X_NUC_97.L_CORE 0.002331
K_2667 X_NUC_21.L_CORE X_NUC_98.L_CORE 0.002316
K_2668 X_NUC_21.L_CORE X_NUC_99.L_CORE 0.002313
K_2669 X_NUC_21.L_CORE X_NUC_100.L_CORE 0.002305
K_2670 X_NUC_21.L_CORE X_NUC_101.L_CORE 0.002096
K_2671 X_NUC_21.L_CORE X_NUC_102.L_CORE 0.002084
K_2672 X_NUC_21.L_CORE X_NUC_103.L_CORE 0.002075
K_2673 X_NUC_21.L_CORE X_NUC_104.L_CORE 0.002083
K_2674 X_NUC_21.L_CORE X_NUC_105.L_CORE 0.002708
K_2675 X_NUC_21.L_CORE X_NUC_106.L_CORE 0.002702
K_2676 X_NUC_21.L_CORE X_NUC_107.L_CORE 0.002681
K_2677 X_NUC_21.L_CORE X_NUC_108.L_CORE 0.002680
K_2678 X_NUC_21.L_CORE X_NUC_109.L_CORE 0.002071
K_2679 X_NUC_21.L_CORE X_NUC_110.L_CORE 0.002058
K_2680 X_NUC_21.L_CORE X_NUC_111.L_CORE 0.002053
K_2681 X_NUC_21.L_CORE X_NUC_112.L_CORE 0.002053
K_2682 X_NUC_21.L_CORE X_NUC_113.L_CORE 0.002254
K_2683 X_NUC_21.L_CORE X_NUC_114.L_CORE 0.002245
K_2684 X_NUC_21.L_CORE X_NUC_115.L_CORE 0.002231
K_2685 X_NUC_21.L_CORE X_NUC_116.L_CORE 0.002237
K_2686 X_NUC_21.L_CORE X_NUC_117.L_CORE 0.005598
K_2687 X_NUC_21.L_CORE X_NUC_118.L_CORE 0.002885
K_2688 X_NUC_21.L_CORE X_NUC_119.L_CORE 0.005604
K_2689 X_NUC_21.L_CORE X_NUC_120.L_CORE 0.003663
K_2690 X_NUC_21.L_CORE X_NUC_121.L_CORE 0.002553
K_2691 X_NUC_21.L_CORE X_NUC_122.L_CORE 0.026360
K_2692 X_NUC_21.L_CORE X_NUC_123.L_CORE 0.002373
K_2693 X_NUC_21.L_CORE X_NUC_124.L_CORE 0.003137
K_2694 X_NUC_21.L_CORE X_NUC_125.L_CORE 0.004341
K_2695 X_NUC_21.L_CORE X_NUC_126.L_CORE 0.002066
K_2696 X_NUC_21.L_CORE X_NUC_127.L_CORE 0.005077
K_2697 X_NUC_21.L_CORE X_NUC_128.L_CORE 0.002424
K_2698 X_NUC_21.L_CORE X_NUC_129.L_CORE 0.002238
K_2699 X_NUC_21.L_CORE X_NUC_130.L_CORE 0.004444
K_2700 X_NUC_21.L_CORE X_NUC_131.L_CORE 0.001943
K_2701 X_NUC_21.L_CORE X_NUC_132.L_CORE 0.002835
K_2702 X_NUC_21.L_CORE X_NUC_133.L_CORE 0.002610
K_2703 X_NUC_21.L_CORE X_NUC_134.L_CORE 0.001918
K_2704 X_NUC_21.L_CORE X_NUC_135.L_CORE 0.003160
K_2705 X_NUC_21.L_CORE X_NUC_136.L_CORE 0.001997
K_2706 X_NUC_21.L_CORE X_NUC_137.L_CORE 0.002144
K_2707 X_NUC_21.L_CORE X_NUC_138.L_CORE 0.002481
K_2708 X_NUC_21.L_CORE X_NUC_139.L_CORE 0.001900
K_2709 X_NUC_21.L_CORE X_NUC_140.L_CORE 0.002198
K_2710 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_2711 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_2712 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.002666
K_2713 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.002633
K_2714 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.002651
K_2715 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.002645
K_2716 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.003538
K_2717 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.003512
K_2718 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.003493
K_2719 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.003547
K_2720 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.005116
K_2721 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.005057
K_2722 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.005115
K_2723 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.005012
K_2724 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.002310
K_2725 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.002287
K_2726 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.002292
K_2727 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.002299
K_2728 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.006353
K_2729 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.006399
K_2730 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.006225
K_2731 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.006376
K_2732 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.002746
K_2733 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.002716
K_2734 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.002732
K_2735 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.002715
K_2736 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.002511
K_2737 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.002492
K_2738 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.002484
K_2739 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.002505
K_2740 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.005937
K_2741 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.005959
K_2742 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.005895
K_2743 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.005806
K_2744 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.002161
K_2745 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.002140
K_2746 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.002145
K_2747 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.002145
K_2748 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.003339
K_2749 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.003332
K_2750 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.003293
K_2751 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.003335
K_2752 X_NUC_22.L_CORE X_NUC_65.L_CORE 0.003066
K_2753 X_NUC_22.L_CORE X_NUC_66.L_CORE 0.003043
K_2754 X_NUC_22.L_CORE X_NUC_67.L_CORE 0.003050
K_2755 X_NUC_22.L_CORE X_NUC_68.L_CORE 0.003022
K_2756 X_NUC_22.L_CORE X_NUC_69.L_CORE 0.002116
K_2757 X_NUC_22.L_CORE X_NUC_70.L_CORE 0.002099
K_2758 X_NUC_22.L_CORE X_NUC_71.L_CORE 0.002096
K_2759 X_NUC_22.L_CORE X_NUC_72.L_CORE 0.002106
K_2760 X_NUC_22.L_CORE X_NUC_73.L_CORE 0.004241
K_2761 X_NUC_22.L_CORE X_NUC_74.L_CORE 0.004260
K_2762 X_NUC_22.L_CORE X_NUC_75.L_CORE 0.004185
K_2763 X_NUC_22.L_CORE X_NUC_76.L_CORE 0.004200
K_2764 X_NUC_22.L_CORE X_NUC_77.L_CORE 0.002215
K_2765 X_NUC_22.L_CORE X_NUC_78.L_CORE 0.002196
K_2766 X_NUC_22.L_CORE X_NUC_79.L_CORE 0.002200
K_2767 X_NUC_22.L_CORE X_NUC_80.L_CORE 0.002194
K_2768 X_NUC_22.L_CORE X_NUC_81.L_CORE 0.002432
K_2769 X_NUC_22.L_CORE X_NUC_82.L_CORE 0.002420
K_2770 X_NUC_22.L_CORE X_NUC_83.L_CORE 0.002404
K_2771 X_NUC_22.L_CORE X_NUC_84.L_CORE 0.002423
K_2772 X_NUC_22.L_CORE X_NUC_85.L_CORE 0.003202
K_2773 X_NUC_22.L_CORE X_NUC_86.L_CORE 0.003193
K_2774 X_NUC_22.L_CORE X_NUC_87.L_CORE 0.003177
K_2775 X_NUC_22.L_CORE X_NUC_88.L_CORE 0.003157
K_2776 X_NUC_22.L_CORE X_NUC_89.L_CORE 0.002005
K_2777 X_NUC_22.L_CORE X_NUC_90.L_CORE 0.001989
K_2778 X_NUC_22.L_CORE X_NUC_91.L_CORE 0.001987
K_2779 X_NUC_22.L_CORE X_NUC_92.L_CORE 0.001990
K_2780 X_NUC_22.L_CORE X_NUC_93.L_CORE 0.002887
K_2781 X_NUC_22.L_CORE X_NUC_94.L_CORE 0.002884
K_2782 X_NUC_22.L_CORE X_NUC_95.L_CORE 0.002852
K_2783 X_NUC_22.L_CORE X_NUC_96.L_CORE 0.002869
K_2784 X_NUC_22.L_CORE X_NUC_97.L_CORE 0.002345
K_2785 X_NUC_22.L_CORE X_NUC_98.L_CORE 0.002331
K_2786 X_NUC_22.L_CORE X_NUC_99.L_CORE 0.002328
K_2787 X_NUC_22.L_CORE X_NUC_100.L_CORE 0.002320
K_2788 X_NUC_22.L_CORE X_NUC_101.L_CORE 0.002108
K_2789 X_NUC_22.L_CORE X_NUC_102.L_CORE 0.002096
K_2790 X_NUC_22.L_CORE X_NUC_103.L_CORE 0.002087
K_2791 X_NUC_22.L_CORE X_NUC_104.L_CORE 0.002095
K_2792 X_NUC_22.L_CORE X_NUC_105.L_CORE 0.002713
K_2793 X_NUC_22.L_CORE X_NUC_106.L_CORE 0.002708
K_2794 X_NUC_22.L_CORE X_NUC_107.L_CORE 0.002686
K_2795 X_NUC_22.L_CORE X_NUC_108.L_CORE 0.002686
K_2796 X_NUC_22.L_CORE X_NUC_109.L_CORE 0.002084
K_2797 X_NUC_22.L_CORE X_NUC_110.L_CORE 0.002071
K_2798 X_NUC_22.L_CORE X_NUC_111.L_CORE 0.002066
K_2799 X_NUC_22.L_CORE X_NUC_112.L_CORE 0.002066
K_2800 X_NUC_22.L_CORE X_NUC_113.L_CORE 0.002263
K_2801 X_NUC_22.L_CORE X_NUC_114.L_CORE 0.002254
K_2802 X_NUC_22.L_CORE X_NUC_115.L_CORE 0.002240
K_2803 X_NUC_22.L_CORE X_NUC_116.L_CORE 0.002246
K_2804 X_NUC_22.L_CORE X_NUC_117.L_CORE 0.005716
K_2805 X_NUC_22.L_CORE X_NUC_118.L_CORE 0.002923
K_2806 X_NUC_22.L_CORE X_NUC_119.L_CORE 0.005656
K_2807 X_NUC_22.L_CORE X_NUC_120.L_CORE 0.003715
K_2808 X_NUC_22.L_CORE X_NUC_121.L_CORE 0.002579
K_2809 X_NUC_22.L_CORE X_NUC_122.L_CORE 0.023478
K_2810 X_NUC_22.L_CORE X_NUC_123.L_CORE 0.002400
K_2811 X_NUC_22.L_CORE X_NUC_124.L_CORE 0.003154
K_2812 X_NUC_22.L_CORE X_NUC_125.L_CORE 0.004372
K_2813 X_NUC_22.L_CORE X_NUC_126.L_CORE 0.002085
K_2814 X_NUC_22.L_CORE X_NUC_127.L_CORE 0.005033
K_2815 X_NUC_22.L_CORE X_NUC_128.L_CORE 0.002446
K_2816 X_NUC_22.L_CORE X_NUC_129.L_CORE 0.002252
K_2817 X_NUC_22.L_CORE X_NUC_130.L_CORE 0.004425
K_2818 X_NUC_22.L_CORE X_NUC_131.L_CORE 0.001959
K_2819 X_NUC_22.L_CORE X_NUC_132.L_CORE 0.002838
K_2820 X_NUC_22.L_CORE X_NUC_133.L_CORE 0.002624
K_2821 X_NUC_22.L_CORE X_NUC_134.L_CORE 0.001931
K_2822 X_NUC_22.L_CORE X_NUC_135.L_CORE 0.003154
K_2823 X_NUC_22.L_CORE X_NUC_136.L_CORE 0.002010
K_2824 X_NUC_22.L_CORE X_NUC_137.L_CORE 0.002152
K_2825 X_NUC_22.L_CORE X_NUC_138.L_CORE 0.002488
K_2826 X_NUC_22.L_CORE X_NUC_139.L_CORE 0.001911
K_2827 X_NUC_22.L_CORE X_NUC_140.L_CORE 0.002205
K_2828 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_2829 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.002647
K_2830 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.002614
K_2831 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.002633
K_2832 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.002627
K_2833 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.003557
K_2834 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.003530
K_2835 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.003512
K_2836 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.003566
K_2837 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.005057
K_2838 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.004998
K_2839 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.005057
K_2840 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.004956
K_2841 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.002305
K_2842 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.002281
K_2843 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.002287
K_2844 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.002294
K_2845 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.006534
K_2846 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.006582
K_2847 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.006399
K_2848 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.006560
K_2849 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.002729
K_2850 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.002700
K_2851 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.002716
K_2852 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.002699
K_2853 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.002518
K_2854 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.002499
K_2855 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.002492
K_2856 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.002513
K_2857 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.006000
K_2858 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.006020
K_2859 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.005959
K_2860 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.005864
K_2861 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.002156
K_2862 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.002135
K_2863 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.002140
K_2864 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.002140
K_2865 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.003380
K_2866 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.003372
K_2867 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.003332
K_2868 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.003376
K_2869 X_NUC_23.L_CORE X_NUC_65.L_CORE 0.003058
K_2870 X_NUC_23.L_CORE X_NUC_66.L_CORE 0.003035
K_2871 X_NUC_23.L_CORE X_NUC_67.L_CORE 0.003043
K_2872 X_NUC_23.L_CORE X_NUC_68.L_CORE 0.003015
K_2873 X_NUC_23.L_CORE X_NUC_69.L_CORE 0.002119
K_2874 X_NUC_23.L_CORE X_NUC_70.L_CORE 0.002102
K_2875 X_NUC_23.L_CORE X_NUC_71.L_CORE 0.002099
K_2876 X_NUC_23.L_CORE X_NUC_72.L_CORE 0.002109
K_2877 X_NUC_23.L_CORE X_NUC_73.L_CORE 0.004319
K_2878 X_NUC_23.L_CORE X_NUC_74.L_CORE 0.004338
K_2879 X_NUC_23.L_CORE X_NUC_75.L_CORE 0.004260
K_2880 X_NUC_23.L_CORE X_NUC_76.L_CORE 0.004275
K_2881 X_NUC_23.L_CORE X_NUC_77.L_CORE 0.002212
K_2882 X_NUC_23.L_CORE X_NUC_78.L_CORE 0.002193
K_2883 X_NUC_23.L_CORE X_NUC_79.L_CORE 0.002196
K_2884 X_NUC_23.L_CORE X_NUC_80.L_CORE 0.002190
K_2885 X_NUC_23.L_CORE X_NUC_81.L_CORE 0.002448
K_2886 X_NUC_23.L_CORE X_NUC_82.L_CORE 0.002436
K_2887 X_NUC_23.L_CORE X_NUC_83.L_CORE 0.002420
K_2888 X_NUC_23.L_CORE X_NUC_84.L_CORE 0.002439
K_2889 X_NUC_23.L_CORE X_NUC_85.L_CORE 0.003218
K_2890 X_NUC_23.L_CORE X_NUC_86.L_CORE 0.003209
K_2891 X_NUC_23.L_CORE X_NUC_87.L_CORE 0.003193
K_2892 X_NUC_23.L_CORE X_NUC_88.L_CORE 0.003172
K_2893 X_NUC_23.L_CORE X_NUC_89.L_CORE 0.002006
K_2894 X_NUC_23.L_CORE X_NUC_90.L_CORE 0.001991
K_2895 X_NUC_23.L_CORE X_NUC_91.L_CORE 0.001989
K_2896 X_NUC_23.L_CORE X_NUC_92.L_CORE 0.001992
K_2897 X_NUC_23.L_CORE X_NUC_93.L_CORE 0.002920
K_2898 X_NUC_23.L_CORE X_NUC_94.L_CORE 0.002917
K_2899 X_NUC_23.L_CORE X_NUC_95.L_CORE 0.002884
K_2900 X_NUC_23.L_CORE X_NUC_96.L_CORE 0.002901
K_2901 X_NUC_23.L_CORE X_NUC_97.L_CORE 0.002348
K_2902 X_NUC_23.L_CORE X_NUC_98.L_CORE 0.002333
K_2903 X_NUC_23.L_CORE X_NUC_99.L_CORE 0.002331
K_2904 X_NUC_23.L_CORE X_NUC_100.L_CORE 0.002322
K_2905 X_NUC_23.L_CORE X_NUC_101.L_CORE 0.002117
K_2906 X_NUC_23.L_CORE X_NUC_102.L_CORE 0.002105
K_2907 X_NUC_23.L_CORE X_NUC_103.L_CORE 0.002096
K_2908 X_NUC_23.L_CORE X_NUC_104.L_CORE 0.002104
K_2909 X_NUC_23.L_CORE X_NUC_105.L_CORE 0.002735
K_2910 X_NUC_23.L_CORE X_NUC_106.L_CORE 0.002729
K_2911 X_NUC_23.L_CORE X_NUC_107.L_CORE 0.002708
K_2912 X_NUC_23.L_CORE X_NUC_108.L_CORE 0.002707
K_2913 X_NUC_23.L_CORE X_NUC_109.L_CORE 0.002089
K_2914 X_NUC_23.L_CORE X_NUC_110.L_CORE 0.002076
K_2915 X_NUC_23.L_CORE X_NUC_111.L_CORE 0.002071
K_2916 X_NUC_23.L_CORE X_NUC_112.L_CORE 0.002071
K_2917 X_NUC_23.L_CORE X_NUC_113.L_CORE 0.002277
K_2918 X_NUC_23.L_CORE X_NUC_114.L_CORE 0.002268
K_2919 X_NUC_23.L_CORE X_NUC_115.L_CORE 0.002254
K_2920 X_NUC_23.L_CORE X_NUC_116.L_CORE 0.002260
K_2921 X_NUC_23.L_CORE X_NUC_117.L_CORE 0.005581
K_2922 X_NUC_23.L_CORE X_NUC_118.L_CORE 0.002899
K_2923 X_NUC_23.L_CORE X_NUC_119.L_CORE 0.005655
K_2924 X_NUC_23.L_CORE X_NUC_120.L_CORE 0.003663
K_2925 X_NUC_23.L_CORE X_NUC_121.L_CORE 0.002574
K_2926 X_NUC_23.L_CORE X_NUC_122.L_CORE 0.024650
K_2927 X_NUC_23.L_CORE X_NUC_123.L_CORE 0.002385
K_2928 X_NUC_23.L_CORE X_NUC_124.L_CORE 0.003173
K_2929 X_NUC_23.L_CORE X_NUC_125.L_CORE 0.004337
K_2930 X_NUC_23.L_CORE X_NUC_126.L_CORE 0.002082
K_2931 X_NUC_23.L_CORE X_NUC_127.L_CORE 0.005154
K_2932 X_NUC_23.L_CORE X_NUC_128.L_CORE 0.002435
K_2933 X_NUC_23.L_CORE X_NUC_129.L_CORE 0.002260
K_2934 X_NUC_23.L_CORE X_NUC_130.L_CORE 0.004469
K_2935 X_NUC_23.L_CORE X_NUC_131.L_CORE 0.001956
K_2936 X_NUC_23.L_CORE X_NUC_132.L_CORE 0.002869
K_2937 X_NUC_23.L_CORE X_NUC_133.L_CORE 0.002624
K_2938 X_NUC_23.L_CORE X_NUC_134.L_CORE 0.001935
K_2939 X_NUC_23.L_CORE X_NUC_135.L_CORE 0.003194
K_2940 X_NUC_23.L_CORE X_NUC_136.L_CORE 0.002010
K_2941 X_NUC_23.L_CORE X_NUC_137.L_CORE 0.002166
K_2942 X_NUC_23.L_CORE X_NUC_138.L_CORE 0.002501
K_2943 X_NUC_23.L_CORE X_NUC_139.L_CORE 0.001917
K_2944 X_NUC_23.L_CORE X_NUC_140.L_CORE 0.002219
K_2945 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.002653
K_2946 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.002620
K_2947 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.002638
K_2948 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.002633
K_2949 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.003504
K_2950 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.003478
K_2951 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.003460
K_2952 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.003512
K_2953 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.005163
K_2954 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.005100
K_2955 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.005161
K_2956 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.005057
K_2957 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.002297
K_2958 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.002274
K_2959 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.002279
K_2960 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.002287
K_2961 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.006373
K_2962 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.006416
K_2963 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.006244
K_2964 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.006399
K_2965 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.002747
K_2966 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.002717
K_2967 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.002733
K_2968 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.002716
K_2969 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.002497
K_2970 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.002478
K_2971 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.002471
K_2972 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.002492
K_2973 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.006098
K_2974 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.006119
K_2975 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.006052
K_2976 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.005959
K_2977 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.002156
K_2978 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.002135
K_2979 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.002140
K_2980 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.002140
K_2981 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.003336
K_2982 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.003329
K_2983 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.003290
K_2984 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.003332
K_2985 X_NUC_24.L_CORE X_NUC_65.L_CORE 0.003087
K_2986 X_NUC_24.L_CORE X_NUC_66.L_CORE 0.003063
K_2987 X_NUC_24.L_CORE X_NUC_67.L_CORE 0.003071
K_2988 X_NUC_24.L_CORE X_NUC_68.L_CORE 0.003043
K_2989 X_NUC_24.L_CORE X_NUC_69.L_CORE 0.002110
K_2990 X_NUC_24.L_CORE X_NUC_70.L_CORE 0.002093
K_2991 X_NUC_24.L_CORE X_NUC_71.L_CORE 0.002090
K_2992 X_NUC_24.L_CORE X_NUC_72.L_CORE 0.002099
K_2993 X_NUC_24.L_CORE X_NUC_73.L_CORE 0.004302
K_2994 X_NUC_24.L_CORE X_NUC_74.L_CORE 0.004321
K_2995 X_NUC_24.L_CORE X_NUC_75.L_CORE 0.004244
K_2996 X_NUC_24.L_CORE X_NUC_76.L_CORE 0.004260
K_2997 X_NUC_24.L_CORE X_NUC_77.L_CORE 0.002218
K_2998 X_NUC_24.L_CORE X_NUC_78.L_CORE 0.002199
K_2999 X_NUC_24.L_CORE X_NUC_79.L_CORE 0.002202
K_3000 X_NUC_24.L_CORE X_NUC_80.L_CORE 0.002196
K_3001 X_NUC_24.L_CORE X_NUC_81.L_CORE 0.002429
K_3002 X_NUC_24.L_CORE X_NUC_82.L_CORE 0.002417
K_3003 X_NUC_24.L_CORE X_NUC_83.L_CORE 0.002402
K_3004 X_NUC_24.L_CORE X_NUC_84.L_CORE 0.002420
K_3005 X_NUC_24.L_CORE X_NUC_85.L_CORE 0.003240
K_3006 X_NUC_24.L_CORE X_NUC_86.L_CORE 0.003230
K_3007 X_NUC_24.L_CORE X_NUC_87.L_CORE 0.003214
K_3008 X_NUC_24.L_CORE X_NUC_88.L_CORE 0.003193
K_3009 X_NUC_24.L_CORE X_NUC_89.L_CORE 0.002003
K_3010 X_NUC_24.L_CORE X_NUC_90.L_CORE 0.001988
K_3011 X_NUC_24.L_CORE X_NUC_91.L_CORE 0.001986
K_3012 X_NUC_24.L_CORE X_NUC_92.L_CORE 0.001989
K_3013 X_NUC_24.L_CORE X_NUC_93.L_CORE 0.002903
K_3014 X_NUC_24.L_CORE X_NUC_94.L_CORE 0.002899
K_3015 X_NUC_24.L_CORE X_NUC_95.L_CORE 0.002867
K_3016 X_NUC_24.L_CORE X_NUC_96.L_CORE 0.002884
K_3017 X_NUC_24.L_CORE X_NUC_97.L_CORE 0.002356
K_3018 X_NUC_24.L_CORE X_NUC_98.L_CORE 0.002341
K_3019 X_NUC_24.L_CORE X_NUC_99.L_CORE 0.002338
K_3020 X_NUC_24.L_CORE X_NUC_100.L_CORE 0.002331
K_3021 X_NUC_24.L_CORE X_NUC_101.L_CORE 0.002108
K_3022 X_NUC_24.L_CORE X_NUC_102.L_CORE 0.002097
K_3023 X_NUC_24.L_CORE X_NUC_103.L_CORE 0.002087
K_3024 X_NUC_24.L_CORE X_NUC_104.L_CORE 0.002096
K_3025 X_NUC_24.L_CORE X_NUC_105.L_CORE 0.002735
K_3026 X_NUC_24.L_CORE X_NUC_106.L_CORE 0.002730
K_3027 X_NUC_24.L_CORE X_NUC_107.L_CORE 0.002708
K_3028 X_NUC_24.L_CORE X_NUC_108.L_CORE 0.002708
K_3029 X_NUC_24.L_CORE X_NUC_109.L_CORE 0.002089
K_3030 X_NUC_24.L_CORE X_NUC_110.L_CORE 0.002076
K_3031 X_NUC_24.L_CORE X_NUC_111.L_CORE 0.002071
K_3032 X_NUC_24.L_CORE X_NUC_112.L_CORE 0.002071
K_3033 X_NUC_24.L_CORE X_NUC_113.L_CORE 0.002271
K_3034 X_NUC_24.L_CORE X_NUC_114.L_CORE 0.002262
K_3035 X_NUC_24.L_CORE X_NUC_115.L_CORE 0.002248
K_3036 X_NUC_24.L_CORE X_NUC_116.L_CORE 0.002254
K_3037 X_NUC_24.L_CORE X_NUC_117.L_CORE 0.005593
K_3038 X_NUC_24.L_CORE X_NUC_118.L_CORE 0.002893
K_3039 X_NUC_24.L_CORE X_NUC_119.L_CORE 0.005526
K_3040 X_NUC_24.L_CORE X_NUC_120.L_CORE 0.003700
K_3041 X_NUC_24.L_CORE X_NUC_121.L_CORE 0.002556
K_3042 X_NUC_24.L_CORE X_NUC_122.L_CORE 0.025299
K_3043 X_NUC_24.L_CORE X_NUC_123.L_CORE 0.002390
K_3044 X_NUC_24.L_CORE X_NUC_124.L_CORE 0.003129
K_3045 X_NUC_24.L_CORE X_NUC_125.L_CORE 0.004418
K_3046 X_NUC_24.L_CORE X_NUC_126.L_CORE 0.002075
K_3047 X_NUC_24.L_CORE X_NUC_127.L_CORE 0.005065
K_3048 X_NUC_24.L_CORE X_NUC_128.L_CORE 0.002449
K_3049 X_NUC_24.L_CORE X_NUC_129.L_CORE 0.002243
K_3050 X_NUC_24.L_CORE X_NUC_130.L_CORE 0.004516
K_3051 X_NUC_24.L_CORE X_NUC_131.L_CORE 0.001957
K_3052 X_NUC_24.L_CORE X_NUC_132.L_CORE 0.002840
K_3053 X_NUC_24.L_CORE X_NUC_133.L_CORE 0.002643
K_3054 X_NUC_24.L_CORE X_NUC_134.L_CORE 0.001928
K_3055 X_NUC_24.L_CORE X_NUC_135.L_CORE 0.003187
K_3056 X_NUC_24.L_CORE X_NUC_136.L_CORE 0.002015
K_3057 X_NUC_24.L_CORE X_NUC_137.L_CORE 0.002155
K_3058 X_NUC_24.L_CORE X_NUC_138.L_CORE 0.002508
K_3059 X_NUC_24.L_CORE X_NUC_139.L_CORE 0.001914
K_3060 X_NUC_24.L_CORE X_NUC_140.L_CORE 0.002215
K_3061 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_3062 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_3063 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_3064 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.002492
K_3065 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.002510
K_3066 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.002488
K_3067 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.002512
K_3068 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.003346
K_3069 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.003397
K_3070 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.003376
K_3071 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.003357
K_3072 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.004867
K_3073 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.004846
K_3074 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.004783
K_3075 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.004890
K_3076 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.002196
K_3077 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.002217
K_3078 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.002199
K_3079 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.002209
K_3080 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.006326
K_3081 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.006407
K_3082 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.006359
K_3083 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.006223
K_3084 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.002634
K_3085 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.002644
K_3086 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.002618
K_3087 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.002648
K_3088 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.002423
K_3089 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.002450
K_3090 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.002431
K_3091 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.002429
K_3092 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.006039
K_3093 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.005968
K_3094 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.005872
K_3095 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.005933
K_3096 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.002091
K_3097 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.002105
K_3098 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.002086
K_3099 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.002100
K_3100 X_NUC_25.L_CORE X_NUC_65.L_CORE 0.003298
K_3101 X_NUC_25.L_CORE X_NUC_66.L_CORE 0.003334
K_3102 X_NUC_25.L_CORE X_NUC_67.L_CORE 0.003307
K_3103 X_NUC_25.L_CORE X_NUC_68.L_CORE 0.003282
K_3104 X_NUC_25.L_CORE X_NUC_69.L_CORE 0.003013
K_3105 X_NUC_25.L_CORE X_NUC_70.L_CORE 0.003013
K_3106 X_NUC_25.L_CORE X_NUC_71.L_CORE 0.002978
K_3107 X_NUC_25.L_CORE X_NUC_72.L_CORE 0.003013
K_3108 X_NUC_25.L_CORE X_NUC_73.L_CORE 0.002069
K_3109 X_NUC_25.L_CORE X_NUC_74.L_CORE 0.002087
K_3110 X_NUC_25.L_CORE X_NUC_75.L_CORE 0.002069
K_3111 X_NUC_25.L_CORE X_NUC_76.L_CORE 0.002074
K_3112 X_NUC_25.L_CORE X_NUC_77.L_CORE 0.004308
K_3113 X_NUC_25.L_CORE X_NUC_78.L_CORE 0.004310
K_3114 X_NUC_25.L_CORE X_NUC_79.L_CORE 0.004258
K_3115 X_NUC_25.L_CORE X_NUC_80.L_CORE 0.004238
K_3116 X_NUC_25.L_CORE X_NUC_81.L_CORE 0.002178
K_3117 X_NUC_25.L_CORE X_NUC_82.L_CORE 0.002188
K_3118 X_NUC_25.L_CORE X_NUC_83.L_CORE 0.002166
K_3119 X_NUC_25.L_CORE X_NUC_84.L_CORE 0.002183
K_3120 X_NUC_25.L_CORE X_NUC_85.L_CORE 0.002410
K_3121 X_NUC_25.L_CORE X_NUC_86.L_CORE 0.002431
K_3122 X_NUC_25.L_CORE X_NUC_87.L_CORE 0.002410
K_3123 X_NUC_25.L_CORE X_NUC_88.L_CORE 0.002405
K_3124 X_NUC_25.L_CORE X_NUC_89.L_CORE 0.003198
K_3125 X_NUC_25.L_CORE X_NUC_90.L_CORE 0.003193
K_3126 X_NUC_25.L_CORE X_NUC_91.L_CORE 0.003154
K_3127 X_NUC_25.L_CORE X_NUC_92.L_CORE 0.003176
K_3128 X_NUC_25.L_CORE X_NUC_93.L_CORE 0.001989
K_3129 X_NUC_25.L_CORE X_NUC_94.L_CORE 0.002003
K_3130 X_NUC_25.L_CORE X_NUC_95.L_CORE 0.001984
K_3131 X_NUC_25.L_CORE X_NUC_96.L_CORE 0.001992
K_3132 X_NUC_25.L_CORE X_NUC_97.L_CORE 0.002880
K_3133 X_NUC_25.L_CORE X_NUC_98.L_CORE 0.002895
K_3134 X_NUC_25.L_CORE X_NUC_99.L_CORE 0.002866
K_3135 X_NUC_25.L_CORE X_NUC_100.L_CORE 0.002858
K_3136 X_NUC_25.L_CORE X_NUC_101.L_CORE 0.002339
K_3137 X_NUC_25.L_CORE X_NUC_102.L_CORE 0.002346
K_3138 X_NUC_25.L_CORE X_NUC_103.L_CORE 0.002320
K_3139 X_NUC_25.L_CORE X_NUC_104.L_CORE 0.002336
K_3140 X_NUC_25.L_CORE X_NUC_105.L_CORE 0.002121
K_3141 X_NUC_25.L_CORE X_NUC_106.L_CORE 0.002135
K_3142 X_NUC_25.L_CORE X_NUC_107.L_CORE 0.002115
K_3143 X_NUC_25.L_CORE X_NUC_108.L_CORE 0.002118
K_3144 X_NUC_25.L_CORE X_NUC_109.L_CORE 0.002646
K_3145 X_NUC_25.L_CORE X_NUC_110.L_CORE 0.002652
K_3146 X_NUC_25.L_CORE X_NUC_111.L_CORE 0.002623
K_3147 X_NUC_25.L_CORE X_NUC_112.L_CORE 0.002629
K_3148 X_NUC_25.L_CORE X_NUC_113.L_CORE 0.002149
K_3149 X_NUC_25.L_CORE X_NUC_114.L_CORE 0.002159
K_3150 X_NUC_25.L_CORE X_NUC_115.L_CORE 0.002137
K_3151 X_NUC_25.L_CORE X_NUC_116.L_CORE 0.002145
K_3152 X_NUC_25.L_CORE X_NUC_117.L_CORE 0.003650
K_3153 X_NUC_25.L_CORE X_NUC_118.L_CORE 0.006271
K_3154 X_NUC_25.L_CORE X_NUC_119.L_CORE 0.002579
K_3155 X_NUC_25.L_CORE X_NUC_120.L_CORE 0.005298
K_3156 X_NUC_25.L_CORE X_NUC_121.L_CORE 0.003420
K_3157 X_NUC_25.L_CORE X_NUC_122.L_CORE 0.002412
K_3158 X_NUC_25.L_CORE X_NUC_123.L_CORE 0.022473
K_3159 X_NUC_25.L_CORE X_NUC_124.L_CORE 0.002274
K_3160 X_NUC_25.L_CORE X_NUC_125.L_CORE 0.003029
K_3161 X_NUC_25.L_CORE X_NUC_126.L_CORE 0.004197
K_3162 X_NUC_25.L_CORE X_NUC_127.L_CORE 0.002012
K_3163 X_NUC_25.L_CORE X_NUC_128.L_CORE 0.004998
K_3164 X_NUC_25.L_CORE X_NUC_129.L_CORE 0.002377
K_3165 X_NUC_25.L_CORE X_NUC_130.L_CORE 0.002206
K_3166 X_NUC_25.L_CORE X_NUC_131.L_CORE 0.004404
K_3167 X_NUC_25.L_CORE X_NUC_132.L_CORE 0.001926
K_3168 X_NUC_25.L_CORE X_NUC_133.L_CORE 0.002821
K_3169 X_NUC_25.L_CORE X_NUC_134.L_CORE 0.002597
K_3170 X_NUC_25.L_CORE X_NUC_135.L_CORE 0.001923
K_3171 X_NUC_25.L_CORE X_NUC_136.L_CORE 0.003122
K_3172 X_NUC_25.L_CORE X_NUC_137.L_CORE 0.002013
K_3173 X_NUC_25.L_CORE X_NUC_138.L_CORE 0.002161
K_3174 X_NUC_25.L_CORE X_NUC_139.L_CORE 0.002434
K_3175 X_NUC_25.L_CORE X_NUC_140.L_CORE 0.001992
K_3176 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_3177 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_3178 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.002473
K_3179 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.002492
K_3180 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.002470
K_3181 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.002493
K_3182 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.003297
K_3183 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.003346
K_3184 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.003326
K_3185 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.003308
K_3186 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.004886
K_3187 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.004867
K_3188 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.004803
K_3189 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.004910
K_3190 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.002176
K_3191 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.002196
K_3192 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.002179
K_3193 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.002188
K_3194 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.006242
K_3195 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.006326
K_3196 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.006277
K_3197 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.006146
K_3198 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.002624
K_3199 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.002634
K_3200 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.002607
K_3201 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.002637
K_3202 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.002396
K_3203 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.002423
K_3204 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.002405
K_3205 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.002403
K_3206 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.006108
K_3207 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.006039
K_3208 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.005937
K_3209 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.006000
K_3210 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.002076
K_3211 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.002091
K_3212 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.002072
K_3213 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.002085
K_3214 X_NUC_26.L_CORE X_NUC_65.L_CORE 0.003264
K_3215 X_NUC_26.L_CORE X_NUC_66.L_CORE 0.003298
K_3216 X_NUC_26.L_CORE X_NUC_67.L_CORE 0.003272
K_3217 X_NUC_26.L_CORE X_NUC_68.L_CORE 0.003248
K_3218 X_NUC_26.L_CORE X_NUC_69.L_CORE 0.003013
K_3219 X_NUC_26.L_CORE X_NUC_70.L_CORE 0.003013
K_3220 X_NUC_26.L_CORE X_NUC_71.L_CORE 0.002978
K_3221 X_NUC_26.L_CORE X_NUC_72.L_CORE 0.003013
K_3222 X_NUC_26.L_CORE X_NUC_73.L_CORE 0.002051
K_3223 X_NUC_26.L_CORE X_NUC_74.L_CORE 0.002069
K_3224 X_NUC_26.L_CORE X_NUC_75.L_CORE 0.002051
K_3225 X_NUC_26.L_CORE X_NUC_76.L_CORE 0.002056
K_3226 X_NUC_26.L_CORE X_NUC_77.L_CORE 0.004304
K_3227 X_NUC_26.L_CORE X_NUC_78.L_CORE 0.004308
K_3228 X_NUC_26.L_CORE X_NUC_79.L_CORE 0.004256
K_3229 X_NUC_26.L_CORE X_NUC_80.L_CORE 0.004236
K_3230 X_NUC_26.L_CORE X_NUC_81.L_CORE 0.002168
K_3231 X_NUC_26.L_CORE X_NUC_82.L_CORE 0.002178
K_3232 X_NUC_26.L_CORE X_NUC_83.L_CORE 0.002156
K_3233 X_NUC_26.L_CORE X_NUC_84.L_CORE 0.002173
K_3234 X_NUC_26.L_CORE X_NUC_85.L_CORE 0.002389
K_3235 X_NUC_26.L_CORE X_NUC_86.L_CORE 0.002410
K_3236 X_NUC_26.L_CORE X_NUC_87.L_CORE 0.002389
K_3237 X_NUC_26.L_CORE X_NUC_88.L_CORE 0.002385
K_3238 X_NUC_26.L_CORE X_NUC_89.L_CORE 0.003201
K_3239 X_NUC_26.L_CORE X_NUC_90.L_CORE 0.003198
K_3240 X_NUC_26.L_CORE X_NUC_91.L_CORE 0.003158
K_3241 X_NUC_26.L_CORE X_NUC_92.L_CORE 0.003180
K_3242 X_NUC_26.L_CORE X_NUC_93.L_CORE 0.001976
K_3243 X_NUC_26.L_CORE X_NUC_94.L_CORE 0.001989
K_3244 X_NUC_26.L_CORE X_NUC_95.L_CORE 0.001971
K_3245 X_NUC_26.L_CORE X_NUC_96.L_CORE 0.001979
K_3246 X_NUC_26.L_CORE X_NUC_97.L_CORE 0.002864
K_3247 X_NUC_26.L_CORE X_NUC_98.L_CORE 0.002880
K_3248 X_NUC_26.L_CORE X_NUC_99.L_CORE 0.002851
K_3249 X_NUC_26.L_CORE X_NUC_100.L_CORE 0.002843
K_3250 X_NUC_26.L_CORE X_NUC_101.L_CORE 0.002332
K_3251 X_NUC_26.L_CORE X_NUC_102.L_CORE 0.002339
K_3252 X_NUC_26.L_CORE X_NUC_103.L_CORE 0.002314
K_3253 X_NUC_26.L_CORE X_NUC_104.L_CORE 0.002329
K_3254 X_NUC_26.L_CORE X_NUC_105.L_CORE 0.002106
K_3255 X_NUC_26.L_CORE X_NUC_106.L_CORE 0.002121
K_3256 X_NUC_26.L_CORE X_NUC_107.L_CORE 0.002101
K_3257 X_NUC_26.L_CORE X_NUC_108.L_CORE 0.002103
K_3258 X_NUC_26.L_CORE X_NUC_109.L_CORE 0.002638
K_3259 X_NUC_26.L_CORE X_NUC_110.L_CORE 0.002646
K_3260 X_NUC_26.L_CORE X_NUC_111.L_CORE 0.002617
K_3261 X_NUC_26.L_CORE X_NUC_112.L_CORE 0.002622
K_3262 X_NUC_26.L_CORE X_NUC_113.L_CORE 0.002139
K_3263 X_NUC_26.L_CORE X_NUC_114.L_CORE 0.002149
K_3264 X_NUC_26.L_CORE X_NUC_115.L_CORE 0.002127
K_3265 X_NUC_26.L_CORE X_NUC_116.L_CORE 0.002135
K_3266 X_NUC_26.L_CORE X_NUC_117.L_CORE 0.003596
K_3267 X_NUC_26.L_CORE X_NUC_118.L_CORE 0.006218
K_3268 X_NUC_26.L_CORE X_NUC_119.L_CORE 0.002553
K_3269 X_NUC_26.L_CORE X_NUC_120.L_CORE 0.005190
K_3270 X_NUC_26.L_CORE X_NUC_121.L_CORE 0.003409
K_3271 X_NUC_26.L_CORE X_NUC_122.L_CORE 0.002385
K_3272 X_NUC_26.L_CORE X_NUC_123.L_CORE 0.024703
K_3273 X_NUC_26.L_CORE X_NUC_124.L_CORE 0.002259
K_3274 X_NUC_26.L_CORE X_NUC_125.L_CORE 0.002991
K_3275 X_NUC_26.L_CORE X_NUC_126.L_CORE 0.004223
K_3276 X_NUC_26.L_CORE X_NUC_127.L_CORE 0.001995
K_3277 X_NUC_26.L_CORE X_NUC_128.L_CORE 0.004968
K_3278 X_NUC_26.L_CORE X_NUC_129.L_CORE 0.002370
K_3279 X_NUC_26.L_CORE X_NUC_130.L_CORE 0.002185
K_3280 X_NUC_26.L_CORE X_NUC_131.L_CORE 0.004441
K_3281 X_NUC_26.L_CORE X_NUC_132.L_CORE 0.001914
K_3282 X_NUC_26.L_CORE X_NUC_133.L_CORE 0.002799
K_3283 X_NUC_26.L_CORE X_NUC_134.L_CORE 0.002597
K_3284 X_NUC_26.L_CORE X_NUC_135.L_CORE 0.001909
K_3285 X_NUC_26.L_CORE X_NUC_136.L_CORE 0.003119
K_3286 X_NUC_26.L_CORE X_NUC_137.L_CORE 0.002005
K_3287 X_NUC_26.L_CORE X_NUC_138.L_CORE 0.002147
K_3288 X_NUC_26.L_CORE X_NUC_139.L_CORE 0.002431
K_3289 X_NUC_26.L_CORE X_NUC_140.L_CORE 0.001983
K_3290 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_3291 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.002495
K_3292 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.002514
K_3293 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.002492
K_3294 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.002515
K_3295 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.003316
K_3296 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.003366
K_3297 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.003346
K_3298 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.003328
K_3299 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.004953
K_3300 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.004932
K_3301 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.004867
K_3302 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.004978
K_3303 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.002193
K_3304 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.002214
K_3305 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.002196
K_3306 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.002206
K_3307 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.006288
K_3308 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.006371
K_3309 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.006326
K_3310 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.006190
K_3311 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.002651
K_3312 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.002661
K_3313 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.002634
K_3314 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.002665
K_3315 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.002414
K_3316 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.002441
K_3317 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.002423
K_3318 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.002421
K_3319 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.006215
K_3320 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.006141
K_3321 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.006039
K_3322 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.006103
K_3323 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.002095
K_3324 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.002110
K_3325 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.002091
K_3326 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.002104
K_3327 X_NUC_27.L_CORE X_NUC_65.L_CORE 0.003289
K_3328 X_NUC_27.L_CORE X_NUC_66.L_CORE 0.003325
K_3329 X_NUC_27.L_CORE X_NUC_67.L_CORE 0.003298
K_3330 X_NUC_27.L_CORE X_NUC_68.L_CORE 0.003274
K_3331 X_NUC_27.L_CORE X_NUC_69.L_CORE 0.003049
K_3332 X_NUC_27.L_CORE X_NUC_70.L_CORE 0.003049
K_3333 X_NUC_27.L_CORE X_NUC_71.L_CORE 0.003013
K_3334 X_NUC_27.L_CORE X_NUC_72.L_CORE 0.003049
K_3335 X_NUC_27.L_CORE X_NUC_73.L_CORE 0.002068
K_3336 X_NUC_27.L_CORE X_NUC_74.L_CORE 0.002086
K_3337 X_NUC_27.L_CORE X_NUC_75.L_CORE 0.002069
K_3338 X_NUC_27.L_CORE X_NUC_76.L_CORE 0.002073
K_3339 X_NUC_27.L_CORE X_NUC_77.L_CORE 0.004357
K_3340 X_NUC_27.L_CORE X_NUC_78.L_CORE 0.004360
K_3341 X_NUC_27.L_CORE X_NUC_79.L_CORE 0.004308
K_3342 X_NUC_27.L_CORE X_NUC_80.L_CORE 0.004286
K_3343 X_NUC_27.L_CORE X_NUC_81.L_CORE 0.002190
K_3344 X_NUC_27.L_CORE X_NUC_82.L_CORE 0.002200
K_3345 X_NUC_27.L_CORE X_NUC_83.L_CORE 0.002178
K_3346 X_NUC_27.L_CORE X_NUC_84.L_CORE 0.002195
K_3347 X_NUC_27.L_CORE X_NUC_85.L_CORE 0.002409
K_3348 X_NUC_27.L_CORE X_NUC_86.L_CORE 0.002430
K_3349 X_NUC_27.L_CORE X_NUC_87.L_CORE 0.002410
K_3350 X_NUC_27.L_CORE X_NUC_88.L_CORE 0.002405
K_3351 X_NUC_27.L_CORE X_NUC_89.L_CORE 0.003242
K_3352 X_NUC_27.L_CORE X_NUC_90.L_CORE 0.003238
K_3353 X_NUC_27.L_CORE X_NUC_91.L_CORE 0.003198
K_3354 X_NUC_27.L_CORE X_NUC_92.L_CORE 0.003220
K_3355 X_NUC_27.L_CORE X_NUC_93.L_CORE 0.001995
K_3356 X_NUC_27.L_CORE X_NUC_94.L_CORE 0.002008
K_3357 X_NUC_27.L_CORE X_NUC_95.L_CORE 0.001989
K_3358 X_NUC_27.L_CORE X_NUC_96.L_CORE 0.001997
K_3359 X_NUC_27.L_CORE X_NUC_97.L_CORE 0.002893
K_3360 X_NUC_27.L_CORE X_NUC_98.L_CORE 0.002909
K_3361 X_NUC_27.L_CORE X_NUC_99.L_CORE 0.002880
K_3362 X_NUC_27.L_CORE X_NUC_100.L_CORE 0.002871
K_3363 X_NUC_27.L_CORE X_NUC_101.L_CORE 0.002358
K_3364 X_NUC_27.L_CORE X_NUC_102.L_CORE 0.002365
K_3365 X_NUC_27.L_CORE X_NUC_103.L_CORE 0.002339
K_3366 X_NUC_27.L_CORE X_NUC_104.L_CORE 0.002354
K_3367 X_NUC_27.L_CORE X_NUC_105.L_CORE 0.002126
K_3368 X_NUC_27.L_CORE X_NUC_106.L_CORE 0.002140
K_3369 X_NUC_27.L_CORE X_NUC_107.L_CORE 0.002121
K_3370 X_NUC_27.L_CORE X_NUC_108.L_CORE 0.002123
K_3371 X_NUC_27.L_CORE X_NUC_109.L_CORE 0.002668
K_3372 X_NUC_27.L_CORE X_NUC_110.L_CORE 0.002675
K_3373 X_NUC_27.L_CORE X_NUC_111.L_CORE 0.002646
K_3374 X_NUC_27.L_CORE X_NUC_112.L_CORE 0.002651
K_3375 X_NUC_27.L_CORE X_NUC_113.L_CORE 0.002160
K_3376 X_NUC_27.L_CORE X_NUC_114.L_CORE 0.002171
K_3377 X_NUC_27.L_CORE X_NUC_115.L_CORE 0.002149
K_3378 X_NUC_27.L_CORE X_NUC_116.L_CORE 0.002156
K_3379 X_NUC_27.L_CORE X_NUC_117.L_CORE 0.003607
K_3380 X_NUC_27.L_CORE X_NUC_118.L_CORE 0.006219
K_3381 X_NUC_27.L_CORE X_NUC_119.L_CORE 0.002570
K_3382 X_NUC_27.L_CORE X_NUC_120.L_CORE 0.005182
K_3383 X_NUC_27.L_CORE X_NUC_121.L_CORE 0.003437
K_3384 X_NUC_27.L_CORE X_NUC_122.L_CORE 0.002399
K_3385 X_NUC_27.L_CORE X_NUC_123.L_CORE 0.023292
K_3386 X_NUC_27.L_CORE X_NUC_124.L_CORE 0.002278
K_3387 X_NUC_27.L_CORE X_NUC_125.L_CORE 0.003006
K_3388 X_NUC_27.L_CORE X_NUC_126.L_CORE 0.004269
K_3389 X_NUC_27.L_CORE X_NUC_127.L_CORE 0.002010
K_3390 X_NUC_27.L_CORE X_NUC_128.L_CORE 0.004993
K_3391 X_NUC_27.L_CORE X_NUC_129.L_CORE 0.002393
K_3392 X_NUC_27.L_CORE X_NUC_130.L_CORE 0.002200
K_3393 X_NUC_27.L_CORE X_NUC_131.L_CORE 0.004494
K_3394 X_NUC_27.L_CORE X_NUC_132.L_CORE 0.001931
K_3395 X_NUC_27.L_CORE X_NUC_133.L_CORE 0.002820
K_3396 X_NUC_27.L_CORE X_NUC_134.L_CORE 0.002625
K_3397 X_NUC_27.L_CORE X_NUC_135.L_CORE 0.001924
K_3398 X_NUC_27.L_CORE X_NUC_136.L_CORE 0.003150
K_3399 X_NUC_27.L_CORE X_NUC_137.L_CORE 0.002025
K_3400 X_NUC_27.L_CORE X_NUC_138.L_CORE 0.002166
K_3401 X_NUC_27.L_CORE X_NUC_139.L_CORE 0.002456
K_3402 X_NUC_27.L_CORE X_NUC_140.L_CORE 0.002001
K_3403 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.002472
K_3404 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.002490
K_3405 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.002468
K_3406 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.002492
K_3407 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.003335
K_3408 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.003385
K_3409 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.003365
K_3410 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.003346
K_3411 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.004842
K_3412 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.004823
K_3413 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.004761
K_3414 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.004867
K_3415 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.002184
K_3416 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.002205
K_3417 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.002187
K_3418 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.002196
K_3419 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.006428
K_3420 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.006517
K_3421 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.006466
K_3422 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.006326
K_3423 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.002620
K_3424 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.002630
K_3425 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.002604
K_3426 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.002634
K_3427 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.002416
K_3428 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.002443
K_3429 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.002425
K_3430 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.002423
K_3431 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.006146
K_3432 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.006073
K_3433 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.005972
K_3434 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.006039
K_3435 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.002081
K_3436 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.002096
K_3437 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.002077
K_3438 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.002091
K_3439 X_NUC_28.L_CORE X_NUC_65.L_CORE 0.003314
K_3440 X_NUC_28.L_CORE X_NUC_66.L_CORE 0.003350
K_3441 X_NUC_28.L_CORE X_NUC_67.L_CORE 0.003323
K_3442 X_NUC_28.L_CORE X_NUC_68.L_CORE 0.003298
K_3443 X_NUC_28.L_CORE X_NUC_69.L_CORE 0.003013
K_3444 X_NUC_28.L_CORE X_NUC_70.L_CORE 0.003013
K_3445 X_NUC_28.L_CORE X_NUC_71.L_CORE 0.002978
K_3446 X_NUC_28.L_CORE X_NUC_72.L_CORE 0.003013
K_3447 X_NUC_28.L_CORE X_NUC_73.L_CORE 0.002064
K_3448 X_NUC_28.L_CORE X_NUC_74.L_CORE 0.002082
K_3449 X_NUC_28.L_CORE X_NUC_75.L_CORE 0.002064
K_3450 X_NUC_28.L_CORE X_NUC_76.L_CORE 0.002069
K_3451 X_NUC_28.L_CORE X_NUC_77.L_CORE 0.004379
K_3452 X_NUC_28.L_CORE X_NUC_78.L_CORE 0.004382
K_3453 X_NUC_28.L_CORE X_NUC_79.L_CORE 0.004328
K_3454 X_NUC_28.L_CORE X_NUC_80.L_CORE 0.004308
K_3455 X_NUC_28.L_CORE X_NUC_81.L_CORE 0.002173
K_3456 X_NUC_28.L_CORE X_NUC_82.L_CORE 0.002183
K_3457 X_NUC_28.L_CORE X_NUC_83.L_CORE 0.002162
K_3458 X_NUC_28.L_CORE X_NUC_84.L_CORE 0.002178
K_3459 X_NUC_28.L_CORE X_NUC_85.L_CORE 0.002414
K_3460 X_NUC_28.L_CORE X_NUC_86.L_CORE 0.002435
K_3461 X_NUC_28.L_CORE X_NUC_87.L_CORE 0.002414
K_3462 X_NUC_28.L_CORE X_NUC_88.L_CORE 0.002410
K_3463 X_NUC_28.L_CORE X_NUC_89.L_CORE 0.003219
K_3464 X_NUC_28.L_CORE X_NUC_90.L_CORE 0.003215
K_3465 X_NUC_28.L_CORE X_NUC_91.L_CORE 0.003175
K_3466 X_NUC_28.L_CORE X_NUC_92.L_CORE 0.003198
K_3467 X_NUC_28.L_CORE X_NUC_93.L_CORE 0.001987
K_3468 X_NUC_28.L_CORE X_NUC_94.L_CORE 0.002000
K_3469 X_NUC_28.L_CORE X_NUC_95.L_CORE 0.001981
K_3470 X_NUC_28.L_CORE X_NUC_96.L_CORE 0.001989
K_3471 X_NUC_28.L_CORE X_NUC_97.L_CORE 0.002902
K_3472 X_NUC_28.L_CORE X_NUC_98.L_CORE 0.002917
K_3473 X_NUC_28.L_CORE X_NUC_99.L_CORE 0.002888
K_3474 X_NUC_28.L_CORE X_NUC_100.L_CORE 0.002880
K_3475 X_NUC_28.L_CORE X_NUC_101.L_CORE 0.002342
K_3476 X_NUC_28.L_CORE X_NUC_102.L_CORE 0.002349
K_3477 X_NUC_28.L_CORE X_NUC_103.L_CORE 0.002324
K_3478 X_NUC_28.L_CORE X_NUC_104.L_CORE 0.002339
K_3479 X_NUC_28.L_CORE X_NUC_105.L_CORE 0.002123
K_3480 X_NUC_28.L_CORE X_NUC_106.L_CORE 0.002138
K_3481 X_NUC_28.L_CORE X_NUC_107.L_CORE 0.002118
K_3482 X_NUC_28.L_CORE X_NUC_108.L_CORE 0.002121
K_3483 X_NUC_28.L_CORE X_NUC_109.L_CORE 0.002662
K_3484 X_NUC_28.L_CORE X_NUC_110.L_CORE 0.002669
K_3485 X_NUC_28.L_CORE X_NUC_111.L_CORE 0.002640
K_3486 X_NUC_28.L_CORE X_NUC_112.L_CORE 0.002646
K_3487 X_NUC_28.L_CORE X_NUC_113.L_CORE 0.002152
K_3488 X_NUC_28.L_CORE X_NUC_114.L_CORE 0.002163
K_3489 X_NUC_28.L_CORE X_NUC_115.L_CORE 0.002141
K_3490 X_NUC_28.L_CORE X_NUC_116.L_CORE 0.002149
K_3491 X_NUC_28.L_CORE X_NUC_117.L_CORE 0.003596
K_3492 X_NUC_28.L_CORE X_NUC_118.L_CORE 0.006095
K_3493 X_NUC_28.L_CORE X_NUC_119.L_CORE 0.002552
K_3494 X_NUC_28.L_CORE X_NUC_120.L_CORE 0.005245
K_3495 X_NUC_28.L_CORE X_NUC_121.L_CORE 0.003383
K_3496 X_NUC_28.L_CORE X_NUC_122.L_CORE 0.002396
K_3497 X_NUC_28.L_CORE X_NUC_123.L_CORE 0.024644
K_3498 X_NUC_28.L_CORE X_NUC_124.L_CORE 0.002258
K_3499 X_NUC_28.L_CORE X_NUC_125.L_CORE 0.003024
K_3500 X_NUC_28.L_CORE X_NUC_126.L_CORE 0.004193
K_3501 X_NUC_28.L_CORE X_NUC_127.L_CORE 0.002002
K_3502 X_NUC_28.L_CORE X_NUC_128.L_CORE 0.005083
K_3503 X_NUC_28.L_CORE X_NUC_129.L_CORE 0.002369
K_3504 X_NUC_28.L_CORE X_NUC_130.L_CORE 0.002203
K_3505 X_NUC_28.L_CORE X_NUC_131.L_CORE 0.004469
K_3506 X_NUC_28.L_CORE X_NUC_132.L_CORE 0.001920
K_3507 X_NUC_28.L_CORE X_NUC_133.L_CORE 0.002837
K_3508 X_NUC_28.L_CORE X_NUC_134.L_CORE 0.002601
K_3509 X_NUC_28.L_CORE X_NUC_135.L_CORE 0.001921
K_3510 X_NUC_28.L_CORE X_NUC_136.L_CORE 0.003157
K_3511 X_NUC_28.L_CORE X_NUC_137.L_CORE 0.002013
K_3512 X_NUC_28.L_CORE X_NUC_138.L_CORE 0.002167
K_3513 X_NUC_28.L_CORE X_NUC_139.L_CORE 0.002447
K_3514 X_NUC_28.L_CORE X_NUC_140.L_CORE 0.001995
K_3515 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_3516 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_3517 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_3518 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.002385
K_3519 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.002387
K_3520 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.002399
K_3521 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.002372
K_3522 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.003220
K_3523 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.003175
K_3524 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.003203
K_3525 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.003184
K_3526 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.004719
K_3527 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.004801
K_3528 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.004773
K_3529 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.004708
K_3530 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.002128
K_3531 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.002120
K_3532 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.002132
K_3533 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.002112
K_3534 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.006260
K_3535 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.006109
K_3536 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.006096
K_3537 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.006130
K_3538 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.002573
K_3539 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.002584
K_3540 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.002586
K_3541 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.002558
K_3542 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.002372
K_3543 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.002352
K_3544 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.002365
K_3545 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.002349
K_3546 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.006095
K_3547 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.006189
K_3548 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.006039
K_3549 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.006027
K_3550 X_NUC_29.L_CORE X_NUC_65.L_CORE 0.002056
K_3551 X_NUC_29.L_CORE X_NUC_66.L_CORE 0.002054
K_3552 X_NUC_29.L_CORE X_NUC_67.L_CORE 0.002060
K_3553 X_NUC_29.L_CORE X_NUC_68.L_CORE 0.002041
K_3554 X_NUC_29.L_CORE X_NUC_69.L_CORE 0.003274
K_3555 X_NUC_29.L_CORE X_NUC_70.L_CORE 0.003233
K_3556 X_NUC_29.L_CORE X_NUC_71.L_CORE 0.003237
K_3557 X_NUC_29.L_CORE X_NUC_72.L_CORE 0.003230
K_3558 X_NUC_29.L_CORE X_NUC_73.L_CORE 0.002994
K_3559 X_NUC_29.L_CORE X_NUC_74.L_CORE 0.003016
K_3560 X_NUC_29.L_CORE X_NUC_75.L_CORE 0.003001
K_3561 X_NUC_29.L_CORE X_NUC_76.L_CORE 0.002974
K_3562 X_NUC_29.L_CORE X_NUC_77.L_CORE 0.002051
K_3563 X_NUC_29.L_CORE X_NUC_78.L_CORE 0.002041
K_3564 X_NUC_29.L_CORE X_NUC_79.L_CORE 0.002047
K_3565 X_NUC_29.L_CORE X_NUC_80.L_CORE 0.002032
K_3566 X_NUC_29.L_CORE X_NUC_81.L_CORE 0.004331
K_3567 X_NUC_29.L_CORE X_NUC_82.L_CORE 0.004312
K_3568 X_NUC_29.L_CORE X_NUC_83.L_CORE 0.004257
K_3569 X_NUC_29.L_CORE X_NUC_84.L_CORE 0.004264
K_3570 X_NUC_29.L_CORE X_NUC_85.L_CORE 0.002172
K_3571 X_NUC_29.L_CORE X_NUC_86.L_CORE 0.002175
K_3572 X_NUC_29.L_CORE X_NUC_87.L_CORE 0.002175
K_3573 X_NUC_29.L_CORE X_NUC_88.L_CORE 0.002156
K_3574 X_NUC_29.L_CORE X_NUC_89.L_CORE 0.002410
K_3575 X_NUC_29.L_CORE X_NUC_90.L_CORE 0.002391
K_3576 X_NUC_29.L_CORE X_NUC_91.L_CORE 0.002394
K_3577 X_NUC_29.L_CORE X_NUC_92.L_CORE 0.002383
K_3578 X_NUC_29.L_CORE X_NUC_93.L_CORE 0.003193
K_3579 X_NUC_29.L_CORE X_NUC_94.L_CORE 0.003209
K_3580 X_NUC_29.L_CORE X_NUC_95.L_CORE 0.003178
K_3581 X_NUC_29.L_CORE X_NUC_96.L_CORE 0.003162
K_3582 X_NUC_29.L_CORE X_NUC_97.L_CORE 0.002004
K_3583 X_NUC_29.L_CORE X_NUC_98.L_CORE 0.002000
K_3584 X_NUC_29.L_CORE X_NUC_99.L_CORE 0.002001
K_3585 X_NUC_29.L_CORE X_NUC_100.L_CORE 0.001986
K_3586 X_NUC_29.L_CORE X_NUC_101.L_CORE 0.002866
K_3587 X_NUC_29.L_CORE X_NUC_102.L_CORE 0.002850
K_3588 X_NUC_29.L_CORE X_NUC_103.L_CORE 0.002837
K_3589 X_NUC_29.L_CORE X_NUC_104.L_CORE 0.002830
K_3590 X_NUC_29.L_CORE X_NUC_105.L_CORE 0.002357
K_3591 X_NUC_29.L_CORE X_NUC_106.L_CORE 0.002361
K_3592 X_NUC_29.L_CORE X_NUC_107.L_CORE 0.002352
K_3593 X_NUC_29.L_CORE X_NUC_108.L_CORE 0.002336
K_3594 X_NUC_29.L_CORE X_NUC_109.L_CORE 0.002167
K_3595 X_NUC_29.L_CORE X_NUC_110.L_CORE 0.002159
K_3596 X_NUC_29.L_CORE X_NUC_111.L_CORE 0.002157
K_3597 X_NUC_29.L_CORE X_NUC_112.L_CORE 0.002145
K_3598 X_NUC_29.L_CORE X_NUC_113.L_CORE 0.002524
K_3599 X_NUC_29.L_CORE X_NUC_114.L_CORE 0.002521
K_3600 X_NUC_29.L_CORE X_NUC_115.L_CORE 0.002508
K_3601 X_NUC_29.L_CORE X_NUC_116.L_CORE 0.002497
K_3602 X_NUC_29.L_CORE X_NUC_117.L_CORE 0.003276
K_3603 X_NUC_29.L_CORE X_NUC_118.L_CORE 0.003176
K_3604 X_NUC_29.L_CORE X_NUC_119.L_CORE 0.006467
K_3605 X_NUC_29.L_CORE X_NUC_120.L_CORE 0.002350
K_3606 X_NUC_29.L_CORE X_NUC_121.L_CORE 0.004893
K_3607 X_NUC_29.L_CORE X_NUC_122.L_CORE 0.003231
K_3608 X_NUC_29.L_CORE X_NUC_123.L_CORE 0.002268
K_3609 X_NUC_29.L_CORE X_NUC_124.L_CORE 0.022649
K_3610 X_NUC_29.L_CORE X_NUC_125.L_CORE 0.002179
K_3611 X_NUC_29.L_CORE X_NUC_126.L_CORE 0.002889
K_3612 X_NUC_29.L_CORE X_NUC_127.L_CORE 0.004129
K_3613 X_NUC_29.L_CORE X_NUC_128.L_CORE 0.001947
K_3614 X_NUC_29.L_CORE X_NUC_129.L_CORE 0.004874
K_3615 X_NUC_29.L_CORE X_NUC_130.L_CORE 0.002336
K_3616 X_NUC_29.L_CORE X_NUC_131.L_CORE 0.002154
K_3617 X_NUC_29.L_CORE X_NUC_132.L_CORE 0.004410
K_3618 X_NUC_29.L_CORE X_NUC_133.L_CORE 0.001903
K_3619 X_NUC_29.L_CORE X_NUC_134.L_CORE 0.002778
K_3620 X_NUC_29.L_CORE X_NUC_135.L_CORE 0.002591
K_3621 X_NUC_29.L_CORE X_NUC_136.L_CORE 0.001918
K_3622 X_NUC_29.L_CORE X_NUC_137.L_CORE 0.003056
K_3623 X_NUC_29.L_CORE X_NUC_138.L_CORE 0.002033
K_3624 X_NUC_29.L_CORE X_NUC_139.L_CORE 0.002167
K_3625 X_NUC_29.L_CORE X_NUC_140.L_CORE 0.002339
K_3626 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_3627 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_3628 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.002383
K_3629 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.002385
K_3630 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.002397
K_3631 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.002370
K_3632 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.003267
K_3633 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.003220
K_3634 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.003249
K_3635 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.003229
K_3636 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.004639
K_3637 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.004719
K_3638 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.004691
K_3639 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.004629
K_3640 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.002137
K_3641 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.002128
K_3642 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.002140
K_3643 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.002120
K_3644 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.006417
K_3645 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.006260
K_3646 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.006244
K_3647 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.006280
K_3648 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.002561
K_3649 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.002573
K_3650 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.002575
K_3651 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.002547
K_3652 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.002392
K_3653 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.002372
K_3654 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.002385
K_3655 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.002368
K_3656 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.006000
K_3657 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.006095
K_3658 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.005950
K_3659 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.005938
K_3660 X_NUC_30.L_CORE X_NUC_65.L_CORE 0.002058
K_3661 X_NUC_30.L_CORE X_NUC_66.L_CORE 0.002056
K_3662 X_NUC_30.L_CORE X_NUC_67.L_CORE 0.002062
K_3663 X_NUC_30.L_CORE X_NUC_68.L_CORE 0.002043
K_3664 X_NUC_30.L_CORE X_NUC_69.L_CORE 0.003316
K_3665 X_NUC_30.L_CORE X_NUC_70.L_CORE 0.003274
K_3666 X_NUC_30.L_CORE X_NUC_71.L_CORE 0.003278
K_3667 X_NUC_30.L_CORE X_NUC_72.L_CORE 0.003270
K_3668 X_NUC_30.L_CORE X_NUC_73.L_CORE 0.002971
K_3669 X_NUC_30.L_CORE X_NUC_74.L_CORE 0.002994
K_3670 X_NUC_30.L_CORE X_NUC_75.L_CORE 0.002978
K_3671 X_NUC_30.L_CORE X_NUC_76.L_CORE 0.002952
K_3672 X_NUC_30.L_CORE X_NUC_77.L_CORE 0.002061
K_3673 X_NUC_30.L_CORE X_NUC_78.L_CORE 0.002051
K_3674 X_NUC_30.L_CORE X_NUC_79.L_CORE 0.002057
K_3675 X_NUC_30.L_CORE X_NUC_80.L_CORE 0.002042
K_3676 X_NUC_30.L_CORE X_NUC_81.L_CORE 0.004348
K_3677 X_NUC_30.L_CORE X_NUC_82.L_CORE 0.004331
K_3678 X_NUC_30.L_CORE X_NUC_83.L_CORE 0.004274
K_3679 X_NUC_30.L_CORE X_NUC_84.L_CORE 0.004281
K_3680 X_NUC_30.L_CORE X_NUC_85.L_CORE 0.002169
K_3681 X_NUC_30.L_CORE X_NUC_86.L_CORE 0.002172
K_3682 X_NUC_30.L_CORE X_NUC_87.L_CORE 0.002171
K_3683 X_NUC_30.L_CORE X_NUC_88.L_CORE 0.002153
K_3684 X_NUC_30.L_CORE X_NUC_89.L_CORE 0.002428
K_3685 X_NUC_30.L_CORE X_NUC_90.L_CORE 0.002410
K_3686 X_NUC_30.L_CORE X_NUC_91.L_CORE 0.002412
K_3687 X_NUC_30.L_CORE X_NUC_92.L_CORE 0.002401
K_3688 X_NUC_30.L_CORE X_NUC_93.L_CORE 0.003177
K_3689 X_NUC_30.L_CORE X_NUC_94.L_CORE 0.003193
K_3690 X_NUC_30.L_CORE X_NUC_95.L_CORE 0.003163
K_3691 X_NUC_30.L_CORE X_NUC_96.L_CORE 0.003147
K_3692 X_NUC_30.L_CORE X_NUC_97.L_CORE 0.002008
K_3693 X_NUC_30.L_CORE X_NUC_98.L_CORE 0.002004
K_3694 X_NUC_30.L_CORE X_NUC_99.L_CORE 0.002006
K_3695 X_NUC_30.L_CORE X_NUC_100.L_CORE 0.001991
K_3696 X_NUC_30.L_CORE X_NUC_101.L_CORE 0.002882
K_3697 X_NUC_30.L_CORE X_NUC_102.L_CORE 0.002866
K_3698 X_NUC_30.L_CORE X_NUC_103.L_CORE 0.002852
K_3699 X_NUC_30.L_CORE X_NUC_104.L_CORE 0.002845
K_3700 X_NUC_30.L_CORE X_NUC_105.L_CORE 0.002352
K_3701 X_NUC_30.L_CORE X_NUC_106.L_CORE 0.002357
K_3702 X_NUC_30.L_CORE X_NUC_107.L_CORE 0.002348
K_3703 X_NUC_30.L_CORE X_NUC_108.L_CORE 0.002332
K_3704 X_NUC_30.L_CORE X_NUC_109.L_CORE 0.002176
K_3705 X_NUC_30.L_CORE X_NUC_110.L_CORE 0.002167
K_3706 X_NUC_30.L_CORE X_NUC_111.L_CORE 0.002166
K_3707 X_NUC_30.L_CORE X_NUC_112.L_CORE 0.002153
K_3708 X_NUC_30.L_CORE X_NUC_113.L_CORE 0.002526
K_3709 X_NUC_30.L_CORE X_NUC_114.L_CORE 0.002524
K_3710 X_NUC_30.L_CORE X_NUC_115.L_CORE 0.002511
K_3711 X_NUC_30.L_CORE X_NUC_116.L_CORE 0.002500
K_3712 X_NUC_30.L_CORE X_NUC_117.L_CORE 0.003278
K_3713 X_NUC_30.L_CORE X_NUC_118.L_CORE 0.003208
K_3714 X_NUC_30.L_CORE X_NUC_119.L_CORE 0.006384
K_3715 X_NUC_30.L_CORE X_NUC_120.L_CORE 0.002356
K_3716 X_NUC_30.L_CORE X_NUC_121.L_CORE 0.005005
K_3717 X_NUC_30.L_CORE X_NUC_122.L_CORE 0.003205
K_3718 X_NUC_30.L_CORE X_NUC_123.L_CORE 0.002284
K_3719 X_NUC_30.L_CORE X_NUC_124.L_CORE 0.021984
K_3720 X_NUC_30.L_CORE X_NUC_125.L_CORE 0.002177
K_3721 X_NUC_30.L_CORE X_NUC_126.L_CORE 0.002927
K_3722 X_NUC_30.L_CORE X_NUC_127.L_CORE 0.004064
K_3723 X_NUC_30.L_CORE X_NUC_128.L_CORE 0.001954
K_3724 X_NUC_30.L_CORE X_NUC_129.L_CORE 0.004954
K_3725 X_NUC_30.L_CORE X_NUC_130.L_CORE 0.002326
K_3726 X_NUC_30.L_CORE X_NUC_131.L_CORE 0.002170
K_3727 X_NUC_30.L_CORE X_NUC_132.L_CORE 0.004370
K_3728 X_NUC_30.L_CORE X_NUC_133.L_CORE 0.001904
K_3729 X_NUC_30.L_CORE X_NUC_134.L_CORE 0.002804
K_3730 X_NUC_30.L_CORE X_NUC_135.L_CORE 0.002577
K_3731 X_NUC_30.L_CORE X_NUC_136.L_CORE 0.001926
K_3732 X_NUC_30.L_CORE X_NUC_137.L_CORE 0.003062
K_3733 X_NUC_30.L_CORE X_NUC_138.L_CORE 0.002032
K_3734 X_NUC_30.L_CORE X_NUC_139.L_CORE 0.002177
K_3735 X_NUC_30.L_CORE X_NUC_140.L_CORE 0.002339
K_3736 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_3737 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.002372
K_3738 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.002373
K_3739 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.002385
K_3740 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.002358
K_3741 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.003237
K_3742 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.003192
K_3743 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.003220
K_3744 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.003201
K_3745 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.004665
K_3746 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.004745
K_3747 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.004719
K_3748 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.004655
K_3749 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.002125
K_3750 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.002116
K_3751 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.002128
K_3752 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.002109
K_3753 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.006432
K_3754 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.006271
K_3755 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.006260
K_3756 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.006294
K_3757 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.002558
K_3758 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.002570
K_3759 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.002573
K_3760 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.002545
K_3761 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.002380
K_3762 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.002359
K_3763 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.002372
K_3764 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.002356
K_3765 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.006146
K_3766 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.006245
K_3767 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.006095
K_3768 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.006080
K_3769 X_NUC_31.L_CORE X_NUC_65.L_CORE 0.002052
K_3770 X_NUC_31.L_CORE X_NUC_66.L_CORE 0.002050
K_3771 X_NUC_31.L_CORE X_NUC_67.L_CORE 0.002056
K_3772 X_NUC_31.L_CORE X_NUC_68.L_CORE 0.002037
K_3773 X_NUC_31.L_CORE X_NUC_69.L_CORE 0.003313
K_3774 X_NUC_31.L_CORE X_NUC_70.L_CORE 0.003270
K_3775 X_NUC_31.L_CORE X_NUC_71.L_CORE 0.003274
K_3776 X_NUC_31.L_CORE X_NUC_72.L_CORE 0.003267
K_3777 X_NUC_31.L_CORE X_NUC_73.L_CORE 0.002986
K_3778 X_NUC_31.L_CORE X_NUC_74.L_CORE 0.003009
K_3779 X_NUC_31.L_CORE X_NUC_75.L_CORE 0.002994
K_3780 X_NUC_31.L_CORE X_NUC_76.L_CORE 0.002967
K_3781 X_NUC_31.L_CORE X_NUC_77.L_CORE 0.002054
K_3782 X_NUC_31.L_CORE X_NUC_78.L_CORE 0.002044
K_3783 X_NUC_31.L_CORE X_NUC_79.L_CORE 0.002051
K_3784 X_NUC_31.L_CORE X_NUC_80.L_CORE 0.002036
K_3785 X_NUC_31.L_CORE X_NUC_81.L_CORE 0.004407
K_3786 X_NUC_31.L_CORE X_NUC_82.L_CORE 0.004388
K_3787 X_NUC_31.L_CORE X_NUC_83.L_CORE 0.004331
K_3788 X_NUC_31.L_CORE X_NUC_84.L_CORE 0.004337
K_3789 X_NUC_31.L_CORE X_NUC_85.L_CORE 0.002169
K_3790 X_NUC_31.L_CORE X_NUC_86.L_CORE 0.002173
K_3791 X_NUC_31.L_CORE X_NUC_87.L_CORE 0.002172
K_3792 X_NUC_31.L_CORE X_NUC_88.L_CORE 0.002153
K_3793 X_NUC_31.L_CORE X_NUC_89.L_CORE 0.002425
K_3794 X_NUC_31.L_CORE X_NUC_90.L_CORE 0.002407
K_3795 X_NUC_31.L_CORE X_NUC_91.L_CORE 0.002410
K_3796 X_NUC_31.L_CORE X_NUC_92.L_CORE 0.002398
K_3797 X_NUC_31.L_CORE X_NUC_93.L_CORE 0.003208
K_3798 X_NUC_31.L_CORE X_NUC_94.L_CORE 0.003224
K_3799 X_NUC_31.L_CORE X_NUC_95.L_CORE 0.003193
K_3800 X_NUC_31.L_CORE X_NUC_96.L_CORE 0.003177
K_3801 X_NUC_31.L_CORE X_NUC_97.L_CORE 0.002007
K_3802 X_NUC_31.L_CORE X_NUC_98.L_CORE 0.002002
K_3803 X_NUC_31.L_CORE X_NUC_99.L_CORE 0.002004
K_3804 X_NUC_31.L_CORE X_NUC_100.L_CORE 0.001989
K_3805 X_NUC_31.L_CORE X_NUC_101.L_CORE 0.002895
K_3806 X_NUC_31.L_CORE X_NUC_102.L_CORE 0.002879
K_3807 X_NUC_31.L_CORE X_NUC_103.L_CORE 0.002866
K_3808 X_NUC_31.L_CORE X_NUC_104.L_CORE 0.002858
K_3809 X_NUC_31.L_CORE X_NUC_105.L_CORE 0.002361
K_3810 X_NUC_31.L_CORE X_NUC_106.L_CORE 0.002365
K_3811 X_NUC_31.L_CORE X_NUC_107.L_CORE 0.002357
K_3812 X_NUC_31.L_CORE X_NUC_108.L_CORE 0.002340
K_3813 X_NUC_31.L_CORE X_NUC_109.L_CORE 0.002177
K_3814 X_NUC_31.L_CORE X_NUC_110.L_CORE 0.002169
K_3815 X_NUC_31.L_CORE X_NUC_111.L_CORE 0.002167
K_3816 X_NUC_31.L_CORE X_NUC_112.L_CORE 0.002155
K_3817 X_NUC_31.L_CORE X_NUC_113.L_CORE 0.002539
K_3818 X_NUC_31.L_CORE X_NUC_114.L_CORE 0.002536
K_3819 X_NUC_31.L_CORE X_NUC_115.L_CORE 0.002524
K_3820 X_NUC_31.L_CORE X_NUC_116.L_CORE 0.002512
K_3821 X_NUC_31.L_CORE X_NUC_117.L_CORE 0.003237
K_3822 X_NUC_31.L_CORE X_NUC_118.L_CORE 0.003162
K_3823 X_NUC_31.L_CORE X_NUC_119.L_CORE 0.006275
K_3824 X_NUC_31.L_CORE X_NUC_120.L_CORE 0.002337
K_3825 X_NUC_31.L_CORE X_NUC_121.L_CORE 0.004917
K_3826 X_NUC_31.L_CORE X_NUC_122.L_CORE 0.003194
K_3827 X_NUC_31.L_CORE X_NUC_123.L_CORE 0.002266
K_3828 X_NUC_31.L_CORE X_NUC_124.L_CORE 0.024156
K_3829 X_NUC_31.L_CORE X_NUC_125.L_CORE 0.002168
K_3830 X_NUC_31.L_CORE X_NUC_126.L_CORE 0.002907
K_3831 X_NUC_31.L_CORE X_NUC_127.L_CORE 0.004097
K_3832 X_NUC_31.L_CORE X_NUC_128.L_CORE 0.001945
K_3833 X_NUC_31.L_CORE X_NUC_129.L_CORE 0.004987
K_3834 X_NUC_31.L_CORE X_NUC_130.L_CORE 0.002327
K_3835 X_NUC_31.L_CORE X_NUC_131.L_CORE 0.002162
K_3836 X_NUC_31.L_CORE X_NUC_132.L_CORE 0.004450
K_3837 X_NUC_31.L_CORE X_NUC_133.L_CORE 0.001901
K_3838 X_NUC_31.L_CORE X_NUC_134.L_CORE 0.002808
K_3839 X_NUC_31.L_CORE X_NUC_135.L_CORE 0.002592
K_3840 X_NUC_31.L_CORE X_NUC_136.L_CORE 0.001923
K_3841 X_NUC_31.L_CORE X_NUC_137.L_CORE 0.003090
K_3842 X_NUC_31.L_CORE X_NUC_138.L_CORE 0.002035
K_3843 X_NUC_31.L_CORE X_NUC_139.L_CORE 0.002181
K_3844 X_NUC_31.L_CORE X_NUC_140.L_CORE 0.002351
K_3845 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.002399
K_3846 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.002401
K_3847 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.002413
K_3848 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.002385
K_3849 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.003257
K_3850 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.003211
K_3851 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.003239
K_3852 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.003220
K_3853 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.004728
K_3854 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.004812
K_3855 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.004784
K_3856 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.004719
K_3857 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.002145
K_3858 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.002136
K_3859 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.002148
K_3860 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.002128
K_3861 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.006393
K_3862 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.006235
K_3863 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.006221
K_3864 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.006260
K_3865 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.002587
K_3866 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.002599
K_3867 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.002601
K_3868 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.002573
K_3869 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.002396
K_3870 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.002376
K_3871 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.002388
K_3872 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.002372
K_3873 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.006159
K_3874 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.006259
K_3875 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.006104
K_3876 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.006095
K_3877 X_NUC_32.L_CORE X_NUC_65.L_CORE 0.002071
K_3878 X_NUC_32.L_CORE X_NUC_66.L_CORE 0.002069
K_3879 X_NUC_32.L_CORE X_NUC_67.L_CORE 0.002075
K_3880 X_NUC_32.L_CORE X_NUC_68.L_CORE 0.002056
K_3881 X_NUC_32.L_CORE X_NUC_69.L_CORE 0.003320
K_3882 X_NUC_32.L_CORE X_NUC_70.L_CORE 0.003277
K_3883 X_NUC_32.L_CORE X_NUC_71.L_CORE 0.003281
K_3884 X_NUC_32.L_CORE X_NUC_72.L_CORE 0.003274
K_3885 X_NUC_32.L_CORE X_NUC_73.L_CORE 0.003013
K_3886 X_NUC_32.L_CORE X_NUC_74.L_CORE 0.003037
K_3887 X_NUC_32.L_CORE X_NUC_75.L_CORE 0.003021
K_3888 X_NUC_32.L_CORE X_NUC_76.L_CORE 0.002994
K_3889 X_NUC_32.L_CORE X_NUC_77.L_CORE 0.002070
K_3890 X_NUC_32.L_CORE X_NUC_78.L_CORE 0.002060
K_3891 X_NUC_32.L_CORE X_NUC_79.L_CORE 0.002066
K_3892 X_NUC_32.L_CORE X_NUC_80.L_CORE 0.002051
K_3893 X_NUC_32.L_CORE X_NUC_81.L_CORE 0.004399
K_3894 X_NUC_32.L_CORE X_NUC_82.L_CORE 0.004381
K_3895 X_NUC_32.L_CORE X_NUC_83.L_CORE 0.004323
K_3896 X_NUC_32.L_CORE X_NUC_84.L_CORE 0.004331
K_3897 X_NUC_32.L_CORE X_NUC_85.L_CORE 0.002188
K_3898 X_NUC_32.L_CORE X_NUC_86.L_CORE 0.002192
K_3899 X_NUC_32.L_CORE X_NUC_87.L_CORE 0.002191
K_3900 X_NUC_32.L_CORE X_NUC_88.L_CORE 0.002172
K_3901 X_NUC_32.L_CORE X_NUC_89.L_CORE 0.002437
K_3902 X_NUC_32.L_CORE X_NUC_90.L_CORE 0.002419
K_3903 X_NUC_32.L_CORE X_NUC_91.L_CORE 0.002421
K_3904 X_NUC_32.L_CORE X_NUC_92.L_CORE 0.002410
K_3905 X_NUC_32.L_CORE X_NUC_93.L_CORE 0.003224
K_3906 X_NUC_32.L_CORE X_NUC_94.L_CORE 0.003241
K_3907 X_NUC_32.L_CORE X_NUC_95.L_CORE 0.003209
K_3908 X_NUC_32.L_CORE X_NUC_96.L_CORE 0.003193
K_3909 X_NUC_32.L_CORE X_NUC_97.L_CORE 0.002022
K_3910 X_NUC_32.L_CORE X_NUC_98.L_CORE 0.002017
K_3911 X_NUC_32.L_CORE X_NUC_99.L_CORE 0.002019
K_3912 X_NUC_32.L_CORE X_NUC_100.L_CORE 0.002004
K_3913 X_NUC_32.L_CORE X_NUC_101.L_CORE 0.002903
K_3914 X_NUC_32.L_CORE X_NUC_102.L_CORE 0.002886
K_3915 X_NUC_32.L_CORE X_NUC_103.L_CORE 0.002873
K_3916 X_NUC_32.L_CORE X_NUC_104.L_CORE 0.002866
K_3917 X_NUC_32.L_CORE X_NUC_105.L_CORE 0.002377
K_3918 X_NUC_32.L_CORE X_NUC_106.L_CORE 0.002382
K_3919 X_NUC_32.L_CORE X_NUC_107.L_CORE 0.002373
K_3920 X_NUC_32.L_CORE X_NUC_108.L_CORE 0.002357
K_3921 X_NUC_32.L_CORE X_NUC_109.L_CORE 0.002190
K_3922 X_NUC_32.L_CORE X_NUC_110.L_CORE 0.002181
K_3923 X_NUC_32.L_CORE X_NUC_111.L_CORE 0.002180
K_3924 X_NUC_32.L_CORE X_NUC_112.L_CORE 0.002167
K_3925 X_NUC_32.L_CORE X_NUC_113.L_CORE 0.002551
K_3926 X_NUC_32.L_CORE X_NUC_114.L_CORE 0.002548
K_3927 X_NUC_32.L_CORE X_NUC_115.L_CORE 0.002535
K_3928 X_NUC_32.L_CORE X_NUC_116.L_CORE 0.002524
K_3929 X_NUC_32.L_CORE X_NUC_117.L_CORE 0.003282
K_3930 X_NUC_32.L_CORE X_NUC_118.L_CORE 0.003194
K_3931 X_NUC_32.L_CORE X_NUC_119.L_CORE 0.006397
K_3932 X_NUC_32.L_CORE X_NUC_120.L_CORE 0.002363
K_3933 X_NUC_32.L_CORE X_NUC_121.L_CORE 0.004934
K_3934 X_NUC_32.L_CORE X_NUC_122.L_CORE 0.003236
K_3935 X_NUC_32.L_CORE X_NUC_123.L_CORE 0.002285
K_3936 X_NUC_32.L_CORE X_NUC_124.L_CORE 0.021863
K_3937 X_NUC_32.L_CORE X_NUC_125.L_CORE 0.002191
K_3938 X_NUC_32.L_CORE X_NUC_126.L_CORE 0.002920
K_3939 X_NUC_32.L_CORE X_NUC_127.L_CORE 0.004136
K_3940 X_NUC_32.L_CORE X_NUC_128.L_CORE 0.001962
K_3941 X_NUC_32.L_CORE X_NUC_129.L_CORE 0.004950
K_3942 X_NUC_32.L_CORE X_NUC_130.L_CORE 0.002349
K_3943 X_NUC_32.L_CORE X_NUC_131.L_CORE 0.002175
K_3944 X_NUC_32.L_CORE X_NUC_132.L_CORE 0.004448
K_3945 X_NUC_32.L_CORE X_NUC_133.L_CORE 0.001917
K_3946 X_NUC_32.L_CORE X_NUC_134.L_CORE 0.002812
K_3947 X_NUC_32.L_CORE X_NUC_135.L_CORE 0.002610
K_3948 X_NUC_32.L_CORE X_NUC_136.L_CORE 0.001935
K_3949 X_NUC_32.L_CORE X_NUC_137.L_CORE 0.003092
K_3950 X_NUC_32.L_CORE X_NUC_138.L_CORE 0.002049
K_3951 X_NUC_32.L_CORE X_NUC_139.L_CORE 0.002190
K_3952 X_NUC_32.L_CORE X_NUC_140.L_CORE 0.002361
K_3953 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_3954 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_3955 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_3956 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.002304
K_3957 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.002286
K_3958 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.002286
K_3959 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.002303
K_3960 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.003124
K_3961 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.003143
K_3962 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.003108
K_3963 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.003151
K_3964 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.004605
K_3965 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.004508
K_3966 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.004541
K_3967 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.004536
K_3968 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.002077
K_3969 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.002070
K_3970 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.002062
K_3971 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.002081
K_3972 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.006205
K_3973 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.006338
K_3974 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.006156
K_3975 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.006239
K_3976 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.002528
K_3977 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.002501
K_3978 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.002502
K_3979 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.002515
K_3980 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.002336
K_3981 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.002340
K_3982 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.002320
K_3983 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.002345
K_3984 X_NUC_33.L_CORE X_NUC_65.L_CORE 0.006131
K_3985 X_NUC_33.L_CORE X_NUC_66.L_CORE 0.006047
K_3986 X_NUC_33.L_CORE X_NUC_67.L_CORE 0.006004
K_3987 X_NUC_33.L_CORE X_NUC_68.L_CORE 0.005963
K_3988 X_NUC_33.L_CORE X_NUC_69.L_CORE 0.002034
K_3989 X_NUC_33.L_CORE X_NUC_70.L_CORE 0.002023
K_3990 X_NUC_33.L_CORE X_NUC_71.L_CORE 0.002017
K_3991 X_NUC_33.L_CORE X_NUC_72.L_CORE 0.002032
K_3992 X_NUC_33.L_CORE X_NUC_73.L_CORE 0.003260
K_3993 X_NUC_33.L_CORE X_NUC_74.L_CORE 0.003284
K_3994 X_NUC_33.L_CORE X_NUC_75.L_CORE 0.003234
K_3995 X_NUC_33.L_CORE X_NUC_76.L_CORE 0.003268
K_3996 X_NUC_33.L_CORE X_NUC_77.L_CORE 0.002984
K_3997 X_NUC_33.L_CORE X_NUC_78.L_CORE 0.002950
K_3998 X_NUC_33.L_CORE X_NUC_79.L_CORE 0.002947
K_3999 X_NUC_33.L_CORE X_NUC_80.L_CORE 0.002953
K_4000 X_NUC_33.L_CORE X_NUC_81.L_CORE 0.002045
K_4001 X_NUC_33.L_CORE X_NUC_82.L_CORE 0.002042
K_4002 X_NUC_33.L_CORE X_NUC_83.L_CORE 0.002029
K_4003 X_NUC_33.L_CORE X_NUC_84.L_CORE 0.002046
K_4004 X_NUC_33.L_CORE X_NUC_85.L_CORE 0.004331
K_4005 X_NUC_33.L_CORE X_NUC_86.L_CORE 0.004345
K_4006 X_NUC_33.L_CORE X_NUC_87.L_CORE 0.004270
K_4007 X_NUC_33.L_CORE X_NUC_88.L_CORE 0.004282
K_4008 X_NUC_33.L_CORE X_NUC_89.L_CORE 0.002178
K_4009 X_NUC_33.L_CORE X_NUC_90.L_CORE 0.002163
K_4010 X_NUC_33.L_CORE X_NUC_91.L_CORE 0.002156
K_4011 X_NUC_33.L_CORE X_NUC_92.L_CORE 0.002168
K_4012 X_NUC_33.L_CORE X_NUC_93.L_CORE 0.002420
K_4013 X_NUC_33.L_CORE X_NUC_94.L_CORE 0.002425
K_4014 X_NUC_33.L_CORE X_NUC_95.L_CORE 0.002399
K_4015 X_NUC_33.L_CORE X_NUC_96.L_CORE 0.002420
K_4016 X_NUC_33.L_CORE X_NUC_97.L_CORE 0.003180
K_4017 X_NUC_33.L_CORE X_NUC_98.L_CORE 0.003157
K_4018 X_NUC_33.L_CORE X_NUC_99.L_CORE 0.003136
K_4019 X_NUC_33.L_CORE X_NUC_100.L_CORE 0.003141
K_4020 X_NUC_33.L_CORE X_NUC_101.L_CORE 0.002035
K_4021 X_NUC_33.L_CORE X_NUC_102.L_CORE 0.002028
K_4022 X_NUC_33.L_CORE X_NUC_103.L_CORE 0.002016
K_4023 X_NUC_33.L_CORE X_NUC_104.L_CORE 0.002031
K_4024 X_NUC_33.L_CORE X_NUC_105.L_CORE 0.002839
K_4025 X_NUC_33.L_CORE X_NUC_106.L_CORE 0.002842
K_4026 X_NUC_33.L_CORE X_NUC_107.L_CORE 0.002808
K_4027 X_NUC_33.L_CORE X_NUC_108.L_CORE 0.002825
K_4028 X_NUC_33.L_CORE X_NUC_109.L_CORE 0.002384
K_4029 X_NUC_33.L_CORE X_NUC_110.L_CORE 0.002371
K_4030 X_NUC_33.L_CORE X_NUC_111.L_CORE 0.002357
K_4031 X_NUC_33.L_CORE X_NUC_112.L_CORE 0.002368
K_4032 X_NUC_33.L_CORE X_NUC_113.L_CORE 0.002256
K_4033 X_NUC_33.L_CORE X_NUC_114.L_CORE 0.002252
K_4034 X_NUC_33.L_CORE X_NUC_115.L_CORE 0.002234
K_4035 X_NUC_33.L_CORE X_NUC_116.L_CORE 0.002248
K_4036 X_NUC_33.L_CORE X_NUC_117.L_CORE 0.004403
K_4037 X_NUC_33.L_CORE X_NUC_118.L_CORE 0.002875
K_4038 X_NUC_33.L_CORE X_NUC_119.L_CORE 0.002932
K_4039 X_NUC_33.L_CORE X_NUC_120.L_CORE 0.006376
K_4040 X_NUC_33.L_CORE X_NUC_121.L_CORE 0.002201
K_4041 X_NUC_33.L_CORE X_NUC_122.L_CORE 0.004757
K_4042 X_NUC_33.L_CORE X_NUC_123.L_CORE 0.003051
K_4043 X_NUC_33.L_CORE X_NUC_124.L_CORE 0.002186
K_4044 X_NUC_33.L_CORE X_NUC_125.L_CORE 0.021584
K_4045 X_NUC_33.L_CORE X_NUC_126.L_CORE 0.002105
K_4046 X_NUC_33.L_CORE X_NUC_127.L_CORE 0.002842
K_4047 X_NUC_33.L_CORE X_NUC_128.L_CORE 0.003974
K_4048 X_NUC_33.L_CORE X_NUC_129.L_CORE 0.001911
K_4049 X_NUC_33.L_CORE X_NUC_130.L_CORE 0.004887
K_4050 X_NUC_33.L_CORE X_NUC_131.L_CORE 0.002292
K_4051 X_NUC_33.L_CORE X_NUC_132.L_CORE 0.002145
K_4052 X_NUC_33.L_CORE X_NUC_133.L_CORE 0.004324
K_4053 X_NUC_33.L_CORE X_NUC_134.L_CORE 0.001896
K_4054 X_NUC_33.L_CORE X_NUC_135.L_CORE 0.002785
K_4055 X_NUC_33.L_CORE X_NUC_136.L_CORE 0.002568
K_4056 X_NUC_33.L_CORE X_NUC_137.L_CORE 0.001943
K_4057 X_NUC_33.L_CORE X_NUC_138.L_CORE 0.002970
K_4058 X_NUC_33.L_CORE X_NUC_139.L_CORE 0.002073
K_4059 X_NUC_33.L_CORE X_NUC_140.L_CORE 0.002206
K_4060 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_4061 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_4062 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.002323
K_4063 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.002304
K_4064 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.002304
K_4065 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.002322
K_4066 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.003105
K_4067 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.003124
K_4068 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.003090
K_4069 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.003132
K_4070 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.004706
K_4071 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.004605
K_4072 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.004639
K_4073 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.004634
K_4074 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.002084
K_4075 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.002077
K_4076 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.002069
K_4077 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.002088
K_4078 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.006074
K_4079 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.006205
K_4080 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.006032
K_4081 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.006109
K_4082 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.002555
K_4083 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.002528
K_4084 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.002529
K_4085 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.002542
K_4086 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.002333
K_4087 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.002336
K_4088 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.002317
K_4089 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.002342
K_4090 X_NUC_34.L_CORE X_NUC_65.L_CORE 0.006214
K_4091 X_NUC_34.L_CORE X_NUC_66.L_CORE 0.006131
K_4092 X_NUC_34.L_CORE X_NUC_67.L_CORE 0.006085
K_4093 X_NUC_34.L_CORE X_NUC_68.L_CORE 0.006041
K_4094 X_NUC_34.L_CORE X_NUC_69.L_CORE 0.002045
K_4095 X_NUC_34.L_CORE X_NUC_70.L_CORE 0.002034
K_4096 X_NUC_34.L_CORE X_NUC_71.L_CORE 0.002028
K_4097 X_NUC_34.L_CORE X_NUC_72.L_CORE 0.002043
K_4098 X_NUC_34.L_CORE X_NUC_73.L_CORE 0.003236
K_4099 X_NUC_34.L_CORE X_NUC_74.L_CORE 0.003260
K_4100 X_NUC_34.L_CORE X_NUC_75.L_CORE 0.003211
K_4101 X_NUC_34.L_CORE X_NUC_76.L_CORE 0.003244
K_4102 X_NUC_34.L_CORE X_NUC_77.L_CORE 0.003019
K_4103 X_NUC_34.L_CORE X_NUC_78.L_CORE 0.002984
K_4104 X_NUC_34.L_CORE X_NUC_79.L_CORE 0.002981
K_4105 X_NUC_34.L_CORE X_NUC_80.L_CORE 0.002987
K_4106 X_NUC_34.L_CORE X_NUC_81.L_CORE 0.002048
K_4107 X_NUC_34.L_CORE X_NUC_82.L_CORE 0.002045
K_4108 X_NUC_34.L_CORE X_NUC_83.L_CORE 0.002032
K_4109 X_NUC_34.L_CORE X_NUC_84.L_CORE 0.002050
K_4110 X_NUC_34.L_CORE X_NUC_85.L_CORE 0.004316
K_4111 X_NUC_34.L_CORE X_NUC_86.L_CORE 0.004331
K_4112 X_NUC_34.L_CORE X_NUC_87.L_CORE 0.004256
K_4113 X_NUC_34.L_CORE X_NUC_88.L_CORE 0.004268
K_4114 X_NUC_34.L_CORE X_NUC_89.L_CORE 0.002193
K_4115 X_NUC_34.L_CORE X_NUC_90.L_CORE 0.002178
K_4116 X_NUC_34.L_CORE X_NUC_91.L_CORE 0.002171
K_4117 X_NUC_34.L_CORE X_NUC_92.L_CORE 0.002183
K_4118 X_NUC_34.L_CORE X_NUC_93.L_CORE 0.002415
K_4119 X_NUC_34.L_CORE X_NUC_94.L_CORE 0.002420
K_4120 X_NUC_34.L_CORE X_NUC_95.L_CORE 0.002395
K_4121 X_NUC_34.L_CORE X_NUC_96.L_CORE 0.002416
K_4122 X_NUC_34.L_CORE X_NUC_97.L_CORE 0.003202
K_4123 X_NUC_34.L_CORE X_NUC_98.L_CORE 0.003180
K_4124 X_NUC_34.L_CORE X_NUC_99.L_CORE 0.003158
K_4125 X_NUC_34.L_CORE X_NUC_100.L_CORE 0.003163
K_4126 X_NUC_34.L_CORE X_NUC_101.L_CORE 0.002042
K_4127 X_NUC_34.L_CORE X_NUC_102.L_CORE 0.002035
K_4128 X_NUC_34.L_CORE X_NUC_103.L_CORE 0.002023
K_4129 X_NUC_34.L_CORE X_NUC_104.L_CORE 0.002038
K_4130 X_NUC_34.L_CORE X_NUC_105.L_CORE 0.002834
K_4131 X_NUC_34.L_CORE X_NUC_106.L_CORE 0.002839
K_4132 X_NUC_34.L_CORE X_NUC_107.L_CORE 0.002804
K_4133 X_NUC_34.L_CORE X_NUC_108.L_CORE 0.002821
K_4134 X_NUC_34.L_CORE X_NUC_109.L_CORE 0.002397
K_4135 X_NUC_34.L_CORE X_NUC_110.L_CORE 0.002384
K_4136 X_NUC_34.L_CORE X_NUC_111.L_CORE 0.002370
K_4137 X_NUC_34.L_CORE X_NUC_112.L_CORE 0.002381
K_4138 X_NUC_34.L_CORE X_NUC_113.L_CORE 0.002260
K_4139 X_NUC_34.L_CORE X_NUC_114.L_CORE 0.002256
K_4140 X_NUC_34.L_CORE X_NUC_115.L_CORE 0.002237
K_4141 X_NUC_34.L_CORE X_NUC_116.L_CORE 0.002252
K_4142 X_NUC_34.L_CORE X_NUC_117.L_CORE 0.004420
K_4143 X_NUC_34.L_CORE X_NUC_118.L_CORE 0.002902
K_4144 X_NUC_34.L_CORE X_NUC_119.L_CORE 0.002927
K_4145 X_NUC_34.L_CORE X_NUC_120.L_CORE 0.006535
K_4146 X_NUC_34.L_CORE X_NUC_121.L_CORE 0.002213
K_4147 X_NUC_34.L_CORE X_NUC_122.L_CORE 0.004689
K_4148 X_NUC_34.L_CORE X_NUC_123.L_CORE 0.003095
K_4149 X_NUC_34.L_CORE X_NUC_124.L_CORE 0.002186
K_4150 X_NUC_34.L_CORE X_NUC_125.L_CORE 0.020796
K_4151 X_NUC_34.L_CORE X_NUC_126.L_CORE 0.002120
K_4152 X_NUC_34.L_CORE X_NUC_127.L_CORE 0.002824
K_4153 X_NUC_34.L_CORE X_NUC_128.L_CORE 0.004044
K_4154 X_NUC_34.L_CORE X_NUC_129.L_CORE 0.001917
K_4155 X_NUC_34.L_CORE X_NUC_130.L_CORE 0.004810
K_4156 X_NUC_34.L_CORE X_NUC_131.L_CORE 0.002314
K_4157 X_NUC_34.L_CORE X_NUC_132.L_CORE 0.002142
K_4158 X_NUC_34.L_CORE X_NUC_133.L_CORE 0.004353
K_4159 X_NUC_34.L_CORE X_NUC_134.L_CORE 0.001905
K_4160 X_NUC_34.L_CORE X_NUC_135.L_CORE 0.002771
K_4161 X_NUC_34.L_CORE X_NUC_136.L_CORE 0.002589
K_4162 X_NUC_34.L_CORE X_NUC_137.L_CORE 0.001946
K_4163 X_NUC_34.L_CORE X_NUC_138.L_CORE 0.002969
K_4164 X_NUC_34.L_CORE X_NUC_139.L_CORE 0.002083
K_4165 X_NUC_34.L_CORE X_NUC_140.L_CORE 0.002208
K_4166 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_4167 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.002323
K_4168 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.002304
K_4169 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.002304
K_4170 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.002322
K_4171 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.003139
K_4172 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.003159
K_4173 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.003124
K_4174 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.003167
K_4175 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.004669
K_4176 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.004570
K_4177 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.004605
K_4178 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.004599
K_4179 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.002092
K_4180 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.002085
K_4181 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.002077
K_4182 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.002097
K_4183 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.006249
K_4184 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.006388
K_4185 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.006205
K_4186 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.006287
K_4187 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.002553
K_4188 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.002526
K_4189 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.002528
K_4190 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.002540
K_4191 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.002352
K_4192 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.002356
K_4193 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.002336
K_4194 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.002361
K_4195 X_NUC_35.L_CORE X_NUC_65.L_CORE 0.006261
K_4196 X_NUC_35.L_CORE X_NUC_66.L_CORE 0.006173
K_4197 X_NUC_35.L_CORE X_NUC_67.L_CORE 0.006131
K_4198 X_NUC_35.L_CORE X_NUC_68.L_CORE 0.006084
K_4199 X_NUC_35.L_CORE X_NUC_69.L_CORE 0.002052
K_4200 X_NUC_35.L_CORE X_NUC_70.L_CORE 0.002041
K_4201 X_NUC_35.L_CORE X_NUC_71.L_CORE 0.002034
K_4202 X_NUC_35.L_CORE X_NUC_72.L_CORE 0.002049
K_4203 X_NUC_35.L_CORE X_NUC_73.L_CORE 0.003285
K_4204 X_NUC_35.L_CORE X_NUC_74.L_CORE 0.003310
K_4205 X_NUC_35.L_CORE X_NUC_75.L_CORE 0.003260
K_4206 X_NUC_35.L_CORE X_NUC_76.L_CORE 0.003295
K_4207 X_NUC_35.L_CORE X_NUC_77.L_CORE 0.003022
K_4208 X_NUC_35.L_CORE X_NUC_78.L_CORE 0.002987
K_4209 X_NUC_35.L_CORE X_NUC_79.L_CORE 0.002984
K_4210 X_NUC_35.L_CORE X_NUC_80.L_CORE 0.002990
K_4211 X_NUC_35.L_CORE X_NUC_81.L_CORE 0.002062
K_4212 X_NUC_35.L_CORE X_NUC_82.L_CORE 0.002059
K_4213 X_NUC_35.L_CORE X_NUC_83.L_CORE 0.002045
K_4214 X_NUC_35.L_CORE X_NUC_84.L_CORE 0.002063
K_4215 X_NUC_35.L_CORE X_NUC_85.L_CORE 0.004393
K_4216 X_NUC_35.L_CORE X_NUC_86.L_CORE 0.004408
K_4217 X_NUC_35.L_CORE X_NUC_87.L_CORE 0.004331
K_4218 X_NUC_35.L_CORE X_NUC_88.L_CORE 0.004343
K_4219 X_NUC_35.L_CORE X_NUC_89.L_CORE 0.002200
K_4220 X_NUC_35.L_CORE X_NUC_90.L_CORE 0.002185
K_4221 X_NUC_35.L_CORE X_NUC_91.L_CORE 0.002178
K_4222 X_NUC_35.L_CORE X_NUC_92.L_CORE 0.002190
K_4223 X_NUC_35.L_CORE X_NUC_93.L_CORE 0.002441
K_4224 X_NUC_35.L_CORE X_NUC_94.L_CORE 0.002446
K_4225 X_NUC_35.L_CORE X_NUC_95.L_CORE 0.002420
K_4226 X_NUC_35.L_CORE X_NUC_96.L_CORE 0.002442
K_4227 X_NUC_35.L_CORE X_NUC_97.L_CORE 0.003224
K_4228 X_NUC_35.L_CORE X_NUC_98.L_CORE 0.003201
K_4229 X_NUC_35.L_CORE X_NUC_99.L_CORE 0.003180
K_4230 X_NUC_35.L_CORE X_NUC_100.L_CORE 0.003184
K_4231 X_NUC_35.L_CORE X_NUC_101.L_CORE 0.002055
K_4232 X_NUC_35.L_CORE X_NUC_102.L_CORE 0.002048
K_4233 X_NUC_35.L_CORE X_NUC_103.L_CORE 0.002035
K_4234 X_NUC_35.L_CORE X_NUC_104.L_CORE 0.002050
K_4235 X_NUC_35.L_CORE X_NUC_105.L_CORE 0.002870
K_4236 X_NUC_35.L_CORE X_NUC_106.L_CORE 0.002874
K_4237 X_NUC_35.L_CORE X_NUC_107.L_CORE 0.002839
K_4238 X_NUC_35.L_CORE X_NUC_108.L_CORE 0.002856
K_4239 X_NUC_35.L_CORE X_NUC_109.L_CORE 0.002412
K_4240 X_NUC_35.L_CORE X_NUC_110.L_CORE 0.002398
K_4241 X_NUC_35.L_CORE X_NUC_111.L_CORE 0.002384
K_4242 X_NUC_35.L_CORE X_NUC_112.L_CORE 0.002395
K_4243 X_NUC_35.L_CORE X_NUC_113.L_CORE 0.002279
K_4244 X_NUC_35.L_CORE X_NUC_114.L_CORE 0.002276
K_4245 X_NUC_35.L_CORE X_NUC_115.L_CORE 0.002256
K_4246 X_NUC_35.L_CORE X_NUC_116.L_CORE 0.002271
K_4247 X_NUC_35.L_CORE X_NUC_117.L_CORE 0.004394
K_4248 X_NUC_35.L_CORE X_NUC_118.L_CORE 0.002889
K_4249 X_NUC_35.L_CORE X_NUC_119.L_CORE 0.002939
K_4250 X_NUC_35.L_CORE X_NUC_120.L_CORE 0.006375
K_4251 X_NUC_35.L_CORE X_NUC_121.L_CORE 0.002214
K_4252 X_NUC_35.L_CORE X_NUC_122.L_CORE 0.004745
K_4253 X_NUC_35.L_CORE X_NUC_123.L_CORE 0.003076
K_4254 X_NUC_35.L_CORE X_NUC_124.L_CORE 0.002197
K_4255 X_NUC_35.L_CORE X_NUC_125.L_CORE 0.021038
K_4256 X_NUC_35.L_CORE X_NUC_126.L_CORE 0.002121
K_4257 X_NUC_35.L_CORE X_NUC_127.L_CORE 0.002855
K_4258 X_NUC_35.L_CORE X_NUC_128.L_CORE 0.004023
K_4259 X_NUC_35.L_CORE X_NUC_129.L_CORE 0.001925
K_4260 X_NUC_35.L_CORE X_NUC_130.L_CORE 0.004919
K_4261 X_NUC_35.L_CORE X_NUC_131.L_CORE 0.002314
K_4262 X_NUC_35.L_CORE X_NUC_132.L_CORE 0.002160
K_4263 X_NUC_35.L_CORE X_NUC_133.L_CORE 0.004387
K_4264 X_NUC_35.L_CORE X_NUC_134.L_CORE 0.001912
K_4265 X_NUC_35.L_CORE X_NUC_135.L_CORE 0.002808
K_4266 X_NUC_35.L_CORE X_NUC_136.L_CORE 0.002597
K_4267 X_NUC_35.L_CORE X_NUC_137.L_CORE 0.001959
K_4268 X_NUC_35.L_CORE X_NUC_138.L_CORE 0.003003
K_4269 X_NUC_35.L_CORE X_NUC_139.L_CORE 0.002094
K_4270 X_NUC_35.L_CORE X_NUC_140.L_CORE 0.002228
K_4271 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.002305
K_4272 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.002287
K_4273 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.002287
K_4274 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.002304
K_4275 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.003097
K_4276 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.003116
K_4277 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.003082
K_4278 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.003124
K_4279 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.004675
K_4280 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.004574
K_4281 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.004609
K_4282 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.004605
K_4283 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.002073
K_4284 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.002066
K_4285 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.002058
K_4286 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.002077
K_4287 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.006165
K_4288 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.006299
K_4289 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.006121
K_4290 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.006205
K_4291 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.002540
K_4292 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.002513
K_4293 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.002515
K_4294 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.002528
K_4295 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.002327
K_4296 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.002331
K_4297 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.002312
K_4298 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.002336
K_4299 X_NUC_36.L_CORE X_NUC_65.L_CORE 0.006309
K_4300 X_NUC_36.L_CORE X_NUC_66.L_CORE 0.006220
K_4301 X_NUC_36.L_CORE X_NUC_67.L_CORE 0.006174
K_4302 X_NUC_36.L_CORE X_NUC_68.L_CORE 0.006131
K_4303 X_NUC_36.L_CORE X_NUC_69.L_CORE 0.002037
K_4304 X_NUC_36.L_CORE X_NUC_70.L_CORE 0.002025
K_4305 X_NUC_36.L_CORE X_NUC_71.L_CORE 0.002019
K_4306 X_NUC_36.L_CORE X_NUC_72.L_CORE 0.002034
K_4307 X_NUC_36.L_CORE X_NUC_73.L_CORE 0.003251
K_4308 X_NUC_36.L_CORE X_NUC_74.L_CORE 0.003275
K_4309 X_NUC_36.L_CORE X_NUC_75.L_CORE 0.003226
K_4310 X_NUC_36.L_CORE X_NUC_76.L_CORE 0.003260
K_4311 X_NUC_36.L_CORE X_NUC_77.L_CORE 0.003016
K_4312 X_NUC_36.L_CORE X_NUC_78.L_CORE 0.002981
K_4313 X_NUC_36.L_CORE X_NUC_79.L_CORE 0.002978
K_4314 X_NUC_36.L_CORE X_NUC_80.L_CORE 0.002984
K_4315 X_NUC_36.L_CORE X_NUC_81.L_CORE 0.002044
K_4316 X_NUC_36.L_CORE X_NUC_82.L_CORE 0.002041
K_4317 X_NUC_36.L_CORE X_NUC_83.L_CORE 0.002027
K_4318 X_NUC_36.L_CORE X_NUC_84.L_CORE 0.002045
K_4319 X_NUC_36.L_CORE X_NUC_85.L_CORE 0.004380
K_4320 X_NUC_36.L_CORE X_NUC_86.L_CORE 0.004395
K_4321 X_NUC_36.L_CORE X_NUC_87.L_CORE 0.004317
K_4322 X_NUC_36.L_CORE X_NUC_88.L_CORE 0.004331
K_4323 X_NUC_36.L_CORE X_NUC_89.L_CORE 0.002188
K_4324 X_NUC_36.L_CORE X_NUC_90.L_CORE 0.002173
K_4325 X_NUC_36.L_CORE X_NUC_91.L_CORE 0.002166
K_4326 X_NUC_36.L_CORE X_NUC_92.L_CORE 0.002178
K_4327 X_NUC_36.L_CORE X_NUC_93.L_CORE 0.002419
K_4328 X_NUC_36.L_CORE X_NUC_94.L_CORE 0.002424
K_4329 X_NUC_36.L_CORE X_NUC_95.L_CORE 0.002399
K_4330 X_NUC_36.L_CORE X_NUC_96.L_CORE 0.002420
K_4331 X_NUC_36.L_CORE X_NUC_97.L_CORE 0.003219
K_4332 X_NUC_36.L_CORE X_NUC_98.L_CORE 0.003196
K_4333 X_NUC_36.L_CORE X_NUC_99.L_CORE 0.003174
K_4334 X_NUC_36.L_CORE X_NUC_100.L_CORE 0.003180
K_4335 X_NUC_36.L_CORE X_NUC_101.L_CORE 0.002040
K_4336 X_NUC_36.L_CORE X_NUC_102.L_CORE 0.002033
K_4337 X_NUC_36.L_CORE X_NUC_103.L_CORE 0.002021
K_4338 X_NUC_36.L_CORE X_NUC_104.L_CORE 0.002035
K_4339 X_NUC_36.L_CORE X_NUC_105.L_CORE 0.002852
K_4340 X_NUC_36.L_CORE X_NUC_106.L_CORE 0.002856
K_4341 X_NUC_36.L_CORE X_NUC_107.L_CORE 0.002821
K_4342 X_NUC_36.L_CORE X_NUC_108.L_CORE 0.002839
K_4343 X_NUC_36.L_CORE X_NUC_109.L_CORE 0.002400
K_4344 X_NUC_36.L_CORE X_NUC_110.L_CORE 0.002387
K_4345 X_NUC_36.L_CORE X_NUC_111.L_CORE 0.002373
K_4346 X_NUC_36.L_CORE X_NUC_112.L_CORE 0.002384
K_4347 X_NUC_36.L_CORE X_NUC_113.L_CORE 0.002264
K_4348 X_NUC_36.L_CORE X_NUC_114.L_CORE 0.002261
K_4349 X_NUC_36.L_CORE X_NUC_115.L_CORE 0.002242
K_4350 X_NUC_36.L_CORE X_NUC_116.L_CORE 0.002256
K_4351 X_NUC_36.L_CORE X_NUC_117.L_CORE 0.004334
K_4352 X_NUC_36.L_CORE X_NUC_118.L_CORE 0.002864
K_4353 X_NUC_36.L_CORE X_NUC_119.L_CORE 0.002900
K_4354 X_NUC_36.L_CORE X_NUC_120.L_CORE 0.006362
K_4355 X_NUC_36.L_CORE X_NUC_121.L_CORE 0.002194
K_4356 X_NUC_36.L_CORE X_NUC_122.L_CORE 0.004667
K_4357 X_NUC_36.L_CORE X_NUC_123.L_CORE 0.003065
K_4358 X_NUC_36.L_CORE X_NUC_124.L_CORE 0.002175
K_4359 X_NUC_36.L_CORE X_NUC_125.L_CORE 0.022924
K_4360 X_NUC_36.L_CORE X_NUC_126.L_CORE 0.002107
K_4361 X_NUC_36.L_CORE X_NUC_127.L_CORE 0.002822
K_4362 X_NUC_36.L_CORE X_NUC_128.L_CORE 0.004036
K_4363 X_NUC_36.L_CORE X_NUC_129.L_CORE 0.001909
K_4364 X_NUC_36.L_CORE X_NUC_130.L_CORE 0.004887
K_4365 X_NUC_36.L_CORE X_NUC_131.L_CORE 0.002305
K_4366 X_NUC_36.L_CORE X_NUC_132.L_CORE 0.002139
K_4367 X_NUC_36.L_CORE X_NUC_133.L_CORE 0.004409
K_4368 X_NUC_36.L_CORE X_NUC_134.L_CORE 0.001900
K_4369 X_NUC_36.L_CORE X_NUC_135.L_CORE 0.002786
K_4370 X_NUC_36.L_CORE X_NUC_136.L_CORE 0.002592
K_4371 X_NUC_36.L_CORE X_NUC_137.L_CORE 0.001945
K_4372 X_NUC_36.L_CORE X_NUC_138.L_CORE 0.002994
K_4373 X_NUC_36.L_CORE X_NUC_139.L_CORE 0.002084
K_4374 X_NUC_36.L_CORE X_NUC_140.L_CORE 0.002214
K_4375 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_4376 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_4377 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_4378 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.002243
K_4379 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.002267
K_4380 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.002254
K_4381 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.002254
K_4382 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.003051
K_4383 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.003065
K_4384 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.003076
K_4385 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.003034
K_4386 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.004519
K_4387 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.004588
K_4388 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.004503
K_4389 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.004570
K_4390 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.002040
K_4391 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.002057
K_4392 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.002051
K_4393 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.002042
K_4394 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.006162
K_4395 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.006126
K_4396 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.006149
K_4397 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.006005
K_4398 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.002497
K_4399 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.002525
K_4400 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.002501
K_4401 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.002509
K_4402 X_NUC_37.L_CORE X_NUC_65.L_CORE 0.002313
K_4403 X_NUC_37.L_CORE X_NUC_66.L_CORE 0.002327
K_4404 X_NUC_37.L_CORE X_NUC_67.L_CORE 0.002325
K_4405 X_NUC_37.L_CORE X_NUC_68.L_CORE 0.002305
K_4406 X_NUC_37.L_CORE X_NUC_69.L_CORE 0.006152
K_4407 X_NUC_37.L_CORE X_NUC_70.L_CORE 0.006191
K_4408 X_NUC_37.L_CORE X_NUC_71.L_CORE 0.006022
K_4409 X_NUC_37.L_CORE X_NUC_72.L_CORE 0.006103
K_4410 X_NUC_37.L_CORE X_NUC_73.L_CORE 0.002023
K_4411 X_NUC_37.L_CORE X_NUC_74.L_CORE 0.002042
K_4412 X_NUC_37.L_CORE X_NUC_75.L_CORE 0.002030
K_4413 X_NUC_37.L_CORE X_NUC_76.L_CORE 0.002026
K_4414 X_NUC_37.L_CORE X_NUC_77.L_CORE 0.003255
K_4415 X_NUC_37.L_CORE X_NUC_78.L_CORE 0.003262
K_4416 X_NUC_37.L_CORE X_NUC_79.L_CORE 0.003259
K_4417 X_NUC_37.L_CORE X_NUC_80.L_CORE 0.003218
K_4418 X_NUC_37.L_CORE X_NUC_81.L_CORE 0.002984
K_4419 X_NUC_37.L_CORE X_NUC_82.L_CORE 0.003015
K_4420 X_NUC_37.L_CORE X_NUC_83.L_CORE 0.002973
K_4421 X_NUC_37.L_CORE X_NUC_84.L_CORE 0.002991
K_4422 X_NUC_37.L_CORE X_NUC_85.L_CORE 0.002051
K_4423 X_NUC_37.L_CORE X_NUC_86.L_CORE 0.002066
K_4424 X_NUC_37.L_CORE X_NUC_87.L_CORE 0.002058
K_4425 X_NUC_37.L_CORE X_NUC_88.L_CORE 0.002047
K_4426 X_NUC_37.L_CORE X_NUC_89.L_CORE 0.004308
K_4427 X_NUC_37.L_CORE X_NUC_90.L_CORE 0.004311
K_4428 X_NUC_37.L_CORE X_NUC_91.L_CORE 0.004259
K_4429 X_NUC_37.L_CORE X_NUC_92.L_CORE 0.004239
K_4430 X_NUC_37.L_CORE X_NUC_93.L_CORE 0.002196
K_4431 X_NUC_37.L_CORE X_NUC_94.L_CORE 0.002216
K_4432 X_NUC_37.L_CORE X_NUC_95.L_CORE 0.002197
K_4433 X_NUC_37.L_CORE X_NUC_96.L_CORE 0.002198
K_4434 X_NUC_37.L_CORE X_NUC_97.L_CORE 0.002441
K_4435 X_NUC_37.L_CORE X_NUC_98.L_CORE 0.002453
K_4436 X_NUC_37.L_CORE X_NUC_99.L_CORE 0.002444
K_4437 X_NUC_37.L_CORE X_NUC_100.L_CORE 0.002425
K_4438 X_NUC_37.L_CORE X_NUC_101.L_CORE 0.003154
K_4439 X_NUC_37.L_CORE X_NUC_102.L_CORE 0.003176
K_4440 X_NUC_37.L_CORE X_NUC_103.L_CORE 0.003131
K_4441 X_NUC_37.L_CORE X_NUC_104.L_CORE 0.003139
K_4442 X_NUC_37.L_CORE X_NUC_105.L_CORE 0.002088
K_4443 X_NUC_37.L_CORE X_NUC_106.L_CORE 0.002103
K_4444 X_NUC_37.L_CORE X_NUC_107.L_CORE 0.002089
K_4445 X_NUC_37.L_CORE X_NUC_108.L_CORE 0.002083
K_4446 X_NUC_37.L_CORE X_NUC_109.L_CORE 0.002790
K_4447 X_NUC_37.L_CORE X_NUC_110.L_CORE 0.002802
K_4448 X_NUC_37.L_CORE X_NUC_111.L_CORE 0.002780
K_4449 X_NUC_37.L_CORE X_NUC_112.L_CORE 0.002766
K_4450 X_NUC_37.L_CORE X_NUC_113.L_CORE 0.002424
K_4451 X_NUC_37.L_CORE X_NUC_114.L_CORE 0.002441
K_4452 X_NUC_37.L_CORE X_NUC_115.L_CORE 0.002417
K_4453 X_NUC_37.L_CORE X_NUC_116.L_CORE 0.002415
K_4454 X_NUC_37.L_CORE X_NUC_117.L_CORE 0.002781
K_4455 X_NUC_37.L_CORE X_NUC_118.L_CORE 0.005093
K_4456 X_NUC_37.L_CORE X_NUC_119.L_CORE 0.002677
K_4457 X_NUC_37.L_CORE X_NUC_120.L_CORE 0.002759
K_4458 X_NUC_37.L_CORE X_NUC_121.L_CORE 0.006482
K_4459 X_NUC_37.L_CORE X_NUC_122.L_CORE 0.002111
K_4460 X_NUC_37.L_CORE X_NUC_123.L_CORE 0.004551
K_4461 X_NUC_37.L_CORE X_NUC_124.L_CORE 0.002984
K_4462 X_NUC_37.L_CORE X_NUC_125.L_CORE 0.002127
K_4463 X_NUC_37.L_CORE X_NUC_126.L_CORE 0.019426
K_4464 X_NUC_37.L_CORE X_NUC_127.L_CORE 0.002075
K_4465 X_NUC_37.L_CORE X_NUC_128.L_CORE 0.002783
K_4466 X_NUC_37.L_CORE X_NUC_129.L_CORE 0.003965
K_4467 X_NUC_37.L_CORE X_NUC_130.L_CORE 0.001898
K_4468 X_NUC_37.L_CORE X_NUC_131.L_CORE 0.004773
K_4469 X_NUC_37.L_CORE X_NUC_132.L_CORE 0.002300
K_4470 X_NUC_37.L_CORE X_NUC_133.L_CORE 0.002143
K_4471 X_NUC_37.L_CORE X_NUC_134.L_CORE 0.004276
K_4472 X_NUC_37.L_CORE X_NUC_135.L_CORE 0.001919
K_4473 X_NUC_37.L_CORE X_NUC_136.L_CORE 0.002773
K_4474 X_NUC_37.L_CORE X_NUC_137.L_CORE 0.002588
K_4475 X_NUC_37.L_CORE X_NUC_138.L_CORE 0.001993
K_4476 X_NUC_37.L_CORE X_NUC_139.L_CORE 0.002846
K_4477 X_NUC_37.L_CORE X_NUC_140.L_CORE 0.002174
K_4478 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_4479 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_4480 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.002219
K_4481 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.002243
K_4482 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.002230
K_4483 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.002230
K_4484 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.003037
K_4485 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.003051
K_4486 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.003062
K_4487 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.003020
K_4488 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.004451
K_4489 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.004519
K_4490 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.004436
K_4491 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.004501
K_4492 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.002022
K_4493 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.002040
K_4494 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.002034
K_4495 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.002025
K_4496 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.006193
K_4497 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.006162
K_4498 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.006183
K_4499 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.006036
K_4500 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.002469
K_4501 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.002497
K_4502 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.002474
K_4503 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.002482
K_4504 X_NUC_38.L_CORE X_NUC_65.L_CORE 0.002299
K_4505 X_NUC_38.L_CORE X_NUC_66.L_CORE 0.002313
K_4506 X_NUC_38.L_CORE X_NUC_67.L_CORE 0.002311
K_4507 X_NUC_38.L_CORE X_NUC_68.L_CORE 0.002291
K_4508 X_NUC_38.L_CORE X_NUC_69.L_CORE 0.006108
K_4509 X_NUC_38.L_CORE X_NUC_70.L_CORE 0.006152
K_4510 X_NUC_38.L_CORE X_NUC_71.L_CORE 0.005983
K_4511 X_NUC_38.L_CORE X_NUC_72.L_CORE 0.006063
K_4512 X_NUC_38.L_CORE X_NUC_73.L_CORE 0.002005
K_4513 X_NUC_38.L_CORE X_NUC_74.L_CORE 0.002023
K_4514 X_NUC_38.L_CORE X_NUC_75.L_CORE 0.002012
K_4515 X_NUC_38.L_CORE X_NUC_76.L_CORE 0.002008
K_4516 X_NUC_38.L_CORE X_NUC_77.L_CORE 0.003247
K_4517 X_NUC_38.L_CORE X_NUC_78.L_CORE 0.003255
K_4518 X_NUC_38.L_CORE X_NUC_79.L_CORE 0.003251
K_4519 X_NUC_38.L_CORE X_NUC_80.L_CORE 0.003211
K_4520 X_NUC_38.L_CORE X_NUC_81.L_CORE 0.002954
K_4521 X_NUC_38.L_CORE X_NUC_82.L_CORE 0.002984
K_4522 X_NUC_38.L_CORE X_NUC_83.L_CORE 0.002943
K_4523 X_NUC_38.L_CORE X_NUC_84.L_CORE 0.002960
K_4524 X_NUC_38.L_CORE X_NUC_85.L_CORE 0.002036
K_4525 X_NUC_38.L_CORE X_NUC_86.L_CORE 0.002051
K_4526 X_NUC_38.L_CORE X_NUC_87.L_CORE 0.002043
K_4527 X_NUC_38.L_CORE X_NUC_88.L_CORE 0.002032
K_4528 X_NUC_38.L_CORE X_NUC_89.L_CORE 0.004302
K_4529 X_NUC_38.L_CORE X_NUC_90.L_CORE 0.004308
K_4530 X_NUC_38.L_CORE X_NUC_91.L_CORE 0.004255
K_4531 X_NUC_38.L_CORE X_NUC_92.L_CORE 0.004235
K_4532 X_NUC_38.L_CORE X_NUC_93.L_CORE 0.002177
K_4533 X_NUC_38.L_CORE X_NUC_94.L_CORE 0.002196
K_4534 X_NUC_38.L_CORE X_NUC_95.L_CORE 0.002178
K_4535 X_NUC_38.L_CORE X_NUC_96.L_CORE 0.002178
K_4536 X_NUC_38.L_CORE X_NUC_97.L_CORE 0.002429
K_4537 X_NUC_38.L_CORE X_NUC_98.L_CORE 0.002441
K_4538 X_NUC_38.L_CORE X_NUC_99.L_CORE 0.002432
K_4539 X_NUC_38.L_CORE X_NUC_100.L_CORE 0.002414
K_4540 X_NUC_38.L_CORE X_NUC_101.L_CORE 0.003132
K_4541 X_NUC_38.L_CORE X_NUC_102.L_CORE 0.003154
K_4542 X_NUC_38.L_CORE X_NUC_103.L_CORE 0.003110
K_4543 X_NUC_38.L_CORE X_NUC_104.L_CORE 0.003118
K_4544 X_NUC_38.L_CORE X_NUC_105.L_CORE 0.002073
K_4545 X_NUC_38.L_CORE X_NUC_106.L_CORE 0.002088
K_4546 X_NUC_38.L_CORE X_NUC_107.L_CORE 0.002074
K_4547 X_NUC_38.L_CORE X_NUC_108.L_CORE 0.002068
K_4548 X_NUC_38.L_CORE X_NUC_109.L_CORE 0.002778
K_4549 X_NUC_38.L_CORE X_NUC_110.L_CORE 0.002790
K_4550 X_NUC_38.L_CORE X_NUC_111.L_CORE 0.002768
K_4551 X_NUC_38.L_CORE X_NUC_112.L_CORE 0.002755
K_4552 X_NUC_38.L_CORE X_NUC_113.L_CORE 0.002407
K_4553 X_NUC_38.L_CORE X_NUC_114.L_CORE 0.002424
K_4554 X_NUC_38.L_CORE X_NUC_115.L_CORE 0.002401
K_4555 X_NUC_38.L_CORE X_NUC_116.L_CORE 0.002399
K_4556 X_NUC_38.L_CORE X_NUC_117.L_CORE 0.002753
K_4557 X_NUC_38.L_CORE X_NUC_118.L_CORE 0.005042
K_4558 X_NUC_38.L_CORE X_NUC_119.L_CORE 0.002645
K_4559 X_NUC_38.L_CORE X_NUC_120.L_CORE 0.002740
K_4560 X_NUC_38.L_CORE X_NUC_121.L_CORE 0.006365
K_4561 X_NUC_38.L_CORE X_NUC_122.L_CORE 0.002091
K_4562 X_NUC_38.L_CORE X_NUC_123.L_CORE 0.004551
K_4563 X_NUC_38.L_CORE X_NUC_124.L_CORE 0.002947
K_4564 X_NUC_38.L_CORE X_NUC_125.L_CORE 0.002112
K_4565 X_NUC_38.L_CORE X_NUC_126.L_CORE 0.020869
K_4566 X_NUC_38.L_CORE X_NUC_127.L_CORE 0.002055
K_4567 X_NUC_38.L_CORE X_NUC_128.L_CORE 0.002774
K_4568 X_NUC_38.L_CORE X_NUC_129.L_CORE 0.003923
K_4569 X_NUC_38.L_CORE X_NUC_130.L_CORE 0.001883
K_4570 X_NUC_38.L_CORE X_NUC_131.L_CORE 0.004801
K_4571 X_NUC_38.L_CORE X_NUC_132.L_CORE 0.002278
K_4572 X_NUC_38.L_CORE X_NUC_133.L_CORE 0.002132
K_4573 X_NUC_38.L_CORE X_NUC_134.L_CORE 0.004264
K_4574 X_NUC_38.L_CORE X_NUC_135.L_CORE 0.001903
K_4575 X_NUC_38.L_CORE X_NUC_136.L_CORE 0.002767
K_4576 X_NUC_38.L_CORE X_NUC_137.L_CORE 0.002568
K_4577 X_NUC_38.L_CORE X_NUC_138.L_CORE 0.001981
K_4578 X_NUC_38.L_CORE X_NUC_139.L_CORE 0.002836
K_4579 X_NUC_38.L_CORE X_NUC_140.L_CORE 0.002160
K_4580 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_4581 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.002231
K_4582 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.002255
K_4583 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.002243
K_4584 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.002242
K_4585 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.003026
K_4586 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.003040
K_4587 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.003051
K_4588 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.003010
K_4589 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.004534
K_4590 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.004604
K_4591 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.004519
K_4592 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.004586
K_4593 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.002028
K_4594 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.002046
K_4595 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.002040
K_4596 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.002031
K_4597 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.006170
K_4598 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.006137
K_4599 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.006162
K_4600 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.006015
K_4601 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.002492
K_4602 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.002521
K_4603 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.002497
K_4604 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.002505
K_4605 X_NUC_39.L_CORE X_NUC_65.L_CORE 0.002301
K_4606 X_NUC_39.L_CORE X_NUC_66.L_CORE 0.002315
K_4607 X_NUC_39.L_CORE X_NUC_67.L_CORE 0.002313
K_4608 X_NUC_39.L_CORE X_NUC_68.L_CORE 0.002293
K_4609 X_NUC_39.L_CORE X_NUC_69.L_CORE 0.006285
K_4610 X_NUC_39.L_CORE X_NUC_70.L_CORE 0.006330
K_4611 X_NUC_39.L_CORE X_NUC_71.L_CORE 0.006152
K_4612 X_NUC_39.L_CORE X_NUC_72.L_CORE 0.006236
K_4613 X_NUC_39.L_CORE X_NUC_73.L_CORE 0.002017
K_4614 X_NUC_39.L_CORE X_NUC_74.L_CORE 0.002035
K_4615 X_NUC_39.L_CORE X_NUC_75.L_CORE 0.002023
K_4616 X_NUC_39.L_CORE X_NUC_76.L_CORE 0.002020
K_4617 X_NUC_39.L_CORE X_NUC_77.L_CORE 0.003251
K_4618 X_NUC_39.L_CORE X_NUC_78.L_CORE 0.003258
K_4619 X_NUC_39.L_CORE X_NUC_79.L_CORE 0.003255
K_4620 X_NUC_39.L_CORE X_NUC_80.L_CORE 0.003214
K_4621 X_NUC_39.L_CORE X_NUC_81.L_CORE 0.002995
K_4622 X_NUC_39.L_CORE X_NUC_82.L_CORE 0.003026
K_4623 X_NUC_39.L_CORE X_NUC_83.L_CORE 0.002984
K_4624 X_NUC_39.L_CORE X_NUC_84.L_CORE 0.003002
K_4625 X_NUC_39.L_CORE X_NUC_85.L_CORE 0.002044
K_4626 X_NUC_39.L_CORE X_NUC_86.L_CORE 0.002059
K_4627 X_NUC_39.L_CORE X_NUC_87.L_CORE 0.002051
K_4628 X_NUC_39.L_CORE X_NUC_88.L_CORE 0.002040
K_4629 X_NUC_39.L_CORE X_NUC_89.L_CORE 0.004356
K_4630 X_NUC_39.L_CORE X_NUC_90.L_CORE 0.004361
K_4631 X_NUC_39.L_CORE X_NUC_91.L_CORE 0.004308
K_4632 X_NUC_39.L_CORE X_NUC_92.L_CORE 0.004286
K_4633 X_NUC_39.L_CORE X_NUC_93.L_CORE 0.002196
K_4634 X_NUC_39.L_CORE X_NUC_94.L_CORE 0.002215
K_4635 X_NUC_39.L_CORE X_NUC_95.L_CORE 0.002196
K_4636 X_NUC_39.L_CORE X_NUC_96.L_CORE 0.002197
K_4637 X_NUC_39.L_CORE X_NUC_97.L_CORE 0.002439
K_4638 X_NUC_39.L_CORE X_NUC_98.L_CORE 0.002451
K_4639 X_NUC_39.L_CORE X_NUC_99.L_CORE 0.002441
K_4640 X_NUC_39.L_CORE X_NUC_100.L_CORE 0.002423
K_4641 X_NUC_39.L_CORE X_NUC_101.L_CORE 0.003177
K_4642 X_NUC_39.L_CORE X_NUC_102.L_CORE 0.003199
K_4643 X_NUC_39.L_CORE X_NUC_103.L_CORE 0.003154
K_4644 X_NUC_39.L_CORE X_NUC_104.L_CORE 0.003162
K_4645 X_NUC_39.L_CORE X_NUC_105.L_CORE 0.002086
K_4646 X_NUC_39.L_CORE X_NUC_106.L_CORE 0.002102
K_4647 X_NUC_39.L_CORE X_NUC_107.L_CORE 0.002088
K_4648 X_NUC_39.L_CORE X_NUC_108.L_CORE 0.002082
K_4649 X_NUC_39.L_CORE X_NUC_109.L_CORE 0.002800
K_4650 X_NUC_39.L_CORE X_NUC_110.L_CORE 0.002813
K_4651 X_NUC_39.L_CORE X_NUC_111.L_CORE 0.002790
K_4652 X_NUC_39.L_CORE X_NUC_112.L_CORE 0.002776
K_4653 X_NUC_39.L_CORE X_NUC_113.L_CORE 0.002430
K_4654 X_NUC_39.L_CORE X_NUC_114.L_CORE 0.002448
K_4655 X_NUC_39.L_CORE X_NUC_115.L_CORE 0.002424
K_4656 X_NUC_39.L_CORE X_NUC_116.L_CORE 0.002422
K_4657 X_NUC_39.L_CORE X_NUC_117.L_CORE 0.002747
K_4658 X_NUC_39.L_CORE X_NUC_118.L_CORE 0.004973
K_4659 X_NUC_39.L_CORE X_NUC_119.L_CORE 0.002653
K_4660 X_NUC_39.L_CORE X_NUC_120.L_CORE 0.002727
K_4661 X_NUC_39.L_CORE X_NUC_121.L_CORE 0.006399
K_4662 X_NUC_39.L_CORE X_NUC_122.L_CORE 0.002096
K_4663 X_NUC_39.L_CORE X_NUC_123.L_CORE 0.004490
K_4664 X_NUC_39.L_CORE X_NUC_124.L_CORE 0.002974
K_4665 X_NUC_39.L_CORE X_NUC_125.L_CORE 0.002112
K_4666 X_NUC_39.L_CORE X_NUC_126.L_CORE 0.021275
K_4667 X_NUC_39.L_CORE X_NUC_127.L_CORE 0.002067
K_4668 X_NUC_39.L_CORE X_NUC_128.L_CORE 0.002767
K_4669 X_NUC_39.L_CORE X_NUC_129.L_CORE 0.003992
K_4670 X_NUC_39.L_CORE X_NUC_130.L_CORE 0.001890
K_4671 X_NUC_39.L_CORE X_NUC_131.L_CORE 0.004805
K_4672 X_NUC_39.L_CORE X_NUC_132.L_CORE 0.002299
K_4673 X_NUC_39.L_CORE X_NUC_133.L_CORE 0.002135
K_4674 X_NUC_39.L_CORE X_NUC_134.L_CORE 0.004344
K_4675 X_NUC_39.L_CORE X_NUC_135.L_CORE 0.001915
K_4676 X_NUC_39.L_CORE X_NUC_136.L_CORE 0.002777
K_4677 X_NUC_39.L_CORE X_NUC_137.L_CORE 0.002600
K_4678 X_NUC_39.L_CORE X_NUC_138.L_CORE 0.001991
K_4679 X_NUC_39.L_CORE X_NUC_139.L_CORE 0.002864
K_4680 X_NUC_39.L_CORE X_NUC_140.L_CORE 0.002178
K_4681 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.002232
K_4682 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.002256
K_4683 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.002243
K_4684 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.002243
K_4685 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.003068
K_4686 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.003083
K_4687 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.003094
K_4688 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.003051
K_4689 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.004468
K_4690 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.004535
K_4691 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.004453
K_4692 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.004519
K_4693 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.002038
K_4694 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.002055
K_4695 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.002049
K_4696 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.002040
K_4697 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.006327
K_4698 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.006291
K_4699 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.006316
K_4700 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.006162
K_4701 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.002484
K_4702 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.002512
K_4703 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.002489
K_4704 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.002497
K_4705 X_NUC_40.L_CORE X_NUC_65.L_CORE 0.002321
K_4706 X_NUC_40.L_CORE X_NUC_66.L_CORE 0.002336
K_4707 X_NUC_40.L_CORE X_NUC_67.L_CORE 0.002334
K_4708 X_NUC_40.L_CORE X_NUC_68.L_CORE 0.002313
K_4709 X_NUC_40.L_CORE X_NUC_69.L_CORE 0.006196
K_4710 X_NUC_40.L_CORE X_NUC_70.L_CORE 0.006239
K_4711 X_NUC_40.L_CORE X_NUC_71.L_CORE 0.006066
K_4712 X_NUC_40.L_CORE X_NUC_72.L_CORE 0.006152
K_4713 X_NUC_40.L_CORE X_NUC_73.L_CORE 0.002020
K_4714 X_NUC_40.L_CORE X_NUC_74.L_CORE 0.002039
K_4715 X_NUC_40.L_CORE X_NUC_75.L_CORE 0.002027
K_4716 X_NUC_40.L_CORE X_NUC_76.L_CORE 0.002023
K_4717 X_NUC_40.L_CORE X_NUC_77.L_CORE 0.003293
K_4718 X_NUC_40.L_CORE X_NUC_78.L_CORE 0.003300
K_4719 X_NUC_40.L_CORE X_NUC_79.L_CORE 0.003297
K_4720 X_NUC_40.L_CORE X_NUC_80.L_CORE 0.003255
K_4721 X_NUC_40.L_CORE X_NUC_81.L_CORE 0.002977
K_4722 X_NUC_40.L_CORE X_NUC_82.L_CORE 0.003008
K_4723 X_NUC_40.L_CORE X_NUC_83.L_CORE 0.002966
K_4724 X_NUC_40.L_CORE X_NUC_84.L_CORE 0.002984
K_4725 X_NUC_40.L_CORE X_NUC_85.L_CORE 0.002055
K_4726 X_NUC_40.L_CORE X_NUC_86.L_CORE 0.002070
K_4727 X_NUC_40.L_CORE X_NUC_87.L_CORE 0.002062
K_4728 X_NUC_40.L_CORE X_NUC_88.L_CORE 0.002051
K_4729 X_NUC_40.L_CORE X_NUC_89.L_CORE 0.004378
K_4730 X_NUC_40.L_CORE X_NUC_90.L_CORE 0.004383
K_4731 X_NUC_40.L_CORE X_NUC_91.L_CORE 0.004328
K_4732 X_NUC_40.L_CORE X_NUC_92.L_CORE 0.004308
K_4733 X_NUC_40.L_CORE X_NUC_93.L_CORE 0.002195
K_4734 X_NUC_40.L_CORE X_NUC_94.L_CORE 0.002215
K_4735 X_NUC_40.L_CORE X_NUC_95.L_CORE 0.002196
K_4736 X_NUC_40.L_CORE X_NUC_96.L_CORE 0.002196
K_4737 X_NUC_40.L_CORE X_NUC_97.L_CORE 0.002458
K_4738 X_NUC_40.L_CORE X_NUC_98.L_CORE 0.002470
K_4739 X_NUC_40.L_CORE X_NUC_99.L_CORE 0.002460
K_4740 X_NUC_40.L_CORE X_NUC_100.L_CORE 0.002441
K_4741 X_NUC_40.L_CORE X_NUC_101.L_CORE 0.003169
K_4742 X_NUC_40.L_CORE X_NUC_102.L_CORE 0.003191
K_4743 X_NUC_40.L_CORE X_NUC_103.L_CORE 0.003145
K_4744 X_NUC_40.L_CORE X_NUC_104.L_CORE 0.003154
K_4745 X_NUC_40.L_CORE X_NUC_105.L_CORE 0.002092
K_4746 X_NUC_40.L_CORE X_NUC_106.L_CORE 0.002108
K_4747 X_NUC_40.L_CORE X_NUC_107.L_CORE 0.002094
K_4748 X_NUC_40.L_CORE X_NUC_108.L_CORE 0.002088
K_4749 X_NUC_40.L_CORE X_NUC_109.L_CORE 0.002814
K_4750 X_NUC_40.L_CORE X_NUC_110.L_CORE 0.002827
K_4751 X_NUC_40.L_CORE X_NUC_111.L_CORE 0.002804
K_4752 X_NUC_40.L_CORE X_NUC_112.L_CORE 0.002790
K_4753 X_NUC_40.L_CORE X_NUC_113.L_CORE 0.002433
K_4754 X_NUC_40.L_CORE X_NUC_114.L_CORE 0.002450
K_4755 X_NUC_40.L_CORE X_NUC_115.L_CORE 0.002426
K_4756 X_NUC_40.L_CORE X_NUC_116.L_CORE 0.002424
K_4757 X_NUC_40.L_CORE X_NUC_117.L_CORE 0.002762
K_4758 X_NUC_40.L_CORE X_NUC_118.L_CORE 0.005024
K_4759 X_NUC_40.L_CORE X_NUC_119.L_CORE 0.002651
K_4760 X_NUC_40.L_CORE X_NUC_120.L_CORE 0.002756
K_4761 X_NUC_40.L_CORE X_NUC_121.L_CORE 0.006289
K_4762 X_NUC_40.L_CORE X_NUC_122.L_CORE 0.002102
K_4763 X_NUC_40.L_CORE X_NUC_123.L_CORE 0.004587
K_4764 X_NUC_40.L_CORE X_NUC_124.L_CORE 0.002954
K_4765 X_NUC_40.L_CORE X_NUC_125.L_CORE 0.002127
K_4766 X_NUC_40.L_CORE X_NUC_126.L_CORE 0.020600
K_4767 X_NUC_40.L_CORE X_NUC_127.L_CORE 0.002066
K_4768 X_NUC_40.L_CORE X_NUC_128.L_CORE 0.002802
K_4769 X_NUC_40.L_CORE X_NUC_129.L_CORE 0.003938
K_4770 X_NUC_40.L_CORE X_NUC_130.L_CORE 0.001898
K_4771 X_NUC_40.L_CORE X_NUC_131.L_CORE 0.004880
K_4772 X_NUC_40.L_CORE X_NUC_132.L_CORE 0.002292
K_4773 X_NUC_40.L_CORE X_NUC_133.L_CORE 0.002152
K_4774 X_NUC_40.L_CORE X_NUC_134.L_CORE 0.004313
K_4775 X_NUC_40.L_CORE X_NUC_135.L_CORE 0.001918
K_4776 X_NUC_40.L_CORE X_NUC_136.L_CORE 0.002802
K_4777 X_NUC_40.L_CORE X_NUC_137.L_CORE 0.002590
K_4778 X_NUC_40.L_CORE X_NUC_138.L_CORE 0.002000
K_4779 X_NUC_40.L_CORE X_NUC_139.L_CORE 0.002871
K_4780 X_NUC_40.L_CORE X_NUC_140.L_CORE 0.002180
K_4781 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_4782 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_4783 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_4784 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.002197
K_4785 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.002180
K_4786 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.002195
K_4787 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.002180
K_4788 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.002998
K_4789 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.002961
K_4790 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.002966
K_4791 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.002986
K_4792 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.004457
K_4793 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.004450
K_4794 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.004484
K_4795 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.004392
K_4796 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.002014
K_4797 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.001996
K_4798 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.002006
K_4799 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.002001
K_4800 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.006134
K_4801 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.006051
K_4802 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.005965
K_4803 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.006087
K_4804 X_NUC_41.L_CORE X_NUC_65.L_CORE 0.002479
K_4805 X_NUC_41.L_CORE X_NUC_66.L_CORE 0.002464
K_4806 X_NUC_41.L_CORE X_NUC_67.L_CORE 0.002478
K_4807 X_NUC_41.L_CORE X_NUC_68.L_CORE 0.002454
K_4808 X_NUC_41.L_CORE X_NUC_69.L_CORE 0.002302
K_4809 X_NUC_41.L_CORE X_NUC_70.L_CORE 0.002278
K_4810 X_NUC_41.L_CORE X_NUC_71.L_CORE 0.002283
K_4811 X_NUC_41.L_CORE X_NUC_72.L_CORE 0.002287
K_4812 X_NUC_41.L_CORE X_NUC_73.L_CORE 0.006158
K_4813 X_NUC_41.L_CORE X_NUC_74.L_CORE 0.006172
K_4814 X_NUC_41.L_CORE X_NUC_75.L_CORE 0.006101
K_4815 X_NUC_41.L_CORE X_NUC_76.L_CORE 0.006012
K_4816 X_NUC_41.L_CORE X_NUC_77.L_CORE 0.002023
K_4817 X_NUC_41.L_CORE X_NUC_78.L_CORE 0.002008
K_4818 X_NUC_41.L_CORE X_NUC_79.L_CORE 0.002016
K_4819 X_NUC_41.L_CORE X_NUC_80.L_CORE 0.002006
K_4820 X_NUC_41.L_CORE X_NUC_81.L_CORE 0.003260
K_4821 X_NUC_41.L_CORE X_NUC_82.L_CORE 0.003226
K_4822 X_NUC_41.L_CORE X_NUC_83.L_CORE 0.003211
K_4823 X_NUC_41.L_CORE X_NUC_84.L_CORE 0.003234
K_4824 X_NUC_41.L_CORE X_NUC_85.L_CORE 0.002994
K_4825 X_NUC_41.L_CORE X_NUC_86.L_CORE 0.002981
K_4826 X_NUC_41.L_CORE X_NUC_87.L_CORE 0.002987
K_4827 X_NUC_41.L_CORE X_NUC_88.L_CORE 0.002954
K_4828 X_NUC_41.L_CORE X_NUC_89.L_CORE 0.002069
K_4829 X_NUC_41.L_CORE X_NUC_90.L_CORE 0.002050
K_4830 X_NUC_41.L_CORE X_NUC_91.L_CORE 0.002054
K_4831 X_NUC_41.L_CORE X_NUC_92.L_CORE 0.002052
K_4832 X_NUC_41.L_CORE X_NUC_93.L_CORE 0.004260
K_4833 X_NUC_41.L_CORE X_NUC_94.L_CORE 0.004237
K_4834 X_NUC_41.L_CORE X_NUC_95.L_CORE 0.004187
K_4835 X_NUC_41.L_CORE X_NUC_96.L_CORE 0.004195
K_4836 X_NUC_41.L_CORE X_NUC_97.L_CORE 0.002228
K_4837 X_NUC_41.L_CORE X_NUC_98.L_CORE 0.002214
K_4838 X_NUC_41.L_CORE X_NUC_99.L_CORE 0.002219
K_4839 X_NUC_41.L_CORE X_NUC_100.L_CORE 0.002205
K_4840 X_NUC_41.L_CORE X_NUC_101.L_CORE 0.002475
K_4841 X_NUC_41.L_CORE X_NUC_102.L_CORE 0.002453
K_4842 X_NUC_41.L_CORE X_NUC_103.L_CORE 0.002448
K_4843 X_NUC_41.L_CORE X_NUC_104.L_CORE 0.002453
K_4844 X_NUC_41.L_CORE X_NUC_105.L_CORE 0.003112
K_4845 X_NUC_41.L_CORE X_NUC_106.L_CORE 0.003098
K_4846 X_NUC_41.L_CORE X_NUC_107.L_CORE 0.003086
K_4847 X_NUC_41.L_CORE X_NUC_108.L_CORE 0.003068
K_4848 X_NUC_41.L_CORE X_NUC_109.L_CORE 0.002173
K_4849 X_NUC_41.L_CORE X_NUC_110.L_CORE 0.002157
K_4850 X_NUC_41.L_CORE X_NUC_111.L_CORE 0.002158
K_4851 X_NUC_41.L_CORE X_NUC_112.L_CORE 0.002152
K_4852 X_NUC_41.L_CORE X_NUC_113.L_CORE 0.002693
K_4853 X_NUC_41.L_CORE X_NUC_114.L_CORE 0.002674
K_4854 X_NUC_41.L_CORE X_NUC_115.L_CORE 0.002664
K_4855 X_NUC_41.L_CORE X_NUC_116.L_CORE 0.002662
K_4856 X_NUC_41.L_CORE X_NUC_117.L_CORE 0.003352
K_4857 X_NUC_41.L_CORE X_NUC_118.L_CORE 0.002419
K_4858 X_NUC_41.L_CORE X_NUC_119.L_CORE 0.005460
K_4859 X_NUC_41.L_CORE X_NUC_120.L_CORE 0.002497
K_4860 X_NUC_41.L_CORE X_NUC_121.L_CORE 0.002604
K_4861 X_NUC_41.L_CORE X_NUC_122.L_CORE 0.006374
K_4862 X_NUC_41.L_CORE X_NUC_123.L_CORE 0.002015
K_4863 X_NUC_41.L_CORE X_NUC_124.L_CORE 0.004391
K_4864 X_NUC_41.L_CORE X_NUC_125.L_CORE 0.002879
K_4865 X_NUC_41.L_CORE X_NUC_126.L_CORE 0.002060
K_4866 X_NUC_41.L_CORE X_NUC_127.L_CORE 0.019716
K_4867 X_NUC_41.L_CORE X_NUC_128.L_CORE 0.002025
K_4868 X_NUC_41.L_CORE X_NUC_129.L_CORE 0.002728
K_4869 X_NUC_41.L_CORE X_NUC_130.L_CORE 0.003899
K_4870 X_NUC_41.L_CORE X_NUC_131.L_CORE 0.001872
K_4871 X_NUC_41.L_CORE X_NUC_132.L_CORE 0.004712
K_4872 X_NUC_41.L_CORE X_NUC_133.L_CORE 0.002282
K_4873 X_NUC_41.L_CORE X_NUC_134.L_CORE 0.002135
K_4874 X_NUC_41.L_CORE X_NUC_135.L_CORE 0.004185
K_4875 X_NUC_41.L_CORE X_NUC_136.L_CORE 0.001929
K_4876 X_NUC_41.L_CORE X_NUC_137.L_CORE 0.002755
K_4877 X_NUC_41.L_CORE X_NUC_138.L_CORE 0.002577
K_4878 X_NUC_41.L_CORE X_NUC_139.L_CORE 0.002053
K_4879 X_NUC_41.L_CORE X_NUC_140.L_CORE 0.002632
K_4880 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_4881 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_4882 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.002215
K_4883 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.002197
K_4884 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.002213
K_4885 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.002197
K_4886 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.003036
K_4887 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.002998
K_4888 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.003003
K_4889 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.003024
K_4890 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.004463
K_4891 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.004457
K_4892 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.004491
K_4893 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.004399
K_4894 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.002033
K_4895 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.002014
K_4896 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.002024
K_4897 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.002019
K_4898 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.006215
K_4899 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.006134
K_4900 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.006042
K_4901 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.006169
K_4902 X_NUC_42.L_CORE X_NUC_65.L_CORE 0.002494
K_4903 X_NUC_42.L_CORE X_NUC_66.L_CORE 0.002479
K_4904 X_NUC_42.L_CORE X_NUC_67.L_CORE 0.002493
K_4905 X_NUC_42.L_CORE X_NUC_68.L_CORE 0.002469
K_4906 X_NUC_42.L_CORE X_NUC_69.L_CORE 0.002326
K_4907 X_NUC_42.L_CORE X_NUC_70.L_CORE 0.002302
K_4908 X_NUC_42.L_CORE X_NUC_71.L_CORE 0.002306
K_4909 X_NUC_42.L_CORE X_NUC_72.L_CORE 0.002311
K_4910 X_NUC_42.L_CORE X_NUC_73.L_CORE 0.006140
K_4911 X_NUC_42.L_CORE X_NUC_74.L_CORE 0.006158
K_4912 X_NUC_42.L_CORE X_NUC_75.L_CORE 0.006085
K_4913 X_NUC_42.L_CORE X_NUC_76.L_CORE 0.005997
K_4914 X_NUC_42.L_CORE X_NUC_77.L_CORE 0.002040
K_4915 X_NUC_42.L_CORE X_NUC_78.L_CORE 0.002023
K_4916 X_NUC_42.L_CORE X_NUC_79.L_CORE 0.002032
K_4917 X_NUC_42.L_CORE X_NUC_80.L_CORE 0.002022
K_4918 X_NUC_42.L_CORE X_NUC_81.L_CORE 0.003294
K_4919 X_NUC_42.L_CORE X_NUC_82.L_CORE 0.003260
K_4920 X_NUC_42.L_CORE X_NUC_83.L_CORE 0.003244
K_4921 X_NUC_42.L_CORE X_NUC_84.L_CORE 0.003268
K_4922 X_NUC_42.L_CORE X_NUC_85.L_CORE 0.003006
K_4923 X_NUC_42.L_CORE X_NUC_86.L_CORE 0.002994
K_4924 X_NUC_42.L_CORE X_NUC_87.L_CORE 0.002999
K_4925 X_NUC_42.L_CORE X_NUC_88.L_CORE 0.002966
K_4926 X_NUC_42.L_CORE X_NUC_89.L_CORE 0.002087
K_4927 X_NUC_42.L_CORE X_NUC_90.L_CORE 0.002069
K_4928 X_NUC_42.L_CORE X_NUC_91.L_CORE 0.002072
K_4929 X_NUC_42.L_CORE X_NUC_92.L_CORE 0.002071
K_4930 X_NUC_42.L_CORE X_NUC_93.L_CORE 0.004282
K_4931 X_NUC_42.L_CORE X_NUC_94.L_CORE 0.004260
K_4932 X_NUC_42.L_CORE X_NUC_95.L_CORE 0.004208
K_4933 X_NUC_42.L_CORE X_NUC_96.L_CORE 0.004216
K_4934 X_NUC_42.L_CORE X_NUC_97.L_CORE 0.002243
K_4935 X_NUC_42.L_CORE X_NUC_98.L_CORE 0.002228
K_4936 X_NUC_42.L_CORE X_NUC_99.L_CORE 0.002233
K_4937 X_NUC_42.L_CORE X_NUC_100.L_CORE 0.002220
K_4938 X_NUC_42.L_CORE X_NUC_101.L_CORE 0.002497
K_4939 X_NUC_42.L_CORE X_NUC_102.L_CORE 0.002475
K_4940 X_NUC_42.L_CORE X_NUC_103.L_CORE 0.002470
K_4941 X_NUC_42.L_CORE X_NUC_104.L_CORE 0.002474
K_4942 X_NUC_42.L_CORE X_NUC_105.L_CORE 0.003125
K_4943 X_NUC_42.L_CORE X_NUC_106.L_CORE 0.003112
K_4944 X_NUC_42.L_CORE X_NUC_107.L_CORE 0.003099
K_4945 X_NUC_42.L_CORE X_NUC_108.L_CORE 0.003081
K_4946 X_NUC_42.L_CORE X_NUC_109.L_CORE 0.002189
K_4947 X_NUC_42.L_CORE X_NUC_110.L_CORE 0.002173
K_4948 X_NUC_42.L_CORE X_NUC_111.L_CORE 0.002174
K_4949 X_NUC_42.L_CORE X_NUC_112.L_CORE 0.002168
K_4950 X_NUC_42.L_CORE X_NUC_113.L_CORE 0.002712
K_4951 X_NUC_42.L_CORE X_NUC_114.L_CORE 0.002693
K_4952 X_NUC_42.L_CORE X_NUC_115.L_CORE 0.002683
K_4953 X_NUC_42.L_CORE X_NUC_116.L_CORE 0.002681
K_4954 X_NUC_42.L_CORE X_NUC_117.L_CORE 0.003383
K_4955 X_NUC_42.L_CORE X_NUC_118.L_CORE 0.002444
K_4956 X_NUC_42.L_CORE X_NUC_119.L_CORE 0.005536
K_4957 X_NUC_42.L_CORE X_NUC_120.L_CORE 0.002516
K_4958 X_NUC_42.L_CORE X_NUC_121.L_CORE 0.002635
K_4959 X_NUC_42.L_CORE X_NUC_122.L_CORE 0.006368
K_4960 X_NUC_42.L_CORE X_NUC_123.L_CORE 0.002032
K_4961 X_NUC_42.L_CORE X_NUC_124.L_CORE 0.004453
K_4962 X_NUC_42.L_CORE X_NUC_125.L_CORE 0.002893
K_4963 X_NUC_42.L_CORE X_NUC_126.L_CORE 0.002081
K_4964 X_NUC_42.L_CORE X_NUC_127.L_CORE 0.018514
K_4965 X_NUC_42.L_CORE X_NUC_128.L_CORE 0.002040
K_4966 X_NUC_42.L_CORE X_NUC_129.L_CORE 0.002758
K_4967 X_NUC_42.L_CORE X_NUC_130.L_CORE 0.003897
K_4968 X_NUC_42.L_CORE X_NUC_131.L_CORE 0.001888
K_4969 X_NUC_42.L_CORE X_NUC_132.L_CORE 0.004744
K_4970 X_NUC_42.L_CORE X_NUC_133.L_CORE 0.002294
K_4971 X_NUC_42.L_CORE X_NUC_134.L_CORE 0.002154
K_4972 X_NUC_42.L_CORE X_NUC_135.L_CORE 0.004181
K_4973 X_NUC_42.L_CORE X_NUC_136.L_CORE 0.001943
K_4974 X_NUC_42.L_CORE X_NUC_137.L_CORE 0.002776
K_4975 X_NUC_42.L_CORE X_NUC_138.L_CORE 0.002587
K_4976 X_NUC_42.L_CORE X_NUC_139.L_CORE 0.002068
K_4977 X_NUC_42.L_CORE X_NUC_140.L_CORE 0.002646
K_4978 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_4979 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.002199
K_4980 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.002181
K_4981 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.002197
K_4982 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.002182
K_4983 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.003031
K_4984 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.002992
K_4985 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.002998
K_4986 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.003019
K_4987 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.004429
K_4988 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.004423
K_4989 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.004457
K_4990 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.004367
K_4991 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.002023
K_4992 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.002005
K_4993 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.002014
K_4994 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.002009
K_4995 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.006312
K_4996 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.006225
K_4997 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.006134
K_4998 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.006264
K_4999 X_NUC_43.L_CORE X_NUC_65.L_CORE 0.002480
K_5000 X_NUC_43.L_CORE X_NUC_66.L_CORE 0.002465
K_5001 X_NUC_43.L_CORE X_NUC_67.L_CORE 0.002479
K_5002 X_NUC_43.L_CORE X_NUC_68.L_CORE 0.002455
K_5003 X_NUC_43.L_CORE X_NUC_69.L_CORE 0.002322
K_5004 X_NUC_43.L_CORE X_NUC_70.L_CORE 0.002297
K_5005 X_NUC_43.L_CORE X_NUC_71.L_CORE 0.002302
K_5006 X_NUC_43.L_CORE X_NUC_72.L_CORE 0.002307
K_5007 X_NUC_43.L_CORE X_NUC_73.L_CORE 0.006212
K_5008 X_NUC_43.L_CORE X_NUC_74.L_CORE 0.006229
K_5009 X_NUC_43.L_CORE X_NUC_75.L_CORE 0.006158
K_5010 X_NUC_43.L_CORE X_NUC_76.L_CORE 0.006065
K_5011 X_NUC_43.L_CORE X_NUC_77.L_CORE 0.002031
K_5012 X_NUC_43.L_CORE X_NUC_78.L_CORE 0.002015
K_5013 X_NUC_43.L_CORE X_NUC_79.L_CORE 0.002023
K_5014 X_NUC_43.L_CORE X_NUC_80.L_CORE 0.002014
K_5015 X_NUC_43.L_CORE X_NUC_81.L_CORE 0.003310
K_5016 X_NUC_43.L_CORE X_NUC_82.L_CORE 0.003275
K_5017 X_NUC_43.L_CORE X_NUC_83.L_CORE 0.003260
K_5018 X_NUC_43.L_CORE X_NUC_84.L_CORE 0.003284
K_5019 X_NUC_43.L_CORE X_NUC_85.L_CORE 0.003000
K_5020 X_NUC_43.L_CORE X_NUC_86.L_CORE 0.002988
K_5021 X_NUC_43.L_CORE X_NUC_87.L_CORE 0.002994
K_5022 X_NUC_43.L_CORE X_NUC_88.L_CORE 0.002961
K_5023 X_NUC_43.L_CORE X_NUC_89.L_CORE 0.002083
K_5024 X_NUC_43.L_CORE X_NUC_90.L_CORE 0.002065
K_5025 X_NUC_43.L_CORE X_NUC_91.L_CORE 0.002069
K_5026 X_NUC_43.L_CORE X_NUC_92.L_CORE 0.002067
K_5027 X_NUC_43.L_CORE X_NUC_93.L_CORE 0.004336
K_5028 X_NUC_43.L_CORE X_NUC_94.L_CORE 0.004313
K_5029 X_NUC_43.L_CORE X_NUC_95.L_CORE 0.004260
K_5030 X_NUC_43.L_CORE X_NUC_96.L_CORE 0.004268
K_5031 X_NUC_43.L_CORE X_NUC_97.L_CORE 0.002238
K_5032 X_NUC_43.L_CORE X_NUC_98.L_CORE 0.002223
K_5033 X_NUC_43.L_CORE X_NUC_99.L_CORE 0.002228
K_5034 X_NUC_43.L_CORE X_NUC_100.L_CORE 0.002215
K_5035 X_NUC_43.L_CORE X_NUC_101.L_CORE 0.002502
K_5036 X_NUC_43.L_CORE X_NUC_102.L_CORE 0.002479
K_5037 X_NUC_43.L_CORE X_NUC_103.L_CORE 0.002475
K_5038 X_NUC_43.L_CORE X_NUC_104.L_CORE 0.002479
K_5039 X_NUC_43.L_CORE X_NUC_105.L_CORE 0.003138
K_5040 X_NUC_43.L_CORE X_NUC_106.L_CORE 0.003124
K_5041 X_NUC_43.L_CORE X_NUC_107.L_CORE 0.003112
K_5042 X_NUC_43.L_CORE X_NUC_108.L_CORE 0.003093
K_5043 X_NUC_43.L_CORE X_NUC_109.L_CORE 0.002188
K_5044 X_NUC_43.L_CORE X_NUC_110.L_CORE 0.002172
K_5045 X_NUC_43.L_CORE X_NUC_111.L_CORE 0.002173
K_5046 X_NUC_43.L_CORE X_NUC_112.L_CORE 0.002167
K_5047 X_NUC_43.L_CORE X_NUC_113.L_CORE 0.002722
K_5048 X_NUC_43.L_CORE X_NUC_114.L_CORE 0.002703
K_5049 X_NUC_43.L_CORE X_NUC_115.L_CORE 0.002693
K_5050 X_NUC_43.L_CORE X_NUC_116.L_CORE 0.002691
K_5051 X_NUC_43.L_CORE X_NUC_117.L_CORE 0.003329
K_5052 X_NUC_43.L_CORE X_NUC_118.L_CORE 0.002420
K_5053 X_NUC_43.L_CORE X_NUC_119.L_CORE 0.005424
K_5054 X_NUC_43.L_CORE X_NUC_120.L_CORE 0.002489
K_5055 X_NUC_43.L_CORE X_NUC_121.L_CORE 0.002617
K_5056 X_NUC_43.L_CORE X_NUC_122.L_CORE 0.006220
K_5057 X_NUC_43.L_CORE X_NUC_123.L_CORE 0.002018
K_5058 X_NUC_43.L_CORE X_NUC_124.L_CORE 0.004446
K_5059 X_NUC_43.L_CORE X_NUC_125.L_CORE 0.002866
K_5060 X_NUC_43.L_CORE X_NUC_126.L_CORE 0.002071
K_5061 X_NUC_43.L_CORE X_NUC_127.L_CORE 0.020201
K_5062 X_NUC_43.L_CORE X_NUC_128.L_CORE 0.002027
K_5063 X_NUC_43.L_CORE X_NUC_129.L_CORE 0.002758
K_5064 X_NUC_43.L_CORE X_NUC_130.L_CORE 0.003886
K_5065 X_NUC_43.L_CORE X_NUC_131.L_CORE 0.001881
K_5066 X_NUC_43.L_CORE X_NUC_132.L_CORE 0.004819
K_5067 X_NUC_43.L_CORE X_NUC_133.L_CORE 0.002285
K_5068 X_NUC_43.L_CORE X_NUC_134.L_CORE 0.002153
K_5069 X_NUC_43.L_CORE X_NUC_135.L_CORE 0.004224
K_5070 X_NUC_43.L_CORE X_NUC_136.L_CORE 0.001938
K_5071 X_NUC_43.L_CORE X_NUC_137.L_CORE 0.002791
K_5072 X_NUC_43.L_CORE X_NUC_138.L_CORE 0.002590
K_5073 X_NUC_43.L_CORE X_NUC_139.L_CORE 0.002069
K_5074 X_NUC_43.L_CORE X_NUC_140.L_CORE 0.002659
K_5075 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.002214
K_5076 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.002196
K_5077 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.002212
K_5078 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.002197
K_5079 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.003010
K_5080 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.002972
K_5081 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.002977
K_5082 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.002998
K_5083 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.004523
K_5084 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.004516
K_5085 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.004552
K_5086 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.004457
K_5087 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.002028
K_5088 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.002009
K_5089 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.002019
K_5090 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.002014
K_5091 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.006176
K_5092 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.006094
K_5093 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.006006
K_5094 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.006134
K_5095 X_NUC_44.L_CORE X_NUC_65.L_CORE 0.002504
K_5096 X_NUC_44.L_CORE X_NUC_66.L_CORE 0.002489
K_5097 X_NUC_44.L_CORE X_NUC_67.L_CORE 0.002503
K_5098 X_NUC_44.L_CORE X_NUC_68.L_CORE 0.002479
K_5099 X_NUC_44.L_CORE X_NUC_69.L_CORE 0.002317
K_5100 X_NUC_44.L_CORE X_NUC_70.L_CORE 0.002293
K_5101 X_NUC_44.L_CORE X_NUC_71.L_CORE 0.002297
K_5102 X_NUC_44.L_CORE X_NUC_72.L_CORE 0.002302
K_5103 X_NUC_44.L_CORE X_NUC_73.L_CORE 0.006310
K_5104 X_NUC_44.L_CORE X_NUC_74.L_CORE 0.006327
K_5105 X_NUC_44.L_CORE X_NUC_75.L_CORE 0.006251
K_5106 X_NUC_44.L_CORE X_NUC_76.L_CORE 0.006158
K_5107 X_NUC_44.L_CORE X_NUC_77.L_CORE 0.002041
K_5108 X_NUC_44.L_CORE X_NUC_78.L_CORE 0.002025
K_5109 X_NUC_44.L_CORE X_NUC_79.L_CORE 0.002033
K_5110 X_NUC_44.L_CORE X_NUC_80.L_CORE 0.002023
K_5111 X_NUC_44.L_CORE X_NUC_81.L_CORE 0.003285
K_5112 X_NUC_44.L_CORE X_NUC_82.L_CORE 0.003251
K_5113 X_NUC_44.L_CORE X_NUC_83.L_CORE 0.003235
K_5114 X_NUC_44.L_CORE X_NUC_84.L_CORE 0.003260
K_5115 X_NUC_44.L_CORE X_NUC_85.L_CORE 0.003034
K_5116 X_NUC_44.L_CORE X_NUC_86.L_CORE 0.003022
K_5117 X_NUC_44.L_CORE X_NUC_87.L_CORE 0.003027
K_5118 X_NUC_44.L_CORE X_NUC_88.L_CORE 0.002994
K_5119 X_NUC_44.L_CORE X_NUC_89.L_CORE 0.002085
K_5120 X_NUC_44.L_CORE X_NUC_90.L_CORE 0.002067
K_5121 X_NUC_44.L_CORE X_NUC_91.L_CORE 0.002070
K_5122 X_NUC_44.L_CORE X_NUC_92.L_CORE 0.002069
K_5123 X_NUC_44.L_CORE X_NUC_93.L_CORE 0.004327
K_5124 X_NUC_44.L_CORE X_NUC_94.L_CORE 0.004304
K_5125 X_NUC_44.L_CORE X_NUC_95.L_CORE 0.004251
K_5126 X_NUC_44.L_CORE X_NUC_96.L_CORE 0.004260
K_5127 X_NUC_44.L_CORE X_NUC_97.L_CORE 0.002252
K_5128 X_NUC_44.L_CORE X_NUC_98.L_CORE 0.002237
K_5129 X_NUC_44.L_CORE X_NUC_99.L_CORE 0.002242
K_5130 X_NUC_44.L_CORE X_NUC_100.L_CORE 0.002228
K_5131 X_NUC_44.L_CORE X_NUC_101.L_CORE 0.002497
K_5132 X_NUC_44.L_CORE X_NUC_102.L_CORE 0.002475
K_5133 X_NUC_44.L_CORE X_NUC_103.L_CORE 0.002470
K_5134 X_NUC_44.L_CORE X_NUC_104.L_CORE 0.002475
K_5135 X_NUC_44.L_CORE X_NUC_105.L_CORE 0.003157
K_5136 X_NUC_44.L_CORE X_NUC_106.L_CORE 0.003143
K_5137 X_NUC_44.L_CORE X_NUC_107.L_CORE 0.003131
K_5138 X_NUC_44.L_CORE X_NUC_108.L_CORE 0.003112
K_5139 X_NUC_44.L_CORE X_NUC_109.L_CORE 0.002195
K_5140 X_NUC_44.L_CORE X_NUC_110.L_CORE 0.002178
K_5141 X_NUC_44.L_CORE X_NUC_111.L_CORE 0.002179
K_5142 X_NUC_44.L_CORE X_NUC_112.L_CORE 0.002173
K_5143 X_NUC_44.L_CORE X_NUC_113.L_CORE 0.002725
K_5144 X_NUC_44.L_CORE X_NUC_114.L_CORE 0.002706
K_5145 X_NUC_44.L_CORE X_NUC_115.L_CORE 0.002695
K_5146 X_NUC_44.L_CORE X_NUC_116.L_CORE 0.002693
K_5147 X_NUC_44.L_CORE X_NUC_117.L_CORE 0.003354
K_5148 X_NUC_44.L_CORE X_NUC_118.L_CORE 0.002425
K_5149 X_NUC_44.L_CORE X_NUC_119.L_CORE 0.005402
K_5150 X_NUC_44.L_CORE X_NUC_120.L_CORE 0.002510
K_5151 X_NUC_44.L_CORE X_NUC_121.L_CORE 0.002609
K_5152 X_NUC_44.L_CORE X_NUC_122.L_CORE 0.006381
K_5153 X_NUC_44.L_CORE X_NUC_123.L_CORE 0.002026
K_5154 X_NUC_44.L_CORE X_NUC_124.L_CORE 0.004377
K_5155 X_NUC_44.L_CORE X_NUC_125.L_CORE 0.002904
K_5156 X_NUC_44.L_CORE X_NUC_126.L_CORE 0.002070
K_5157 X_NUC_44.L_CORE X_NUC_127.L_CORE 0.019705
K_5158 X_NUC_44.L_CORE X_NUC_128.L_CORE 0.002041
K_5159 X_NUC_44.L_CORE X_NUC_129.L_CORE 0.002739
K_5160 X_NUC_44.L_CORE X_NUC_130.L_CORE 0.003954
K_5161 X_NUC_44.L_CORE X_NUC_131.L_CORE 0.001885
K_5162 X_NUC_44.L_CORE X_NUC_132.L_CORE 0.004750
K_5163 X_NUC_44.L_CORE X_NUC_133.L_CORE 0.002305
K_5164 X_NUC_44.L_CORE X_NUC_134.L_CORE 0.002149
K_5165 X_NUC_44.L_CORE X_NUC_135.L_CORE 0.004255
K_5166 X_NUC_44.L_CORE X_NUC_136.L_CORE 0.001946
K_5167 X_NUC_44.L_CORE X_NUC_137.L_CORE 0.002779
K_5168 X_NUC_44.L_CORE X_NUC_138.L_CORE 0.002609
K_5169 X_NUC_44.L_CORE X_NUC_139.L_CORE 0.002071
K_5170 X_NUC_44.L_CORE X_NUC_140.L_CORE 0.002663
K_5171 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_5172 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_5173 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_5174 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.002164
K_5175 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.002167
K_5176 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.002154
K_5177 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.002176
K_5178 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.002962
K_5179 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.003003
K_5180 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.002974
K_5181 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.002984
K_5182 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.004418
K_5183 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.004362
K_5184 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.004340
K_5185 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.004410
K_5186 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.002000
K_5187 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.002010
K_5188 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.001995
K_5189 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.002011
K_5190 X_NUC_45.L_CORE X_NUC_65.L_CORE 0.006119
K_5191 X_NUC_45.L_CORE X_NUC_66.L_CORE 0.006271
K_5192 X_NUC_45.L_CORE X_NUC_67.L_CORE 0.006140
K_5193 X_NUC_45.L_CORE X_NUC_68.L_CORE 0.006107
K_5194 X_NUC_45.L_CORE X_NUC_69.L_CORE 0.002473
K_5195 X_NUC_45.L_CORE X_NUC_70.L_CORE 0.002468
K_5196 X_NUC_45.L_CORE X_NUC_71.L_CORE 0.002452
K_5197 X_NUC_45.L_CORE X_NUC_72.L_CORE 0.002479
K_5198 X_NUC_45.L_CORE X_NUC_73.L_CORE 0.002302
K_5199 X_NUC_45.L_CORE X_NUC_74.L_CORE 0.002323
K_5200 X_NUC_45.L_CORE X_NUC_75.L_CORE 0.002301
K_5201 X_NUC_45.L_CORE X_NUC_76.L_CORE 0.002314
K_5202 X_NUC_45.L_CORE X_NUC_77.L_CORE 0.006152
K_5203 X_NUC_45.L_CORE X_NUC_78.L_CORE 0.006082
K_5204 X_NUC_45.L_CORE X_NUC_79.L_CORE 0.005980
K_5205 X_NUC_45.L_CORE X_NUC_80.L_CORE 0.006041
K_5206 X_NUC_45.L_CORE X_NUC_81.L_CORE 0.002034
K_5207 X_NUC_45.L_CORE X_NUC_82.L_CORE 0.002040
K_5208 X_NUC_45.L_CORE X_NUC_83.L_CORE 0.002023
K_5209 X_NUC_45.L_CORE X_NUC_84.L_CORE 0.002041
K_5210 X_NUC_45.L_CORE X_NUC_85.L_CORE 0.003274
K_5211 X_NUC_45.L_CORE X_NUC_86.L_CORE 0.003317
K_5212 X_NUC_45.L_CORE X_NUC_87.L_CORE 0.003270
K_5213 X_NUC_45.L_CORE X_NUC_88.L_CORE 0.003278
K_5214 X_NUC_45.L_CORE X_NUC_89.L_CORE 0.003013
K_5215 X_NUC_45.L_CORE X_NUC_90.L_CORE 0.003001
K_5216 X_NUC_45.L_CORE X_NUC_91.L_CORE 0.002973
K_5217 X_NUC_45.L_CORE X_NUC_92.L_CORE 0.003006
K_5218 X_NUC_45.L_CORE X_NUC_93.L_CORE 0.002099
K_5219 X_NUC_45.L_CORE X_NUC_94.L_CORE 0.002112
K_5220 X_NUC_45.L_CORE X_NUC_95.L_CORE 0.002092
K_5221 X_NUC_45.L_CORE X_NUC_96.L_CORE 0.002106
K_5222 X_NUC_45.L_CORE X_NUC_97.L_CORE 0.004186
K_5223 X_NUC_45.L_CORE X_NUC_98.L_CORE 0.004209
K_5224 X_NUC_45.L_CORE X_NUC_99.L_CORE 0.004134
K_5225 X_NUC_45.L_CORE X_NUC_100.L_CORE 0.004149
K_5226 X_NUC_45.L_CORE X_NUC_101.L_CORE 0.002277
K_5227 X_NUC_45.L_CORE X_NUC_102.L_CORE 0.002279
K_5228 X_NUC_45.L_CORE X_NUC_103.L_CORE 0.002258
K_5229 X_NUC_45.L_CORE X_NUC_104.L_CORE 0.002278
K_5230 X_NUC_45.L_CORE X_NUC_105.L_CORE 0.002522
K_5231 X_NUC_45.L_CORE X_NUC_106.L_CORE 0.002541
K_5232 X_NUC_45.L_CORE X_NUC_107.L_CORE 0.002511
K_5233 X_NUC_45.L_CORE X_NUC_108.L_CORE 0.002524
K_5234 X_NUC_45.L_CORE X_NUC_109.L_CORE 0.003041
K_5235 X_NUC_45.L_CORE X_NUC_110.L_CORE 0.003042
K_5236 X_NUC_45.L_CORE X_NUC_111.L_CORE 0.003004
K_5237 X_NUC_45.L_CORE X_NUC_112.L_CORE 0.003027
K_5238 X_NUC_45.L_CORE X_NUC_113.L_CORE 0.002331
K_5239 X_NUC_45.L_CORE X_NUC_114.L_CORE 0.002339
K_5240 X_NUC_45.L_CORE X_NUC_115.L_CORE 0.002314
K_5241 X_NUC_45.L_CORE X_NUC_116.L_CORE 0.002330
K_5242 X_NUC_45.L_CORE X_NUC_117.L_CORE 0.003141
K_5243 X_NUC_45.L_CORE X_NUC_118.L_CORE 0.003368
K_5244 X_NUC_45.L_CORE X_NUC_119.L_CORE 0.002257
K_5245 X_NUC_45.L_CORE X_NUC_120.L_CORE 0.005863
K_5246 X_NUC_45.L_CORE X_NUC_121.L_CORE 0.002396
K_5247 X_NUC_45.L_CORE X_NUC_122.L_CORE 0.002537
K_5248 X_NUC_45.L_CORE X_NUC_123.L_CORE 0.006259
K_5249 X_NUC_45.L_CORE X_NUC_124.L_CORE 0.001970
K_5250 X_NUC_45.L_CORE X_NUC_125.L_CORE 0.004372
K_5251 X_NUC_45.L_CORE X_NUC_126.L_CORE 0.002822
K_5252 X_NUC_45.L_CORE X_NUC_127.L_CORE 0.002045
K_5253 X_NUC_45.L_CORE X_NUC_128.L_CORE 0.017872
K_5254 X_NUC_45.L_CORE X_NUC_129.L_CORE 0.002014
K_5255 X_NUC_45.L_CORE X_NUC_130.L_CORE 0.002740
K_5256 X_NUC_45.L_CORE X_NUC_131.L_CORE 0.003848
K_5257 X_NUC_45.L_CORE X_NUC_132.L_CORE 0.001885
K_5258 X_NUC_45.L_CORE X_NUC_133.L_CORE 0.004705
K_5259 X_NUC_45.L_CORE X_NUC_134.L_CORE 0.002298
K_5260 X_NUC_45.L_CORE X_NUC_135.L_CORE 0.002173
K_5261 X_NUC_45.L_CORE X_NUC_136.L_CORE 0.004067
K_5262 X_NUC_45.L_CORE X_NUC_137.L_CORE 0.001982
K_5263 X_NUC_45.L_CORE X_NUC_138.L_CORE 0.002772
K_5264 X_NUC_45.L_CORE X_NUC_139.L_CORE 0.002585
K_5265 X_NUC_45.L_CORE X_NUC_140.L_CORE 0.002205
K_5266 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_5267 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_5268 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.002162
K_5269 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.002164
K_5270 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.002151
K_5271 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.002174
K_5272 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.002922
K_5273 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.002962
K_5274 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.002933
K_5275 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.002943
K_5276 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.004473
K_5277 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.004418
K_5278 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.004393
K_5279 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.004466
K_5280 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.001989
K_5281 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.002000
K_5282 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.001985
K_5283 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.002001
K_5284 X_NUC_46.L_CORE X_NUC_65.L_CORE 0.005973
K_5285 X_NUC_46.L_CORE X_NUC_66.L_CORE 0.006119
K_5286 X_NUC_46.L_CORE X_NUC_67.L_CORE 0.005995
K_5287 X_NUC_46.L_CORE X_NUC_68.L_CORE 0.005964
K_5288 X_NUC_46.L_CORE X_NUC_69.L_CORE 0.002478
K_5289 X_NUC_46.L_CORE X_NUC_70.L_CORE 0.002473
K_5290 X_NUC_46.L_CORE X_NUC_71.L_CORE 0.002456
K_5291 X_NUC_46.L_CORE X_NUC_72.L_CORE 0.002484
K_5292 X_NUC_46.L_CORE X_NUC_73.L_CORE 0.002281
K_5293 X_NUC_46.L_CORE X_NUC_74.L_CORE 0.002302
K_5294 X_NUC_46.L_CORE X_NUC_75.L_CORE 0.002280
K_5295 X_NUC_46.L_CORE X_NUC_76.L_CORE 0.002293
K_5296 X_NUC_46.L_CORE X_NUC_77.L_CORE 0.006218
K_5297 X_NUC_46.L_CORE X_NUC_78.L_CORE 0.006152
K_5298 X_NUC_46.L_CORE X_NUC_79.L_CORE 0.006043
K_5299 X_NUC_46.L_CORE X_NUC_80.L_CORE 0.006107
K_5300 X_NUC_46.L_CORE X_NUC_81.L_CORE 0.002029
K_5301 X_NUC_46.L_CORE X_NUC_82.L_CORE 0.002034
K_5302 X_NUC_46.L_CORE X_NUC_83.L_CORE 0.002018
K_5303 X_NUC_46.L_CORE X_NUC_84.L_CORE 0.002036
K_5304 X_NUC_46.L_CORE X_NUC_85.L_CORE 0.003233
K_5305 X_NUC_46.L_CORE X_NUC_86.L_CORE 0.003274
K_5306 X_NUC_46.L_CORE X_NUC_87.L_CORE 0.003230
K_5307 X_NUC_46.L_CORE X_NUC_88.L_CORE 0.003237
K_5308 X_NUC_46.L_CORE X_NUC_89.L_CORE 0.003025
K_5309 X_NUC_46.L_CORE X_NUC_90.L_CORE 0.003013
K_5310 X_NUC_46.L_CORE X_NUC_91.L_CORE 0.002985
K_5311 X_NUC_46.L_CORE X_NUC_92.L_CORE 0.003018
K_5312 X_NUC_46.L_CORE X_NUC_93.L_CORE 0.002087
K_5313 X_NUC_46.L_CORE X_NUC_94.L_CORE 0.002099
K_5314 X_NUC_46.L_CORE X_NUC_95.L_CORE 0.002080
K_5315 X_NUC_46.L_CORE X_NUC_96.L_CORE 0.002094
K_5316 X_NUC_46.L_CORE X_NUC_97.L_CORE 0.004162
K_5317 X_NUC_46.L_CORE X_NUC_98.L_CORE 0.004186
K_5318 X_NUC_46.L_CORE X_NUC_99.L_CORE 0.004112
K_5319 X_NUC_46.L_CORE X_NUC_100.L_CORE 0.004126
K_5320 X_NUC_46.L_CORE X_NUC_101.L_CORE 0.002275
K_5321 X_NUC_46.L_CORE X_NUC_102.L_CORE 0.002277
K_5322 X_NUC_46.L_CORE X_NUC_103.L_CORE 0.002256
K_5323 X_NUC_46.L_CORE X_NUC_104.L_CORE 0.002276
K_5324 X_NUC_46.L_CORE X_NUC_105.L_CORE 0.002503
K_5325 X_NUC_46.L_CORE X_NUC_106.L_CORE 0.002522
K_5326 X_NUC_46.L_CORE X_NUC_107.L_CORE 0.002492
K_5327 X_NUC_46.L_CORE X_NUC_108.L_CORE 0.002505
K_5328 X_NUC_46.L_CORE X_NUC_109.L_CORE 0.003039
K_5329 X_NUC_46.L_CORE X_NUC_110.L_CORE 0.003041
K_5330 X_NUC_46.L_CORE X_NUC_111.L_CORE 0.003002
K_5331 X_NUC_46.L_CORE X_NUC_112.L_CORE 0.003025
K_5332 X_NUC_46.L_CORE X_NUC_113.L_CORE 0.002322
K_5333 X_NUC_46.L_CORE X_NUC_114.L_CORE 0.002331
K_5334 X_NUC_46.L_CORE X_NUC_115.L_CORE 0.002305
K_5335 X_NUC_46.L_CORE X_NUC_116.L_CORE 0.002322
K_5336 X_NUC_46.L_CORE X_NUC_117.L_CORE 0.003116
K_5337 X_NUC_46.L_CORE X_NUC_118.L_CORE 0.003372
K_5338 X_NUC_46.L_CORE X_NUC_119.L_CORE 0.002243
K_5339 X_NUC_46.L_CORE X_NUC_120.L_CORE 0.005779
K_5340 X_NUC_46.L_CORE X_NUC_121.L_CORE 0.002397
K_5341 X_NUC_46.L_CORE X_NUC_122.L_CORE 0.002510
K_5342 X_NUC_46.L_CORE X_NUC_123.L_CORE 0.006384
K_5343 X_NUC_46.L_CORE X_NUC_124.L_CORE 0.001963
K_5344 X_NUC_46.L_CORE X_NUC_125.L_CORE 0.004283
K_5345 X_NUC_46.L_CORE X_NUC_126.L_CORE 0.002837
K_5346 X_NUC_46.L_CORE X_NUC_127.L_CORE 0.002029
K_5347 X_NUC_46.L_CORE X_NUC_128.L_CORE 0.018345
K_5348 X_NUC_46.L_CORE X_NUC_129.L_CORE 0.002012
K_5349 X_NUC_46.L_CORE X_NUC_130.L_CORE 0.002706
K_5350 X_NUC_46.L_CORE X_NUC_131.L_CORE 0.003892
K_5351 X_NUC_46.L_CORE X_NUC_132.L_CORE 0.001876
K_5352 X_NUC_46.L_CORE X_NUC_133.L_CORE 0.004638
K_5353 X_NUC_46.L_CORE X_NUC_134.L_CORE 0.002302
K_5354 X_NUC_46.L_CORE X_NUC_135.L_CORE 0.002156
K_5355 X_NUC_46.L_CORE X_NUC_136.L_CORE 0.004083
K_5356 X_NUC_46.L_CORE X_NUC_137.L_CORE 0.001977
K_5357 X_NUC_46.L_CORE X_NUC_138.L_CORE 0.002750
K_5358 X_NUC_46.L_CORE X_NUC_139.L_CORE 0.002587
K_5359 X_NUC_46.L_CORE X_NUC_140.L_CORE 0.002196
K_5360 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_5361 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.002175
K_5362 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.002177
K_5363 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.002164
K_5364 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.002187
K_5365 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.002949
K_5366 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.002990
K_5367 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.002962
K_5368 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.002972
K_5369 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.004498
K_5370 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.004441
K_5371 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.004418
K_5372 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.004491
K_5373 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.002004
K_5374 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.002015
K_5375 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.002000
K_5376 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.002016
K_5377 X_NUC_47.L_CORE X_NUC_65.L_CORE 0.006093
K_5378 X_NUC_47.L_CORE X_NUC_66.L_CORE 0.006246
K_5379 X_NUC_47.L_CORE X_NUC_67.L_CORE 0.006119
K_5380 X_NUC_47.L_CORE X_NUC_68.L_CORE 0.006084
K_5381 X_NUC_47.L_CORE X_NUC_69.L_CORE 0.002495
K_5382 X_NUC_47.L_CORE X_NUC_70.L_CORE 0.002490
K_5383 X_NUC_47.L_CORE X_NUC_71.L_CORE 0.002473
K_5384 X_NUC_47.L_CORE X_NUC_72.L_CORE 0.002502
K_5385 X_NUC_47.L_CORE X_NUC_73.L_CORE 0.002303
K_5386 X_NUC_47.L_CORE X_NUC_74.L_CORE 0.002324
K_5387 X_NUC_47.L_CORE X_NUC_75.L_CORE 0.002302
K_5388 X_NUC_47.L_CORE X_NUC_76.L_CORE 0.002315
K_5389 X_NUC_47.L_CORE X_NUC_77.L_CORE 0.006334
K_5390 X_NUC_47.L_CORE X_NUC_78.L_CORE 0.006261
K_5391 X_NUC_47.L_CORE X_NUC_79.L_CORE 0.006152
K_5392 X_NUC_47.L_CORE X_NUC_80.L_CORE 0.006216
K_5393 X_NUC_47.L_CORE X_NUC_81.L_CORE 0.002045
K_5394 X_NUC_47.L_CORE X_NUC_82.L_CORE 0.002050
K_5395 X_NUC_47.L_CORE X_NUC_83.L_CORE 0.002034
K_5396 X_NUC_47.L_CORE X_NUC_84.L_CORE 0.002052
K_5397 X_NUC_47.L_CORE X_NUC_85.L_CORE 0.003277
K_5398 X_NUC_47.L_CORE X_NUC_86.L_CORE 0.003320
K_5399 X_NUC_47.L_CORE X_NUC_87.L_CORE 0.003274
K_5400 X_NUC_47.L_CORE X_NUC_88.L_CORE 0.003281
K_5401 X_NUC_47.L_CORE X_NUC_89.L_CORE 0.003054
K_5402 X_NUC_47.L_CORE X_NUC_90.L_CORE 0.003042
K_5403 X_NUC_47.L_CORE X_NUC_91.L_CORE 0.003013
K_5404 X_NUC_47.L_CORE X_NUC_92.L_CORE 0.003047
K_5405 X_NUC_47.L_CORE X_NUC_93.L_CORE 0.002107
K_5406 X_NUC_47.L_CORE X_NUC_94.L_CORE 0.002120
K_5407 X_NUC_47.L_CORE X_NUC_95.L_CORE 0.002099
K_5408 X_NUC_47.L_CORE X_NUC_96.L_CORE 0.002114
K_5409 X_NUC_47.L_CORE X_NUC_97.L_CORE 0.004238
K_5410 X_NUC_47.L_CORE X_NUC_98.L_CORE 0.004263
K_5411 X_NUC_47.L_CORE X_NUC_99.L_CORE 0.004186
K_5412 X_NUC_47.L_CORE X_NUC_100.L_CORE 0.004200
K_5413 X_NUC_47.L_CORE X_NUC_101.L_CORE 0.002296
K_5414 X_NUC_47.L_CORE X_NUC_102.L_CORE 0.002298
K_5415 X_NUC_47.L_CORE X_NUC_103.L_CORE 0.002277
K_5416 X_NUC_47.L_CORE X_NUC_104.L_CORE 0.002298
K_5417 X_NUC_47.L_CORE X_NUC_105.L_CORE 0.002533
K_5418 X_NUC_47.L_CORE X_NUC_106.L_CORE 0.002553
K_5419 X_NUC_47.L_CORE X_NUC_107.L_CORE 0.002522
K_5420 X_NUC_47.L_CORE X_NUC_108.L_CORE 0.002535
K_5421 X_NUC_47.L_CORE X_NUC_109.L_CORE 0.003079
K_5422 X_NUC_47.L_CORE X_NUC_110.L_CORE 0.003081
K_5423 X_NUC_47.L_CORE X_NUC_111.L_CORE 0.003041
K_5424 X_NUC_47.L_CORE X_NUC_112.L_CORE 0.003065
K_5425 X_NUC_47.L_CORE X_NUC_113.L_CORE 0.002347
K_5426 X_NUC_47.L_CORE X_NUC_114.L_CORE 0.002356
K_5427 X_NUC_47.L_CORE X_NUC_115.L_CORE 0.002331
K_5428 X_NUC_47.L_CORE X_NUC_116.L_CORE 0.002347
K_5429 X_NUC_47.L_CORE X_NUC_117.L_CORE 0.003118
K_5430 X_NUC_47.L_CORE X_NUC_118.L_CORE 0.003365
K_5431 X_NUC_47.L_CORE X_NUC_119.L_CORE 0.002252
K_5432 X_NUC_47.L_CORE X_NUC_120.L_CORE 0.005733
K_5433 X_NUC_47.L_CORE X_NUC_121.L_CORE 0.002404
K_5434 X_NUC_47.L_CORE X_NUC_122.L_CORE 0.002525
K_5435 X_NUC_47.L_CORE X_NUC_123.L_CORE 0.006310
K_5436 X_NUC_47.L_CORE X_NUC_124.L_CORE 0.001974
K_5437 X_NUC_47.L_CORE X_NUC_125.L_CORE 0.004313
K_5438 X_NUC_47.L_CORE X_NUC_126.L_CORE 0.002847
K_5439 X_NUC_47.L_CORE X_NUC_127.L_CORE 0.002044
K_5440 X_NUC_47.L_CORE X_NUC_128.L_CORE 0.018475
K_5441 X_NUC_47.L_CORE X_NUC_129.L_CORE 0.002025
K_5442 X_NUC_47.L_CORE X_NUC_130.L_CORE 0.002732
K_5443 X_NUC_47.L_CORE X_NUC_131.L_CORE 0.003916
K_5444 X_NUC_47.L_CORE X_NUC_132.L_CORE 0.001890
K_5445 X_NUC_47.L_CORE X_NUC_133.L_CORE 0.004716
K_5446 X_NUC_47.L_CORE X_NUC_134.L_CORE 0.002319
K_5447 X_NUC_47.L_CORE X_NUC_135.L_CORE 0.002177
K_5448 X_NUC_47.L_CORE X_NUC_136.L_CORE 0.004141
K_5449 X_NUC_47.L_CORE X_NUC_137.L_CORE 0.001994
K_5450 X_NUC_47.L_CORE X_NUC_138.L_CORE 0.002785
K_5451 X_NUC_47.L_CORE X_NUC_139.L_CORE 0.002614
K_5452 X_NUC_47.L_CORE X_NUC_140.L_CORE 0.002219
K_5453 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.002153
K_5454 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.002155
K_5455 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.002142
K_5456 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.002164
K_5457 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.002939
K_5458 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.002980
K_5459 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.002951
K_5460 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.002962
K_5461 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.004423
K_5462 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.004369
K_5463 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.004346
K_5464 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.004418
K_5465 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.001988
K_5466 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.001999
K_5467 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.001984
K_5468 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.002000
K_5469 X_NUC_48.L_CORE X_NUC_65.L_CORE 0.006126
K_5470 X_NUC_48.L_CORE X_NUC_66.L_CORE 0.006282
K_5471 X_NUC_48.L_CORE X_NUC_67.L_CORE 0.006150
K_5472 X_NUC_48.L_CORE X_NUC_68.L_CORE 0.006119
K_5473 X_NUC_48.L_CORE X_NUC_69.L_CORE 0.002467
K_5474 X_NUC_48.L_CORE X_NUC_70.L_CORE 0.002462
K_5475 X_NUC_48.L_CORE X_NUC_71.L_CORE 0.002446
K_5476 X_NUC_48.L_CORE X_NUC_72.L_CORE 0.002473
K_5477 X_NUC_48.L_CORE X_NUC_73.L_CORE 0.002290
K_5478 X_NUC_48.L_CORE X_NUC_74.L_CORE 0.002311
K_5479 X_NUC_48.L_CORE X_NUC_75.L_CORE 0.002289
K_5480 X_NUC_48.L_CORE X_NUC_76.L_CORE 0.002302
K_5481 X_NUC_48.L_CORE X_NUC_77.L_CORE 0.006263
K_5482 X_NUC_48.L_CORE X_NUC_78.L_CORE 0.006192
K_5483 X_NUC_48.L_CORE X_NUC_79.L_CORE 0.006084
K_5484 X_NUC_48.L_CORE X_NUC_80.L_CORE 0.006152
K_5485 X_NUC_48.L_CORE X_NUC_81.L_CORE 0.002027
K_5486 X_NUC_48.L_CORE X_NUC_82.L_CORE 0.002032
K_5487 X_NUC_48.L_CORE X_NUC_83.L_CORE 0.002016
K_5488 X_NUC_48.L_CORE X_NUC_84.L_CORE 0.002034
K_5489 X_NUC_48.L_CORE X_NUC_85.L_CORE 0.003270
K_5490 X_NUC_48.L_CORE X_NUC_86.L_CORE 0.003313
K_5491 X_NUC_48.L_CORE X_NUC_87.L_CORE 0.003267
K_5492 X_NUC_48.L_CORE X_NUC_88.L_CORE 0.003274
K_5493 X_NUC_48.L_CORE X_NUC_89.L_CORE 0.003020
K_5494 X_NUC_48.L_CORE X_NUC_90.L_CORE 0.003008
K_5495 X_NUC_48.L_CORE X_NUC_91.L_CORE 0.002980
K_5496 X_NUC_48.L_CORE X_NUC_92.L_CORE 0.003013
K_5497 X_NUC_48.L_CORE X_NUC_93.L_CORE 0.002092
K_5498 X_NUC_48.L_CORE X_NUC_94.L_CORE 0.002105
K_5499 X_NUC_48.L_CORE X_NUC_95.L_CORE 0.002085
K_5500 X_NUC_48.L_CORE X_NUC_96.L_CORE 0.002099
K_5501 X_NUC_48.L_CORE X_NUC_97.L_CORE 0.004223
K_5502 X_NUC_48.L_CORE X_NUC_98.L_CORE 0.004247
K_5503 X_NUC_48.L_CORE X_NUC_99.L_CORE 0.004170
K_5504 X_NUC_48.L_CORE X_NUC_100.L_CORE 0.004186
K_5505 X_NUC_48.L_CORE X_NUC_101.L_CORE 0.002275
K_5506 X_NUC_48.L_CORE X_NUC_102.L_CORE 0.002277
K_5507 X_NUC_48.L_CORE X_NUC_103.L_CORE 0.002256
K_5508 X_NUC_48.L_CORE X_NUC_104.L_CORE 0.002277
K_5509 X_NUC_48.L_CORE X_NUC_105.L_CORE 0.002520
K_5510 X_NUC_48.L_CORE X_NUC_106.L_CORE 0.002539
K_5511 X_NUC_48.L_CORE X_NUC_107.L_CORE 0.002509
K_5512 X_NUC_48.L_CORE X_NUC_108.L_CORE 0.002522
K_5513 X_NUC_48.L_CORE X_NUC_109.L_CORE 0.003055
K_5514 X_NUC_48.L_CORE X_NUC_110.L_CORE 0.003056
K_5515 X_NUC_48.L_CORE X_NUC_111.L_CORE 0.003017
K_5516 X_NUC_48.L_CORE X_NUC_112.L_CORE 0.003041
K_5517 X_NUC_48.L_CORE X_NUC_113.L_CORE 0.002330
K_5518 X_NUC_48.L_CORE X_NUC_114.L_CORE 0.002339
K_5519 X_NUC_48.L_CORE X_NUC_115.L_CORE 0.002314
K_5520 X_NUC_48.L_CORE X_NUC_116.L_CORE 0.002331
K_5521 X_NUC_48.L_CORE X_NUC_117.L_CORE 0.003094
K_5522 X_NUC_48.L_CORE X_NUC_118.L_CORE 0.003325
K_5523 X_NUC_48.L_CORE X_NUC_119.L_CORE 0.002234
K_5524 X_NUC_48.L_CORE X_NUC_120.L_CORE 0.005715
K_5525 X_NUC_48.L_CORE X_NUC_121.L_CORE 0.002378
K_5526 X_NUC_48.L_CORE X_NUC_122.L_CORE 0.002512
K_5527 X_NUC_48.L_CORE X_NUC_123.L_CORE 0.006201
K_5528 X_NUC_48.L_CORE X_NUC_124.L_CORE 0.001957
K_5529 X_NUC_48.L_CORE X_NUC_125.L_CORE 0.004323
K_5530 X_NUC_48.L_CORE X_NUC_126.L_CORE 0.002811
K_5531 X_NUC_48.L_CORE X_NUC_127.L_CORE 0.002031
K_5532 X_NUC_48.L_CORE X_NUC_128.L_CORE 0.019520
K_5533 X_NUC_48.L_CORE X_NUC_129.L_CORE 0.002005
K_5534 X_NUC_48.L_CORE X_NUC_130.L_CORE 0.002726
K_5535 X_NUC_48.L_CORE X_NUC_131.L_CORE 0.003868
K_5536 X_NUC_48.L_CORE X_NUC_132.L_CORE 0.001876
K_5537 X_NUC_48.L_CORE X_NUC_133.L_CORE 0.004738
K_5538 X_NUC_48.L_CORE X_NUC_134.L_CORE 0.002296
K_5539 X_NUC_48.L_CORE X_NUC_135.L_CORE 0.002167
K_5540 X_NUC_48.L_CORE X_NUC_136.L_CORE 0.004117
K_5541 X_NUC_48.L_CORE X_NUC_137.L_CORE 0.001978
K_5542 X_NUC_48.L_CORE X_NUC_138.L_CORE 0.002777
K_5543 X_NUC_48.L_CORE X_NUC_139.L_CORE 0.002593
K_5544 X_NUC_48.L_CORE X_NUC_140.L_CORE 0.002205
K_5545 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_5546 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_5547 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_5548 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.002144
K_5549 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.002157
K_5550 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.002158
K_5551 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.002140
K_5552 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.002941
K_5553 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.002918
K_5554 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.002943
K_5555 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.002909
K_5556 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.004398
K_5557 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.004489
K_5558 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.004436
K_5559 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.004418
K_5560 X_NUC_49.L_CORE X_NUC_65.L_CORE 0.001995
K_5561 X_NUC_49.L_CORE X_NUC_66.L_CORE 0.001998
K_5562 X_NUC_49.L_CORE X_NUC_67.L_CORE 0.002004
K_5563 X_NUC_49.L_CORE X_NUC_68.L_CORE 0.001985
K_5564 X_NUC_49.L_CORE X_NUC_69.L_CORE 0.006119
K_5565 X_NUC_49.L_CORE X_NUC_70.L_CORE 0.005992
K_5566 X_NUC_49.L_CORE X_NUC_71.L_CORE 0.006028
K_5567 X_NUC_49.L_CORE X_NUC_72.L_CORE 0.005951
K_5568 X_NUC_49.L_CORE X_NUC_73.L_CORE 0.002479
K_5569 X_NUC_49.L_CORE X_NUC_74.L_CORE 0.002502
K_5570 X_NUC_49.L_CORE X_NUC_75.L_CORE 0.002494
K_5571 X_NUC_49.L_CORE X_NUC_76.L_CORE 0.002476
K_5572 X_NUC_49.L_CORE X_NUC_77.L_CORE 0.002313
K_5573 X_NUC_49.L_CORE X_NUC_78.L_CORE 0.002307
K_5574 X_NUC_49.L_CORE X_NUC_79.L_CORE 0.002317
K_5575 X_NUC_49.L_CORE X_NUC_80.L_CORE 0.002293
K_5576 X_NUC_49.L_CORE X_NUC_81.L_CORE 0.006131
K_5577 X_NUC_49.L_CORE X_NUC_82.L_CORE 0.006224
K_5578 X_NUC_49.L_CORE X_NUC_83.L_CORE 0.006074
K_5579 X_NUC_49.L_CORE X_NUC_84.L_CORE 0.006061
K_5580 X_NUC_49.L_CORE X_NUC_85.L_CORE 0.002056
K_5581 X_NUC_49.L_CORE X_NUC_86.L_CORE 0.002064
K_5582 X_NUC_49.L_CORE X_NUC_87.L_CORE 0.002064
K_5583 X_NUC_49.L_CORE X_NUC_88.L_CORE 0.002047
K_5584 X_NUC_49.L_CORE X_NUC_89.L_CORE 0.003298
K_5585 X_NUC_49.L_CORE X_NUC_90.L_CORE 0.003274
K_5586 X_NUC_49.L_CORE X_NUC_91.L_CORE 0.003282
K_5587 X_NUC_49.L_CORE X_NUC_92.L_CORE 0.003248
K_5588 X_NUC_49.L_CORE X_NUC_93.L_CORE 0.003043
K_5589 X_NUC_49.L_CORE X_NUC_94.L_CORE 0.003074
K_5590 X_NUC_49.L_CORE X_NUC_95.L_CORE 0.003049
K_5591 X_NUC_49.L_CORE X_NUC_96.L_CORE 0.003031
K_5592 X_NUC_49.L_CORE X_NUC_97.L_CORE 0.002146
K_5593 X_NUC_49.L_CORE X_NUC_98.L_CORE 0.002146
K_5594 X_NUC_49.L_CORE X_NUC_99.L_CORE 0.002149
K_5595 X_NUC_49.L_CORE X_NUC_100.L_CORE 0.002129
K_5596 X_NUC_49.L_CORE X_NUC_101.L_CORE 0.004080
K_5597 X_NUC_49.L_CORE X_NUC_102.L_CORE 0.004076
K_5598 X_NUC_49.L_CORE X_NUC_103.L_CORE 0.004042
K_5599 X_NUC_49.L_CORE X_NUC_104.L_CORE 0.004012
K_5600 X_NUC_49.L_CORE X_NUC_105.L_CORE 0.002347
K_5601 X_NUC_49.L_CORE X_NUC_106.L_CORE 0.002359
K_5602 X_NUC_49.L_CORE X_NUC_107.L_CORE 0.002351
K_5603 X_NUC_49.L_CORE X_NUC_108.L_CORE 0.002333
K_5604 X_NUC_49.L_CORE X_NUC_109.L_CORE 0.002587
K_5605 X_NUC_49.L_CORE X_NUC_110.L_CORE 0.002584
K_5606 X_NUC_49.L_CORE X_NUC_111.L_CORE 0.002582
K_5607 X_NUC_49.L_CORE X_NUC_112.L_CORE 0.002559
K_5608 X_NUC_49.L_CORE X_NUC_113.L_CORE 0.002905
K_5609 X_NUC_49.L_CORE X_NUC_114.L_CORE 0.002916
K_5610 X_NUC_49.L_CORE X_NUC_115.L_CORE 0.002898
K_5611 X_NUC_49.L_CORE X_NUC_116.L_CORE 0.002877
K_5612 X_NUC_49.L_CORE X_NUC_117.L_CORE 0.002519
K_5613 X_NUC_49.L_CORE X_NUC_118.L_CORE 0.003085
K_5614 X_NUC_49.L_CORE X_NUC_119.L_CORE 0.003344
K_5615 X_NUC_49.L_CORE X_NUC_120.L_CORE 0.002132
K_5616 X_NUC_49.L_CORE X_NUC_121.L_CORE 0.006042
K_5617 X_NUC_49.L_CORE X_NUC_122.L_CORE 0.002325
K_5618 X_NUC_49.L_CORE X_NUC_123.L_CORE 0.002448
K_5619 X_NUC_49.L_CORE X_NUC_124.L_CORE 0.006368
K_5620 X_NUC_49.L_CORE X_NUC_125.L_CORE 0.001929
K_5621 X_NUC_49.L_CORE X_NUC_126.L_CORE 0.004226
K_5622 X_NUC_49.L_CORE X_NUC_127.L_CORE 0.002809
K_5623 X_NUC_49.L_CORE X_NUC_128.L_CORE 0.002016
K_5624 X_NUC_49.L_CORE X_NUC_129.L_CORE 0.017052
K_5625 X_NUC_49.L_CORE X_NUC_130.L_CORE 0.002012
K_5626 X_NUC_49.L_CORE X_NUC_131.L_CORE 0.002708
K_5627 X_NUC_49.L_CORE X_NUC_132.L_CORE 0.003889
K_5628 X_NUC_49.L_CORE X_NUC_133.L_CORE 0.001894
K_5629 X_NUC_49.L_CORE X_NUC_134.L_CORE 0.004584
K_5630 X_NUC_49.L_CORE X_NUC_135.L_CORE 0.002335
K_5631 X_NUC_49.L_CORE X_NUC_136.L_CORE 0.002198
K_5632 X_NUC_49.L_CORE X_NUC_137.L_CORE 0.003954
K_5633 X_NUC_49.L_CORE X_NUC_138.L_CORE 0.002050
K_5634 X_NUC_49.L_CORE X_NUC_139.L_CORE 0.002747
K_5635 X_NUC_49.L_CORE X_NUC_140.L_CORE 0.002581
K_5636 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_5637 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_5638 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.002130
K_5639 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.002144
K_5640 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.002145
K_5641 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.002128
K_5642 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.002963
K_5643 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.002941
K_5644 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.002966
K_5645 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.002931
K_5646 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.004311
K_5647 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.004398
K_5648 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.004347
K_5649 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.004331
K_5650 X_NUC_50.L_CORE X_NUC_65.L_CORE 0.001991
K_5651 X_NUC_50.L_CORE X_NUC_66.L_CORE 0.001995
K_5652 X_NUC_50.L_CORE X_NUC_67.L_CORE 0.002001
K_5653 X_NUC_50.L_CORE X_NUC_68.L_CORE 0.001982
K_5654 X_NUC_50.L_CORE X_NUC_69.L_CORE 0.006250
K_5655 X_NUC_50.L_CORE X_NUC_70.L_CORE 0.006119
K_5656 X_NUC_50.L_CORE X_NUC_71.L_CORE 0.006155
K_5657 X_NUC_50.L_CORE X_NUC_72.L_CORE 0.006073
K_5658 X_NUC_50.L_CORE X_NUC_73.L_CORE 0.002457
K_5659 X_NUC_50.L_CORE X_NUC_74.L_CORE 0.002479
K_5660 X_NUC_50.L_CORE X_NUC_75.L_CORE 0.002471
K_5661 X_NUC_50.L_CORE X_NUC_76.L_CORE 0.002454
K_5662 X_NUC_50.L_CORE X_NUC_77.L_CORE 0.002320
K_5663 X_NUC_50.L_CORE X_NUC_78.L_CORE 0.002313
K_5664 X_NUC_50.L_CORE X_NUC_79.L_CORE 0.002323
K_5665 X_NUC_50.L_CORE X_NUC_80.L_CORE 0.002299
K_5666 X_NUC_50.L_CORE X_NUC_81.L_CORE 0.006037
K_5667 X_NUC_50.L_CORE X_NUC_82.L_CORE 0.006131
K_5668 X_NUC_50.L_CORE X_NUC_83.L_CORE 0.005985
K_5669 X_NUC_50.L_CORE X_NUC_84.L_CORE 0.005972
K_5670 X_NUC_50.L_CORE X_NUC_85.L_CORE 0.002048
K_5671 X_NUC_50.L_CORE X_NUC_86.L_CORE 0.002056
K_5672 X_NUC_50.L_CORE X_NUC_87.L_CORE 0.002056
K_5673 X_NUC_50.L_CORE X_NUC_88.L_CORE 0.002039
K_5674 X_NUC_50.L_CORE X_NUC_89.L_CORE 0.003323
K_5675 X_NUC_50.L_CORE X_NUC_90.L_CORE 0.003298
K_5676 X_NUC_50.L_CORE X_NUC_91.L_CORE 0.003307
K_5677 X_NUC_50.L_CORE X_NUC_92.L_CORE 0.003272
K_5678 X_NUC_50.L_CORE X_NUC_93.L_CORE 0.003012
K_5679 X_NUC_50.L_CORE X_NUC_94.L_CORE 0.003043
K_5680 X_NUC_50.L_CORE X_NUC_95.L_CORE 0.003018
K_5681 X_NUC_50.L_CORE X_NUC_96.L_CORE 0.003000
K_5682 X_NUC_50.L_CORE X_NUC_97.L_CORE 0.002145
K_5683 X_NUC_50.L_CORE X_NUC_98.L_CORE 0.002146
K_5684 X_NUC_50.L_CORE X_NUC_99.L_CORE 0.002148
K_5685 X_NUC_50.L_CORE X_NUC_100.L_CORE 0.002128
K_5686 X_NUC_50.L_CORE X_NUC_101.L_CORE 0.004083
K_5687 X_NUC_50.L_CORE X_NUC_102.L_CORE 0.004080
K_5688 X_NUC_50.L_CORE X_NUC_103.L_CORE 0.004045
K_5689 X_NUC_50.L_CORE X_NUC_104.L_CORE 0.004015
K_5690 X_NUC_50.L_CORE X_NUC_105.L_CORE 0.002335
K_5691 X_NUC_50.L_CORE X_NUC_106.L_CORE 0.002347
K_5692 X_NUC_50.L_CORE X_NUC_107.L_CORE 0.002339
K_5693 X_NUC_50.L_CORE X_NUC_108.L_CORE 0.002321
K_5694 X_NUC_50.L_CORE X_NUC_109.L_CORE 0.002590
K_5695 X_NUC_50.L_CORE X_NUC_110.L_CORE 0.002587
K_5696 X_NUC_50.L_CORE X_NUC_111.L_CORE 0.002585
K_5697 X_NUC_50.L_CORE X_NUC_112.L_CORE 0.002562
K_5698 X_NUC_50.L_CORE X_NUC_113.L_CORE 0.002894
K_5699 X_NUC_50.L_CORE X_NUC_114.L_CORE 0.002905
K_5700 X_NUC_50.L_CORE X_NUC_115.L_CORE 0.002887
K_5701 X_NUC_50.L_CORE X_NUC_116.L_CORE 0.002866
K_5702 X_NUC_50.L_CORE X_NUC_117.L_CORE 0.002510
K_5703 X_NUC_50.L_CORE X_NUC_118.L_CORE 0.003095
K_5704 X_NUC_50.L_CORE X_NUC_119.L_CORE 0.003309
K_5705 X_NUC_50.L_CORE X_NUC_120.L_CORE 0.002130
K_5706 X_NUC_50.L_CORE X_NUC_121.L_CORE 0.006109
K_5707 X_NUC_50.L_CORE X_NUC_122.L_CORE 0.002307
K_5708 X_NUC_50.L_CORE X_NUC_123.L_CORE 0.002459
K_5709 X_NUC_50.L_CORE X_NUC_124.L_CORE 0.006197
K_5710 X_NUC_50.L_CORE X_NUC_125.L_CORE 0.001923
K_5711 X_NUC_50.L_CORE X_NUC_126.L_CORE 0.004296
K_5712 X_NUC_50.L_CORE X_NUC_127.L_CORE 0.002775
K_5713 X_NUC_50.L_CORE X_NUC_128.L_CORE 0.002018
K_5714 X_NUC_50.L_CORE X_NUC_129.L_CORE 0.017257
K_5715 X_NUC_50.L_CORE X_NUC_130.L_CORE 0.002000
K_5716 X_NUC_50.L_CORE X_NUC_131.L_CORE 0.002729
K_5717 X_NUC_50.L_CORE X_NUC_132.L_CORE 0.003826
K_5718 X_NUC_50.L_CORE X_NUC_133.L_CORE 0.001891
K_5719 X_NUC_50.L_CORE X_NUC_134.L_CORE 0.004641
K_5720 X_NUC_50.L_CORE X_NUC_135.L_CORE 0.002317
K_5721 X_NUC_50.L_CORE X_NUC_136.L_CORE 0.002203
K_5722 X_NUC_50.L_CORE X_NUC_137.L_CORE 0.003930
K_5723 X_NUC_50.L_CORE X_NUC_138.L_CORE 0.002043
K_5724 X_NUC_50.L_CORE X_NUC_139.L_CORE 0.002754
K_5725 X_NUC_50.L_CORE X_NUC_140.L_CORE 0.002570
K_5726 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_5727 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.002129
K_5728 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.002142
K_5729 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.002144
K_5730 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.002126
K_5731 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.002937
K_5732 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.002915
K_5733 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.002941
K_5734 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.002906
K_5735 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.004360
K_5736 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.004449
K_5737 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.004398
K_5738 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.004380
K_5739 X_NUC_51.L_CORE X_NUC_65.L_CORE 0.001986
K_5740 X_NUC_51.L_CORE X_NUC_66.L_CORE 0.001989
K_5741 X_NUC_51.L_CORE X_NUC_67.L_CORE 0.001995
K_5742 X_NUC_51.L_CORE X_NUC_68.L_CORE 0.001976
K_5743 X_NUC_51.L_CORE X_NUC_69.L_CORE 0.006210
K_5744 X_NUC_51.L_CORE X_NUC_70.L_CORE 0.006079
K_5745 X_NUC_51.L_CORE X_NUC_71.L_CORE 0.006119
K_5746 X_NUC_51.L_CORE X_NUC_72.L_CORE 0.006037
K_5747 X_NUC_51.L_CORE X_NUC_73.L_CORE 0.002464
K_5748 X_NUC_51.L_CORE X_NUC_74.L_CORE 0.002487
K_5749 X_NUC_51.L_CORE X_NUC_75.L_CORE 0.002479
K_5750 X_NUC_51.L_CORE X_NUC_76.L_CORE 0.002461
K_5751 X_NUC_51.L_CORE X_NUC_77.L_CORE 0.002310
K_5752 X_NUC_51.L_CORE X_NUC_78.L_CORE 0.002303
K_5753 X_NUC_51.L_CORE X_NUC_79.L_CORE 0.002313
K_5754 X_NUC_51.L_CORE X_NUC_80.L_CORE 0.002290
K_5755 X_NUC_51.L_CORE X_NUC_81.L_CORE 0.006184
K_5756 X_NUC_51.L_CORE X_NUC_82.L_CORE 0.006283
K_5757 X_NUC_51.L_CORE X_NUC_83.L_CORE 0.006131
K_5758 X_NUC_51.L_CORE X_NUC_84.L_CORE 0.006115
K_5759 X_NUC_51.L_CORE X_NUC_85.L_CORE 0.002048
K_5760 X_NUC_51.L_CORE X_NUC_86.L_CORE 0.002056
K_5761 X_NUC_51.L_CORE X_NUC_87.L_CORE 0.002056
K_5762 X_NUC_51.L_CORE X_NUC_88.L_CORE 0.002039
K_5763 X_NUC_51.L_CORE X_NUC_89.L_CORE 0.003314
K_5764 X_NUC_51.L_CORE X_NUC_90.L_CORE 0.003289
K_5765 X_NUC_51.L_CORE X_NUC_91.L_CORE 0.003298
K_5766 X_NUC_51.L_CORE X_NUC_92.L_CORE 0.003263
K_5767 X_NUC_51.L_CORE X_NUC_93.L_CORE 0.003036
K_5768 X_NUC_51.L_CORE X_NUC_94.L_CORE 0.003067
K_5769 X_NUC_51.L_CORE X_NUC_95.L_CORE 0.003043
K_5770 X_NUC_51.L_CORE X_NUC_96.L_CORE 0.003024
K_5771 X_NUC_51.L_CORE X_NUC_97.L_CORE 0.002142
K_5772 X_NUC_51.L_CORE X_NUC_98.L_CORE 0.002143
K_5773 X_NUC_51.L_CORE X_NUC_99.L_CORE 0.002146
K_5774 X_NUC_51.L_CORE X_NUC_100.L_CORE 0.002126
K_5775 X_NUC_51.L_CORE X_NUC_101.L_CORE 0.004119
K_5776 X_NUC_51.L_CORE X_NUC_102.L_CORE 0.004115
K_5777 X_NUC_51.L_CORE X_NUC_103.L_CORE 0.004080
K_5778 X_NUC_51.L_CORE X_NUC_104.L_CORE 0.004049
K_5779 X_NUC_51.L_CORE X_NUC_105.L_CORE 0.002342
K_5780 X_NUC_51.L_CORE X_NUC_106.L_CORE 0.002355
K_5781 X_NUC_51.L_CORE X_NUC_107.L_CORE 0.002347
K_5782 X_NUC_51.L_CORE X_NUC_108.L_CORE 0.002329
K_5783 X_NUC_51.L_CORE X_NUC_109.L_CORE 0.002592
K_5784 X_NUC_51.L_CORE X_NUC_110.L_CORE 0.002589
K_5785 X_NUC_51.L_CORE X_NUC_111.L_CORE 0.002587
K_5786 X_NUC_51.L_CORE X_NUC_112.L_CORE 0.002564
K_5787 X_NUC_51.L_CORE X_NUC_113.L_CORE 0.002912
K_5788 X_NUC_51.L_CORE X_NUC_114.L_CORE 0.002923
K_5789 X_NUC_51.L_CORE X_NUC_115.L_CORE 0.002905
K_5790 X_NUC_51.L_CORE X_NUC_116.L_CORE 0.002883
K_5791 X_NUC_51.L_CORE X_NUC_117.L_CORE 0.002491
K_5792 X_NUC_51.L_CORE X_NUC_118.L_CORE 0.003053
K_5793 X_NUC_51.L_CORE X_NUC_119.L_CORE 0.003292
K_5794 X_NUC_51.L_CORE X_NUC_120.L_CORE 0.002115
K_5795 X_NUC_51.L_CORE X_NUC_121.L_CORE 0.005939
K_5796 X_NUC_51.L_CORE X_NUC_122.L_CORE 0.002302
K_5797 X_NUC_51.L_CORE X_NUC_123.L_CORE 0.002436
K_5798 X_NUC_51.L_CORE X_NUC_124.L_CORE 0.006227
K_5799 X_NUC_51.L_CORE X_NUC_125.L_CORE 0.001917
K_5800 X_NUC_51.L_CORE X_NUC_126.L_CORE 0.004230
K_5801 X_NUC_51.L_CORE X_NUC_127.L_CORE 0.002784
K_5802 X_NUC_51.L_CORE X_NUC_128.L_CORE 0.002008
K_5803 X_NUC_51.L_CORE X_NUC_129.L_CORE 0.018473
K_5804 X_NUC_51.L_CORE X_NUC_130.L_CORE 0.002000
K_5805 X_NUC_51.L_CORE X_NUC_131.L_CORE 0.002711
K_5806 X_NUC_51.L_CORE X_NUC_132.L_CORE 0.003877
K_5807 X_NUC_51.L_CORE X_NUC_133.L_CORE 0.001888
K_5808 X_NUC_51.L_CORE X_NUC_134.L_CORE 0.004651
K_5809 X_NUC_51.L_CORE X_NUC_135.L_CORE 0.002326
K_5810 X_NUC_51.L_CORE X_NUC_136.L_CORE 0.002198
K_5811 X_NUC_51.L_CORE X_NUC_137.L_CORE 0.003985
K_5812 X_NUC_51.L_CORE X_NUC_138.L_CORE 0.002046
K_5813 X_NUC_51.L_CORE X_NUC_139.L_CORE 0.002760
K_5814 X_NUC_51.L_CORE X_NUC_140.L_CORE 0.002585
K_5815 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.002146
K_5816 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.002160
K_5817 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.002161
K_5818 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.002144
K_5819 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.002972
K_5820 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.002950
K_5821 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.002976
K_5822 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.002941
K_5823 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.004377
K_5824 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.004467
K_5825 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.004414
K_5826 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.004398
K_5827 X_NUC_52.L_CORE X_NUC_65.L_CORE 0.002004
K_5828 X_NUC_52.L_CORE X_NUC_66.L_CORE 0.002008
K_5829 X_NUC_52.L_CORE X_NUC_67.L_CORE 0.002014
K_5830 X_NUC_52.L_CORE X_NUC_68.L_CORE 0.001995
K_5831 X_NUC_52.L_CORE X_NUC_69.L_CORE 0.006297
K_5832 X_NUC_52.L_CORE X_NUC_70.L_CORE 0.006161
K_5833 X_NUC_52.L_CORE X_NUC_71.L_CORE 0.006200
K_5834 X_NUC_52.L_CORE X_NUC_72.L_CORE 0.006119
K_5835 X_NUC_52.L_CORE X_NUC_73.L_CORE 0.002482
K_5836 X_NUC_52.L_CORE X_NUC_74.L_CORE 0.002505
K_5837 X_NUC_52.L_CORE X_NUC_75.L_CORE 0.002497
K_5838 X_NUC_52.L_CORE X_NUC_76.L_CORE 0.002479
K_5839 X_NUC_52.L_CORE X_NUC_77.L_CORE 0.002334
K_5840 X_NUC_52.L_CORE X_NUC_78.L_CORE 0.002327
K_5841 X_NUC_52.L_CORE X_NUC_79.L_CORE 0.002337
K_5842 X_NUC_52.L_CORE X_NUC_80.L_CORE 0.002313
K_5843 X_NUC_52.L_CORE X_NUC_81.L_CORE 0.006198
K_5844 X_NUC_52.L_CORE X_NUC_82.L_CORE 0.006298
K_5845 X_NUC_52.L_CORE X_NUC_83.L_CORE 0.006143
K_5846 X_NUC_52.L_CORE X_NUC_84.L_CORE 0.006131
K_5847 X_NUC_52.L_CORE X_NUC_85.L_CORE 0.002065
K_5848 X_NUC_52.L_CORE X_NUC_86.L_CORE 0.002074
K_5849 X_NUC_52.L_CORE X_NUC_87.L_CORE 0.002074
K_5850 X_NUC_52.L_CORE X_NUC_88.L_CORE 0.002056
K_5851 X_NUC_52.L_CORE X_NUC_89.L_CORE 0.003350
K_5852 X_NUC_52.L_CORE X_NUC_90.L_CORE 0.003325
K_5853 X_NUC_52.L_CORE X_NUC_91.L_CORE 0.003334
K_5854 X_NUC_52.L_CORE X_NUC_92.L_CORE 0.003298
K_5855 X_NUC_52.L_CORE X_NUC_93.L_CORE 0.003054
K_5856 X_NUC_52.L_CORE X_NUC_94.L_CORE 0.003086
K_5857 X_NUC_52.L_CORE X_NUC_95.L_CORE 0.003061
K_5858 X_NUC_52.L_CORE X_NUC_96.L_CORE 0.003043
K_5859 X_NUC_52.L_CORE X_NUC_97.L_CORE 0.002162
K_5860 X_NUC_52.L_CORE X_NUC_98.L_CORE 0.002163
K_5861 X_NUC_52.L_CORE X_NUC_99.L_CORE 0.002166
K_5862 X_NUC_52.L_CORE X_NUC_100.L_CORE 0.002146
K_5863 X_NUC_52.L_CORE X_NUC_101.L_CORE 0.004151
K_5864 X_NUC_52.L_CORE X_NUC_102.L_CORE 0.004147
K_5865 X_NUC_52.L_CORE X_NUC_103.L_CORE 0.004111
K_5866 X_NUC_52.L_CORE X_NUC_104.L_CORE 0.004080
K_5867 X_NUC_52.L_CORE X_NUC_105.L_CORE 0.002361
K_5868 X_NUC_52.L_CORE X_NUC_106.L_CORE 0.002373
K_5869 X_NUC_52.L_CORE X_NUC_107.L_CORE 0.002365
K_5870 X_NUC_52.L_CORE X_NUC_108.L_CORE 0.002347
K_5871 X_NUC_52.L_CORE X_NUC_109.L_CORE 0.002616
K_5872 X_NUC_52.L_CORE X_NUC_110.L_CORE 0.002613
K_5873 X_NUC_52.L_CORE X_NUC_111.L_CORE 0.002611
K_5874 X_NUC_52.L_CORE X_NUC_112.L_CORE 0.002587
K_5875 X_NUC_52.L_CORE X_NUC_113.L_CORE 0.002933
K_5876 X_NUC_52.L_CORE X_NUC_114.L_CORE 0.002945
K_5877 X_NUC_52.L_CORE X_NUC_115.L_CORE 0.002926
K_5878 X_NUC_52.L_CORE X_NUC_116.L_CORE 0.002905
K_5879 X_NUC_52.L_CORE X_NUC_117.L_CORE 0.002513
K_5880 X_NUC_52.L_CORE X_NUC_118.L_CORE 0.003086
K_5881 X_NUC_52.L_CORE X_NUC_119.L_CORE 0.003314
K_5882 X_NUC_52.L_CORE X_NUC_120.L_CORE 0.002135
K_5883 X_NUC_52.L_CORE X_NUC_121.L_CORE 0.006001
K_5884 X_NUC_52.L_CORE X_NUC_122.L_CORE 0.002320
K_5885 X_NUC_52.L_CORE X_NUC_123.L_CORE 0.002462
K_5886 X_NUC_52.L_CORE X_NUC_124.L_CORE 0.006217
K_5887 X_NUC_52.L_CORE X_NUC_125.L_CORE 0.001933
K_5888 X_NUC_52.L_CORE X_NUC_126.L_CORE 0.004279
K_5889 X_NUC_52.L_CORE X_NUC_127.L_CORE 0.002799
K_5890 X_NUC_52.L_CORE X_NUC_128.L_CORE 0.002027
K_5891 X_NUC_52.L_CORE X_NUC_129.L_CORE 0.017582
K_5892 X_NUC_52.L_CORE X_NUC_130.L_CORE 0.002015
K_5893 X_NUC_52.L_CORE X_NUC_131.L_CORE 0.002739
K_5894 X_NUC_52.L_CORE X_NUC_132.L_CORE 0.003884
K_5895 X_NUC_52.L_CORE X_NUC_133.L_CORE 0.001904
K_5896 X_NUC_52.L_CORE X_NUC_134.L_CORE 0.004685
K_5897 X_NUC_52.L_CORE X_NUC_135.L_CORE 0.002341
K_5898 X_NUC_52.L_CORE X_NUC_136.L_CORE 0.002218
K_5899 X_NUC_52.L_CORE X_NUC_137.L_CORE 0.003998
K_5900 X_NUC_52.L_CORE X_NUC_138.L_CORE 0.002062
K_5901 X_NUC_52.L_CORE X_NUC_139.L_CORE 0.002782
K_5902 X_NUC_52.L_CORE X_NUC_140.L_CORE 0.002602
K_5903 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_5904 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_5905 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_5906 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.002133
K_5907 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.002112
K_5908 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.002120
K_5909 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.002124
K_5910 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.002934
K_5911 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.002926
K_5912 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.002907
K_5913 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.002947
K_5914 X_NUC_53.L_CORE X_NUC_65.L_CORE 0.004398
K_5915 X_NUC_53.L_CORE X_NUC_66.L_CORE 0.004321
K_5916 X_NUC_53.L_CORE X_NUC_67.L_CORE 0.004367
K_5917 X_NUC_53.L_CORE X_NUC_68.L_CORE 0.004322
K_5918 X_NUC_53.L_CORE X_NUC_69.L_CORE 0.002000
K_5919 X_NUC_53.L_CORE X_NUC_70.L_CORE 0.001985
K_5920 X_NUC_53.L_CORE X_NUC_71.L_CORE 0.001984
K_5921 X_NUC_53.L_CORE X_NUC_72.L_CORE 0.001996
K_5922 X_NUC_53.L_CORE X_NUC_73.L_CORE 0.006134
K_5923 X_NUC_53.L_CORE X_NUC_74.L_CORE 0.006165
K_5924 X_NUC_53.L_CORE X_NUC_75.L_CORE 0.006009
K_5925 X_NUC_53.L_CORE X_NUC_76.L_CORE 0.006155
K_5926 X_NUC_53.L_CORE X_NUC_77.L_CORE 0.002497
K_5927 X_NUC_53.L_CORE X_NUC_78.L_CORE 0.002468
K_5928 X_NUC_53.L_CORE X_NUC_79.L_CORE 0.002478
K_5929 X_NUC_53.L_CORE X_NUC_80.L_CORE 0.002476
K_5930 X_NUC_53.L_CORE X_NUC_81.L_CORE 0.002336
K_5931 X_NUC_53.L_CORE X_NUC_82.L_CORE 0.002324
K_5932 X_NUC_53.L_CORE X_NUC_83.L_CORE 0.002314
K_5933 X_NUC_53.L_CORE X_NUC_84.L_CORE 0.002336
K_5934 X_NUC_53.L_CORE X_NUC_85.L_CORE 0.006095
K_5935 X_NUC_53.L_CORE X_NUC_86.L_CORE 0.006009
K_5936 X_NUC_53.L_CORE X_NUC_87.L_CORE 0.005969
K_5937 X_NUC_53.L_CORE X_NUC_88.L_CORE 0.005928
K_5938 X_NUC_53.L_CORE X_NUC_89.L_CORE 0.002091
K_5939 X_NUC_53.L_CORE X_NUC_90.L_CORE 0.002072
K_5940 X_NUC_53.L_CORE X_NUC_91.L_CORE 0.002073
K_5941 X_NUC_53.L_CORE X_NUC_92.L_CORE 0.002080
K_5942 X_NUC_53.L_CORE X_NUC_93.L_CORE 0.003332
K_5943 X_NUC_53.L_CORE X_NUC_94.L_CORE 0.003324
K_5944 X_NUC_53.L_CORE X_NUC_95.L_CORE 0.003286
K_5945 X_NUC_53.L_CORE X_NUC_96.L_CORE 0.003328
K_5946 X_NUC_53.L_CORE X_NUC_97.L_CORE 0.003082
K_5947 X_NUC_53.L_CORE X_NUC_98.L_CORE 0.003046
K_5948 X_NUC_53.L_CORE X_NUC_99.L_CORE 0.003048
K_5949 X_NUC_53.L_CORE X_NUC_100.L_CORE 0.003043
K_5950 X_NUC_53.L_CORE X_NUC_101.L_CORE 0.002212
K_5951 X_NUC_53.L_CORE X_NUC_102.L_CORE 0.002197
K_5952 X_NUC_53.L_CORE X_NUC_103.L_CORE 0.002190
K_5953 X_NUC_53.L_CORE X_NUC_104.L_CORE 0.002204
K_5954 X_NUC_53.L_CORE X_NUC_105.L_CORE 0.003935
K_5955 X_NUC_53.L_CORE X_NUC_106.L_CORE 0.003911
K_5956 X_NUC_53.L_CORE X_NUC_107.L_CORE 0.003865
K_5957 X_NUC_53.L_CORE X_NUC_108.L_CORE 0.003889
K_5958 X_NUC_53.L_CORE X_NUC_109.L_CORE 0.002450
K_5959 X_NUC_53.L_CORE X_NUC_110.L_CORE 0.002428
K_5960 X_NUC_53.L_CORE X_NUC_111.L_CORE 0.002424
K_5961 X_NUC_53.L_CORE X_NUC_112.L_CORE 0.002430
K_5962 X_NUC_53.L_CORE X_NUC_113.L_CORE 0.002680
K_5963 X_NUC_53.L_CORE X_NUC_114.L_CORE 0.002663
K_5964 X_NUC_53.L_CORE X_NUC_115.L_CORE 0.002646
K_5965 X_NUC_53.L_CORE X_NUC_116.L_CORE 0.002663
K_5966 X_NUC_53.L_CORE X_NUC_117.L_CORE 0.003263
K_5967 X_NUC_53.L_CORE X_NUC_118.L_CORE 0.002267
K_5968 X_NUC_53.L_CORE X_NUC_119.L_CORE 0.003029
K_5969 X_NUC_53.L_CORE X_NUC_120.L_CORE 0.003259
K_5970 X_NUC_53.L_CORE X_NUC_121.L_CORE 0.002041
K_5971 X_NUC_53.L_CORE X_NUC_122.L_CORE 0.006296
K_5972 X_NUC_53.L_CORE X_NUC_123.L_CORE 0.002246
K_5973 X_NUC_53.L_CORE X_NUC_124.L_CORE 0.002399
K_5974 X_NUC_53.L_CORE X_NUC_125.L_CORE 0.006201
K_5975 X_NUC_53.L_CORE X_NUC_126.L_CORE 0.001892
K_5976 X_NUC_53.L_CORE X_NUC_127.L_CORE 0.004230
K_5977 X_NUC_53.L_CORE X_NUC_128.L_CORE 0.002754
K_5978 X_NUC_53.L_CORE X_NUC_129.L_CORE 0.002003
K_5979 X_NUC_53.L_CORE X_NUC_130.L_CORE 0.016485
K_5980 X_NUC_53.L_CORE X_NUC_131.L_CORE 0.002001
K_5981 X_NUC_53.L_CORE X_NUC_132.L_CORE 0.002726
K_5982 X_NUC_53.L_CORE X_NUC_133.L_CORE 0.003834
K_5983 X_NUC_53.L_CORE X_NUC_134.L_CORE 0.001911
K_5984 X_NUC_53.L_CORE X_NUC_135.L_CORE 0.004553
K_5985 X_NUC_53.L_CORE X_NUC_136.L_CORE 0.002355
K_5986 X_NUC_53.L_CORE X_NUC_137.L_CORE 0.002249
K_5987 X_NUC_53.L_CORE X_NUC_138.L_CORE 0.003760
K_5988 X_NUC_53.L_CORE X_NUC_139.L_CORE 0.002144
K_5989 X_NUC_53.L_CORE X_NUC_140.L_CORE 0.002703
K_5990 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_5991 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_5992 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.002155
K_5993 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.002133
K_5994 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.002141
K_5995 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.002146
K_5996 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.002940
K_5997 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.002934
K_5998 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.002914
K_5999 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.002954
K_6000 X_NUC_54.L_CORE X_NUC_65.L_CORE 0.004477
K_6001 X_NUC_54.L_CORE X_NUC_66.L_CORE 0.004398
K_6002 X_NUC_54.L_CORE X_NUC_67.L_CORE 0.004445
K_6003 X_NUC_54.L_CORE X_NUC_68.L_CORE 0.004398
K_6004 X_NUC_54.L_CORE X_NUC_69.L_CORE 0.002015
K_6005 X_NUC_54.L_CORE X_NUC_70.L_CORE 0.002000
K_6006 X_NUC_54.L_CORE X_NUC_71.L_CORE 0.001999
K_6007 X_NUC_54.L_CORE X_NUC_72.L_CORE 0.002011
K_6008 X_NUC_54.L_CORE X_NUC_73.L_CORE 0.006098
K_6009 X_NUC_54.L_CORE X_NUC_74.L_CORE 0.006134
K_6010 X_NUC_54.L_CORE X_NUC_75.L_CORE 0.005978
K_6011 X_NUC_54.L_CORE X_NUC_76.L_CORE 0.006121
K_6012 X_NUC_54.L_CORE X_NUC_77.L_CORE 0.002526
K_6013 X_NUC_54.L_CORE X_NUC_78.L_CORE 0.002497
K_6014 X_NUC_54.L_CORE X_NUC_79.L_CORE 0.002507
K_6015 X_NUC_54.L_CORE X_NUC_80.L_CORE 0.002505
K_6016 X_NUC_54.L_CORE X_NUC_81.L_CORE 0.002348
K_6017 X_NUC_54.L_CORE X_NUC_82.L_CORE 0.002336
K_6018 X_NUC_54.L_CORE X_NUC_83.L_CORE 0.002326
K_6019 X_NUC_54.L_CORE X_NUC_84.L_CORE 0.002348
K_6020 X_NUC_54.L_CORE X_NUC_85.L_CORE 0.006179
K_6021 X_NUC_54.L_CORE X_NUC_86.L_CORE 0.006095
K_6022 X_NUC_54.L_CORE X_NUC_87.L_CORE 0.006050
K_6023 X_NUC_54.L_CORE X_NUC_88.L_CORE 0.006008
K_6024 X_NUC_54.L_CORE X_NUC_89.L_CORE 0.002109
K_6025 X_NUC_54.L_CORE X_NUC_90.L_CORE 0.002091
K_6026 X_NUC_54.L_CORE X_NUC_91.L_CORE 0.002091
K_6027 X_NUC_54.L_CORE X_NUC_92.L_CORE 0.002099
K_6028 X_NUC_54.L_CORE X_NUC_93.L_CORE 0.003340
K_6029 X_NUC_54.L_CORE X_NUC_94.L_CORE 0.003332
K_6030 X_NUC_54.L_CORE X_NUC_95.L_CORE 0.003293
K_6031 X_NUC_54.L_CORE X_NUC_96.L_CORE 0.003336
K_6032 X_NUC_54.L_CORE X_NUC_97.L_CORE 0.003119
K_6033 X_NUC_54.L_CORE X_NUC_98.L_CORE 0.003082
K_6034 X_NUC_54.L_CORE X_NUC_99.L_CORE 0.003084
K_6035 X_NUC_54.L_CORE X_NUC_100.L_CORE 0.003078
K_6036 X_NUC_54.L_CORE X_NUC_101.L_CORE 0.002227
K_6037 X_NUC_54.L_CORE X_NUC_102.L_CORE 0.002212
K_6038 X_NUC_54.L_CORE X_NUC_103.L_CORE 0.002204
K_6039 X_NUC_54.L_CORE X_NUC_104.L_CORE 0.002219
K_6040 X_NUC_54.L_CORE X_NUC_105.L_CORE 0.003957
K_6041 X_NUC_54.L_CORE X_NUC_106.L_CORE 0.003935
K_6042 X_NUC_54.L_CORE X_NUC_107.L_CORE 0.003887
K_6043 X_NUC_54.L_CORE X_NUC_108.L_CORE 0.003912
K_6044 X_NUC_54.L_CORE X_NUC_109.L_CORE 0.002472
K_6045 X_NUC_54.L_CORE X_NUC_110.L_CORE 0.002450
K_6046 X_NUC_54.L_CORE X_NUC_111.L_CORE 0.002445
K_6047 X_NUC_54.L_CORE X_NUC_112.L_CORE 0.002452
K_6048 X_NUC_54.L_CORE X_NUC_113.L_CORE 0.002697
K_6049 X_NUC_54.L_CORE X_NUC_114.L_CORE 0.002680
K_6050 X_NUC_54.L_CORE X_NUC_115.L_CORE 0.002662
K_6051 X_NUC_54.L_CORE X_NUC_116.L_CORE 0.002680
K_6052 X_NUC_54.L_CORE X_NUC_117.L_CORE 0.003289
K_6053 X_NUC_54.L_CORE X_NUC_118.L_CORE 0.002287
K_6054 X_NUC_54.L_CORE X_NUC_119.L_CORE 0.003040
K_6055 X_NUC_54.L_CORE X_NUC_120.L_CORE 0.003299
K_6056 X_NUC_54.L_CORE X_NUC_121.L_CORE 0.002055
K_6057 X_NUC_54.L_CORE X_NUC_122.L_CORE 0.006272
K_6058 X_NUC_54.L_CORE X_NUC_123.L_CORE 0.002270
K_6059 X_NUC_54.L_CORE X_NUC_124.L_CORE 0.002408
K_6060 X_NUC_54.L_CORE X_NUC_125.L_CORE 0.006316
K_6061 X_NUC_54.L_CORE X_NUC_126.L_CORE 0.001907
K_6062 X_NUC_54.L_CORE X_NUC_127.L_CORE 0.004211
K_6063 X_NUC_54.L_CORE X_NUC_128.L_CORE 0.002789
K_6064 X_NUC_54.L_CORE X_NUC_129.L_CORE 0.002014
K_6065 X_NUC_54.L_CORE X_NUC_130.L_CORE 0.015983
K_6066 X_NUC_54.L_CORE X_NUC_131.L_CORE 0.002020
K_6067 X_NUC_54.L_CORE X_NUC_132.L_CORE 0.002731
K_6068 X_NUC_54.L_CORE X_NUC_133.L_CORE 0.003886
K_6069 X_NUC_54.L_CORE X_NUC_134.L_CORE 0.001924
K_6070 X_NUC_54.L_CORE X_NUC_135.L_CORE 0.004542
K_6071 X_NUC_54.L_CORE X_NUC_136.L_CORE 0.002379
K_6072 X_NUC_54.L_CORE X_NUC_137.L_CORE 0.002260
K_6073 X_NUC_54.L_CORE X_NUC_138.L_CORE 0.003788
K_6074 X_NUC_54.L_CORE X_NUC_139.L_CORE 0.002161
K_6075 X_NUC_54.L_CORE X_NUC_140.L_CORE 0.002717
K_6076 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_6077 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.002147
K_6078 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.002125
K_6079 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.002133
K_6080 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.002137
K_6081 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.002961
K_6082 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.002953
K_6083 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.002934
K_6084 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.002975
K_6085 X_NUC_55.L_CORE X_NUC_65.L_CORE 0.004428
K_6086 X_NUC_55.L_CORE X_NUC_66.L_CORE 0.004351
K_6087 X_NUC_55.L_CORE X_NUC_67.L_CORE 0.004398
K_6088 X_NUC_55.L_CORE X_NUC_68.L_CORE 0.004352
K_6089 X_NUC_55.L_CORE X_NUC_69.L_CORE 0.002015
K_6090 X_NUC_55.L_CORE X_NUC_70.L_CORE 0.002000
K_6091 X_NUC_55.L_CORE X_NUC_71.L_CORE 0.002000
K_6092 X_NUC_55.L_CORE X_NUC_72.L_CORE 0.002011
K_6093 X_NUC_55.L_CORE X_NUC_73.L_CORE 0.006261
K_6094 X_NUC_55.L_CORE X_NUC_74.L_CORE 0.006297
K_6095 X_NUC_55.L_CORE X_NUC_75.L_CORE 0.006134
K_6096 X_NUC_55.L_CORE X_NUC_76.L_CORE 0.006286
K_6097 X_NUC_55.L_CORE X_NUC_77.L_CORE 0.002516
K_6098 X_NUC_55.L_CORE X_NUC_78.L_CORE 0.002487
K_6099 X_NUC_55.L_CORE X_NUC_79.L_CORE 0.002497
K_6100 X_NUC_55.L_CORE X_NUC_80.L_CORE 0.002495
K_6101 X_NUC_55.L_CORE X_NUC_81.L_CORE 0.002359
K_6102 X_NUC_55.L_CORE X_NUC_82.L_CORE 0.002347
K_6103 X_NUC_55.L_CORE X_NUC_83.L_CORE 0.002336
K_6104 X_NUC_55.L_CORE X_NUC_84.L_CORE 0.002359
K_6105 X_NUC_55.L_CORE X_NUC_85.L_CORE 0.006224
K_6106 X_NUC_55.L_CORE X_NUC_86.L_CORE 0.006135
K_6107 X_NUC_55.L_CORE X_NUC_87.L_CORE 0.006095
K_6108 X_NUC_55.L_CORE X_NUC_88.L_CORE 0.006049
K_6109 X_NUC_55.L_CORE X_NUC_89.L_CORE 0.002109
K_6110 X_NUC_55.L_CORE X_NUC_90.L_CORE 0.002090
K_6111 X_NUC_55.L_CORE X_NUC_91.L_CORE 0.002091
K_6112 X_NUC_55.L_CORE X_NUC_92.L_CORE 0.002098
K_6113 X_NUC_55.L_CORE X_NUC_93.L_CORE 0.003380
K_6114 X_NUC_55.L_CORE X_NUC_94.L_CORE 0.003372
K_6115 X_NUC_55.L_CORE X_NUC_95.L_CORE 0.003332
K_6116 X_NUC_55.L_CORE X_NUC_96.L_CORE 0.003376
K_6117 X_NUC_55.L_CORE X_NUC_97.L_CORE 0.003117
K_6118 X_NUC_55.L_CORE X_NUC_98.L_CORE 0.003080
K_6119 X_NUC_55.L_CORE X_NUC_99.L_CORE 0.003082
K_6120 X_NUC_55.L_CORE X_NUC_100.L_CORE 0.003076
K_6121 X_NUC_55.L_CORE X_NUC_101.L_CORE 0.002234
K_6122 X_NUC_55.L_CORE X_NUC_102.L_CORE 0.002219
K_6123 X_NUC_55.L_CORE X_NUC_103.L_CORE 0.002212
K_6124 X_NUC_55.L_CORE X_NUC_104.L_CORE 0.002226
K_6125 X_NUC_55.L_CORE X_NUC_105.L_CORE 0.004007
K_6126 X_NUC_55.L_CORE X_NUC_106.L_CORE 0.003983
K_6127 X_NUC_55.L_CORE X_NUC_107.L_CORE 0.003935
K_6128 X_NUC_55.L_CORE X_NUC_108.L_CORE 0.003960
K_6129 X_NUC_55.L_CORE X_NUC_109.L_CORE 0.002477
K_6130 X_NUC_55.L_CORE X_NUC_110.L_CORE 0.002454
K_6131 X_NUC_55.L_CORE X_NUC_111.L_CORE 0.002450
K_6132 X_NUC_55.L_CORE X_NUC_112.L_CORE 0.002456
K_6133 X_NUC_55.L_CORE X_NUC_113.L_CORE 0.002715
K_6134 X_NUC_55.L_CORE X_NUC_114.L_CORE 0.002697
K_6135 X_NUC_55.L_CORE X_NUC_115.L_CORE 0.002680
K_6136 X_NUC_55.L_CORE X_NUC_116.L_CORE 0.002698
K_6137 X_NUC_55.L_CORE X_NUC_117.L_CORE 0.003253
K_6138 X_NUC_55.L_CORE X_NUC_118.L_CORE 0.002271
K_6139 X_NUC_55.L_CORE X_NUC_119.L_CORE 0.003032
K_6140 X_NUC_55.L_CORE X_NUC_120.L_CORE 0.003252
K_6141 X_NUC_55.L_CORE X_NUC_121.L_CORE 0.002049
K_6142 X_NUC_55.L_CORE X_NUC_122.L_CORE 0.006220
K_6143 X_NUC_55.L_CORE X_NUC_123.L_CORE 0.002254
K_6144 X_NUC_55.L_CORE X_NUC_124.L_CORE 0.002412
K_6145 X_NUC_55.L_CORE X_NUC_125.L_CORE 0.006142
K_6146 X_NUC_55.L_CORE X_NUC_126.L_CORE 0.001902
K_6147 X_NUC_55.L_CORE X_NUC_127.L_CORE 0.004258
K_6148 X_NUC_55.L_CORE X_NUC_128.L_CORE 0.002766
K_6149 X_NUC_55.L_CORE X_NUC_129.L_CORE 0.002018
K_6150 X_NUC_55.L_CORE X_NUC_130.L_CORE 0.016868
K_6151 X_NUC_55.L_CORE X_NUC_131.L_CORE 0.002014
K_6152 X_NUC_55.L_CORE X_NUC_132.L_CORE 0.002753
K_6153 X_NUC_55.L_CORE X_NUC_133.L_CORE 0.003866
K_6154 X_NUC_55.L_CORE X_NUC_134.L_CORE 0.001926
K_6155 X_NUC_55.L_CORE X_NUC_135.L_CORE 0.004635
K_6156 X_NUC_55.L_CORE X_NUC_136.L_CORE 0.002376
K_6157 X_NUC_55.L_CORE X_NUC_137.L_CORE 0.002273
K_6158 X_NUC_55.L_CORE X_NUC_138.L_CORE 0.003818
K_6159 X_NUC_55.L_CORE X_NUC_139.L_CORE 0.002166
K_6160 X_NUC_55.L_CORE X_NUC_140.L_CORE 0.002738
K_6161 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.002142
K_6162 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.002121
K_6163 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.002129
K_6164 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.002133
K_6165 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.002920
K_6166 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.002913
K_6167 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.002894
K_6168 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.002934
K_6169 X_NUC_56.L_CORE X_NUC_65.L_CORE 0.004476
K_6170 X_NUC_56.L_CORE X_NUC_66.L_CORE 0.004396
K_6171 X_NUC_56.L_CORE X_NUC_67.L_CORE 0.004444
K_6172 X_NUC_56.L_CORE X_NUC_68.L_CORE 0.004398
K_6173 X_NUC_56.L_CORE X_NUC_69.L_CORE 0.002003
K_6174 X_NUC_56.L_CORE X_NUC_70.L_CORE 0.001988
K_6175 X_NUC_56.L_CORE X_NUC_71.L_CORE 0.001988
K_6176 X_NUC_56.L_CORE X_NUC_72.L_CORE 0.002000
K_6177 X_NUC_56.L_CORE X_NUC_73.L_CORE 0.006108
K_6178 X_NUC_56.L_CORE X_NUC_74.L_CORE 0.006141
K_6179 X_NUC_56.L_CORE X_NUC_75.L_CORE 0.005987
K_6180 X_NUC_56.L_CORE X_NUC_76.L_CORE 0.006134
K_6181 X_NUC_56.L_CORE X_NUC_77.L_CORE 0.002518
K_6182 X_NUC_56.L_CORE X_NUC_78.L_CORE 0.002489
K_6183 X_NUC_56.L_CORE X_NUC_79.L_CORE 0.002499
K_6184 X_NUC_56.L_CORE X_NUC_80.L_CORE 0.002497
K_6185 X_NUC_56.L_CORE X_NUC_81.L_CORE 0.002336
K_6186 X_NUC_56.L_CORE X_NUC_82.L_CORE 0.002324
K_6187 X_NUC_56.L_CORE X_NUC_83.L_CORE 0.002314
K_6188 X_NUC_56.L_CORE X_NUC_84.L_CORE 0.002336
K_6189 X_NUC_56.L_CORE X_NUC_85.L_CORE 0.006270
K_6190 X_NUC_56.L_CORE X_NUC_86.L_CORE 0.006180
K_6191 X_NUC_56.L_CORE X_NUC_87.L_CORE 0.006136
K_6192 X_NUC_56.L_CORE X_NUC_88.L_CORE 0.006095
K_6193 X_NUC_56.L_CORE X_NUC_89.L_CORE 0.002101
K_6194 X_NUC_56.L_CORE X_NUC_90.L_CORE 0.002082
K_6195 X_NUC_56.L_CORE X_NUC_91.L_CORE 0.002083
K_6196 X_NUC_56.L_CORE X_NUC_92.L_CORE 0.002091
K_6197 X_NUC_56.L_CORE X_NUC_93.L_CORE 0.003336
K_6198 X_NUC_56.L_CORE X_NUC_94.L_CORE 0.003328
K_6199 X_NUC_56.L_CORE X_NUC_95.L_CORE 0.003290
K_6200 X_NUC_56.L_CORE X_NUC_96.L_CORE 0.003332
K_6201 X_NUC_56.L_CORE X_NUC_97.L_CORE 0.003123
K_6202 X_NUC_56.L_CORE X_NUC_98.L_CORE 0.003086
K_6203 X_NUC_56.L_CORE X_NUC_99.L_CORE 0.003088
K_6204 X_NUC_56.L_CORE X_NUC_100.L_CORE 0.003082
K_6205 X_NUC_56.L_CORE X_NUC_101.L_CORE 0.002219
K_6206 X_NUC_56.L_CORE X_NUC_102.L_CORE 0.002205
K_6207 X_NUC_56.L_CORE X_NUC_103.L_CORE 0.002197
K_6208 X_NUC_56.L_CORE X_NUC_104.L_CORE 0.002212
K_6209 X_NUC_56.L_CORE X_NUC_105.L_CORE 0.003981
K_6210 X_NUC_56.L_CORE X_NUC_106.L_CORE 0.003957
K_6211 X_NUC_56.L_CORE X_NUC_107.L_CORE 0.003909
K_6212 X_NUC_56.L_CORE X_NUC_108.L_CORE 0.003935
K_6213 X_NUC_56.L_CORE X_NUC_109.L_CORE 0.002470
K_6214 X_NUC_56.L_CORE X_NUC_110.L_CORE 0.002447
K_6215 X_NUC_56.L_CORE X_NUC_111.L_CORE 0.002443
K_6216 X_NUC_56.L_CORE X_NUC_112.L_CORE 0.002450
K_6217 X_NUC_56.L_CORE X_NUC_113.L_CORE 0.002696
K_6218 X_NUC_56.L_CORE X_NUC_114.L_CORE 0.002679
K_6219 X_NUC_56.L_CORE X_NUC_115.L_CORE 0.002662
K_6220 X_NUC_56.L_CORE X_NUC_116.L_CORE 0.002680
K_6221 X_NUC_56.L_CORE X_NUC_117.L_CORE 0.003240
K_6222 X_NUC_56.L_CORE X_NUC_118.L_CORE 0.002264
K_6223 X_NUC_56.L_CORE X_NUC_119.L_CORE 0.002999
K_6224 X_NUC_56.L_CORE X_NUC_120.L_CORE 0.003263
K_6225 X_NUC_56.L_CORE X_NUC_121.L_CORE 0.002037
K_6226 X_NUC_56.L_CORE X_NUC_122.L_CORE 0.006126
K_6227 X_NUC_56.L_CORE X_NUC_123.L_CORE 0.002253
K_6228 X_NUC_56.L_CORE X_NUC_124.L_CORE 0.002387
K_6229 X_NUC_56.L_CORE X_NUC_125.L_CORE 0.006268
K_6230 X_NUC_56.L_CORE X_NUC_126.L_CORE 0.001894
K_6231 X_NUC_56.L_CORE X_NUC_127.L_CORE 0.004175
K_6232 X_NUC_56.L_CORE X_NUC_128.L_CORE 0.002778
K_6233 X_NUC_56.L_CORE X_NUC_129.L_CORE 0.002002
K_6234 X_NUC_56.L_CORE X_NUC_130.L_CORE 0.017240
K_6235 X_NUC_56.L_CORE X_NUC_131.L_CORE 0.002011
K_6236 X_NUC_56.L_CORE X_NUC_132.L_CORE 0.002719
K_6237 X_NUC_56.L_CORE X_NUC_133.L_CORE 0.003902
K_6238 X_NUC_56.L_CORE X_NUC_134.L_CORE 0.001916
K_6239 X_NUC_56.L_CORE X_NUC_135.L_CORE 0.004572
K_6240 X_NUC_56.L_CORE X_NUC_136.L_CORE 0.002377
K_6241 X_NUC_56.L_CORE X_NUC_137.L_CORE 0.002254
K_6242 X_NUC_56.L_CORE X_NUC_138.L_CORE 0.003819
K_6243 X_NUC_56.L_CORE X_NUC_139.L_CORE 0.002158
K_6244 X_NUC_56.L_CORE X_NUC_140.L_CORE 0.002721
K_6245 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.207973
K_6246 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.207973
K_6247 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.207973
K_6248 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.002133
K_6249 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.002152
K_6250 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.002136
K_6251 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.002148
K_6252 X_NUC_57.L_CORE X_NUC_65.L_CORE 0.002941
K_6253 X_NUC_57.L_CORE X_NUC_66.L_CORE 0.002974
K_6254 X_NUC_57.L_CORE X_NUC_67.L_CORE 0.002967
K_6255 X_NUC_57.L_CORE X_NUC_68.L_CORE 0.002941
K_6256 X_NUC_57.L_CORE X_NUC_69.L_CORE 0.004418
K_6257 X_NUC_57.L_CORE X_NUC_70.L_CORE 0.004445
K_6258 X_NUC_57.L_CORE X_NUC_71.L_CORE 0.004372
K_6259 X_NUC_57.L_CORE X_NUC_72.L_CORE 0.004459
K_6260 X_NUC_57.L_CORE X_NUC_73.L_CORE 0.002014
K_6261 X_NUC_57.L_CORE X_NUC_74.L_CORE 0.002034
K_6262 X_NUC_57.L_CORE X_NUC_75.L_CORE 0.002021
K_6263 X_NUC_57.L_CORE X_NUC_76.L_CORE 0.002023
K_6264 X_NUC_57.L_CORE X_NUC_77.L_CORE 0.006162
K_6265 X_NUC_57.L_CORE X_NUC_78.L_CORE 0.006244
K_6266 X_NUC_57.L_CORE X_NUC_79.L_CORE 0.006197
K_6267 X_NUC_57.L_CORE X_NUC_80.L_CORE 0.006069
K_6268 X_NUC_57.L_CORE X_NUC_81.L_CORE 0.002528
K_6269 X_NUC_57.L_CORE X_NUC_82.L_CORE 0.002548
K_6270 X_NUC_57.L_CORE X_NUC_83.L_CORE 0.002522
K_6271 X_NUC_57.L_CORE X_NUC_84.L_CORE 0.002543
K_6272 X_NUC_57.L_CORE X_NUC_85.L_CORE 0.002372
K_6273 X_NUC_57.L_CORE X_NUC_86.L_CORE 0.002397
K_6274 X_NUC_57.L_CORE X_NUC_87.L_CORE 0.002383
K_6275 X_NUC_57.L_CORE X_NUC_88.L_CORE 0.002375
K_6276 X_NUC_57.L_CORE X_NUC_89.L_CORE 0.006039
K_6277 X_NUC_57.L_CORE X_NUC_90.L_CORE 0.006081
K_6278 X_NUC_57.L_CORE X_NUC_91.L_CORE 0.005916
K_6279 X_NUC_57.L_CORE X_NUC_92.L_CORE 0.005997
K_6280 X_NUC_57.L_CORE X_NUC_93.L_CORE 0.002140
K_6281 X_NUC_57.L_CORE X_NUC_94.L_CORE 0.002160
K_6282 X_NUC_57.L_CORE X_NUC_95.L_CORE 0.002141
K_6283 X_NUC_57.L_CORE X_NUC_96.L_CORE 0.002148
K_6284 X_NUC_57.L_CORE X_NUC_97.L_CORE 0.003376
K_6285 X_NUC_57.L_CORE X_NUC_98.L_CORE 0.003413
K_6286 X_NUC_57.L_CORE X_NUC_99.L_CORE 0.003384
K_6287 X_NUC_57.L_CORE X_NUC_100.L_CORE 0.003359
K_6288 X_NUC_57.L_CORE X_NUC_101.L_CORE 0.003132
K_6289 X_NUC_57.L_CORE X_NUC_102.L_CORE 0.003158
K_6290 X_NUC_57.L_CORE X_NUC_103.L_CORE 0.003111
K_6291 X_NUC_57.L_CORE X_NUC_104.L_CORE 0.003139
K_6292 X_NUC_57.L_CORE X_NUC_105.L_CORE 0.002306
K_6293 X_NUC_57.L_CORE X_NUC_106.L_CORE 0.002328
K_6294 X_NUC_57.L_CORE X_NUC_107.L_CORE 0.002308
K_6295 X_NUC_57.L_CORE X_NUC_108.L_CORE 0.002308
K_6296 X_NUC_57.L_CORE X_NUC_109.L_CORE 0.003731
K_6297 X_NUC_57.L_CORE X_NUC_110.L_CORE 0.003767
K_6298 X_NUC_57.L_CORE X_NUC_111.L_CORE 0.003709
K_6299 X_NUC_57.L_CORE X_NUC_112.L_CORE 0.003709
K_6300 X_NUC_57.L_CORE X_NUC_113.L_CORE 0.002621
K_6301 X_NUC_57.L_CORE X_NUC_114.L_CORE 0.002645
K_6302 X_NUC_57.L_CORE X_NUC_115.L_CORE 0.002614
K_6303 X_NUC_57.L_CORE X_NUC_116.L_CORE 0.002622
K_6304 X_NUC_57.L_CORE X_NUC_117.L_CORE 0.002470
K_6305 X_NUC_57.L_CORE X_NUC_118.L_CORE 0.003665
K_6306 X_NUC_57.L_CORE X_NUC_119.L_CORE 0.002155
K_6307 X_NUC_57.L_CORE X_NUC_120.L_CORE 0.002999
K_6308 X_NUC_57.L_CORE X_NUC_121.L_CORE 0.003248
K_6309 X_NUC_57.L_CORE X_NUC_122.L_CORE 0.001998
K_6310 X_NUC_57.L_CORE X_NUC_123.L_CORE 0.006481
K_6311 X_NUC_57.L_CORE X_NUC_124.L_CORE 0.002227
K_6312 X_NUC_57.L_CORE X_NUC_125.L_CORE 0.002382
K_6313 X_NUC_57.L_CORE X_NUC_126.L_CORE 0.006251
K_6314 X_NUC_57.L_CORE X_NUC_127.L_CORE 0.001893
K_6315 X_NUC_57.L_CORE X_NUC_128.L_CORE 0.004225
K_6316 X_NUC_57.L_CORE X_NUC_129.L_CORE 0.002776
K_6317 X_NUC_57.L_CORE X_NUC_130.L_CORE 0.002022
K_6318 X_NUC_57.L_CORE X_NUC_131.L_CORE 0.015116
K_6319 X_NUC_57.L_CORE X_NUC_132.L_CORE 0.002035
K_6320 X_NUC_57.L_CORE X_NUC_133.L_CORE 0.002768
K_6321 X_NUC_57.L_CORE X_NUC_134.L_CORE 0.003884
K_6322 X_NUC_57.L_CORE X_NUC_135.L_CORE 0.001966
K_6323 X_NUC_57.L_CORE X_NUC_136.L_CORE 0.004490
K_6324 X_NUC_57.L_CORE X_NUC_137.L_CORE 0.002437
K_6325 X_NUC_57.L_CORE X_NUC_138.L_CORE 0.002344
K_6326 X_NUC_57.L_CORE X_NUC_139.L_CORE 0.003565
K_6327 X_NUC_57.L_CORE X_NUC_140.L_CORE 0.002358
K_6328 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.207973
K_6329 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.207973
K_6330 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.002115
K_6331 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.002133
K_6332 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.002118
K_6333 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.002129
K_6334 X_NUC_58.L_CORE X_NUC_65.L_CORE 0.002908
K_6335 X_NUC_58.L_CORE X_NUC_66.L_CORE 0.002941
K_6336 X_NUC_58.L_CORE X_NUC_67.L_CORE 0.002933
K_6337 X_NUC_58.L_CORE X_NUC_68.L_CORE 0.002909
K_6338 X_NUC_58.L_CORE X_NUC_69.L_CORE 0.004389
K_6339 X_NUC_58.L_CORE X_NUC_70.L_CORE 0.004418
K_6340 X_NUC_58.L_CORE X_NUC_71.L_CORE 0.004346
K_6341 X_NUC_58.L_CORE X_NUC_72.L_CORE 0.004431
K_6342 X_NUC_58.L_CORE X_NUC_73.L_CORE 0.001995
K_6343 X_NUC_58.L_CORE X_NUC_74.L_CORE 0.002014
K_6344 X_NUC_58.L_CORE X_NUC_75.L_CORE 0.002002
K_6345 X_NUC_58.L_CORE X_NUC_76.L_CORE 0.002004
K_6346 X_NUC_58.L_CORE X_NUC_77.L_CORE 0.006079
K_6347 X_NUC_58.L_CORE X_NUC_78.L_CORE 0.006162
K_6348 X_NUC_58.L_CORE X_NUC_79.L_CORE 0.006115
K_6349 X_NUC_58.L_CORE X_NUC_80.L_CORE 0.005992
K_6350 X_NUC_58.L_CORE X_NUC_81.L_CORE 0.002507
K_6351 X_NUC_58.L_CORE X_NUC_82.L_CORE 0.002528
K_6352 X_NUC_58.L_CORE X_NUC_83.L_CORE 0.002501
K_6353 X_NUC_58.L_CORE X_NUC_84.L_CORE 0.002522
K_6354 X_NUC_58.L_CORE X_NUC_85.L_CORE 0.002348
K_6355 X_NUC_58.L_CORE X_NUC_86.L_CORE 0.002372
K_6356 X_NUC_58.L_CORE X_NUC_87.L_CORE 0.002359
K_6357 X_NUC_58.L_CORE X_NUC_88.L_CORE 0.002350
K_6358 X_NUC_58.L_CORE X_NUC_89.L_CORE 0.005993
K_6359 X_NUC_58.L_CORE X_NUC_90.L_CORE 0.006039
K_6360 X_NUC_58.L_CORE X_NUC_91.L_CORE 0.005875
K_6361 X_NUC_58.L_CORE X_NUC_92.L_CORE 0.005955
K_6362 X_NUC_58.L_CORE X_NUC_93.L_CORE 0.002121
K_6363 X_NUC_58.L_CORE X_NUC_94.L_CORE 0.002140
K_6364 X_NUC_58.L_CORE X_NUC_95.L_CORE 0.002122
K_6365 X_NUC_58.L_CORE X_NUC_96.L_CORE 0.002129
K_6366 X_NUC_58.L_CORE X_NUC_97.L_CORE 0.003339
K_6367 X_NUC_58.L_CORE X_NUC_98.L_CORE 0.003376
K_6368 X_NUC_58.L_CORE X_NUC_99.L_CORE 0.003347
K_6369 X_NUC_58.L_CORE X_NUC_100.L_CORE 0.003323
K_6370 X_NUC_58.L_CORE X_NUC_101.L_CORE 0.003107
K_6371 X_NUC_58.L_CORE X_NUC_102.L_CORE 0.003132
K_6372 X_NUC_58.L_CORE X_NUC_103.L_CORE 0.003086
K_6373 X_NUC_58.L_CORE X_NUC_104.L_CORE 0.003113
K_6374 X_NUC_58.L_CORE X_NUC_105.L_CORE 0.002284
K_6375 X_NUC_58.L_CORE X_NUC_106.L_CORE 0.002306
K_6376 X_NUC_58.L_CORE X_NUC_107.L_CORE 0.002286
K_6377 X_NUC_58.L_CORE X_NUC_108.L_CORE 0.002286
K_6378 X_NUC_58.L_CORE X_NUC_109.L_CORE 0.003695
K_6379 X_NUC_58.L_CORE X_NUC_110.L_CORE 0.003731
K_6380 X_NUC_58.L_CORE X_NUC_111.L_CORE 0.003674
K_6381 X_NUC_58.L_CORE X_NUC_112.L_CORE 0.003674
K_6382 X_NUC_58.L_CORE X_NUC_113.L_CORE 0.002597
K_6383 X_NUC_58.L_CORE X_NUC_114.L_CORE 0.002621
K_6384 X_NUC_58.L_CORE X_NUC_115.L_CORE 0.002590
K_6385 X_NUC_58.L_CORE X_NUC_116.L_CORE 0.002599
K_6386 X_NUC_58.L_CORE X_NUC_117.L_CORE 0.002448
K_6387 X_NUC_58.L_CORE X_NUC_118.L_CORE 0.003639
K_6388 X_NUC_58.L_CORE X_NUC_119.L_CORE 0.002136
K_6389 X_NUC_58.L_CORE X_NUC_120.L_CORE 0.002970
K_6390 X_NUC_58.L_CORE X_NUC_121.L_CORE 0.003228
K_6391 X_NUC_58.L_CORE X_NUC_122.L_CORE 0.001980
K_6392 X_NUC_58.L_CORE X_NUC_123.L_CORE 0.006441
K_6393 X_NUC_58.L_CORE X_NUC_124.L_CORE 0.002210
K_6394 X_NUC_58.L_CORE X_NUC_125.L_CORE 0.002359
K_6395 X_NUC_58.L_CORE X_NUC_126.L_CORE 0.006259
K_6396 X_NUC_58.L_CORE X_NUC_127.L_CORE 0.001876
K_6397 X_NUC_58.L_CORE X_NUC_128.L_CORE 0.004183
K_6398 X_NUC_58.L_CORE X_NUC_129.L_CORE 0.002758
K_6399 X_NUC_58.L_CORE X_NUC_130.L_CORE 0.002003
K_6400 X_NUC_58.L_CORE X_NUC_131.L_CORE 0.015532
K_6401 X_NUC_58.L_CORE X_NUC_132.L_CORE 0.002019
K_6402 X_NUC_58.L_CORE X_NUC_133.L_CORE 0.002741
K_6403 X_NUC_58.L_CORE X_NUC_134.L_CORE 0.003866
K_6404 X_NUC_58.L_CORE X_NUC_135.L_CORE 0.001949
K_6405 X_NUC_58.L_CORE X_NUC_136.L_CORE 0.004453
K_6406 X_NUC_58.L_CORE X_NUC_137.L_CORE 0.002419
K_6407 X_NUC_58.L_CORE X_NUC_138.L_CORE 0.002323
K_6408 X_NUC_58.L_CORE X_NUC_139.L_CORE 0.003541
K_6409 X_NUC_58.L_CORE X_NUC_140.L_CORE 0.002338
K_6410 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.207973
K_6411 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.002130
K_6412 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.002149
K_6413 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.002133
K_6414 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.002145
K_6415 X_NUC_59.L_CORE X_NUC_65.L_CORE 0.002915
K_6416 X_NUC_59.L_CORE X_NUC_66.L_CORE 0.002947
K_6417 X_NUC_59.L_CORE X_NUC_67.L_CORE 0.002941
K_6418 X_NUC_59.L_CORE X_NUC_68.L_CORE 0.002916
K_6419 X_NUC_59.L_CORE X_NUC_69.L_CORE 0.004462
K_6420 X_NUC_59.L_CORE X_NUC_70.L_CORE 0.004491
K_6421 X_NUC_59.L_CORE X_NUC_71.L_CORE 0.004418
K_6422 X_NUC_59.L_CORE X_NUC_72.L_CORE 0.004506
K_6423 X_NUC_59.L_CORE X_NUC_73.L_CORE 0.002007
K_6424 X_NUC_59.L_CORE X_NUC_74.L_CORE 0.002027
K_6425 X_NUC_59.L_CORE X_NUC_75.L_CORE 0.002014
K_6426 X_NUC_59.L_CORE X_NUC_76.L_CORE 0.002016
K_6427 X_NUC_59.L_CORE X_NUC_77.L_CORE 0.006123
K_6428 X_NUC_59.L_CORE X_NUC_78.L_CORE 0.006205
K_6429 X_NUC_59.L_CORE X_NUC_79.L_CORE 0.006162
K_6430 X_NUC_59.L_CORE X_NUC_80.L_CORE 0.006033
K_6431 X_NUC_59.L_CORE X_NUC_81.L_CORE 0.002533
K_6432 X_NUC_59.L_CORE X_NUC_82.L_CORE 0.002554
K_6433 X_NUC_59.L_CORE X_NUC_83.L_CORE 0.002528
K_6434 X_NUC_59.L_CORE X_NUC_84.L_CORE 0.002549
K_6435 X_NUC_59.L_CORE X_NUC_85.L_CORE 0.002361
K_6436 X_NUC_59.L_CORE X_NUC_86.L_CORE 0.002386
K_6437 X_NUC_59.L_CORE X_NUC_87.L_CORE 0.002372
K_6438 X_NUC_59.L_CORE X_NUC_88.L_CORE 0.002364
K_6439 X_NUC_59.L_CORE X_NUC_89.L_CORE 0.006165
K_6440 X_NUC_59.L_CORE X_NUC_90.L_CORE 0.006212
K_6441 X_NUC_59.L_CORE X_NUC_91.L_CORE 0.006039
K_6442 X_NUC_59.L_CORE X_NUC_92.L_CORE 0.006123
K_6443 X_NUC_59.L_CORE X_NUC_93.L_CORE 0.002139
K_6444 X_NUC_59.L_CORE X_NUC_94.L_CORE 0.002159
K_6445 X_NUC_59.L_CORE X_NUC_95.L_CORE 0.002140
K_6446 X_NUC_59.L_CORE X_NUC_96.L_CORE 0.002147
K_6447 X_NUC_59.L_CORE X_NUC_97.L_CORE 0.003367
K_6448 X_NUC_59.L_CORE X_NUC_98.L_CORE 0.003405
K_6449 X_NUC_59.L_CORE X_NUC_99.L_CORE 0.003376
K_6450 X_NUC_59.L_CORE X_NUC_100.L_CORE 0.003351
K_6451 X_NUC_59.L_CORE X_NUC_101.L_CORE 0.003153
K_6452 X_NUC_59.L_CORE X_NUC_102.L_CORE 0.003180
K_6453 X_NUC_59.L_CORE X_NUC_103.L_CORE 0.003132
K_6454 X_NUC_59.L_CORE X_NUC_104.L_CORE 0.003160
K_6455 X_NUC_59.L_CORE X_NUC_105.L_CORE 0.002303
K_6456 X_NUC_59.L_CORE X_NUC_106.L_CORE 0.002326
K_6457 X_NUC_59.L_CORE X_NUC_107.L_CORE 0.002306
K_6458 X_NUC_59.L_CORE X_NUC_108.L_CORE 0.002305
K_6459 X_NUC_59.L_CORE X_NUC_109.L_CORE 0.003753
K_6460 X_NUC_59.L_CORE X_NUC_110.L_CORE 0.003790
K_6461 X_NUC_59.L_CORE X_NUC_111.L_CORE 0.003731
K_6462 X_NUC_59.L_CORE X_NUC_112.L_CORE 0.003731
K_6463 X_NUC_59.L_CORE X_NUC_113.L_CORE 0.002628
K_6464 X_NUC_59.L_CORE X_NUC_114.L_CORE 0.002653
K_6465 X_NUC_59.L_CORE X_NUC_115.L_CORE 0.002621
K_6466 X_NUC_59.L_CORE X_NUC_116.L_CORE 0.002630
K_6467 X_NUC_59.L_CORE X_NUC_117.L_CORE 0.002445
K_6468 X_NUC_59.L_CORE X_NUC_118.L_CORE 0.003618
K_6469 X_NUC_59.L_CORE X_NUC_119.L_CORE 0.002142
K_6470 X_NUC_59.L_CORE X_NUC_120.L_CORE 0.002957
K_6471 X_NUC_59.L_CORE X_NUC_121.L_CORE 0.003236
K_6472 X_NUC_59.L_CORE X_NUC_122.L_CORE 0.001985
K_6473 X_NUC_59.L_CORE X_NUC_123.L_CORE 0.006296
K_6474 X_NUC_59.L_CORE X_NUC_124.L_CORE 0.002222
K_6475 X_NUC_59.L_CORE X_NUC_125.L_CORE 0.002361
K_6476 X_NUC_59.L_CORE X_NUC_126.L_CORE 0.006294
K_6477 X_NUC_59.L_CORE X_NUC_127.L_CORE 0.001886
K_6478 X_NUC_59.L_CORE X_NUC_128.L_CORE 0.004165
K_6479 X_NUC_59.L_CORE X_NUC_129.L_CORE 0.002784
K_6480 X_NUC_59.L_CORE X_NUC_130.L_CORE 0.002011
K_6481 X_NUC_59.L_CORE X_NUC_131.L_CORE 0.016052
K_6482 X_NUC_59.L_CORE X_NUC_132.L_CORE 0.002035
K_6483 X_NUC_59.L_CORE X_NUC_133.L_CORE 0.002751
K_6484 X_NUC_59.L_CORE X_NUC_134.L_CORE 0.003932
K_6485 X_NUC_59.L_CORE X_NUC_135.L_CORE 0.001962
K_6486 X_NUC_59.L_CORE X_NUC_136.L_CORE 0.004503
K_6487 X_NUC_59.L_CORE X_NUC_137.L_CORE 0.002446
K_6488 X_NUC_59.L_CORE X_NUC_138.L_CORE 0.002340
K_6489 X_NUC_59.L_CORE X_NUC_139.L_CORE 0.003599
K_6490 X_NUC_59.L_CORE X_NUC_140.L_CORE 0.002363
K_6491 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.002119
K_6492 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.002137
K_6493 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.002122
K_6494 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.002133
K_6495 X_NUC_60.L_CORE X_NUC_65.L_CORE 0.002939
K_6496 X_NUC_60.L_CORE X_NUC_66.L_CORE 0.002973
K_6497 X_NUC_60.L_CORE X_NUC_67.L_CORE 0.002966
K_6498 X_NUC_60.L_CORE X_NUC_68.L_CORE 0.002941
K_6499 X_NUC_60.L_CORE X_NUC_69.L_CORE 0.004375
K_6500 X_NUC_60.L_CORE X_NUC_70.L_CORE 0.004402
K_6501 X_NUC_60.L_CORE X_NUC_71.L_CORE 0.004332
K_6502 X_NUC_60.L_CORE X_NUC_72.L_CORE 0.004418
K_6503 X_NUC_60.L_CORE X_NUC_73.L_CORE 0.002006
K_6504 X_NUC_60.L_CORE X_NUC_74.L_CORE 0.002025
K_6505 X_NUC_60.L_CORE X_NUC_75.L_CORE 0.002013
K_6506 X_NUC_60.L_CORE X_NUC_76.L_CORE 0.002014
K_6507 X_NUC_60.L_CORE X_NUC_77.L_CORE 0.006255
K_6508 X_NUC_60.L_CORE X_NUC_78.L_CORE 0.006343
K_6509 X_NUC_60.L_CORE X_NUC_79.L_CORE 0.006294
K_6510 X_NUC_60.L_CORE X_NUC_80.L_CORE 0.006162
K_6511 X_NUC_60.L_CORE X_NUC_81.L_CORE 0.002512
K_6512 X_NUC_60.L_CORE X_NUC_82.L_CORE 0.002533
K_6513 X_NUC_60.L_CORE X_NUC_83.L_CORE 0.002507
K_6514 X_NUC_60.L_CORE X_NUC_84.L_CORE 0.002528
K_6515 X_NUC_60.L_CORE X_NUC_85.L_CORE 0.002370
K_6516 X_NUC_60.L_CORE X_NUC_86.L_CORE 0.002394
K_6517 X_NUC_60.L_CORE X_NUC_87.L_CORE 0.002381
K_6518 X_NUC_60.L_CORE X_NUC_88.L_CORE 0.002372
K_6519 X_NUC_60.L_CORE X_NUC_89.L_CORE 0.006076
K_6520 X_NUC_60.L_CORE X_NUC_90.L_CORE 0.006121
K_6521 X_NUC_60.L_CORE X_NUC_91.L_CORE 0.005953
K_6522 X_NUC_60.L_CORE X_NUC_92.L_CORE 0.006039
K_6523 X_NUC_60.L_CORE X_NUC_93.L_CORE 0.002132
K_6524 X_NUC_60.L_CORE X_NUC_94.L_CORE 0.002151
K_6525 X_NUC_60.L_CORE X_NUC_95.L_CORE 0.002133
K_6526 X_NUC_60.L_CORE X_NUC_96.L_CORE 0.002140
K_6527 X_NUC_60.L_CORE X_NUC_97.L_CORE 0.003392
K_6528 X_NUC_60.L_CORE X_NUC_98.L_CORE 0.003430
K_6529 X_NUC_60.L_CORE X_NUC_99.L_CORE 0.003400
K_6530 X_NUC_60.L_CORE X_NUC_100.L_CORE 0.003376
K_6531 X_NUC_60.L_CORE X_NUC_101.L_CORE 0.003125
K_6532 X_NUC_60.L_CORE X_NUC_102.L_CORE 0.003151
K_6533 X_NUC_60.L_CORE X_NUC_103.L_CORE 0.003104
K_6534 X_NUC_60.L_CORE X_NUC_104.L_CORE 0.003132
K_6535 X_NUC_60.L_CORE X_NUC_105.L_CORE 0.002303
K_6536 X_NUC_60.L_CORE X_NUC_106.L_CORE 0.002326
K_6537 X_NUC_60.L_CORE X_NUC_107.L_CORE 0.002306
K_6538 X_NUC_60.L_CORE X_NUC_108.L_CORE 0.002306
K_6539 X_NUC_60.L_CORE X_NUC_109.L_CORE 0.003752
K_6540 X_NUC_60.L_CORE X_NUC_110.L_CORE 0.003790
K_6541 X_NUC_60.L_CORE X_NUC_111.L_CORE 0.003730
K_6542 X_NUC_60.L_CORE X_NUC_112.L_CORE 0.003731
K_6543 X_NUC_60.L_CORE X_NUC_113.L_CORE 0.002619
K_6544 X_NUC_60.L_CORE X_NUC_114.L_CORE 0.002644
K_6545 X_NUC_60.L_CORE X_NUC_115.L_CORE 0.002612
K_6546 X_NUC_60.L_CORE X_NUC_116.L_CORE 0.002621
K_6547 X_NUC_60.L_CORE X_NUC_117.L_CORE 0.002446
K_6548 X_NUC_60.L_CORE X_NUC_118.L_CORE 0.003607
K_6549 X_NUC_60.L_CORE X_NUC_119.L_CORE 0.002134
K_6550 X_NUC_60.L_CORE X_NUC_120.L_CORE 0.002976
K_6551 X_NUC_60.L_CORE X_NUC_121.L_CORE 0.003200
K_6552 X_NUC_60.L_CORE X_NUC_122.L_CORE 0.001985
K_6553 X_NUC_60.L_CORE X_NUC_123.L_CORE 0.006396
K_6554 X_NUC_60.L_CORE X_NUC_124.L_CORE 0.002207
K_6555 X_NUC_60.L_CORE X_NUC_125.L_CORE 0.002373
K_6556 X_NUC_60.L_CORE X_NUC_126.L_CORE 0.006122
K_6557 X_NUC_60.L_CORE X_NUC_127.L_CORE 0.001882
K_6558 X_NUC_60.L_CORE X_NUC_128.L_CORE 0.004238
K_6559 X_NUC_60.L_CORE X_NUC_129.L_CORE 0.002752
K_6560 X_NUC_60.L_CORE X_NUC_130.L_CORE 0.002015
K_6561 X_NUC_60.L_CORE X_NUC_131.L_CORE 0.016136
K_6562 X_NUC_60.L_CORE X_NUC_132.L_CORE 0.002024
K_6563 X_NUC_60.L_CORE X_NUC_133.L_CORE 0.002773
K_6564 X_NUC_60.L_CORE X_NUC_134.L_CORE 0.003871
K_6565 X_NUC_60.L_CORE X_NUC_135.L_CORE 0.001960
K_6566 X_NUC_60.L_CORE X_NUC_136.L_CORE 0.004550
K_6567 X_NUC_60.L_CORE X_NUC_137.L_CORE 0.002429
K_6568 X_NUC_60.L_CORE X_NUC_138.L_CORE 0.002346
K_6569 X_NUC_60.L_CORE X_NUC_139.L_CORE 0.003584
K_6570 X_NUC_60.L_CORE X_NUC_140.L_CORE 0.002357
K_6571 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.207973
K_6572 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.207973
K_6573 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.207973
K_6574 X_NUC_61.L_CORE X_NUC_65.L_CORE 0.002144
K_6575 X_NUC_61.L_CORE X_NUC_66.L_CORE 0.002137
K_6576 X_NUC_61.L_CORE X_NUC_67.L_CORE 0.002150
K_6577 X_NUC_61.L_CORE X_NUC_68.L_CORE 0.002129
K_6578 X_NUC_61.L_CORE X_NUC_69.L_CORE 0.002962
K_6579 X_NUC_61.L_CORE X_NUC_70.L_CORE 0.002921
K_6580 X_NUC_61.L_CORE X_NUC_71.L_CORE 0.002940
K_6581 X_NUC_61.L_CORE X_NUC_72.L_CORE 0.002936
K_6582 X_NUC_61.L_CORE X_NUC_73.L_CORE 0.004457
K_6583 X_NUC_61.L_CORE X_NUC_74.L_CORE 0.004495
K_6584 X_NUC_61.L_CORE X_NUC_75.L_CORE 0.004503
K_6585 X_NUC_61.L_CORE X_NUC_76.L_CORE 0.004418
K_6586 X_NUC_61.L_CORE X_NUC_77.L_CORE 0.002040
K_6587 X_NUC_61.L_CORE X_NUC_78.L_CORE 0.002026
K_6588 X_NUC_61.L_CORE X_NUC_79.L_CORE 0.002038
K_6589 X_NUC_61.L_CORE X_NUC_80.L_CORE 0.002024
K_6590 X_NUC_61.L_CORE X_NUC_81.L_CORE 0.006205
K_6591 X_NUC_61.L_CORE X_NUC_82.L_CORE 0.006055
K_6592 X_NUC_61.L_CORE X_NUC_83.L_CORE 0.006045
K_6593 X_NUC_61.L_CORE X_NUC_84.L_CORE 0.006076
K_6594 X_NUC_61.L_CORE X_NUC_85.L_CORE 0.002573
K_6595 X_NUC_61.L_CORE X_NUC_86.L_CORE 0.002571
K_6596 X_NUC_61.L_CORE X_NUC_87.L_CORE 0.002581
K_6597 X_NUC_61.L_CORE X_NUC_88.L_CORE 0.002550
K_6598 X_NUC_61.L_CORE X_NUC_89.L_CORE 0.002423
K_6599 X_NUC_61.L_CORE X_NUC_90.L_CORE 0.002399
K_6600 X_NUC_61.L_CORE X_NUC_91.L_CORE 0.002410
K_6601 X_NUC_61.L_CORE X_NUC_92.L_CORE 0.002399
K_6602 X_NUC_61.L_CORE X_NUC_93.L_CORE 0.005959
K_6603 X_NUC_61.L_CORE X_NUC_94.L_CORE 0.005970
K_6604 X_NUC_61.L_CORE X_NUC_95.L_CORE 0.005911
K_6605 X_NUC_61.L_CORE X_NUC_96.L_CORE 0.005821
K_6606 X_NUC_61.L_CORE X_NUC_97.L_CORE 0.002208
K_6607 X_NUC_61.L_CORE X_NUC_98.L_CORE 0.002198
K_6608 X_NUC_61.L_CORE X_NUC_99.L_CORE 0.002207
K_6609 X_NUC_61.L_CORE X_NUC_100.L_CORE 0.002188
K_6610 X_NUC_61.L_CORE X_NUC_101.L_CORE 0.003428
K_6611 X_NUC_61.L_CORE X_NUC_102.L_CORE 0.003384
K_6612 X_NUC_61.L_CORE X_NUC_103.L_CORE 0.003387
K_6613 X_NUC_61.L_CORE X_NUC_104.L_CORE 0.003378
K_6614 X_NUC_61.L_CORE X_NUC_105.L_CORE 0.003192
K_6615 X_NUC_61.L_CORE X_NUC_106.L_CORE 0.003188
K_6616 X_NUC_61.L_CORE X_NUC_107.L_CORE 0.003188
K_6617 X_NUC_61.L_CORE X_NUC_108.L_CORE 0.003150
K_6618 X_NUC_61.L_CORE X_NUC_109.L_CORE 0.002446
K_6619 X_NUC_61.L_CORE X_NUC_110.L_CORE 0.002428
K_6620 X_NUC_61.L_CORE X_NUC_111.L_CORE 0.002435
K_6621 X_NUC_61.L_CORE X_NUC_112.L_CORE 0.002418
K_6622 X_NUC_61.L_CORE X_NUC_113.L_CORE 0.003409
K_6623 X_NUC_61.L_CORE X_NUC_114.L_CORE 0.003385
K_6624 X_NUC_61.L_CORE X_NUC_115.L_CORE 0.003380
K_6625 X_NUC_61.L_CORE X_NUC_116.L_CORE 0.003354
K_6626 X_NUC_61.L_CORE X_NUC_117.L_CORE 0.002524
K_6627 X_NUC_61.L_CORE X_NUC_118.L_CORE 0.002285
K_6628 X_NUC_61.L_CORE X_NUC_119.L_CORE 0.003909
K_6629 X_NUC_61.L_CORE X_NUC_120.L_CORE 0.002056
K_6630 X_NUC_61.L_CORE X_NUC_121.L_CORE 0.002928
K_6631 X_NUC_61.L_CORE X_NUC_122.L_CORE 0.003214
K_6632 X_NUC_61.L_CORE X_NUC_123.L_CORE 0.001942
K_6633 X_NUC_61.L_CORE X_NUC_124.L_CORE 0.006565
K_6634 X_NUC_61.L_CORE X_NUC_125.L_CORE 0.002192
K_6635 X_NUC_61.L_CORE X_NUC_126.L_CORE 0.002340
K_6636 X_NUC_61.L_CORE X_NUC_127.L_CORE 0.006341
K_6637 X_NUC_61.L_CORE X_NUC_128.L_CORE 0.001876
K_6638 X_NUC_61.L_CORE X_NUC_129.L_CORE 0.004171
K_6639 X_NUC_61.L_CORE X_NUC_130.L_CORE 0.002783
K_6640 X_NUC_61.L_CORE X_NUC_131.L_CORE 0.002019
K_6641 X_NUC_61.L_CORE X_NUC_132.L_CORE 0.014507
K_6642 X_NUC_61.L_CORE X_NUC_133.L_CORE 0.002054
K_6643 X_NUC_61.L_CORE X_NUC_134.L_CORE 0.002779
K_6644 X_NUC_61.L_CORE X_NUC_135.L_CORE 0.003915
K_6645 X_NUC_61.L_CORE X_NUC_136.L_CORE 0.002009
K_6646 X_NUC_61.L_CORE X_NUC_137.L_CORE 0.004347
K_6647 X_NUC_61.L_CORE X_NUC_138.L_CORE 0.002511
K_6648 X_NUC_61.L_CORE X_NUC_139.L_CORE 0.002439
K_6649 X_NUC_61.L_CORE X_NUC_140.L_CORE 0.003214
K_6650 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.207973
K_6651 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.207973
K_6652 X_NUC_62.L_CORE X_NUC_65.L_CORE 0.002150
K_6653 X_NUC_62.L_CORE X_NUC_66.L_CORE 0.002144
K_6654 X_NUC_62.L_CORE X_NUC_67.L_CORE 0.002157
K_6655 X_NUC_62.L_CORE X_NUC_68.L_CORE 0.002135
K_6656 X_NUC_62.L_CORE X_NUC_69.L_CORE 0.003004
K_6657 X_NUC_62.L_CORE X_NUC_70.L_CORE 0.002962
K_6658 X_NUC_62.L_CORE X_NUC_71.L_CORE 0.002982
K_6659 X_NUC_62.L_CORE X_NUC_72.L_CORE 0.002977
K_6660 X_NUC_62.L_CORE X_NUC_73.L_CORE 0.004419
K_6661 X_NUC_62.L_CORE X_NUC_74.L_CORE 0.004457
K_6662 X_NUC_62.L_CORE X_NUC_75.L_CORE 0.004464
K_6663 X_NUC_62.L_CORE X_NUC_76.L_CORE 0.004381
K_6664 X_NUC_62.L_CORE X_NUC_77.L_CORE 0.002053
K_6665 X_NUC_62.L_CORE X_NUC_78.L_CORE 0.002040
K_6666 X_NUC_62.L_CORE X_NUC_79.L_CORE 0.002052
K_6667 X_NUC_62.L_CORE X_NUC_80.L_CORE 0.002037
K_6668 X_NUC_62.L_CORE X_NUC_81.L_CORE 0.006360
K_6669 X_NUC_62.L_CORE X_NUC_82.L_CORE 0.006205
K_6670 X_NUC_62.L_CORE X_NUC_83.L_CORE 0.006191
K_6671 X_NUC_62.L_CORE X_NUC_84.L_CORE 0.006225
K_6672 X_NUC_62.L_CORE X_NUC_85.L_CORE 0.002574
K_6673 X_NUC_62.L_CORE X_NUC_86.L_CORE 0.002573
K_6674 X_NUC_62.L_CORE X_NUC_87.L_CORE 0.002582
K_6675 X_NUC_62.L_CORE X_NUC_88.L_CORE 0.002552
K_6676 X_NUC_62.L_CORE X_NUC_89.L_CORE 0.002448
K_6677 X_NUC_62.L_CORE X_NUC_90.L_CORE 0.002423
K_6678 X_NUC_62.L_CORE X_NUC_91.L_CORE 0.002435
K_6679 X_NUC_62.L_CORE X_NUC_92.L_CORE 0.002424
K_6680 X_NUC_62.L_CORE X_NUC_93.L_CORE 0.005942
K_6681 X_NUC_62.L_CORE X_NUC_94.L_CORE 0.005959
K_6682 X_NUC_62.L_CORE X_NUC_95.L_CORE 0.005898
K_6683 X_NUC_62.L_CORE X_NUC_96.L_CORE 0.005808
K_6684 X_NUC_62.L_CORE X_NUC_97.L_CORE 0.002218
K_6685 X_NUC_62.L_CORE X_NUC_98.L_CORE 0.002208
K_6686 X_NUC_62.L_CORE X_NUC_99.L_CORE 0.002217
K_6687 X_NUC_62.L_CORE X_NUC_100.L_CORE 0.002198
K_6688 X_NUC_62.L_CORE X_NUC_101.L_CORE 0.003473
K_6689 X_NUC_62.L_CORE X_NUC_102.L_CORE 0.003428
K_6690 X_NUC_62.L_CORE X_NUC_103.L_CORE 0.003431
K_6691 X_NUC_62.L_CORE X_NUC_104.L_CORE 0.003421
K_6692 X_NUC_62.L_CORE X_NUC_105.L_CORE 0.003195
K_6693 X_NUC_62.L_CORE X_NUC_106.L_CORE 0.003192
K_6694 X_NUC_62.L_CORE X_NUC_107.L_CORE 0.003191
K_6695 X_NUC_62.L_CORE X_NUC_108.L_CORE 0.003153
K_6696 X_NUC_62.L_CORE X_NUC_109.L_CORE 0.002464
K_6697 X_NUC_62.L_CORE X_NUC_110.L_CORE 0.002446
K_6698 X_NUC_62.L_CORE X_NUC_111.L_CORE 0.002453
K_6699 X_NUC_62.L_CORE X_NUC_112.L_CORE 0.002436
K_6700 X_NUC_62.L_CORE X_NUC_113.L_CORE 0.003432
K_6701 X_NUC_62.L_CORE X_NUC_114.L_CORE 0.003409
K_6702 X_NUC_62.L_CORE X_NUC_115.L_CORE 0.003403
K_6703 X_NUC_62.L_CORE X_NUC_116.L_CORE 0.003377
K_6704 X_NUC_62.L_CORE X_NUC_117.L_CORE 0.002531
K_6705 X_NUC_62.L_CORE X_NUC_118.L_CORE 0.002302
K_6706 X_NUC_62.L_CORE X_NUC_119.L_CORE 0.003915
K_6707 X_NUC_62.L_CORE X_NUC_120.L_CORE 0.002064
K_6708 X_NUC_62.L_CORE X_NUC_121.L_CORE 0.002962
K_6709 X_NUC_62.L_CORE X_NUC_122.L_CORE 0.003201
K_6710 X_NUC_62.L_CORE X_NUC_123.L_CORE 0.001955
K_6711 X_NUC_62.L_CORE X_NUC_124.L_CORE 0.006669
K_6712 X_NUC_62.L_CORE X_NUC_125.L_CORE 0.002194
K_6713 X_NUC_62.L_CORE X_NUC_126.L_CORE 0.002365
K_6714 X_NUC_62.L_CORE X_NUC_127.L_CORE 0.006210
K_6715 X_NUC_62.L_CORE X_NUC_128.L_CORE 0.001886
K_6716 X_NUC_62.L_CORE X_NUC_129.L_CORE 0.004252
K_6717 X_NUC_62.L_CORE X_NUC_130.L_CORE 0.002775
K_6718 X_NUC_62.L_CORE X_NUC_131.L_CORE 0.002036
K_6719 X_NUC_62.L_CORE X_NUC_132.L_CORE 0.014340
K_6720 X_NUC_62.L_CORE X_NUC_133.L_CORE 0.002059
K_6721 X_NUC_62.L_CORE X_NUC_134.L_CORE 0.002815
K_6722 X_NUC_62.L_CORE X_NUC_135.L_CORE 0.003891
K_6723 X_NUC_62.L_CORE X_NUC_136.L_CORE 0.002021
K_6724 X_NUC_62.L_CORE X_NUC_137.L_CORE 0.004402
K_6725 X_NUC_62.L_CORE X_NUC_138.L_CORE 0.002515
K_6726 X_NUC_62.L_CORE X_NUC_139.L_CORE 0.002459
K_6727 X_NUC_62.L_CORE X_NUC_140.L_CORE 0.003227
K_6728 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.207973
K_6729 X_NUC_63.L_CORE X_NUC_65.L_CORE 0.002137
K_6730 X_NUC_63.L_CORE X_NUC_66.L_CORE 0.002130
K_6731 X_NUC_63.L_CORE X_NUC_67.L_CORE 0.002144
K_6732 X_NUC_63.L_CORE X_NUC_68.L_CORE 0.002123
K_6733 X_NUC_63.L_CORE X_NUC_69.L_CORE 0.002984
K_6734 X_NUC_63.L_CORE X_NUC_70.L_CORE 0.002942
K_6735 X_NUC_63.L_CORE X_NUC_71.L_CORE 0.002962
K_6736 X_NUC_63.L_CORE X_NUC_72.L_CORE 0.002958
K_6737 X_NUC_63.L_CORE X_NUC_73.L_CORE 0.004411
K_6738 X_NUC_63.L_CORE X_NUC_74.L_CORE 0.004449
K_6739 X_NUC_63.L_CORE X_NUC_75.L_CORE 0.004457
K_6740 X_NUC_63.L_CORE X_NUC_76.L_CORE 0.004374
K_6741 X_NUC_63.L_CORE X_NUC_77.L_CORE 0.002041
K_6742 X_NUC_63.L_CORE X_NUC_78.L_CORE 0.002028
K_6743 X_NUC_63.L_CORE X_NUC_79.L_CORE 0.002040
K_6744 X_NUC_63.L_CORE X_NUC_80.L_CORE 0.002025
K_6745 X_NUC_63.L_CORE X_NUC_81.L_CORE 0.006372
K_6746 X_NUC_63.L_CORE X_NUC_82.L_CORE 0.006213
K_6747 X_NUC_63.L_CORE X_NUC_83.L_CORE 0.006205
K_6748 X_NUC_63.L_CORE X_NUC_84.L_CORE 0.006236
K_6749 X_NUC_63.L_CORE X_NUC_85.L_CORE 0.002564
K_6750 X_NUC_63.L_CORE X_NUC_86.L_CORE 0.002562
K_6751 X_NUC_63.L_CORE X_NUC_87.L_CORE 0.002573
K_6752 X_NUC_63.L_CORE X_NUC_88.L_CORE 0.002542
K_6753 X_NUC_63.L_CORE X_NUC_89.L_CORE 0.002436
K_6754 X_NUC_63.L_CORE X_NUC_90.L_CORE 0.002411
K_6755 X_NUC_63.L_CORE X_NUC_91.L_CORE 0.002423
K_6756 X_NUC_63.L_CORE X_NUC_92.L_CORE 0.002412
K_6757 X_NUC_63.L_CORE X_NUC_93.L_CORE 0.006002
K_6758 X_NUC_63.L_CORE X_NUC_94.L_CORE 0.006016
K_6759 X_NUC_63.L_CORE X_NUC_95.L_CORE 0.005959
K_6760 X_NUC_63.L_CORE X_NUC_96.L_CORE 0.005863
K_6761 X_NUC_63.L_CORE X_NUC_97.L_CORE 0.002209
K_6762 X_NUC_63.L_CORE X_NUC_98.L_CORE 0.002199
K_6763 X_NUC_63.L_CORE X_NUC_99.L_CORE 0.002208
K_6764 X_NUC_63.L_CORE X_NUC_100.L_CORE 0.002189
K_6765 X_NUC_63.L_CORE X_NUC_101.L_CORE 0.003469
K_6766 X_NUC_63.L_CORE X_NUC_102.L_CORE 0.003424
K_6767 X_NUC_63.L_CORE X_NUC_103.L_CORE 0.003428
K_6768 X_NUC_63.L_CORE X_NUC_104.L_CORE 0.003417
K_6769 X_NUC_63.L_CORE X_NUC_105.L_CORE 0.003195
K_6770 X_NUC_63.L_CORE X_NUC_106.L_CORE 0.003192
K_6771 X_NUC_63.L_CORE X_NUC_107.L_CORE 0.003192
K_6772 X_NUC_63.L_CORE X_NUC_108.L_CORE 0.003153
K_6773 X_NUC_63.L_CORE X_NUC_109.L_CORE 0.002457
K_6774 X_NUC_63.L_CORE X_NUC_110.L_CORE 0.002438
K_6775 X_NUC_63.L_CORE X_NUC_111.L_CORE 0.002446
K_6776 X_NUC_63.L_CORE X_NUC_112.L_CORE 0.002429
K_6777 X_NUC_63.L_CORE X_NUC_113.L_CORE 0.003438
K_6778 X_NUC_63.L_CORE X_NUC_114.L_CORE 0.003413
K_6779 X_NUC_63.L_CORE X_NUC_115.L_CORE 0.003409
K_6780 X_NUC_63.L_CORE X_NUC_116.L_CORE 0.003382
K_6781 X_NUC_63.L_CORE X_NUC_117.L_CORE 0.002502
K_6782 X_NUC_63.L_CORE X_NUC_118.L_CORE 0.002278
K_6783 X_NUC_63.L_CORE X_NUC_119.L_CORE 0.003852
K_6784 X_NUC_63.L_CORE X_NUC_120.L_CORE 0.002045
K_6785 X_NUC_63.L_CORE X_NUC_121.L_CORE 0.002927
K_6786 X_NUC_63.L_CORE X_NUC_122.L_CORE 0.003169
K_6787 X_NUC_63.L_CORE X_NUC_123.L_CORE 0.001939
K_6788 X_NUC_63.L_CORE X_NUC_124.L_CORE 0.006532
K_6789 X_NUC_63.L_CORE X_NUC_125.L_CORE 0.002178
K_6790 X_NUC_63.L_CORE X_NUC_126.L_CORE 0.002346
K_6791 X_NUC_63.L_CORE X_NUC_127.L_CORE 0.006171
K_6792 X_NUC_63.L_CORE X_NUC_128.L_CORE 0.001873
K_6793 X_NUC_63.L_CORE X_NUC_129.L_CORE 0.004223
K_6794 X_NUC_63.L_CORE X_NUC_130.L_CORE 0.002762
K_6795 X_NUC_63.L_CORE X_NUC_131.L_CORE 0.002024
K_6796 X_NUC_63.L_CORE X_NUC_132.L_CORE 0.015262
K_6797 X_NUC_63.L_CORE X_NUC_133.L_CORE 0.002050
K_6798 X_NUC_63.L_CORE X_NUC_134.L_CORE 0.002804
K_6799 X_NUC_63.L_CORE X_NUC_135.L_CORE 0.003902
K_6800 X_NUC_63.L_CORE X_NUC_136.L_CORE 0.002013
K_6801 X_NUC_63.L_CORE X_NUC_137.L_CORE 0.004427
K_6802 X_NUC_63.L_CORE X_NUC_138.L_CORE 0.002511
K_6803 X_NUC_63.L_CORE X_NUC_139.L_CORE 0.002454
K_6804 X_NUC_63.L_CORE X_NUC_140.L_CORE 0.003237
K_6805 X_NUC_64.L_CORE X_NUC_65.L_CORE 0.002158
K_6806 X_NUC_64.L_CORE X_NUC_66.L_CORE 0.002151
K_6807 X_NUC_64.L_CORE X_NUC_67.L_CORE 0.002165
K_6808 X_NUC_64.L_CORE X_NUC_68.L_CORE 0.002144
K_6809 X_NUC_64.L_CORE X_NUC_69.L_CORE 0.002988
K_6810 X_NUC_64.L_CORE X_NUC_70.L_CORE 0.002946
K_6811 X_NUC_64.L_CORE X_NUC_71.L_CORE 0.002966
K_6812 X_NUC_64.L_CORE X_NUC_72.L_CORE 0.002962
K_6813 X_NUC_64.L_CORE X_NUC_73.L_CORE 0.004496
K_6814 X_NUC_64.L_CORE X_NUC_74.L_CORE 0.004535
K_6815 X_NUC_64.L_CORE X_NUC_75.L_CORE 0.004544
K_6816 X_NUC_64.L_CORE X_NUC_76.L_CORE 0.004457
K_6817 X_NUC_64.L_CORE X_NUC_77.L_CORE 0.002056
K_6818 X_NUC_64.L_CORE X_NUC_78.L_CORE 0.002042
K_6819 X_NUC_64.L_CORE X_NUC_79.L_CORE 0.002054
K_6820 X_NUC_64.L_CORE X_NUC_80.L_CORE 0.002040
K_6821 X_NUC_64.L_CORE X_NUC_81.L_CORE 0.006336
K_6822 X_NUC_64.L_CORE X_NUC_82.L_CORE 0.006180
K_6823 X_NUC_64.L_CORE X_NUC_83.L_CORE 0.006169
K_6824 X_NUC_64.L_CORE X_NUC_84.L_CORE 0.006205
K_6825 X_NUC_64.L_CORE X_NUC_85.L_CORE 0.002595
K_6826 X_NUC_64.L_CORE X_NUC_86.L_CORE 0.002593
K_6827 X_NUC_64.L_CORE X_NUC_87.L_CORE 0.002604
K_6828 X_NUC_64.L_CORE X_NUC_88.L_CORE 0.002573
K_6829 X_NUC_64.L_CORE X_NUC_89.L_CORE 0.002447
K_6830 X_NUC_64.L_CORE X_NUC_90.L_CORE 0.002422
K_6831 X_NUC_64.L_CORE X_NUC_91.L_CORE 0.002434
K_6832 X_NUC_64.L_CORE X_NUC_92.L_CORE 0.002423
K_6833 X_NUC_64.L_CORE X_NUC_93.L_CORE 0.006102
K_6834 X_NUC_64.L_CORE X_NUC_94.L_CORE 0.006116
K_6835 X_NUC_64.L_CORE X_NUC_95.L_CORE 0.006053
K_6836 X_NUC_64.L_CORE X_NUC_96.L_CORE 0.005959
K_6837 X_NUC_64.L_CORE X_NUC_97.L_CORE 0.002229
K_6838 X_NUC_64.L_CORE X_NUC_98.L_CORE 0.002218
K_6839 X_NUC_64.L_CORE X_NUC_99.L_CORE 0.002227
K_6840 X_NUC_64.L_CORE X_NUC_100.L_CORE 0.002208
K_6841 X_NUC_64.L_CORE X_NUC_101.L_CORE 0.003480
K_6842 X_NUC_64.L_CORE X_NUC_102.L_CORE 0.003434
K_6843 X_NUC_64.L_CORE X_NUC_103.L_CORE 0.003438
K_6844 X_NUC_64.L_CORE X_NUC_104.L_CORE 0.003428
K_6845 X_NUC_64.L_CORE X_NUC_105.L_CORE 0.003234
K_6846 X_NUC_64.L_CORE X_NUC_106.L_CORE 0.003231
K_6847 X_NUC_64.L_CORE X_NUC_107.L_CORE 0.003231
K_6848 X_NUC_64.L_CORE X_NUC_108.L_CORE 0.003192
K_6849 X_NUC_64.L_CORE X_NUC_109.L_CORE 0.002474
K_6850 X_NUC_64.L_CORE X_NUC_110.L_CORE 0.002455
K_6851 X_NUC_64.L_CORE X_NUC_111.L_CORE 0.002463
K_6852 X_NUC_64.L_CORE X_NUC_112.L_CORE 0.002446
K_6853 X_NUC_64.L_CORE X_NUC_113.L_CORE 0.003465
K_6854 X_NUC_64.L_CORE X_NUC_114.L_CORE 0.003440
K_6855 X_NUC_64.L_CORE X_NUC_115.L_CORE 0.003435
K_6856 X_NUC_64.L_CORE X_NUC_116.L_CORE 0.003409
K_6857 X_NUC_64.L_CORE X_NUC_117.L_CORE 0.002522
K_6858 X_NUC_64.L_CORE X_NUC_118.L_CORE 0.002289
K_6859 X_NUC_64.L_CORE X_NUC_119.L_CORE 0.003876
K_6860 X_NUC_64.L_CORE X_NUC_120.L_CORE 0.002062
K_6861 X_NUC_64.L_CORE X_NUC_121.L_CORE 0.002929
K_6862 X_NUC_64.L_CORE X_NUC_122.L_CORE 0.003208
K_6863 X_NUC_64.L_CORE X_NUC_123.L_CORE 0.001951
K_6864 X_NUC_64.L_CORE X_NUC_124.L_CORE 0.006465
K_6865 X_NUC_64.L_CORE X_NUC_125.L_CORE 0.002201
K_6866 X_NUC_64.L_CORE X_NUC_126.L_CORE 0.002352
K_6867 X_NUC_64.L_CORE X_NUC_127.L_CORE 0.006292
K_6868 X_NUC_64.L_CORE X_NUC_128.L_CORE 0.001888
K_6869 X_NUC_64.L_CORE X_NUC_129.L_CORE 0.004196
K_6870 X_NUC_64.L_CORE X_NUC_130.L_CORE 0.002798
K_6871 X_NUC_64.L_CORE X_NUC_131.L_CORE 0.002034
K_6872 X_NUC_64.L_CORE X_NUC_132.L_CORE 0.015012
K_6873 X_NUC_64.L_CORE X_NUC_133.L_CORE 0.002069
K_6874 X_NUC_64.L_CORE X_NUC_134.L_CORE 0.002807
K_6875 X_NUC_64.L_CORE X_NUC_135.L_CORE 0.003960
K_6876 X_NUC_64.L_CORE X_NUC_136.L_CORE 0.002026
K_6877 X_NUC_64.L_CORE X_NUC_137.L_CORE 0.004427
K_6878 X_NUC_64.L_CORE X_NUC_138.L_CORE 0.002537
K_6879 X_NUC_64.L_CORE X_NUC_139.L_CORE 0.002467
K_6880 X_NUC_64.L_CORE X_NUC_140.L_CORE 0.003263
K_6881 X_NUC_65.L_CORE X_NUC_66.L_CORE 0.207973
K_6882 X_NUC_65.L_CORE X_NUC_67.L_CORE 0.207973
K_6883 X_NUC_65.L_CORE X_NUC_68.L_CORE 0.207973
K_6884 X_NUC_65.L_CORE X_NUC_69.L_CORE 0.002164
K_6885 X_NUC_65.L_CORE X_NUC_70.L_CORE 0.002155
K_6886 X_NUC_65.L_CORE X_NUC_71.L_CORE 0.002149
K_6887 X_NUC_65.L_CORE X_NUC_72.L_CORE 0.002169
K_6888 X_NUC_65.L_CORE X_NUC_73.L_CORE 0.002998
K_6889 X_NUC_65.L_CORE X_NUC_74.L_CORE 0.003027
K_6890 X_NUC_65.L_CORE X_NUC_75.L_CORE 0.002993
K_6891 X_NUC_65.L_CORE X_NUC_76.L_CORE 0.003025
K_6892 X_NUC_65.L_CORE X_NUC_77.L_CORE 0.004519
K_6893 X_NUC_65.L_CORE X_NUC_78.L_CORE 0.004434
K_6894 X_NUC_65.L_CORE X_NUC_79.L_CORE 0.004441
K_6895 X_NUC_65.L_CORE X_NUC_80.L_CORE 0.004479
K_6896 X_NUC_65.L_CORE X_NUC_81.L_CORE 0.002077
K_6897 X_NUC_65.L_CORE X_NUC_82.L_CORE 0.002077
K_6898 X_NUC_65.L_CORE X_NUC_83.L_CORE 0.002065
K_6899 X_NUC_65.L_CORE X_NUC_84.L_CORE 0.002085
K_6900 X_NUC_65.L_CORE X_NUC_85.L_CORE 0.006260
K_6901 X_NUC_65.L_CORE X_NUC_86.L_CORE 0.006394
K_6902 X_NUC_65.L_CORE X_NUC_87.L_CORE 0.006209
K_6903 X_NUC_65.L_CORE X_NUC_88.L_CORE 0.006295
K_6904 X_NUC_65.L_CORE X_NUC_89.L_CORE 0.002634
K_6905 X_NUC_65.L_CORE X_NUC_90.L_CORE 0.002614
K_6906 X_NUC_65.L_CORE X_NUC_91.L_CORE 0.002605
K_6907 X_NUC_65.L_CORE X_NUC_92.L_CORE 0.002630
K_6908 X_NUC_65.L_CORE X_NUC_93.L_CORE 0.002492
K_6909 X_NUC_65.L_CORE X_NUC_94.L_CORE 0.002502
K_6910 X_NUC_65.L_CORE X_NUC_95.L_CORE 0.002477
K_6911 X_NUC_65.L_CORE X_NUC_96.L_CORE 0.002504
K_6912 X_NUC_65.L_CORE X_NUC_97.L_CORE 0.005845
K_6913 X_NUC_65.L_CORE X_NUC_98.L_CORE 0.005778
K_6914 X_NUC_65.L_CORE X_NUC_99.L_CORE 0.005687
K_6915 X_NUC_65.L_CORE X_NUC_100.L_CORE 0.005753
K_6916 X_NUC_65.L_CORE X_NUC_101.L_CORE 0.002301
K_6917 X_NUC_65.L_CORE X_NUC_102.L_CORE 0.002295
K_6918 X_NUC_65.L_CORE X_NUC_103.L_CORE 0.002280
K_6919 X_NUC_65.L_CORE X_NUC_104.L_CORE 0.002303
K_6920 X_NUC_65.L_CORE X_NUC_105.L_CORE 0.003485
K_6921 X_NUC_65.L_CORE X_NUC_106.L_CORE 0.003508
K_6922 X_NUC_65.L_CORE X_NUC_107.L_CORE 0.003451
K_6923 X_NUC_65.L_CORE X_NUC_108.L_CORE 0.003492
K_6924 X_NUC_65.L_CORE X_NUC_109.L_CORE 0.003256
K_6925 X_NUC_65.L_CORE X_NUC_110.L_CORE 0.003235
K_6926 X_NUC_65.L_CORE X_NUC_111.L_CORE 0.003207
K_6927 X_NUC_65.L_CORE X_NUC_112.L_CORE 0.003240
K_6928 X_NUC_65.L_CORE X_NUC_113.L_CORE 0.002692
K_6929 X_NUC_65.L_CORE X_NUC_114.L_CORE 0.002692
K_6930 X_NUC_65.L_CORE X_NUC_115.L_CORE 0.002664
K_6931 X_NUC_65.L_CORE X_NUC_116.L_CORE 0.002693
K_6932 X_NUC_65.L_CORE X_NUC_117.L_CORE 0.002776
K_6933 X_NUC_65.L_CORE X_NUC_118.L_CORE 0.002435
K_6934 X_NUC_65.L_CORE X_NUC_119.L_CORE 0.002201
K_6935 X_NUC_65.L_CORE X_NUC_120.L_CORE 0.004107
K_6936 X_NUC_65.L_CORE X_NUC_121.L_CORE 0.001999
K_6937 X_NUC_65.L_CORE X_NUC_122.L_CORE 0.002929
K_6938 X_NUC_65.L_CORE X_NUC_123.L_CORE 0.003170
K_6939 X_NUC_65.L_CORE X_NUC_124.L_CORE 0.001924
K_6940 X_NUC_65.L_CORE X_NUC_125.L_CORE 0.006828
K_6941 X_NUC_65.L_CORE X_NUC_126.L_CORE 0.002175
K_6942 X_NUC_65.L_CORE X_NUC_127.L_CORE 0.002356
K_6943 X_NUC_65.L_CORE X_NUC_128.L_CORE 0.006230
K_6944 X_NUC_65.L_CORE X_NUC_129.L_CORE 0.001887
K_6945 X_NUC_65.L_CORE X_NUC_130.L_CORE 0.004281
K_6946 X_NUC_65.L_CORE X_NUC_131.L_CORE 0.002791
K_6947 X_NUC_65.L_CORE X_NUC_132.L_CORE 0.002059
K_6948 X_NUC_65.L_CORE X_NUC_133.L_CORE 0.013536
K_6949 X_NUC_65.L_CORE X_NUC_134.L_CORE 0.002097
K_6950 X_NUC_65.L_CORE X_NUC_135.L_CORE 0.002870
K_6951 X_NUC_65.L_CORE X_NUC_136.L_CORE 0.003914
K_6952 X_NUC_65.L_CORE X_NUC_137.L_CORE 0.002097
K_6953 X_NUC_65.L_CORE X_NUC_138.L_CORE 0.004257
K_6954 X_NUC_65.L_CORE X_NUC_139.L_CORE 0.002627
K_6955 X_NUC_65.L_CORE X_NUC_140.L_CORE 0.002642
K_6956 X_NUC_66.L_CORE X_NUC_67.L_CORE 0.207973
K_6957 X_NUC_66.L_CORE X_NUC_68.L_CORE 0.207973
K_6958 X_NUC_66.L_CORE X_NUC_69.L_CORE 0.002174
K_6959 X_NUC_66.L_CORE X_NUC_70.L_CORE 0.002164
K_6960 X_NUC_66.L_CORE X_NUC_71.L_CORE 0.002159
K_6961 X_NUC_66.L_CORE X_NUC_72.L_CORE 0.002179
K_6962 X_NUC_66.L_CORE X_NUC_73.L_CORE 0.002970
K_6963 X_NUC_66.L_CORE X_NUC_74.L_CORE 0.002998
K_6964 X_NUC_66.L_CORE X_NUC_75.L_CORE 0.002965
K_6965 X_NUC_66.L_CORE X_NUC_76.L_CORE 0.002996
K_6966 X_NUC_66.L_CORE X_NUC_77.L_CORE 0.004607
K_6967 X_NUC_66.L_CORE X_NUC_78.L_CORE 0.004519
K_6968 X_NUC_66.L_CORE X_NUC_79.L_CORE 0.004525
K_6969 X_NUC_66.L_CORE X_NUC_80.L_CORE 0.004566
K_6970 X_NUC_66.L_CORE X_NUC_81.L_CORE 0.002077
K_6971 X_NUC_66.L_CORE X_NUC_82.L_CORE 0.002077
K_6972 X_NUC_66.L_CORE X_NUC_83.L_CORE 0.002065
K_6973 X_NUC_66.L_CORE X_NUC_84.L_CORE 0.002085
K_6974 X_NUC_66.L_CORE X_NUC_85.L_CORE 0.006129
K_6975 X_NUC_66.L_CORE X_NUC_86.L_CORE 0.006260
K_6976 X_NUC_66.L_CORE X_NUC_87.L_CORE 0.006083
K_6977 X_NUC_66.L_CORE X_NUC_88.L_CORE 0.006164
K_6978 X_NUC_66.L_CORE X_NUC_89.L_CORE 0.002654
K_6979 X_NUC_66.L_CORE X_NUC_90.L_CORE 0.002634
K_6980 X_NUC_66.L_CORE X_NUC_91.L_CORE 0.002625
K_6981 X_NUC_66.L_CORE X_NUC_92.L_CORE 0.002650
K_6982 X_NUC_66.L_CORE X_NUC_93.L_CORE 0.002481
K_6983 X_NUC_66.L_CORE X_NUC_94.L_CORE 0.002492
K_6984 X_NUC_66.L_CORE X_NUC_95.L_CORE 0.002467
K_6985 X_NUC_66.L_CORE X_NUC_96.L_CORE 0.002493
K_6986 X_NUC_66.L_CORE X_NUC_97.L_CORE 0.005910
K_6987 X_NUC_66.L_CORE X_NUC_98.L_CORE 0.005845
K_6988 X_NUC_66.L_CORE X_NUC_99.L_CORE 0.005749
K_6989 X_NUC_66.L_CORE X_NUC_100.L_CORE 0.005817
K_6990 X_NUC_66.L_CORE X_NUC_101.L_CORE 0.002307
K_6991 X_NUC_66.L_CORE X_NUC_102.L_CORE 0.002301
K_6992 X_NUC_66.L_CORE X_NUC_103.L_CORE 0.002286
K_6993 X_NUC_66.L_CORE X_NUC_104.L_CORE 0.002309
K_6994 X_NUC_66.L_CORE X_NUC_105.L_CORE 0.003462
K_6995 X_NUC_66.L_CORE X_NUC_106.L_CORE 0.003485
K_6996 X_NUC_66.L_CORE X_NUC_107.L_CORE 0.003430
K_6997 X_NUC_66.L_CORE X_NUC_108.L_CORE 0.003469
K_6998 X_NUC_66.L_CORE X_NUC_109.L_CORE 0.003276
K_6999 X_NUC_66.L_CORE X_NUC_110.L_CORE 0.003256
K_7000 X_NUC_66.L_CORE X_NUC_111.L_CORE 0.003227
K_7001 X_NUC_66.L_CORE X_NUC_112.L_CORE 0.003261
K_7002 X_NUC_66.L_CORE X_NUC_113.L_CORE 0.002691
K_7003 X_NUC_66.L_CORE X_NUC_114.L_CORE 0.002692
K_7004 X_NUC_66.L_CORE X_NUC_115.L_CORE 0.002664
K_7005 X_NUC_66.L_CORE X_NUC_116.L_CORE 0.002692
K_7006 X_NUC_66.L_CORE X_NUC_117.L_CORE 0.002772
K_7007 X_NUC_66.L_CORE X_NUC_118.L_CORE 0.002446
K_7008 X_NUC_66.L_CORE X_NUC_119.L_CORE 0.002195
K_7009 X_NUC_66.L_CORE X_NUC_120.L_CORE 0.004123
K_7010 X_NUC_66.L_CORE X_NUC_121.L_CORE 0.002005
K_7011 X_NUC_66.L_CORE X_NUC_122.L_CORE 0.002904
K_7012 X_NUC_66.L_CORE X_NUC_123.L_CORE 0.003207
K_7013 X_NUC_66.L_CORE X_NUC_124.L_CORE 0.001922
K_7014 X_NUC_66.L_CORE X_NUC_125.L_CORE 0.006690
K_7015 X_NUC_66.L_CORE X_NUC_126.L_CORE 0.002189
K_7016 X_NUC_66.L_CORE X_NUC_127.L_CORE 0.002341
K_7017 X_NUC_66.L_CORE X_NUC_128.L_CORE 0.006414
K_7018 X_NUC_66.L_CORE X_NUC_129.L_CORE 0.001890
K_7019 X_NUC_66.L_CORE X_NUC_130.L_CORE 0.004202
K_7020 X_NUC_66.L_CORE X_NUC_131.L_CORE 0.002823
K_7021 X_NUC_66.L_CORE X_NUC_132.L_CORE 0.002053
K_7022 X_NUC_66.L_CORE X_NUC_133.L_CORE 0.013524
K_7023 X_NUC_66.L_CORE X_NUC_134.L_CORE 0.002106
K_7024 X_NUC_66.L_CORE X_NUC_135.L_CORE 0.002846
K_7025 X_NUC_66.L_CORE X_NUC_136.L_CORE 0.003968
K_7026 X_NUC_66.L_CORE X_NUC_137.L_CORE 0.002097
K_7027 X_NUC_66.L_CORE X_NUC_138.L_CORE 0.004226
K_7028 X_NUC_66.L_CORE X_NUC_139.L_CORE 0.002640
K_7029 X_NUC_66.L_CORE X_NUC_140.L_CORE 0.002638
K_7030 X_NUC_67.L_CORE X_NUC_68.L_CORE 0.207973
K_7031 X_NUC_67.L_CORE X_NUC_69.L_CORE 0.002180
K_7032 X_NUC_67.L_CORE X_NUC_70.L_CORE 0.002170
K_7033 X_NUC_67.L_CORE X_NUC_71.L_CORE 0.002164
K_7034 X_NUC_67.L_CORE X_NUC_72.L_CORE 0.002185
K_7035 X_NUC_67.L_CORE X_NUC_73.L_CORE 0.003003
K_7036 X_NUC_67.L_CORE X_NUC_74.L_CORE 0.003032
K_7037 X_NUC_67.L_CORE X_NUC_75.L_CORE 0.002998
K_7038 X_NUC_67.L_CORE X_NUC_76.L_CORE 0.003030
K_7039 X_NUC_67.L_CORE X_NUC_77.L_CORE 0.004600
K_7040 X_NUC_67.L_CORE X_NUC_78.L_CORE 0.004511
K_7041 X_NUC_67.L_CORE X_NUC_79.L_CORE 0.004519
K_7042 X_NUC_67.L_CORE X_NUC_80.L_CORE 0.004558
K_7043 X_NUC_67.L_CORE X_NUC_81.L_CORE 0.002089
K_7044 X_NUC_67.L_CORE X_NUC_82.L_CORE 0.002089
K_7045 X_NUC_67.L_CORE X_NUC_83.L_CORE 0.002077
K_7046 X_NUC_67.L_CORE X_NUC_84.L_CORE 0.002098
K_7047 X_NUC_67.L_CORE X_NUC_85.L_CORE 0.006307
K_7048 X_NUC_67.L_CORE X_NUC_86.L_CORE 0.006447
K_7049 X_NUC_67.L_CORE X_NUC_87.L_CORE 0.006260
K_7050 X_NUC_67.L_CORE X_NUC_88.L_CORE 0.006345
K_7051 X_NUC_67.L_CORE X_NUC_89.L_CORE 0.002663
K_7052 X_NUC_67.L_CORE X_NUC_90.L_CORE 0.002643
K_7053 X_NUC_67.L_CORE X_NUC_91.L_CORE 0.002634
K_7054 X_NUC_67.L_CORE X_NUC_92.L_CORE 0.002659
K_7055 X_NUC_67.L_CORE X_NUC_93.L_CORE 0.002506
K_7056 X_NUC_67.L_CORE X_NUC_94.L_CORE 0.002517
K_7057 X_NUC_67.L_CORE X_NUC_95.L_CORE 0.002492
K_7058 X_NUC_67.L_CORE X_NUC_96.L_CORE 0.002518
K_7059 X_NUC_67.L_CORE X_NUC_97.L_CORE 0.006012
K_7060 X_NUC_67.L_CORE X_NUC_98.L_CORE 0.005941
K_7061 X_NUC_67.L_CORE X_NUC_99.L_CORE 0.005845
K_7062 X_NUC_67.L_CORE X_NUC_100.L_CORE 0.005914
K_7063 X_NUC_67.L_CORE X_NUC_101.L_CORE 0.002322
K_7064 X_NUC_67.L_CORE X_NUC_102.L_CORE 0.002316
K_7065 X_NUC_67.L_CORE X_NUC_103.L_CORE 0.002301
K_7066 X_NUC_67.L_CORE X_NUC_104.L_CORE 0.002324
K_7067 X_NUC_67.L_CORE X_NUC_105.L_CORE 0.003519
K_7068 X_NUC_67.L_CORE X_NUC_106.L_CORE 0.003543
K_7069 X_NUC_67.L_CORE X_NUC_107.L_CORE 0.003485
K_7070 X_NUC_67.L_CORE X_NUC_108.L_CORE 0.003526
K_7071 X_NUC_67.L_CORE X_NUC_109.L_CORE 0.003307
K_7072 X_NUC_67.L_CORE X_NUC_110.L_CORE 0.003285
K_7073 X_NUC_67.L_CORE X_NUC_111.L_CORE 0.003256
K_7074 X_NUC_67.L_CORE X_NUC_112.L_CORE 0.003290
K_7075 X_NUC_67.L_CORE X_NUC_113.L_CORE 0.002720
K_7076 X_NUC_67.L_CORE X_NUC_114.L_CORE 0.002721
K_7077 X_NUC_67.L_CORE X_NUC_115.L_CORE 0.002692
K_7078 X_NUC_67.L_CORE X_NUC_116.L_CORE 0.002721
K_7079 X_NUC_67.L_CORE X_NUC_117.L_CORE 0.002762
K_7080 X_NUC_67.L_CORE X_NUC_118.L_CORE 0.002436
K_7081 X_NUC_67.L_CORE X_NUC_119.L_CORE 0.002198
K_7082 X_NUC_67.L_CORE X_NUC_120.L_CORE 0.004069
K_7083 X_NUC_67.L_CORE X_NUC_121.L_CORE 0.002005
K_7084 X_NUC_67.L_CORE X_NUC_122.L_CORE 0.002913
K_7085 X_NUC_67.L_CORE X_NUC_123.L_CORE 0.003180
K_7086 X_NUC_67.L_CORE X_NUC_124.L_CORE 0.001928
K_7087 X_NUC_67.L_CORE X_NUC_125.L_CORE 0.006641
K_7088 X_NUC_67.L_CORE X_NUC_126.L_CORE 0.002187
K_7089 X_NUC_67.L_CORE X_NUC_127.L_CORE 0.002356
K_7090 X_NUC_67.L_CORE X_NUC_128.L_CORE 0.006279
K_7091 X_NUC_67.L_CORE X_NUC_129.L_CORE 0.001896
K_7092 X_NUC_67.L_CORE X_NUC_130.L_CORE 0.004259
K_7093 X_NUC_67.L_CORE X_NUC_131.L_CORE 0.002819
K_7094 X_NUC_67.L_CORE X_NUC_132.L_CORE 0.002067
K_7095 X_NUC_67.L_CORE X_NUC_133.L_CORE 0.014088
K_7096 X_NUC_67.L_CORE X_NUC_134.L_CORE 0.002114
K_7097 X_NUC_67.L_CORE X_NUC_135.L_CORE 0.002882
K_7098 X_NUC_67.L_CORE X_NUC_136.L_CORE 0.003986
K_7099 X_NUC_67.L_CORE X_NUC_137.L_CORE 0.002112
K_7100 X_NUC_67.L_CORE X_NUC_138.L_CORE 0.004313
K_7101 X_NUC_67.L_CORE X_NUC_139.L_CORE 0.002659
K_7102 X_NUC_67.L_CORE X_NUC_140.L_CORE 0.002668
K_7103 X_NUC_68.L_CORE X_NUC_69.L_CORE 0.002160
K_7104 X_NUC_68.L_CORE X_NUC_70.L_CORE 0.002150
K_7105 X_NUC_68.L_CORE X_NUC_71.L_CORE 0.002144
K_7106 X_NUC_68.L_CORE X_NUC_72.L_CORE 0.002164
K_7107 X_NUC_68.L_CORE X_NUC_73.L_CORE 0.002971
K_7108 X_NUC_68.L_CORE X_NUC_74.L_CORE 0.002999
K_7109 X_NUC_68.L_CORE X_NUC_75.L_CORE 0.002966
K_7110 X_NUC_68.L_CORE X_NUC_76.L_CORE 0.002998
K_7111 X_NUC_68.L_CORE X_NUC_77.L_CORE 0.004558
K_7112 X_NUC_68.L_CORE X_NUC_78.L_CORE 0.004472
K_7113 X_NUC_68.L_CORE X_NUC_79.L_CORE 0.004479
K_7114 X_NUC_68.L_CORE X_NUC_80.L_CORE 0.004519
K_7115 X_NUC_68.L_CORE X_NUC_81.L_CORE 0.002069
K_7116 X_NUC_68.L_CORE X_NUC_82.L_CORE 0.002069
K_7117 X_NUC_68.L_CORE X_NUC_83.L_CORE 0.002057
K_7118 X_NUC_68.L_CORE X_NUC_84.L_CORE 0.002077
K_7119 X_NUC_68.L_CORE X_NUC_85.L_CORE 0.006221
K_7120 X_NUC_68.L_CORE X_NUC_86.L_CORE 0.006355
K_7121 X_NUC_68.L_CORE X_NUC_87.L_CORE 0.006173
K_7122 X_NUC_68.L_CORE X_NUC_88.L_CORE 0.006260
K_7123 X_NUC_68.L_CORE X_NUC_89.L_CORE 0.002638
K_7124 X_NUC_68.L_CORE X_NUC_90.L_CORE 0.002618
K_7125 X_NUC_68.L_CORE X_NUC_91.L_CORE 0.002609
K_7126 X_NUC_68.L_CORE X_NUC_92.L_CORE 0.002634
K_7127 X_NUC_68.L_CORE X_NUC_93.L_CORE 0.002479
K_7128 X_NUC_68.L_CORE X_NUC_94.L_CORE 0.002490
K_7129 X_NUC_68.L_CORE X_NUC_95.L_CORE 0.002466
K_7130 X_NUC_68.L_CORE X_NUC_96.L_CORE 0.002492
K_7131 X_NUC_68.L_CORE X_NUC_97.L_CORE 0.005938
K_7132 X_NUC_68.L_CORE X_NUC_98.L_CORE 0.005869
K_7133 X_NUC_68.L_CORE X_NUC_99.L_CORE 0.005775
K_7134 X_NUC_68.L_CORE X_NUC_100.L_CORE 0.005845
K_7135 X_NUC_68.L_CORE X_NUC_101.L_CORE 0.002299
K_7136 X_NUC_68.L_CORE X_NUC_102.L_CORE 0.002293
K_7137 X_NUC_68.L_CORE X_NUC_103.L_CORE 0.002278
K_7138 X_NUC_68.L_CORE X_NUC_104.L_CORE 0.002301
K_7139 X_NUC_68.L_CORE X_NUC_105.L_CORE 0.003478
K_7140 X_NUC_68.L_CORE X_NUC_106.L_CORE 0.003501
K_7141 X_NUC_68.L_CORE X_NUC_107.L_CORE 0.003445
K_7142 X_NUC_68.L_CORE X_NUC_108.L_CORE 0.003485
K_7143 X_NUC_68.L_CORE X_NUC_109.L_CORE 0.003271
K_7144 X_NUC_68.L_CORE X_NUC_110.L_CORE 0.003251
K_7145 X_NUC_68.L_CORE X_NUC_111.L_CORE 0.003222
K_7146 X_NUC_68.L_CORE X_NUC_112.L_CORE 0.003256
K_7147 X_NUC_68.L_CORE X_NUC_113.L_CORE 0.002691
K_7148 X_NUC_68.L_CORE X_NUC_114.L_CORE 0.002691
K_7149 X_NUC_68.L_CORE X_NUC_115.L_CORE 0.002663
K_7150 X_NUC_68.L_CORE X_NUC_116.L_CORE 0.002692
K_7151 X_NUC_68.L_CORE X_NUC_117.L_CORE 0.002743
K_7152 X_NUC_68.L_CORE X_NUC_118.L_CORE 0.002418
K_7153 X_NUC_68.L_CORE X_NUC_119.L_CORE 0.002180
K_7154 X_NUC_68.L_CORE X_NUC_120.L_CORE 0.004052
K_7155 X_NUC_68.L_CORE X_NUC_121.L_CORE 0.001988
K_7156 X_NUC_68.L_CORE X_NUC_122.L_CORE 0.002890
K_7157 X_NUC_68.L_CORE X_NUC_123.L_CORE 0.003161
K_7158 X_NUC_68.L_CORE X_NUC_124.L_CORE 0.001912
K_7159 X_NUC_68.L_CORE X_NUC_125.L_CORE 0.006636
K_7160 X_NUC_68.L_CORE X_NUC_126.L_CORE 0.002170
K_7161 X_NUC_68.L_CORE X_NUC_127.L_CORE 0.002334
K_7162 X_NUC_68.L_CORE X_NUC_128.L_CORE 0.006281
K_7163 X_NUC_68.L_CORE X_NUC_129.L_CORE 0.001879
K_7164 X_NUC_68.L_CORE X_NUC_130.L_CORE 0.004223
K_7165 X_NUC_68.L_CORE X_NUC_131.L_CORE 0.002798
K_7166 X_NUC_68.L_CORE X_NUC_132.L_CORE 0.002048
K_7167 X_NUC_68.L_CORE X_NUC_133.L_CORE 0.014257
K_7168 X_NUC_68.L_CORE X_NUC_134.L_CORE 0.002095
K_7169 X_NUC_68.L_CORE X_NUC_135.L_CORE 0.002854
K_7170 X_NUC_68.L_CORE X_NUC_136.L_CORE 0.003956
K_7171 X_NUC_68.L_CORE X_NUC_137.L_CORE 0.002092
K_7172 X_NUC_68.L_CORE X_NUC_138.L_CORE 0.004271
K_7173 X_NUC_68.L_CORE X_NUC_139.L_CORE 0.002635
K_7174 X_NUC_68.L_CORE X_NUC_140.L_CORE 0.002642
K_7175 X_NUC_69.L_CORE X_NUC_70.L_CORE 0.207973
K_7176 X_NUC_69.L_CORE X_NUC_71.L_CORE 0.207973
K_7177 X_NUC_69.L_CORE X_NUC_72.L_CORE 0.207973
K_7178 X_NUC_69.L_CORE X_NUC_73.L_CORE 0.002197
K_7179 X_NUC_69.L_CORE X_NUC_74.L_CORE 0.002219
K_7180 X_NUC_69.L_CORE X_NUC_75.L_CORE 0.002211
K_7181 X_NUC_69.L_CORE X_NUC_76.L_CORE 0.002203
K_7182 X_NUC_69.L_CORE X_NUC_77.L_CORE 0.003051
K_7183 X_NUC_69.L_CORE X_NUC_78.L_CORE 0.003052
K_7184 X_NUC_69.L_CORE X_NUC_79.L_CORE 0.003070
K_7185 X_NUC_69.L_CORE X_NUC_80.L_CORE 0.003026
K_7186 X_NUC_69.L_CORE X_NUC_81.L_CORE 0.004605
K_7187 X_NUC_69.L_CORE X_NUC_82.L_CORE 0.004702
K_7188 X_NUC_69.L_CORE X_NUC_83.L_CORE 0.004620
K_7189 X_NUC_69.L_CORE X_NUC_84.L_CORE 0.004649
K_7190 X_NUC_69.L_CORE X_NUC_85.L_CORE 0.002128
K_7191 X_NUC_69.L_CORE X_NUC_86.L_CORE 0.002143
K_7192 X_NUC_69.L_CORE X_NUC_87.L_CORE 0.002141
K_7193 X_NUC_69.L_CORE X_NUC_88.L_CORE 0.002125
K_7194 X_NUC_69.L_CORE X_NUC_89.L_CORE 0.006326
K_7195 X_NUC_69.L_CORE X_NUC_90.L_CORE 0.006293
K_7196 X_NUC_69.L_CORE X_NUC_91.L_CORE 0.006312
K_7197 X_NUC_69.L_CORE X_NUC_92.L_CORE 0.006161
K_7198 X_NUC_69.L_CORE X_NUC_93.L_CORE 0.002716
K_7199 X_NUC_69.L_CORE X_NUC_94.L_CORE 0.002750
K_7200 X_NUC_69.L_CORE X_NUC_95.L_CORE 0.002729
K_7201 X_NUC_69.L_CORE X_NUC_96.L_CORE 0.002723
K_7202 X_NUC_69.L_CORE X_NUC_97.L_CORE 0.002583
K_7203 X_NUC_69.L_CORE X_NUC_98.L_CORE 0.002594
K_7204 X_NUC_69.L_CORE X_NUC_99.L_CORE 0.002596
K_7205 X_NUC_69.L_CORE X_NUC_100.L_CORE 0.002567
K_7206 X_NUC_69.L_CORE X_NUC_101.L_CORE 0.005686
K_7207 X_NUC_69.L_CORE X_NUC_102.L_CORE 0.005780
K_7208 X_NUC_69.L_CORE X_NUC_103.L_CORE 0.005654
K_7209 X_NUC_69.L_CORE X_NUC_104.L_CORE 0.005636
K_7210 X_NUC_69.L_CORE X_NUC_105.L_CORE 0.002431
K_7211 X_NUC_69.L_CORE X_NUC_106.L_CORE 0.002453
K_7212 X_NUC_69.L_CORE X_NUC_107.L_CORE 0.002442
K_7213 X_NUC_69.L_CORE X_NUC_108.L_CORE 0.002427
K_7214 X_NUC_69.L_CORE X_NUC_109.L_CORE 0.003538
K_7215 X_NUC_69.L_CORE X_NUC_110.L_CORE 0.003555
K_7216 X_NUC_69.L_CORE X_NUC_111.L_CORE 0.003542
K_7217 X_NUC_69.L_CORE X_NUC_112.L_CORE 0.003499
K_7218 X_NUC_69.L_CORE X_NUC_113.L_CORE 0.003303
K_7219 X_NUC_69.L_CORE X_NUC_114.L_CORE 0.003339
K_7220 X_NUC_69.L_CORE X_NUC_115.L_CORE 0.003307
K_7221 X_NUC_69.L_CORE X_NUC_116.L_CORE 0.003288
K_7222 X_NUC_69.L_CORE X_NUC_117.L_CORE 0.002190
K_7223 X_NUC_69.L_CORE X_NUC_118.L_CORE 0.002936
K_7224 X_NUC_69.L_CORE X_NUC_119.L_CORE 0.002393
K_7225 X_NUC_69.L_CORE X_NUC_120.L_CORE 0.002139
K_7226 X_NUC_69.L_CORE X_NUC_121.L_CORE 0.004290
K_7227 X_NUC_69.L_CORE X_NUC_122.L_CORE 0.001972
K_7228 X_NUC_69.L_CORE X_NUC_123.L_CORE 0.002899
K_7229 X_NUC_69.L_CORE X_NUC_124.L_CORE 0.003201
K_7230 X_NUC_69.L_CORE X_NUC_125.L_CORE 0.001916
K_7231 X_NUC_69.L_CORE X_NUC_126.L_CORE 0.006834
K_7232 X_NUC_69.L_CORE X_NUC_127.L_CORE 0.002194
K_7233 X_NUC_69.L_CORE X_NUC_128.L_CORE 0.002359
K_7234 X_NUC_69.L_CORE X_NUC_129.L_CORE 0.006463
K_7235 X_NUC_69.L_CORE X_NUC_130.L_CORE 0.001914
K_7236 X_NUC_69.L_CORE X_NUC_131.L_CORE 0.004279
K_7237 X_NUC_69.L_CORE X_NUC_132.L_CORE 0.002872
K_7238 X_NUC_69.L_CORE X_NUC_133.L_CORE 0.002103
K_7239 X_NUC_69.L_CORE X_NUC_134.L_CORE 0.012616
K_7240 X_NUC_69.L_CORE X_NUC_135.L_CORE 0.002175
K_7241 X_NUC_69.L_CORE X_NUC_136.L_CORE 0.002943
K_7242 X_NUC_69.L_CORE X_NUC_137.L_CORE 0.004016
K_7243 X_NUC_69.L_CORE X_NUC_138.L_CORE 0.002222
K_7244 X_NUC_69.L_CORE X_NUC_139.L_CORE 0.004051
K_7245 X_NUC_69.L_CORE X_NUC_140.L_CORE 0.002833
K_7246 X_NUC_70.L_CORE X_NUC_71.L_CORE 0.207973
K_7247 X_NUC_70.L_CORE X_NUC_72.L_CORE 0.207973
K_7248 X_NUC_70.L_CORE X_NUC_73.L_CORE 0.002176
K_7249 X_NUC_70.L_CORE X_NUC_74.L_CORE 0.002197
K_7250 X_NUC_70.L_CORE X_NUC_75.L_CORE 0.002190
K_7251 X_NUC_70.L_CORE X_NUC_76.L_CORE 0.002181
K_7252 X_NUC_70.L_CORE X_NUC_77.L_CORE 0.003050
K_7253 X_NUC_70.L_CORE X_NUC_78.L_CORE 0.003051
K_7254 X_NUC_70.L_CORE X_NUC_79.L_CORE 0.003070
K_7255 X_NUC_70.L_CORE X_NUC_80.L_CORE 0.003025
K_7256 X_NUC_70.L_CORE X_NUC_81.L_CORE 0.004512
K_7257 X_NUC_70.L_CORE X_NUC_82.L_CORE 0.004605
K_7258 X_NUC_70.L_CORE X_NUC_83.L_CORE 0.004527
K_7259 X_NUC_70.L_CORE X_NUC_84.L_CORE 0.004555
K_7260 X_NUC_70.L_CORE X_NUC_85.L_CORE 0.002114
K_7261 X_NUC_70.L_CORE X_NUC_86.L_CORE 0.002128
K_7262 X_NUC_70.L_CORE X_NUC_87.L_CORE 0.002126
K_7263 X_NUC_70.L_CORE X_NUC_88.L_CORE 0.002111
K_7264 X_NUC_70.L_CORE X_NUC_89.L_CORE 0.006354
K_7265 X_NUC_70.L_CORE X_NUC_90.L_CORE 0.006326
K_7266 X_NUC_70.L_CORE X_NUC_91.L_CORE 0.006343
K_7267 X_NUC_70.L_CORE X_NUC_92.L_CORE 0.006190
K_7268 X_NUC_70.L_CORE X_NUC_93.L_CORE 0.002683
K_7269 X_NUC_70.L_CORE X_NUC_94.L_CORE 0.002716
K_7270 X_NUC_70.L_CORE X_NUC_95.L_CORE 0.002695
K_7271 X_NUC_70.L_CORE X_NUC_96.L_CORE 0.002689
K_7272 X_NUC_70.L_CORE X_NUC_97.L_CORE 0.002572
K_7273 X_NUC_70.L_CORE X_NUC_98.L_CORE 0.002583
K_7274 X_NUC_70.L_CORE X_NUC_99.L_CORE 0.002584
K_7275 X_NUC_70.L_CORE X_NUC_100.L_CORE 0.002556
K_7276 X_NUC_70.L_CORE X_NUC_101.L_CORE 0.005593
K_7277 X_NUC_70.L_CORE X_NUC_102.L_CORE 0.005686
K_7278 X_NUC_70.L_CORE X_NUC_103.L_CORE 0.005564
K_7279 X_NUC_70.L_CORE X_NUC_104.L_CORE 0.005547
K_7280 X_NUC_70.L_CORE X_NUC_105.L_CORE 0.002410
K_7281 X_NUC_70.L_CORE X_NUC_106.L_CORE 0.002431
K_7282 X_NUC_70.L_CORE X_NUC_107.L_CORE 0.002420
K_7283 X_NUC_70.L_CORE X_NUC_108.L_CORE 0.002405
K_7284 X_NUC_70.L_CORE X_NUC_109.L_CORE 0.003521
K_7285 X_NUC_70.L_CORE X_NUC_110.L_CORE 0.003538
K_7286 X_NUC_70.L_CORE X_NUC_111.L_CORE 0.003526
K_7287 X_NUC_70.L_CORE X_NUC_112.L_CORE 0.003483
K_7288 X_NUC_70.L_CORE X_NUC_113.L_CORE 0.003267
K_7289 X_NUC_70.L_CORE X_NUC_114.L_CORE 0.003303
K_7290 X_NUC_70.L_CORE X_NUC_115.L_CORE 0.003271
K_7291 X_NUC_70.L_CORE X_NUC_116.L_CORE 0.003253
K_7292 X_NUC_70.L_CORE X_NUC_117.L_CORE 0.002178
K_7293 X_NUC_70.L_CORE X_NUC_118.L_CORE 0.002931
K_7294 X_NUC_70.L_CORE X_NUC_119.L_CORE 0.002372
K_7295 X_NUC_70.L_CORE X_NUC_120.L_CORE 0.002132
K_7296 X_NUC_70.L_CORE X_NUC_121.L_CORE 0.004269
K_7297 X_NUC_70.L_CORE X_NUC_122.L_CORE 0.001957
K_7298 X_NUC_70.L_CORE X_NUC_123.L_CORE 0.002903
K_7299 X_NUC_70.L_CORE X_NUC_124.L_CORE 0.003161
K_7300 X_NUC_70.L_CORE X_NUC_125.L_CORE 0.001906
K_7301 X_NUC_70.L_CORE X_NUC_126.L_CORE 0.006950
K_7302 X_NUC_70.L_CORE X_NUC_127.L_CORE 0.002172
K_7303 X_NUC_70.L_CORE X_NUC_128.L_CORE 0.002355
K_7304 X_NUC_70.L_CORE X_NUC_129.L_CORE 0.006326
K_7305 X_NUC_70.L_CORE X_NUC_130.L_CORE 0.001900
K_7306 X_NUC_70.L_CORE X_NUC_131.L_CORE 0.004314
K_7307 X_NUC_70.L_CORE X_NUC_132.L_CORE 0.002834
K_7308 X_NUC_70.L_CORE X_NUC_133.L_CORE 0.002094
K_7309 X_NUC_70.L_CORE X_NUC_134.L_CORE 0.012649
K_7310 X_NUC_70.L_CORE X_NUC_135.L_CORE 0.002154
K_7311 X_NUC_70.L_CORE X_NUC_136.L_CORE 0.002941
K_7312 X_NUC_70.L_CORE X_NUC_137.L_CORE 0.003955
K_7313 X_NUC_70.L_CORE X_NUC_138.L_CORE 0.002207
K_7314 X_NUC_70.L_CORE X_NUC_139.L_CORE 0.004036
K_7315 X_NUC_70.L_CORE X_NUC_140.L_CORE 0.002806
K_7316 X_NUC_71.L_CORE X_NUC_72.L_CORE 0.207973
K_7317 X_NUC_71.L_CORE X_NUC_73.L_CORE 0.002183
K_7318 X_NUC_71.L_CORE X_NUC_74.L_CORE 0.002204
K_7319 X_NUC_71.L_CORE X_NUC_75.L_CORE 0.002197
K_7320 X_NUC_71.L_CORE X_NUC_76.L_CORE 0.002188
K_7321 X_NUC_71.L_CORE X_NUC_77.L_CORE 0.003032
K_7322 X_NUC_71.L_CORE X_NUC_78.L_CORE 0.003033
K_7323 X_NUC_71.L_CORE X_NUC_79.L_CORE 0.003051
K_7324 X_NUC_71.L_CORE X_NUC_80.L_CORE 0.003007
K_7325 X_NUC_71.L_CORE X_NUC_81.L_CORE 0.004588
K_7326 X_NUC_71.L_CORE X_NUC_82.L_CORE 0.004685
K_7327 X_NUC_71.L_CORE X_NUC_83.L_CORE 0.004605
K_7328 X_NUC_71.L_CORE X_NUC_84.L_CORE 0.004633
K_7329 X_NUC_71.L_CORE X_NUC_85.L_CORE 0.002115
K_7330 X_NUC_71.L_CORE X_NUC_86.L_CORE 0.002130
K_7331 X_NUC_71.L_CORE X_NUC_87.L_CORE 0.002128
K_7332 X_NUC_71.L_CORE X_NUC_88.L_CORE 0.002112
K_7333 X_NUC_71.L_CORE X_NUC_89.L_CORE 0.006335
K_7334 X_NUC_71.L_CORE X_NUC_90.L_CORE 0.006304
K_7335 X_NUC_71.L_CORE X_NUC_91.L_CORE 0.006326
K_7336 X_NUC_71.L_CORE X_NUC_92.L_CORE 0.006171
K_7337 X_NUC_71.L_CORE X_NUC_93.L_CORE 0.002703
K_7338 X_NUC_71.L_CORE X_NUC_94.L_CORE 0.002737
K_7339 X_NUC_71.L_CORE X_NUC_95.L_CORE 0.002716
K_7340 X_NUC_71.L_CORE X_NUC_96.L_CORE 0.002710
K_7341 X_NUC_71.L_CORE X_NUC_97.L_CORE 0.002570
K_7342 X_NUC_71.L_CORE X_NUC_98.L_CORE 0.002581
K_7343 X_NUC_71.L_CORE X_NUC_99.L_CORE 0.002583
K_7344 X_NUC_71.L_CORE X_NUC_100.L_CORE 0.002555
K_7345 X_NUC_71.L_CORE X_NUC_101.L_CORE 0.005715
K_7346 X_NUC_71.L_CORE X_NUC_102.L_CORE 0.005812
K_7347 X_NUC_71.L_CORE X_NUC_103.L_CORE 0.005686
K_7348 X_NUC_71.L_CORE X_NUC_104.L_CORE 0.005666
K_7349 X_NUC_71.L_CORE X_NUC_105.L_CORE 0.002420
K_7350 X_NUC_71.L_CORE X_NUC_106.L_CORE 0.002442
K_7351 X_NUC_71.L_CORE X_NUC_107.L_CORE 0.002431
K_7352 X_NUC_71.L_CORE X_NUC_108.L_CORE 0.002416
K_7353 X_NUC_71.L_CORE X_NUC_109.L_CORE 0.003534
K_7354 X_NUC_71.L_CORE X_NUC_110.L_CORE 0.003550
K_7355 X_NUC_71.L_CORE X_NUC_111.L_CORE 0.003538
K_7356 X_NUC_71.L_CORE X_NUC_112.L_CORE 0.003494
K_7357 X_NUC_71.L_CORE X_NUC_113.L_CORE 0.003299
K_7358 X_NUC_71.L_CORE X_NUC_114.L_CORE 0.003335
K_7359 X_NUC_71.L_CORE X_NUC_115.L_CORE 0.003303
K_7360 X_NUC_71.L_CORE X_NUC_116.L_CORE 0.003284
K_7361 X_NUC_71.L_CORE X_NUC_117.L_CORE 0.002167
K_7362 X_NUC_71.L_CORE X_NUC_118.L_CORE 0.002899
K_7363 X_NUC_71.L_CORE X_NUC_119.L_CORE 0.002368
K_7364 X_NUC_71.L_CORE X_NUC_120.L_CORE 0.002119
K_7365 X_NUC_71.L_CORE X_NUC_121.L_CORE 0.004222
K_7366 X_NUC_71.L_CORE X_NUC_122.L_CORE 0.001955
K_7367 X_NUC_71.L_CORE X_NUC_123.L_CORE 0.002869
K_7368 X_NUC_71.L_CORE X_NUC_124.L_CORE 0.003170
K_7369 X_NUC_71.L_CORE X_NUC_125.L_CORE 0.001901
K_7370 X_NUC_71.L_CORE X_NUC_126.L_CORE 0.006727
K_7371 X_NUC_71.L_CORE X_NUC_127.L_CORE 0.002178
K_7372 X_NUC_71.L_CORE X_NUC_128.L_CORE 0.002341
K_7373 X_NUC_71.L_CORE X_NUC_129.L_CORE 0.006424
K_7374 X_NUC_71.L_CORE X_NUC_130.L_CORE 0.001901
K_7375 X_NUC_71.L_CORE X_NUC_131.L_CORE 0.004258
K_7376 X_NUC_71.L_CORE X_NUC_132.L_CORE 0.002858
K_7377 X_NUC_71.L_CORE X_NUC_133.L_CORE 0.002091
K_7378 X_NUC_71.L_CORE X_NUC_134.L_CORE 0.013216
K_7379 X_NUC_71.L_CORE X_NUC_135.L_CORE 0.002164
K_7380 X_NUC_71.L_CORE X_NUC_136.L_CORE 0.002934
K_7381 X_NUC_71.L_CORE X_NUC_137.L_CORE 0.004022
K_7382 X_NUC_71.L_CORE X_NUC_138.L_CORE 0.002213
K_7383 X_NUC_71.L_CORE X_NUC_139.L_CORE 0.004065
K_7384 X_NUC_71.L_CORE X_NUC_140.L_CORE 0.002829
K_7385 X_NUC_72.L_CORE X_NUC_73.L_CORE 0.002191
K_7386 X_NUC_72.L_CORE X_NUC_74.L_CORE 0.002213
K_7387 X_NUC_72.L_CORE X_NUC_75.L_CORE 0.002205
K_7388 X_NUC_72.L_CORE X_NUC_76.L_CORE 0.002197
K_7389 X_NUC_72.L_CORE X_NUC_77.L_CORE 0.003076
K_7390 X_NUC_72.L_CORE X_NUC_78.L_CORE 0.003077
K_7391 X_NUC_72.L_CORE X_NUC_79.L_CORE 0.003096
K_7392 X_NUC_72.L_CORE X_NUC_80.L_CORE 0.003051
K_7393 X_NUC_72.L_CORE X_NUC_81.L_CORE 0.004560
K_7394 X_NUC_72.L_CORE X_NUC_82.L_CORE 0.004655
K_7395 X_NUC_72.L_CORE X_NUC_83.L_CORE 0.004575
K_7396 X_NUC_72.L_CORE X_NUC_84.L_CORE 0.004605
K_7397 X_NUC_72.L_CORE X_NUC_85.L_CORE 0.002131
K_7398 X_NUC_72.L_CORE X_NUC_86.L_CORE 0.002146
K_7399 X_NUC_72.L_CORE X_NUC_87.L_CORE 0.002144
K_7400 X_NUC_72.L_CORE X_NUC_88.L_CORE 0.002128
K_7401 X_NUC_72.L_CORE X_NUC_89.L_CORE 0.006499
K_7402 X_NUC_72.L_CORE X_NUC_90.L_CORE 0.006466
K_7403 X_NUC_72.L_CORE X_NUC_91.L_CORE 0.006487
K_7404 X_NUC_72.L_CORE X_NUC_92.L_CORE 0.006326
K_7405 X_NUC_72.L_CORE X_NUC_93.L_CORE 0.002709
K_7406 X_NUC_72.L_CORE X_NUC_94.L_CORE 0.002743
K_7407 X_NUC_72.L_CORE X_NUC_95.L_CORE 0.002722
K_7408 X_NUC_72.L_CORE X_NUC_96.L_CORE 0.002716
K_7409 X_NUC_72.L_CORE X_NUC_97.L_CORE 0.002599
K_7410 X_NUC_72.L_CORE X_NUC_98.L_CORE 0.002610
K_7411 X_NUC_72.L_CORE X_NUC_99.L_CORE 0.002612
K_7412 X_NUC_72.L_CORE X_NUC_100.L_CORE 0.002583
K_7413 X_NUC_72.L_CORE X_NUC_101.L_CORE 0.005734
K_7414 X_NUC_72.L_CORE X_NUC_102.L_CORE 0.005832
K_7415 X_NUC_72.L_CORE X_NUC_103.L_CORE 0.005703
K_7416 X_NUC_72.L_CORE X_NUC_104.L_CORE 0.005686
K_7417 X_NUC_72.L_CORE X_NUC_105.L_CORE 0.002435
K_7418 X_NUC_72.L_CORE X_NUC_106.L_CORE 0.002457
K_7419 X_NUC_72.L_CORE X_NUC_107.L_CORE 0.002446
K_7420 X_NUC_72.L_CORE X_NUC_108.L_CORE 0.002431
K_7421 X_NUC_72.L_CORE X_NUC_109.L_CORE 0.003579
K_7422 X_NUC_72.L_CORE X_NUC_110.L_CORE 0.003596
K_7423 X_NUC_72.L_CORE X_NUC_111.L_CORE 0.003583
K_7424 X_NUC_72.L_CORE X_NUC_112.L_CORE 0.003538
K_7425 X_NUC_72.L_CORE X_NUC_113.L_CORE 0.003317
K_7426 X_NUC_72.L_CORE X_NUC_114.L_CORE 0.003355
K_7427 X_NUC_72.L_CORE X_NUC_115.L_CORE 0.003321
K_7428 X_NUC_72.L_CORE X_NUC_116.L_CORE 0.003303
K_7429 X_NUC_72.L_CORE X_NUC_117.L_CORE 0.002178
K_7430 X_NUC_72.L_CORE X_NUC_118.L_CORE 0.002918
K_7431 X_NUC_72.L_CORE X_NUC_119.L_CORE 0.002372
K_7432 X_NUC_72.L_CORE X_NUC_120.L_CORE 0.002136
K_7433 X_NUC_72.L_CORE X_NUC_121.L_CORE 0.004217
K_7434 X_NUC_72.L_CORE X_NUC_122.L_CORE 0.001963
K_7435 X_NUC_72.L_CORE X_NUC_123.L_CORE 0.002903
K_7436 X_NUC_72.L_CORE X_NUC_124.L_CORE 0.003157
K_7437 X_NUC_72.L_CORE X_NUC_125.L_CORE 0.001914
K_7438 X_NUC_72.L_CORE X_NUC_126.L_CORE 0.006817
K_7439 X_NUC_72.L_CORE X_NUC_127.L_CORE 0.002182
K_7440 X_NUC_72.L_CORE X_NUC_128.L_CORE 0.002367
K_7441 X_NUC_72.L_CORE X_NUC_129.L_CORE 0.006293
K_7442 X_NUC_72.L_CORE X_NUC_130.L_CORE 0.001912
K_7443 X_NUC_72.L_CORE X_NUC_131.L_CORE 0.004340
K_7444 X_NUC_72.L_CORE X_NUC_132.L_CORE 0.002853
K_7445 X_NUC_72.L_CORE X_NUC_133.L_CORE 0.002110
K_7446 X_NUC_72.L_CORE X_NUC_134.L_CORE 0.013181
K_7447 X_NUC_72.L_CORE X_NUC_135.L_CORE 0.002172
K_7448 X_NUC_72.L_CORE X_NUC_136.L_CORE 0.002973
K_7449 X_NUC_72.L_CORE X_NUC_137.L_CORE 0.004012
K_7450 X_NUC_72.L_CORE X_NUC_138.L_CORE 0.002229
K_7451 X_NUC_72.L_CORE X_NUC_139.L_CORE 0.004112
K_7452 X_NUC_72.L_CORE X_NUC_140.L_CORE 0.002843
K_7453 X_NUC_73.L_CORE X_NUC_74.L_CORE 0.207973
K_7454 X_NUC_73.L_CORE X_NUC_75.L_CORE 0.207973
K_7455 X_NUC_73.L_CORE X_NUC_76.L_CORE 0.207973
K_7456 X_NUC_73.L_CORE X_NUC_77.L_CORE 0.002243
K_7457 X_NUC_73.L_CORE X_NUC_78.L_CORE 0.002220
K_7458 X_NUC_73.L_CORE X_NUC_79.L_CORE 0.002235
K_7459 X_NUC_73.L_CORE X_NUC_80.L_CORE 0.002227
K_7460 X_NUC_73.L_CORE X_NUC_81.L_CORE 0.003124
K_7461 X_NUC_73.L_CORE X_NUC_82.L_CORE 0.003092
K_7462 X_NUC_73.L_CORE X_NUC_83.L_CORE 0.003088
K_7463 X_NUC_73.L_CORE X_NUC_84.L_CORE 0.003121
K_7464 X_NUC_73.L_CORE X_NUC_85.L_CORE 0.004719
K_7465 X_NUC_73.L_CORE X_NUC_86.L_CORE 0.004664
K_7466 X_NUC_73.L_CORE X_NUC_87.L_CORE 0.004716
K_7467 X_NUC_73.L_CORE X_NUC_88.L_CORE 0.004630
K_7468 X_NUC_73.L_CORE X_NUC_89.L_CORE 0.002196
K_7469 X_NUC_73.L_CORE X_NUC_90.L_CORE 0.002174
K_7470 X_NUC_73.L_CORE X_NUC_91.L_CORE 0.002182
K_7471 X_NUC_73.L_CORE X_NUC_92.L_CORE 0.002183
K_7472 X_NUC_73.L_CORE X_NUC_93.L_CORE 0.006399
K_7473 X_NUC_73.L_CORE X_NUC_94.L_CORE 0.006304
K_7474 X_NUC_73.L_CORE X_NUC_95.L_CORE 0.006213
K_7475 X_NUC_73.L_CORE X_NUC_96.L_CORE 0.006339
K_7476 X_NUC_73.L_CORE X_NUC_97.L_CORE 0.002824
K_7477 X_NUC_73.L_CORE X_NUC_98.L_CORE 0.002793
K_7478 X_NUC_73.L_CORE X_NUC_99.L_CORE 0.002810
K_7479 X_NUC_73.L_CORE X_NUC_100.L_CORE 0.002791
K_7480 X_NUC_73.L_CORE X_NUC_101.L_CORE 0.002705
K_7481 X_NUC_73.L_CORE X_NUC_102.L_CORE 0.002675
K_7482 X_NUC_73.L_CORE X_NUC_103.L_CORE 0.002675
K_7483 X_NUC_73.L_CORE X_NUC_104.L_CORE 0.002689
K_7484 X_NUC_73.L_CORE X_NUC_105.L_CORE 0.005461
K_7485 X_NUC_73.L_CORE X_NUC_106.L_CORE 0.005375
K_7486 X_NUC_73.L_CORE X_NUC_107.L_CORE 0.005361
K_7487 X_NUC_73.L_CORE X_NUC_108.L_CORE 0.005325
K_7488 X_NUC_73.L_CORE X_NUC_109.L_CORE 0.002625
K_7489 X_NUC_73.L_CORE X_NUC_110.L_CORE 0.002595
K_7490 X_NUC_73.L_CORE X_NUC_111.L_CORE 0.002602
K_7491 X_NUC_73.L_CORE X_NUC_112.L_CORE 0.002599
K_7492 X_NUC_73.L_CORE X_NUC_113.L_CORE 0.003548
K_7493 X_NUC_73.L_CORE X_NUC_114.L_CORE 0.003502
K_7494 X_NUC_73.L_CORE X_NUC_115.L_CORE 0.003493
K_7495 X_NUC_73.L_CORE X_NUC_116.L_CORE 0.003505
K_7496 X_NUC_73.L_CORE X_NUC_117.L_CORE 0.002560
K_7497 X_NUC_73.L_CORE X_NUC_118.L_CORE 0.002024
K_7498 X_NUC_73.L_CORE X_NUC_119.L_CORE 0.003019
K_7499 X_NUC_73.L_CORE X_NUC_120.L_CORE 0.002335
K_7500 X_NUC_73.L_CORE X_NUC_121.L_CORE 0.002087
K_7501 X_NUC_73.L_CORE X_NUC_122.L_CORE 0.004411
K_7502 X_NUC_73.L_CORE X_NUC_123.L_CORE 0.001934
K_7503 X_NUC_73.L_CORE X_NUC_124.L_CORE 0.002887
K_7504 X_NUC_73.L_CORE X_NUC_125.L_CORE 0.003176
K_7505 X_NUC_73.L_CORE X_NUC_126.L_CORE 0.001902
K_7506 X_NUC_73.L_CORE X_NUC_127.L_CORE 0.007039
K_7507 X_NUC_73.L_CORE X_NUC_128.L_CORE 0.002188
K_7508 X_NUC_73.L_CORE X_NUC_129.L_CORE 0.002370
K_7509 X_NUC_73.L_CORE X_NUC_130.L_CORE 0.006496
K_7510 X_NUC_73.L_CORE X_NUC_131.L_CORE 0.001929
K_7511 X_NUC_73.L_CORE X_NUC_132.L_CORE 0.004364
K_7512 X_NUC_73.L_CORE X_NUC_133.L_CORE 0.002906
K_7513 X_NUC_73.L_CORE X_NUC_134.L_CORE 0.002148
K_7514 X_NUC_73.L_CORE X_NUC_135.L_CORE 0.011704
K_7515 X_NUC_73.L_CORE X_NUC_136.L_CORE 0.002240
K_7516 X_NUC_73.L_CORE X_NUC_137.L_CORE 0.003039
K_7517 X_NUC_73.L_CORE X_NUC_138.L_CORE 0.004004
K_7518 X_NUC_73.L_CORE X_NUC_139.L_CORE 0.002383
K_7519 X_NUC_73.L_CORE X_NUC_140.L_CORE 0.003675
K_7520 X_NUC_74.L_CORE X_NUC_75.L_CORE 0.207973
K_7521 X_NUC_74.L_CORE X_NUC_76.L_CORE 0.207973
K_7522 X_NUC_74.L_CORE X_NUC_77.L_CORE 0.002266
K_7523 X_NUC_74.L_CORE X_NUC_78.L_CORE 0.002243
K_7524 X_NUC_74.L_CORE X_NUC_79.L_CORE 0.002258
K_7525 X_NUC_74.L_CORE X_NUC_80.L_CORE 0.002249
K_7526 X_NUC_74.L_CORE X_NUC_81.L_CORE 0.003157
K_7527 X_NUC_74.L_CORE X_NUC_82.L_CORE 0.003124
K_7528 X_NUC_74.L_CORE X_NUC_83.L_CORE 0.003119
K_7529 X_NUC_74.L_CORE X_NUC_84.L_CORE 0.003153
K_7530 X_NUC_74.L_CORE X_NUC_85.L_CORE 0.004774
K_7531 X_NUC_74.L_CORE X_NUC_86.L_CORE 0.004719
K_7532 X_NUC_74.L_CORE X_NUC_87.L_CORE 0.004772
K_7533 X_NUC_74.L_CORE X_NUC_88.L_CORE 0.004683
K_7534 X_NUC_74.L_CORE X_NUC_89.L_CORE 0.002220
K_7535 X_NUC_74.L_CORE X_NUC_90.L_CORE 0.002196
K_7536 X_NUC_74.L_CORE X_NUC_91.L_CORE 0.002204
K_7537 X_NUC_74.L_CORE X_NUC_92.L_CORE 0.002206
K_7538 X_NUC_74.L_CORE X_NUC_93.L_CORE 0.006493
K_7539 X_NUC_74.L_CORE X_NUC_94.L_CORE 0.006399
K_7540 X_NUC_74.L_CORE X_NUC_95.L_CORE 0.006302
K_7541 X_NUC_74.L_CORE X_NUC_96.L_CORE 0.006433
K_7542 X_NUC_74.L_CORE X_NUC_97.L_CORE 0.002856
K_7543 X_NUC_74.L_CORE X_NUC_98.L_CORE 0.002824
K_7544 X_NUC_74.L_CORE X_NUC_99.L_CORE 0.002841
K_7545 X_NUC_74.L_CORE X_NUC_100.L_CORE 0.002822
K_7546 X_NUC_74.L_CORE X_NUC_101.L_CORE 0.002736
K_7547 X_NUC_74.L_CORE X_NUC_102.L_CORE 0.002705
K_7548 X_NUC_74.L_CORE X_NUC_103.L_CORE 0.002705
K_7549 X_NUC_74.L_CORE X_NUC_104.L_CORE 0.002719
K_7550 X_NUC_74.L_CORE X_NUC_105.L_CORE 0.005546
K_7551 X_NUC_74.L_CORE X_NUC_106.L_CORE 0.005461
K_7552 X_NUC_74.L_CORE X_NUC_107.L_CORE 0.005444
K_7553 X_NUC_74.L_CORE X_NUC_108.L_CORE 0.005407
K_7554 X_NUC_74.L_CORE X_NUC_109.L_CORE 0.002655
K_7555 X_NUC_74.L_CORE X_NUC_110.L_CORE 0.002625
K_7556 X_NUC_74.L_CORE X_NUC_111.L_CORE 0.002632
K_7557 X_NUC_74.L_CORE X_NUC_112.L_CORE 0.002628
K_7558 X_NUC_74.L_CORE X_NUC_113.L_CORE 0.003594
K_7559 X_NUC_74.L_CORE X_NUC_114.L_CORE 0.003548
K_7560 X_NUC_74.L_CORE X_NUC_115.L_CORE 0.003537
K_7561 X_NUC_74.L_CORE X_NUC_116.L_CORE 0.003550
K_7562 X_NUC_74.L_CORE X_NUC_117.L_CORE 0.002575
K_7563 X_NUC_74.L_CORE X_NUC_118.L_CORE 0.002040
K_7564 X_NUC_74.L_CORE X_NUC_119.L_CORE 0.003033
K_7565 X_NUC_74.L_CORE X_NUC_120.L_CORE 0.002351
K_7566 X_NUC_74.L_CORE X_NUC_121.L_CORE 0.002103
K_7567 X_NUC_74.L_CORE X_NUC_122.L_CORE 0.004415
K_7568 X_NUC_74.L_CORE X_NUC_123.L_CORE 0.001950
K_7569 X_NUC_74.L_CORE X_NUC_124.L_CORE 0.002906
K_7570 X_NUC_74.L_CORE X_NUC_125.L_CORE 0.003196
K_7571 X_NUC_74.L_CORE X_NUC_126.L_CORE 0.001919
K_7572 X_NUC_74.L_CORE X_NUC_127.L_CORE 0.007004
K_7573 X_NUC_74.L_CORE X_NUC_128.L_CORE 0.002207
K_7574 X_NUC_74.L_CORE X_NUC_129.L_CORE 0.002390
K_7575 X_NUC_74.L_CORE X_NUC_130.L_CORE 0.006503
K_7576 X_NUC_74.L_CORE X_NUC_131.L_CORE 0.001947
K_7577 X_NUC_74.L_CORE X_NUC_132.L_CORE 0.004395
K_7578 X_NUC_74.L_CORE X_NUC_133.L_CORE 0.002933
K_7579 X_NUC_74.L_CORE X_NUC_134.L_CORE 0.002169
K_7580 X_NUC_74.L_CORE X_NUC_135.L_CORE 0.011740
K_7581 X_NUC_74.L_CORE X_NUC_136.L_CORE 0.002262
K_7582 X_NUC_74.L_CORE X_NUC_137.L_CORE 0.003069
K_7583 X_NUC_74.L_CORE X_NUC_138.L_CORE 0.004047
K_7584 X_NUC_74.L_CORE X_NUC_139.L_CORE 0.002407
K_7585 X_NUC_74.L_CORE X_NUC_140.L_CORE 0.003718
K_7586 X_NUC_75.L_CORE X_NUC_76.L_CORE 0.207973
K_7587 X_NUC_75.L_CORE X_NUC_77.L_CORE 0.002250
K_7588 X_NUC_75.L_CORE X_NUC_78.L_CORE 0.002228
K_7589 X_NUC_75.L_CORE X_NUC_79.L_CORE 0.002243
K_7590 X_NUC_75.L_CORE X_NUC_80.L_CORE 0.002234
K_7591 X_NUC_75.L_CORE X_NUC_81.L_CORE 0.003161
K_7592 X_NUC_75.L_CORE X_NUC_82.L_CORE 0.003128
K_7593 X_NUC_75.L_CORE X_NUC_83.L_CORE 0.003124
K_7594 X_NUC_75.L_CORE X_NUC_84.L_CORE 0.003158
K_7595 X_NUC_75.L_CORE X_NUC_85.L_CORE 0.004720
K_7596 X_NUC_75.L_CORE X_NUC_86.L_CORE 0.004666
K_7597 X_NUC_75.L_CORE X_NUC_87.L_CORE 0.004719
K_7598 X_NUC_75.L_CORE X_NUC_88.L_CORE 0.004632
K_7599 X_NUC_75.L_CORE X_NUC_89.L_CORE 0.002211
K_7600 X_NUC_75.L_CORE X_NUC_90.L_CORE 0.002188
K_7601 X_NUC_75.L_CORE X_NUC_91.L_CORE 0.002196
K_7602 X_NUC_75.L_CORE X_NUC_92.L_CORE 0.002198
K_7603 X_NUC_75.L_CORE X_NUC_93.L_CORE 0.006596
K_7604 X_NUC_75.L_CORE X_NUC_94.L_CORE 0.006495
K_7605 X_NUC_75.L_CORE X_NUC_95.L_CORE 0.006399
K_7606 X_NUC_75.L_CORE X_NUC_96.L_CORE 0.006534
K_7607 X_NUC_75.L_CORE X_NUC_97.L_CORE 0.002838
K_7608 X_NUC_75.L_CORE X_NUC_98.L_CORE 0.002807
K_7609 X_NUC_75.L_CORE X_NUC_99.L_CORE 0.002824
K_7610 X_NUC_75.L_CORE X_NUC_100.L_CORE 0.002805
K_7611 X_NUC_75.L_CORE X_NUC_101.L_CORE 0.002736
K_7612 X_NUC_75.L_CORE X_NUC_102.L_CORE 0.002705
K_7613 X_NUC_75.L_CORE X_NUC_103.L_CORE 0.002705
K_7614 X_NUC_75.L_CORE X_NUC_104.L_CORE 0.002719
K_7615 X_NUC_75.L_CORE X_NUC_105.L_CORE 0.005562
K_7616 X_NUC_75.L_CORE X_NUC_106.L_CORE 0.005474
K_7617 X_NUC_75.L_CORE X_NUC_107.L_CORE 0.005461
K_7618 X_NUC_75.L_CORE X_NUC_108.L_CORE 0.005422
K_7619 X_NUC_75.L_CORE X_NUC_109.L_CORE 0.002648
K_7620 X_NUC_75.L_CORE X_NUC_110.L_CORE 0.002618
K_7621 X_NUC_75.L_CORE X_NUC_111.L_CORE 0.002625
K_7622 X_NUC_75.L_CORE X_NUC_112.L_CORE 0.002621
K_7623 X_NUC_75.L_CORE X_NUC_113.L_CORE 0.003604
K_7624 X_NUC_75.L_CORE X_NUC_114.L_CORE 0.003557
K_7625 X_NUC_75.L_CORE X_NUC_115.L_CORE 0.003548
K_7626 X_NUC_75.L_CORE X_NUC_116.L_CORE 0.003560
K_7627 X_NUC_75.L_CORE X_NUC_117.L_CORE 0.002546
K_7628 X_NUC_75.L_CORE X_NUC_118.L_CORE 0.002023
K_7629 X_NUC_75.L_CORE X_NUC_119.L_CORE 0.003006
K_7630 X_NUC_75.L_CORE X_NUC_120.L_CORE 0.002325
K_7631 X_NUC_75.L_CORE X_NUC_121.L_CORE 0.002091
K_7632 X_NUC_75.L_CORE X_NUC_122.L_CORE 0.004339
K_7633 X_NUC_75.L_CORE X_NUC_123.L_CORE 0.001935
K_7634 X_NUC_75.L_CORE X_NUC_124.L_CORE 0.002897
K_7635 X_NUC_75.L_CORE X_NUC_125.L_CORE 0.003151
K_7636 X_NUC_75.L_CORE X_NUC_126.L_CORE 0.001909
K_7637 X_NUC_75.L_CORE X_NUC_127.L_CORE 0.006979
K_7638 X_NUC_75.L_CORE X_NUC_128.L_CORE 0.002188
K_7639 X_NUC_75.L_CORE X_NUC_129.L_CORE 0.002386
K_7640 X_NUC_75.L_CORE X_NUC_130.L_CORE 0.006372
K_7641 X_NUC_75.L_CORE X_NUC_131.L_CORE 0.001937
K_7642 X_NUC_75.L_CORE X_NUC_132.L_CORE 0.004428
K_7643 X_NUC_75.L_CORE X_NUC_133.L_CORE 0.002907
K_7644 X_NUC_75.L_CORE X_NUC_134.L_CORE 0.002165
K_7645 X_NUC_75.L_CORE X_NUC_135.L_CORE 0.012207
K_7646 X_NUC_75.L_CORE X_NUC_136.L_CORE 0.002251
K_7647 X_NUC_75.L_CORE X_NUC_137.L_CORE 0.003081
K_7648 X_NUC_75.L_CORE X_NUC_138.L_CORE 0.004038
K_7649 X_NUC_75.L_CORE X_NUC_139.L_CORE 0.002404
K_7650 X_NUC_75.L_CORE X_NUC_140.L_CORE 0.003737
K_7651 X_NUC_76.L_CORE X_NUC_77.L_CORE 0.002259
K_7652 X_NUC_76.L_CORE X_NUC_78.L_CORE 0.002236
K_7653 X_NUC_76.L_CORE X_NUC_79.L_CORE 0.002251
K_7654 X_NUC_76.L_CORE X_NUC_80.L_CORE 0.002243
K_7655 X_NUC_76.L_CORE X_NUC_81.L_CORE 0.003127
K_7656 X_NUC_76.L_CORE X_NUC_82.L_CORE 0.003095
K_7657 X_NUC_76.L_CORE X_NUC_83.L_CORE 0.003091
K_7658 X_NUC_76.L_CORE X_NUC_84.L_CORE 0.003124
K_7659 X_NUC_76.L_CORE X_NUC_85.L_CORE 0.004811
K_7660 X_NUC_76.L_CORE X_NUC_86.L_CORE 0.004754
K_7661 X_NUC_76.L_CORE X_NUC_87.L_CORE 0.004809
K_7662 X_NUC_76.L_CORE X_NUC_88.L_CORE 0.004719
K_7663 X_NUC_76.L_CORE X_NUC_89.L_CORE 0.002209
K_7664 X_NUC_76.L_CORE X_NUC_90.L_CORE 0.002187
K_7665 X_NUC_76.L_CORE X_NUC_91.L_CORE 0.002194
K_7666 X_NUC_76.L_CORE X_NUC_92.L_CORE 0.002196
K_7667 X_NUC_76.L_CORE X_NUC_93.L_CORE 0.006455
K_7668 X_NUC_76.L_CORE X_NUC_94.L_CORE 0.006360
K_7669 X_NUC_76.L_CORE X_NUC_95.L_CORE 0.006267
K_7670 X_NUC_76.L_CORE X_NUC_96.L_CORE 0.006399
K_7671 X_NUC_76.L_CORE X_NUC_97.L_CORE 0.002857
K_7672 X_NUC_76.L_CORE X_NUC_98.L_CORE 0.002825
K_7673 X_NUC_76.L_CORE X_NUC_99.L_CORE 0.002843
K_7674 X_NUC_76.L_CORE X_NUC_100.L_CORE 0.002824
K_7675 X_NUC_76.L_CORE X_NUC_101.L_CORE 0.002721
K_7676 X_NUC_76.L_CORE X_NUC_102.L_CORE 0.002691
K_7677 X_NUC_76.L_CORE X_NUC_103.L_CORE 0.002691
K_7678 X_NUC_76.L_CORE X_NUC_104.L_CORE 0.002705
K_7679 X_NUC_76.L_CORE X_NUC_105.L_CORE 0.005603
K_7680 X_NUC_76.L_CORE X_NUC_106.L_CORE 0.005512
K_7681 X_NUC_76.L_CORE X_NUC_107.L_CORE 0.005497
K_7682 X_NUC_76.L_CORE X_NUC_108.L_CORE 0.005461
K_7683 X_NUC_76.L_CORE X_NUC_109.L_CORE 0.002652
K_7684 X_NUC_76.L_CORE X_NUC_110.L_CORE 0.002621
K_7685 X_NUC_76.L_CORE X_NUC_111.L_CORE 0.002628
K_7686 X_NUC_76.L_CORE X_NUC_112.L_CORE 0.002625
K_7687 X_NUC_76.L_CORE X_NUC_113.L_CORE 0.003591
K_7688 X_NUC_76.L_CORE X_NUC_114.L_CORE 0.003544
K_7689 X_NUC_76.L_CORE X_NUC_115.L_CORE 0.003534
K_7690 X_NUC_76.L_CORE X_NUC_116.L_CORE 0.003548
K_7691 X_NUC_76.L_CORE X_NUC_117.L_CORE 0.002550
K_7692 X_NUC_76.L_CORE X_NUC_118.L_CORE 0.002023
K_7693 X_NUC_76.L_CORE X_NUC_119.L_CORE 0.002992
K_7694 X_NUC_76.L_CORE X_NUC_120.L_CORE 0.002337
K_7695 X_NUC_76.L_CORE X_NUC_121.L_CORE 0.002083
K_7696 X_NUC_76.L_CORE X_NUC_122.L_CORE 0.004359
K_7697 X_NUC_76.L_CORE X_NUC_123.L_CORE 0.001939
K_7698 X_NUC_76.L_CORE X_NUC_124.L_CORE 0.002868
K_7699 X_NUC_76.L_CORE X_NUC_125.L_CORE 0.003188
K_7700 X_NUC_76.L_CORE X_NUC_126.L_CORE 0.001905
K_7701 X_NUC_76.L_CORE X_NUC_127.L_CORE 0.006827
K_7702 X_NUC_76.L_CORE X_NUC_128.L_CORE 0.002201
K_7703 X_NUC_76.L_CORE X_NUC_129.L_CORE 0.002369
K_7704 X_NUC_76.L_CORE X_NUC_130.L_CORE 0.006568
K_7705 X_NUC_76.L_CORE X_NUC_131.L_CORE 0.001939
K_7706 X_NUC_76.L_CORE X_NUC_132.L_CORE 0.004341
K_7707 X_NUC_76.L_CORE X_NUC_133.L_CORE 0.002938
K_7708 X_NUC_76.L_CORE X_NUC_134.L_CORE 0.002156
K_7709 X_NUC_76.L_CORE X_NUC_135.L_CORE 0.012207
K_7710 X_NUC_76.L_CORE X_NUC_136.L_CORE 0.002259
K_7711 X_NUC_76.L_CORE X_NUC_137.L_CORE 0.003053
K_7712 X_NUC_76.L_CORE X_NUC_138.L_CORE 0.004082
K_7713 X_NUC_76.L_CORE X_NUC_139.L_CORE 0.002402
K_7714 X_NUC_76.L_CORE X_NUC_140.L_CORE 0.003726
K_7715 X_NUC_77.L_CORE X_NUC_78.L_CORE 0.207973
K_7716 X_NUC_77.L_CORE X_NUC_79.L_CORE 0.207973
K_7717 X_NUC_77.L_CORE X_NUC_80.L_CORE 0.207973
K_7718 X_NUC_77.L_CORE X_NUC_81.L_CORE 0.002304
K_7719 X_NUC_77.L_CORE X_NUC_82.L_CORE 0.002316
K_7720 X_NUC_77.L_CORE X_NUC_83.L_CORE 0.002298
K_7721 X_NUC_77.L_CORE X_NUC_84.L_CORE 0.002321
K_7722 X_NUC_77.L_CORE X_NUC_85.L_CORE 0.003220
K_7723 X_NUC_77.L_CORE X_NUC_86.L_CORE 0.003271
K_7724 X_NUC_77.L_CORE X_NUC_87.L_CORE 0.003242
K_7725 X_NUC_77.L_CORE X_NUC_88.L_CORE 0.003240
K_7726 X_NUC_77.L_CORE X_NUC_89.L_CORE 0.004867
K_7727 X_NUC_77.L_CORE X_NUC_90.L_CORE 0.004848
K_7728 X_NUC_77.L_CORE X_NUC_91.L_CORE 0.004784
K_7729 X_NUC_77.L_CORE X_NUC_92.L_CORE 0.004891
K_7730 X_NUC_77.L_CORE X_NUC_93.L_CORE 0.002287
K_7731 X_NUC_77.L_CORE X_NUC_94.L_CORE 0.002306
K_7732 X_NUC_77.L_CORE X_NUC_95.L_CORE 0.002286
K_7733 X_NUC_77.L_CORE X_NUC_96.L_CORE 0.002301
K_7734 X_NUC_77.L_CORE X_NUC_97.L_CORE 0.006470
K_7735 X_NUC_77.L_CORE X_NUC_98.L_CORE 0.006639
K_7736 X_NUC_77.L_CORE X_NUC_99.L_CORE 0.006481
K_7737 X_NUC_77.L_CORE X_NUC_100.L_CORE 0.006459
K_7738 X_NUC_77.L_CORE X_NUC_101.L_CORE 0.002967
K_7739 X_NUC_77.L_CORE X_NUC_102.L_CORE 0.002979
K_7740 X_NUC_77.L_CORE X_NUC_103.L_CORE 0.002945
K_7741 X_NUC_77.L_CORE X_NUC_104.L_CORE 0.002983
K_7742 X_NUC_77.L_CORE X_NUC_105.L_CORE 0.002872
K_7743 X_NUC_77.L_CORE X_NUC_106.L_CORE 0.002908
K_7744 X_NUC_77.L_CORE X_NUC_107.L_CORE 0.002873
K_7745 X_NUC_77.L_CORE X_NUC_108.L_CORE 0.002886
K_7746 X_NUC_77.L_CORE X_NUC_109.L_CORE 0.005129
K_7747 X_NUC_77.L_CORE X_NUC_110.L_CORE 0.005174
K_7748 X_NUC_77.L_CORE X_NUC_111.L_CORE 0.005050
K_7749 X_NUC_77.L_CORE X_NUC_112.L_CORE 0.005124
K_7750 X_NUC_77.L_CORE X_NUC_113.L_CORE 0.002974
K_7751 X_NUC_77.L_CORE X_NUC_114.L_CORE 0.003000
K_7752 X_NUC_77.L_CORE X_NUC_115.L_CORE 0.002959
K_7753 X_NUC_77.L_CORE X_NUC_116.L_CORE 0.002987
K_7754 X_NUC_77.L_CORE X_NUC_117.L_CORE 0.002298
K_7755 X_NUC_77.L_CORE X_NUC_118.L_CORE 0.002685
K_7756 X_NUC_77.L_CORE X_NUC_119.L_CORE 0.001959
K_7757 X_NUC_77.L_CORE X_NUC_120.L_CORE 0.003101
K_7758 X_NUC_77.L_CORE X_NUC_121.L_CORE 0.002320
K_7759 X_NUC_77.L_CORE X_NUC_122.L_CORE 0.002080
K_7760 X_NUC_77.L_CORE X_NUC_123.L_CORE 0.004510
K_7761 X_NUC_77.L_CORE X_NUC_124.L_CORE 0.001938
K_7762 X_NUC_77.L_CORE X_NUC_125.L_CORE 0.002922
K_7763 X_NUC_77.L_CORE X_NUC_126.L_CORE 0.003198
K_7764 X_NUC_77.L_CORE X_NUC_127.L_CORE 0.001929
K_7765 X_NUC_77.L_CORE X_NUC_128.L_CORE 0.007190
K_7766 X_NUC_77.L_CORE X_NUC_129.L_CORE 0.002227
K_7767 X_NUC_77.L_CORE X_NUC_130.L_CORE 0.002432
K_7768 X_NUC_77.L_CORE X_NUC_131.L_CORE 0.006577
K_7769 X_NUC_77.L_CORE X_NUC_132.L_CORE 0.001990
K_7770 X_NUC_77.L_CORE X_NUC_133.L_CORE 0.004540
K_7771 X_NUC_77.L_CORE X_NUC_134.L_CORE 0.003010
K_7772 X_NUC_77.L_CORE X_NUC_135.L_CORE 0.002251
K_7773 X_NUC_77.L_CORE X_NUC_136.L_CORE 0.010821
K_7774 X_NUC_77.L_CORE X_NUC_137.L_CORE 0.002376
K_7775 X_NUC_77.L_CORE X_NUC_138.L_CORE 0.003224
K_7776 X_NUC_77.L_CORE X_NUC_139.L_CORE 0.004043
K_7777 X_NUC_77.L_CORE X_NUC_140.L_CORE 0.002742
K_7778 X_NUC_78.L_CORE X_NUC_79.L_CORE 0.207973
K_7779 X_NUC_78.L_CORE X_NUC_80.L_CORE 0.207973
K_7780 X_NUC_78.L_CORE X_NUC_81.L_CORE 0.002293
K_7781 X_NUC_78.L_CORE X_NUC_82.L_CORE 0.002304
K_7782 X_NUC_78.L_CORE X_NUC_83.L_CORE 0.002287
K_7783 X_NUC_78.L_CORE X_NUC_84.L_CORE 0.002309
K_7784 X_NUC_78.L_CORE X_NUC_85.L_CORE 0.003172
K_7785 X_NUC_78.L_CORE X_NUC_86.L_CORE 0.003220
K_7786 X_NUC_78.L_CORE X_NUC_87.L_CORE 0.003193
K_7787 X_NUC_78.L_CORE X_NUC_88.L_CORE 0.003190
K_7788 X_NUC_78.L_CORE X_NUC_89.L_CORE 0.004884
K_7789 X_NUC_78.L_CORE X_NUC_90.L_CORE 0.004867
K_7790 X_NUC_78.L_CORE X_NUC_91.L_CORE 0.004801
K_7791 X_NUC_78.L_CORE X_NUC_92.L_CORE 0.004909
K_7792 X_NUC_78.L_CORE X_NUC_93.L_CORE 0.002267
K_7793 X_NUC_78.L_CORE X_NUC_94.L_CORE 0.002287
K_7794 X_NUC_78.L_CORE X_NUC_95.L_CORE 0.002266
K_7795 X_NUC_78.L_CORE X_NUC_96.L_CORE 0.002281
K_7796 X_NUC_78.L_CORE X_NUC_97.L_CORE 0.006308
K_7797 X_NUC_78.L_CORE X_NUC_98.L_CORE 0.006470
K_7798 X_NUC_78.L_CORE X_NUC_99.L_CORE 0.006321
K_7799 X_NUC_78.L_CORE X_NUC_100.L_CORE 0.006301
K_7800 X_NUC_78.L_CORE X_NUC_101.L_CORE 0.002954
K_7801 X_NUC_78.L_CORE X_NUC_102.L_CORE 0.002967
K_7802 X_NUC_78.L_CORE X_NUC_103.L_CORE 0.002933
K_7803 X_NUC_78.L_CORE X_NUC_104.L_CORE 0.002970
K_7804 X_NUC_78.L_CORE X_NUC_105.L_CORE 0.002838
K_7805 X_NUC_78.L_CORE X_NUC_106.L_CORE 0.002872
K_7806 X_NUC_78.L_CORE X_NUC_107.L_CORE 0.002839
K_7807 X_NUC_78.L_CORE X_NUC_108.L_CORE 0.002851
K_7808 X_NUC_78.L_CORE X_NUC_109.L_CORE 0.005081
K_7809 X_NUC_78.L_CORE X_NUC_110.L_CORE 0.005129
K_7810 X_NUC_78.L_CORE X_NUC_111.L_CORE 0.005007
K_7811 X_NUC_78.L_CORE X_NUC_112.L_CORE 0.005079
K_7812 X_NUC_78.L_CORE X_NUC_113.L_CORE 0.002949
K_7813 X_NUC_78.L_CORE X_NUC_114.L_CORE 0.002974
K_7814 X_NUC_78.L_CORE X_NUC_115.L_CORE 0.002934
K_7815 X_NUC_78.L_CORE X_NUC_116.L_CORE 0.002961
K_7816 X_NUC_78.L_CORE X_NUC_117.L_CORE 0.002285
K_7817 X_NUC_78.L_CORE X_NUC_118.L_CORE 0.002681
K_7818 X_NUC_78.L_CORE X_NUC_119.L_CORE 0.001948
K_7819 X_NUC_78.L_CORE X_NUC_120.L_CORE 0.003080
K_7820 X_NUC_78.L_CORE X_NUC_121.L_CORE 0.002317
K_7821 X_NUC_78.L_CORE X_NUC_122.L_CORE 0.002063
K_7822 X_NUC_78.L_CORE X_NUC_123.L_CORE 0.004529
K_7823 X_NUC_78.L_CORE X_NUC_124.L_CORE 0.001929
K_7824 X_NUC_78.L_CORE X_NUC_125.L_CORE 0.002888
K_7825 X_NUC_78.L_CORE X_NUC_126.L_CORE 0.003211
K_7826 X_NUC_78.L_CORE X_NUC_127.L_CORE 0.001914
K_7827 X_NUC_78.L_CORE X_NUC_128.L_CORE 0.007112
K_7828 X_NUC_78.L_CORE X_NUC_129.L_CORE 0.002222
K_7829 X_NUC_78.L_CORE X_NUC_130.L_CORE 0.002405
K_7830 X_NUC_78.L_CORE X_NUC_131.L_CORE 0.006714
K_7831 X_NUC_78.L_CORE X_NUC_132.L_CORE 0.001977
K_7832 X_NUC_78.L_CORE X_NUC_133.L_CORE 0.004454
K_7833 X_NUC_78.L_CORE X_NUC_134.L_CORE 0.003012
K_7834 X_NUC_78.L_CORE X_NUC_135.L_CORE 0.002229
K_7835 X_NUC_78.L_CORE X_NUC_136.L_CORE 0.010750
K_7836 X_NUC_78.L_CORE X_NUC_137.L_CORE 0.002364
K_7837 X_NUC_78.L_CORE X_NUC_138.L_CORE 0.003180
K_7838 X_NUC_78.L_CORE X_NUC_139.L_CORE 0.004030
K_7839 X_NUC_78.L_CORE X_NUC_140.L_CORE 0.002719
K_7840 X_NUC_79.L_CORE X_NUC_80.L_CORE 0.207973
K_7841 X_NUC_79.L_CORE X_NUC_81.L_CORE 0.002311
K_7842 X_NUC_79.L_CORE X_NUC_82.L_CORE 0.002322
K_7843 X_NUC_79.L_CORE X_NUC_83.L_CORE 0.002304
K_7844 X_NUC_79.L_CORE X_NUC_84.L_CORE 0.002327
K_7845 X_NUC_79.L_CORE X_NUC_85.L_CORE 0.003198
K_7846 X_NUC_79.L_CORE X_NUC_86.L_CORE 0.003248
K_7847 X_NUC_79.L_CORE X_NUC_87.L_CORE 0.003220
K_7848 X_NUC_79.L_CORE X_NUC_88.L_CORE 0.003217
K_7849 X_NUC_79.L_CORE X_NUC_89.L_CORE 0.004952
K_7850 X_NUC_79.L_CORE X_NUC_90.L_CORE 0.004933
K_7851 X_NUC_79.L_CORE X_NUC_91.L_CORE 0.004867
K_7852 X_NUC_79.L_CORE X_NUC_92.L_CORE 0.004978
K_7853 X_NUC_79.L_CORE X_NUC_93.L_CORE 0.002287
K_7854 X_NUC_79.L_CORE X_NUC_94.L_CORE 0.002307
K_7855 X_NUC_79.L_CORE X_NUC_95.L_CORE 0.002287
K_7856 X_NUC_79.L_CORE X_NUC_96.L_CORE 0.002302
K_7857 X_NUC_79.L_CORE X_NUC_97.L_CORE 0.006454
K_7858 X_NUC_79.L_CORE X_NUC_98.L_CORE 0.006624
K_7859 X_NUC_79.L_CORE X_NUC_99.L_CORE 0.006470
K_7860 X_NUC_79.L_CORE X_NUC_100.L_CORE 0.006446
K_7861 X_NUC_79.L_CORE X_NUC_101.L_CORE 0.002989
K_7862 X_NUC_79.L_CORE X_NUC_102.L_CORE 0.003002
K_7863 X_NUC_79.L_CORE X_NUC_103.L_CORE 0.002967
K_7864 X_NUC_79.L_CORE X_NUC_104.L_CORE 0.003006
K_7865 X_NUC_79.L_CORE X_NUC_105.L_CORE 0.002870
K_7866 X_NUC_79.L_CORE X_NUC_106.L_CORE 0.002906
K_7867 X_NUC_79.L_CORE X_NUC_107.L_CORE 0.002872
K_7868 X_NUC_79.L_CORE X_NUC_108.L_CORE 0.002885
K_7869 X_NUC_79.L_CORE X_NUC_109.L_CORE 0.005207
K_7870 X_NUC_79.L_CORE X_NUC_110.L_CORE 0.005256
K_7871 X_NUC_79.L_CORE X_NUC_111.L_CORE 0.005129
K_7872 X_NUC_79.L_CORE X_NUC_112.L_CORE 0.005204
K_7873 X_NUC_79.L_CORE X_NUC_113.L_CORE 0.002989
K_7874 X_NUC_79.L_CORE X_NUC_114.L_CORE 0.003015
K_7875 X_NUC_79.L_CORE X_NUC_115.L_CORE 0.002974
K_7876 X_NUC_79.L_CORE X_NUC_116.L_CORE 0.003002
K_7877 X_NUC_79.L_CORE X_NUC_117.L_CORE 0.002280
K_7878 X_NUC_79.L_CORE X_NUC_118.L_CORE 0.002669
K_7879 X_NUC_79.L_CORE X_NUC_119.L_CORE 0.001951
K_7880 X_NUC_79.L_CORE X_NUC_120.L_CORE 0.003059
K_7881 X_NUC_79.L_CORE X_NUC_121.L_CORE 0.002318
K_7882 X_NUC_79.L_CORE X_NUC_122.L_CORE 0.002066
K_7883 X_NUC_79.L_CORE X_NUC_123.L_CORE 0.004461
K_7884 X_NUC_79.L_CORE X_NUC_124.L_CORE 0.001936
K_7885 X_NUC_79.L_CORE X_NUC_125.L_CORE 0.002886
K_7886 X_NUC_79.L_CORE X_NUC_126.L_CORE 0.003209
K_7887 X_NUC_79.L_CORE X_NUC_127.L_CORE 0.001923
K_7888 X_NUC_79.L_CORE X_NUC_128.L_CORE 0.006957
K_7889 X_NUC_79.L_CORE X_NUC_129.L_CORE 0.002233
K_7890 X_NUC_79.L_CORE X_NUC_130.L_CORE 0.002416
K_7891 X_NUC_79.L_CORE X_NUC_131.L_CORE 0.006696
K_7892 X_NUC_79.L_CORE X_NUC_132.L_CORE 0.001990
K_7893 X_NUC_79.L_CORE X_NUC_133.L_CORE 0.004480
K_7894 X_NUC_79.L_CORE X_NUC_134.L_CORE 0.003037
K_7895 X_NUC_79.L_CORE X_NUC_135.L_CORE 0.002247
K_7896 X_NUC_79.L_CORE X_NUC_136.L_CORE 0.011226
K_7897 X_NUC_79.L_CORE X_NUC_137.L_CORE 0.002387
K_7898 X_NUC_79.L_CORE X_NUC_138.L_CORE 0.003219
K_7899 X_NUC_79.L_CORE X_NUC_139.L_CORE 0.004103
K_7900 X_NUC_79.L_CORE X_NUC_140.L_CORE 0.002753
K_7901 X_NUC_80.L_CORE X_NUC_81.L_CORE 0.002288
K_7902 X_NUC_80.L_CORE X_NUC_82.L_CORE 0.002299
K_7903 X_NUC_80.L_CORE X_NUC_83.L_CORE 0.002282
K_7904 X_NUC_80.L_CORE X_NUC_84.L_CORE 0.002304
K_7905 X_NUC_80.L_CORE X_NUC_85.L_CORE 0.003201
K_7906 X_NUC_80.L_CORE X_NUC_86.L_CORE 0.003250
K_7907 X_NUC_80.L_CORE X_NUC_87.L_CORE 0.003222
K_7908 X_NUC_80.L_CORE X_NUC_88.L_CORE 0.003220
K_7909 X_NUC_80.L_CORE X_NUC_89.L_CORE 0.004841
K_7910 X_NUC_80.L_CORE X_NUC_90.L_CORE 0.004824
K_7911 X_NUC_80.L_CORE X_NUC_91.L_CORE 0.004761
K_7912 X_NUC_80.L_CORE X_NUC_92.L_CORE 0.004867
K_7913 X_NUC_80.L_CORE X_NUC_93.L_CORE 0.002272
K_7914 X_NUC_80.L_CORE X_NUC_94.L_CORE 0.002291
K_7915 X_NUC_80.L_CORE X_NUC_95.L_CORE 0.002271
K_7916 X_NUC_80.L_CORE X_NUC_96.L_CORE 0.002287
K_7917 X_NUC_80.L_CORE X_NUC_97.L_CORE 0.006475
K_7918 X_NUC_80.L_CORE X_NUC_98.L_CORE 0.006648
K_7919 X_NUC_80.L_CORE X_NUC_99.L_CORE 0.006489
K_7920 X_NUC_80.L_CORE X_NUC_100.L_CORE 0.006470
K_7921 X_NUC_80.L_CORE X_NUC_101.L_CORE 0.002951
K_7922 X_NUC_80.L_CORE X_NUC_102.L_CORE 0.002963
K_7923 X_NUC_80.L_CORE X_NUC_103.L_CORE 0.002929
K_7924 X_NUC_80.L_CORE X_NUC_104.L_CORE 0.002967
K_7925 X_NUC_80.L_CORE X_NUC_105.L_CORE 0.002858
K_7926 X_NUC_80.L_CORE X_NUC_106.L_CORE 0.002893
K_7927 X_NUC_80.L_CORE X_NUC_107.L_CORE 0.002859
K_7928 X_NUC_80.L_CORE X_NUC_108.L_CORE 0.002872
K_7929 X_NUC_80.L_CORE X_NUC_109.L_CORE 0.005130
K_7930 X_NUC_80.L_CORE X_NUC_110.L_CORE 0.005177
K_7931 X_NUC_80.L_CORE X_NUC_111.L_CORE 0.005053
K_7932 X_NUC_80.L_CORE X_NUC_112.L_CORE 0.005129
K_7933 X_NUC_80.L_CORE X_NUC_113.L_CORE 0.002961
K_7934 X_NUC_80.L_CORE X_NUC_114.L_CORE 0.002987
K_7935 X_NUC_80.L_CORE X_NUC_115.L_CORE 0.002947
K_7936 X_NUC_80.L_CORE X_NUC_116.L_CORE 0.002974
K_7937 X_NUC_80.L_CORE X_NUC_117.L_CORE 0.002274
K_7938 X_NUC_80.L_CORE X_NUC_118.L_CORE 0.002654
K_7939 X_NUC_80.L_CORE X_NUC_119.L_CORE 0.001941
K_7940 X_NUC_80.L_CORE X_NUC_120.L_CORE 0.003065
K_7941 X_NUC_80.L_CORE X_NUC_121.L_CORE 0.002297
K_7942 X_NUC_80.L_CORE X_NUC_122.L_CORE 0.002062
K_7943 X_NUC_80.L_CORE X_NUC_123.L_CORE 0.004446
K_7944 X_NUC_80.L_CORE X_NUC_124.L_CORE 0.001922
K_7945 X_NUC_80.L_CORE X_NUC_125.L_CORE 0.002896
K_7946 X_NUC_80.L_CORE X_NUC_126.L_CORE 0.003168
K_7947 X_NUC_80.L_CORE X_NUC_127.L_CORE 0.001914
K_7948 X_NUC_80.L_CORE X_NUC_128.L_CORE 0.007108
K_7949 X_NUC_80.L_CORE X_NUC_129.L_CORE 0.002211
K_7950 X_NUC_80.L_CORE X_NUC_130.L_CORE 0.002416
K_7951 X_NUC_80.L_CORE X_NUC_131.L_CORE 0.006540
K_7952 X_NUC_80.L_CORE X_NUC_132.L_CORE 0.001976
K_7953 X_NUC_80.L_CORE X_NUC_133.L_CORE 0.004524
K_7954 X_NUC_80.L_CORE X_NUC_134.L_CORE 0.002994
K_7955 X_NUC_80.L_CORE X_NUC_135.L_CORE 0.002238
K_7956 X_NUC_80.L_CORE X_NUC_136.L_CORE 0.011154
K_7957 X_NUC_80.L_CORE X_NUC_137.L_CORE 0.002364
K_7958 X_NUC_80.L_CORE X_NUC_138.L_CORE 0.003216
K_7959 X_NUC_80.L_CORE X_NUC_139.L_CORE 0.004043
K_7960 X_NUC_80.L_CORE X_NUC_140.L_CORE 0.002733
K_7961 X_NUC_81.L_CORE X_NUC_82.L_CORE 0.207973
K_7962 X_NUC_81.L_CORE X_NUC_83.L_CORE 0.207973
K_7963 X_NUC_81.L_CORE X_NUC_84.L_CORE 0.207973
K_7964 X_NUC_81.L_CORE X_NUC_85.L_CORE 0.002385
K_7965 X_NUC_81.L_CORE X_NUC_86.L_CORE 0.002393
K_7966 X_NUC_81.L_CORE X_NUC_87.L_CORE 0.002401
K_7967 X_NUC_81.L_CORE X_NUC_88.L_CORE 0.002375
K_7968 X_NUC_81.L_CORE X_NUC_89.L_CORE 0.003346
K_7969 X_NUC_81.L_CORE X_NUC_90.L_CORE 0.003306
K_7970 X_NUC_81.L_CORE X_NUC_91.L_CORE 0.003338
K_7971 X_NUC_81.L_CORE X_NUC_92.L_CORE 0.003305
K_7972 X_NUC_81.L_CORE X_NUC_93.L_CORE 0.005057
K_7973 X_NUC_81.L_CORE X_NUC_94.L_CORE 0.005149
K_7974 X_NUC_81.L_CORE X_NUC_95.L_CORE 0.005117
K_7975 X_NUC_81.L_CORE X_NUC_96.L_CORE 0.005040
K_7976 X_NUC_81.L_CORE X_NUC_97.L_CORE 0.002407
K_7977 X_NUC_81.L_CORE X_NUC_98.L_CORE 0.002402
K_7978 X_NUC_81.L_CORE X_NUC_99.L_CORE 0.002414
K_7979 X_NUC_81.L_CORE X_NUC_100.L_CORE 0.002388
K_7980 X_NUC_81.L_CORE X_NUC_101.L_CORE 0.006523
K_7981 X_NUC_81.L_CORE X_NUC_102.L_CORE 0.006396
K_7982 X_NUC_81.L_CORE X_NUC_103.L_CORE 0.006431
K_7983 X_NUC_81.L_CORE X_NUC_104.L_CORE 0.006328
K_7984 X_NUC_81.L_CORE X_NUC_105.L_CORE 0.003162
K_7985 X_NUC_81.L_CORE X_NUC_106.L_CORE 0.003178
K_7986 X_NUC_81.L_CORE X_NUC_107.L_CORE 0.003180
K_7987 X_NUC_81.L_CORE X_NUC_108.L_CORE 0.003138
K_7988 X_NUC_81.L_CORE X_NUC_109.L_CORE 0.003113
K_7989 X_NUC_81.L_CORE X_NUC_110.L_CORE 0.003095
K_7990 X_NUC_81.L_CORE X_NUC_111.L_CORE 0.003111
K_7991 X_NUC_81.L_CORE X_NUC_112.L_CORE 0.003073
K_7992 X_NUC_81.L_CORE X_NUC_113.L_CORE 0.004572
K_7993 X_NUC_81.L_CORE X_NUC_114.L_CORE 0.004574
K_7994 X_NUC_81.L_CORE X_NUC_115.L_CORE 0.004566
K_7995 X_NUC_81.L_CORE X_NUC_116.L_CORE 0.004491
K_7996 X_NUC_81.L_CORE X_NUC_117.L_CORE 0.002125
K_7997 X_NUC_81.L_CORE X_NUC_118.L_CORE 0.002254
K_7998 X_NUC_81.L_CORE X_NUC_119.L_CORE 0.002754
K_7999 X_NUC_81.L_CORE X_NUC_120.L_CORE 0.001907
K_8000 X_NUC_81.L_CORE X_NUC_121.L_CORE 0.003127
K_8001 X_NUC_81.L_CORE X_NUC_122.L_CORE 0.002313
K_8002 X_NUC_81.L_CORE X_NUC_123.L_CORE 0.002057
K_8003 X_NUC_81.L_CORE X_NUC_124.L_CORE 0.004615
K_8004 X_NUC_81.L_CORE X_NUC_125.L_CORE 0.001939
K_8005 X_NUC_81.L_CORE X_NUC_126.L_CORE 0.002910
K_8006 X_NUC_81.L_CORE X_NUC_127.L_CORE 0.003257
K_8007 X_NUC_81.L_CORE X_NUC_128.L_CORE 0.001942
K_8008 X_NUC_81.L_CORE X_NUC_129.L_CORE 0.007197
K_8009 X_NUC_81.L_CORE X_NUC_130.L_CORE 0.002274
K_8010 X_NUC_81.L_CORE X_NUC_131.L_CORE 0.002463
K_8011 X_NUC_81.L_CORE X_NUC_132.L_CORE 0.006949
K_8012 X_NUC_81.L_CORE X_NUC_133.L_CORE 0.002046
K_8013 X_NUC_81.L_CORE X_NUC_134.L_CORE 0.004604
K_8014 X_NUC_81.L_CORE X_NUC_135.L_CORE 0.003151
K_8015 X_NUC_81.L_CORE X_NUC_136.L_CORE 0.002346
K_8016 X_NUC_81.L_CORE X_NUC_137.L_CORE 0.009800
K_8017 X_NUC_81.L_CORE X_NUC_138.L_CORE 0.002543
K_8018 X_NUC_81.L_CORE X_NUC_139.L_CORE 0.003385
K_8019 X_NUC_81.L_CORE X_NUC_140.L_CORE 0.003937
K_8020 X_NUC_82.L_CORE X_NUC_83.L_CORE 0.207973
K_8021 X_NUC_82.L_CORE X_NUC_84.L_CORE 0.207973
K_8022 X_NUC_82.L_CORE X_NUC_85.L_CORE 0.002378
K_8023 X_NUC_82.L_CORE X_NUC_86.L_CORE 0.002385
K_8024 X_NUC_82.L_CORE X_NUC_87.L_CORE 0.002394
K_8025 X_NUC_82.L_CORE X_NUC_88.L_CORE 0.002368
K_8026 X_NUC_82.L_CORE X_NUC_89.L_CORE 0.003388
K_8027 X_NUC_82.L_CORE X_NUC_90.L_CORE 0.003346
K_8028 X_NUC_82.L_CORE X_NUC_91.L_CORE 0.003380
K_8029 X_NUC_82.L_CORE X_NUC_92.L_CORE 0.003345
K_8030 X_NUC_82.L_CORE X_NUC_93.L_CORE 0.004967
K_8031 X_NUC_82.L_CORE X_NUC_94.L_CORE 0.005057
K_8032 X_NUC_82.L_CORE X_NUC_95.L_CORE 0.005026
K_8033 X_NUC_82.L_CORE X_NUC_96.L_CORE 0.004952
K_8034 X_NUC_82.L_CORE X_NUC_97.L_CORE 0.002411
K_8035 X_NUC_82.L_CORE X_NUC_98.L_CORE 0.002407
K_8036 X_NUC_82.L_CORE X_NUC_99.L_CORE 0.002419
K_8037 X_NUC_82.L_CORE X_NUC_100.L_CORE 0.002392
K_8038 X_NUC_82.L_CORE X_NUC_101.L_CORE 0.006651
K_8039 X_NUC_82.L_CORE X_NUC_102.L_CORE 0.006523
K_8040 X_NUC_82.L_CORE X_NUC_103.L_CORE 0.006557
K_8041 X_NUC_82.L_CORE X_NUC_104.L_CORE 0.006448
K_8042 X_NUC_82.L_CORE X_NUC_105.L_CORE 0.003144
K_8043 X_NUC_82.L_CORE X_NUC_106.L_CORE 0.003162
K_8044 X_NUC_82.L_CORE X_NUC_107.L_CORE 0.003163
K_8045 X_NUC_82.L_CORE X_NUC_108.L_CORE 0.003121
K_8046 X_NUC_82.L_CORE X_NUC_109.L_CORE 0.003131
K_8047 X_NUC_82.L_CORE X_NUC_110.L_CORE 0.003113
K_8048 X_NUC_82.L_CORE X_NUC_111.L_CORE 0.003129
K_8049 X_NUC_82.L_CORE X_NUC_112.L_CORE 0.003090
K_8050 X_NUC_82.L_CORE X_NUC_113.L_CORE 0.004568
K_8051 X_NUC_82.L_CORE X_NUC_114.L_CORE 0.004572
K_8052 X_NUC_82.L_CORE X_NUC_115.L_CORE 0.004563
K_8053 X_NUC_82.L_CORE X_NUC_116.L_CORE 0.004488
K_8054 X_NUC_82.L_CORE X_NUC_117.L_CORE 0.002123
K_8055 X_NUC_82.L_CORE X_NUC_118.L_CORE 0.002263
K_8056 X_NUC_82.L_CORE X_NUC_119.L_CORE 0.002743
K_8057 X_NUC_82.L_CORE X_NUC_120.L_CORE 0.001909
K_8058 X_NUC_82.L_CORE X_NUC_121.L_CORE 0.003149
K_8059 X_NUC_82.L_CORE X_NUC_122.L_CORE 0.002301
K_8060 X_NUC_82.L_CORE X_NUC_123.L_CORE 0.002067
K_8061 X_NUC_82.L_CORE X_NUC_124.L_CORE 0.004588
K_8062 X_NUC_82.L_CORE X_NUC_125.L_CORE 0.001936
K_8063 X_NUC_82.L_CORE X_NUC_126.L_CORE 0.002943
K_8064 X_NUC_82.L_CORE X_NUC_127.L_CORE 0.003217
K_8065 X_NUC_82.L_CORE X_NUC_128.L_CORE 0.001947
K_8066 X_NUC_82.L_CORE X_NUC_129.L_CORE 0.007370
K_8067 X_NUC_82.L_CORE X_NUC_130.L_CORE 0.002262
K_8068 X_NUC_82.L_CORE X_NUC_131.L_CORE 0.002485
K_8069 X_NUC_82.L_CORE X_NUC_132.L_CORE 0.006728
K_8070 X_NUC_82.L_CORE X_NUC_133.L_CORE 0.002046
K_8071 X_NUC_82.L_CORE X_NUC_134.L_CORE 0.004703
K_8072 X_NUC_82.L_CORE X_NUC_135.L_CORE 0.003119
K_8073 X_NUC_82.L_CORE X_NUC_136.L_CORE 0.002357
K_8074 X_NUC_82.L_CORE X_NUC_137.L_CORE 0.009812
K_8075 X_NUC_82.L_CORE X_NUC_138.L_CORE 0.002536
K_8076 X_NUC_82.L_CORE X_NUC_139.L_CORE 0.003414
K_8077 X_NUC_82.L_CORE X_NUC_140.L_CORE 0.003923
K_8078 X_NUC_83.L_CORE X_NUC_84.L_CORE 0.207973
K_8079 X_NUC_83.L_CORE X_NUC_85.L_CORE 0.002369
K_8080 X_NUC_83.L_CORE X_NUC_86.L_CORE 0.002377
K_8081 X_NUC_83.L_CORE X_NUC_87.L_CORE 0.002385
K_8082 X_NUC_83.L_CORE X_NUC_88.L_CORE 0.002359
K_8083 X_NUC_83.L_CORE X_NUC_89.L_CORE 0.003354
K_8084 X_NUC_83.L_CORE X_NUC_90.L_CORE 0.003313
K_8085 X_NUC_83.L_CORE X_NUC_91.L_CORE 0.003346
K_8086 X_NUC_83.L_CORE X_NUC_92.L_CORE 0.003312
K_8087 X_NUC_83.L_CORE X_NUC_93.L_CORE 0.004996
K_8088 X_NUC_83.L_CORE X_NUC_94.L_CORE 0.005086
K_8089 X_NUC_83.L_CORE X_NUC_95.L_CORE 0.005057
K_8090 X_NUC_83.L_CORE X_NUC_96.L_CORE 0.004981
K_8091 X_NUC_83.L_CORE X_NUC_97.L_CORE 0.002399
K_8092 X_NUC_83.L_CORE X_NUC_98.L_CORE 0.002394
K_8093 X_NUC_83.L_CORE X_NUC_99.L_CORE 0.002407
K_8094 X_NUC_83.L_CORE X_NUC_100.L_CORE 0.002380
K_8095 X_NUC_83.L_CORE X_NUC_101.L_CORE 0.006612
K_8096 X_NUC_83.L_CORE X_NUC_102.L_CORE 0.006483
K_8097 X_NUC_83.L_CORE X_NUC_103.L_CORE 0.006523
K_8098 X_NUC_83.L_CORE X_NUC_104.L_CORE 0.006413
K_8099 X_NUC_83.L_CORE X_NUC_105.L_CORE 0.003143
K_8100 X_NUC_83.L_CORE X_NUC_106.L_CORE 0.003160
K_8101 X_NUC_83.L_CORE X_NUC_107.L_CORE 0.003162
K_8102 X_NUC_83.L_CORE X_NUC_108.L_CORE 0.003120
K_8103 X_NUC_83.L_CORE X_NUC_109.L_CORE 0.003115
K_8104 X_NUC_83.L_CORE X_NUC_110.L_CORE 0.003097
K_8105 X_NUC_83.L_CORE X_NUC_111.L_CORE 0.003113
K_8106 X_NUC_83.L_CORE X_NUC_112.L_CORE 0.003075
K_8107 X_NUC_83.L_CORE X_NUC_113.L_CORE 0.004576
K_8108 X_NUC_83.L_CORE X_NUC_114.L_CORE 0.004579
K_8109 X_NUC_83.L_CORE X_NUC_115.L_CORE 0.004572
K_8110 X_NUC_83.L_CORE X_NUC_116.L_CORE 0.004495
K_8111 X_NUC_83.L_CORE X_NUC_117.L_CORE 0.002106
K_8112 X_NUC_83.L_CORE X_NUC_118.L_CORE 0.002239
K_8113 X_NUC_83.L_CORE X_NUC_119.L_CORE 0.002720
K_8114 X_NUC_83.L_CORE X_NUC_120.L_CORE 0.001894
K_8115 X_NUC_83.L_CORE X_NUC_121.L_CORE 0.003105
K_8116 X_NUC_83.L_CORE X_NUC_122.L_CORE 0.002288
K_8117 X_NUC_83.L_CORE X_NUC_123.L_CORE 0.002048
K_8118 X_NUC_83.L_CORE X_NUC_124.L_CORE 0.004539
K_8119 X_NUC_83.L_CORE X_NUC_125.L_CORE 0.001925
K_8120 X_NUC_83.L_CORE X_NUC_126.L_CORE 0.002905
K_8121 X_NUC_83.L_CORE X_NUC_127.L_CORE 0.003210
K_8122 X_NUC_83.L_CORE X_NUC_128.L_CORE 0.001934
K_8123 X_NUC_83.L_CORE X_NUC_129.L_CORE 0.007203
K_8124 X_NUC_83.L_CORE X_NUC_130.L_CORE 0.002254
K_8125 X_NUC_83.L_CORE X_NUC_131.L_CORE 0.002462
K_8126 X_NUC_83.L_CORE X_NUC_132.L_CORE 0.006801
K_8127 X_NUC_83.L_CORE X_NUC_133.L_CORE 0.002036
K_8128 X_NUC_83.L_CORE X_NUC_134.L_CORE 0.004647
K_8129 X_NUC_83.L_CORE X_NUC_135.L_CORE 0.003123
K_8130 X_NUC_83.L_CORE X_NUC_136.L_CORE 0.002343
K_8131 X_NUC_83.L_CORE X_NUC_137.L_CORE 0.010055
K_8132 X_NUC_83.L_CORE X_NUC_138.L_CORE 0.002532
K_8133 X_NUC_83.L_CORE X_NUC_139.L_CORE 0.003399
K_8134 X_NUC_83.L_CORE X_NUC_140.L_CORE 0.003938
K_8135 X_NUC_84.L_CORE X_NUC_85.L_CORE 0.002396
K_8136 X_NUC_84.L_CORE X_NUC_86.L_CORE 0.002403
K_8137 X_NUC_84.L_CORE X_NUC_87.L_CORE 0.002412
K_8138 X_NUC_84.L_CORE X_NUC_88.L_CORE 0.002385
K_8139 X_NUC_84.L_CORE X_NUC_89.L_CORE 0.003389
K_8140 X_NUC_84.L_CORE X_NUC_90.L_CORE 0.003347
K_8141 X_NUC_84.L_CORE X_NUC_91.L_CORE 0.003381
K_8142 X_NUC_84.L_CORE X_NUC_92.L_CORE 0.003346
K_8143 X_NUC_84.L_CORE X_NUC_93.L_CORE 0.005071
K_8144 X_NUC_84.L_CORE X_NUC_94.L_CORE 0.005165
K_8145 X_NUC_84.L_CORE X_NUC_95.L_CORE 0.005133
K_8146 X_NUC_84.L_CORE X_NUC_96.L_CORE 0.005057
K_8147 X_NUC_84.L_CORE X_NUC_97.L_CORE 0.002426
K_8148 X_NUC_84.L_CORE X_NUC_98.L_CORE 0.002421
K_8149 X_NUC_84.L_CORE X_NUC_99.L_CORE 0.002434
K_8150 X_NUC_84.L_CORE X_NUC_100.L_CORE 0.002407
K_8151 X_NUC_84.L_CORE X_NUC_101.L_CORE 0.006730
K_8152 X_NUC_84.L_CORE X_NUC_102.L_CORE 0.006594
K_8153 X_NUC_84.L_CORE X_NUC_103.L_CORE 0.006633
K_8154 X_NUC_84.L_CORE X_NUC_104.L_CORE 0.006523
K_8155 X_NUC_84.L_CORE X_NUC_105.L_CORE 0.003185
K_8156 X_NUC_84.L_CORE X_NUC_106.L_CORE 0.003203
K_8157 X_NUC_84.L_CORE X_NUC_107.L_CORE 0.003204
K_8158 X_NUC_84.L_CORE X_NUC_108.L_CORE 0.003162
K_8159 X_NUC_84.L_CORE X_NUC_109.L_CORE 0.003155
K_8160 X_NUC_84.L_CORE X_NUC_110.L_CORE 0.003136
K_8161 X_NUC_84.L_CORE X_NUC_111.L_CORE 0.003153
K_8162 X_NUC_84.L_CORE X_NUC_112.L_CORE 0.003113
K_8163 X_NUC_84.L_CORE X_NUC_113.L_CORE 0.004655
K_8164 X_NUC_84.L_CORE X_NUC_114.L_CORE 0.004659
K_8165 X_NUC_84.L_CORE X_NUC_115.L_CORE 0.004651
K_8166 X_NUC_84.L_CORE X_NUC_116.L_CORE 0.004572
K_8167 X_NUC_84.L_CORE X_NUC_117.L_CORE 0.002118
K_8168 X_NUC_84.L_CORE X_NUC_118.L_CORE 0.002251
K_8169 X_NUC_84.L_CORE X_NUC_119.L_CORE 0.002731
K_8170 X_NUC_84.L_CORE X_NUC_120.L_CORE 0.001908
K_8171 X_NUC_84.L_CORE X_NUC_121.L_CORE 0.003112
K_8172 X_NUC_84.L_CORE X_NUC_122.L_CORE 0.002305
K_8173 X_NUC_84.L_CORE X_NUC_123.L_CORE 0.002063
K_8174 X_NUC_84.L_CORE X_NUC_124.L_CORE 0.004529
K_8175 X_NUC_84.L_CORE X_NUC_125.L_CORE 0.001941
K_8176 X_NUC_84.L_CORE X_NUC_126.L_CORE 0.002920
K_8177 X_NUC_84.L_CORE X_NUC_127.L_CORE 0.003231
K_8178 X_NUC_84.L_CORE X_NUC_128.L_CORE 0.001950
K_8179 X_NUC_84.L_CORE X_NUC_129.L_CORE 0.007124
K_8180 X_NUC_84.L_CORE X_NUC_130.L_CORE 0.002275
K_8181 X_NUC_84.L_CORE X_NUC_131.L_CORE 0.002482
K_8182 X_NUC_84.L_CORE X_NUC_132.L_CORE 0.006823
K_8183 X_NUC_84.L_CORE X_NUC_133.L_CORE 0.002056
K_8184 X_NUC_84.L_CORE X_NUC_134.L_CORE 0.004676
K_8185 X_NUC_84.L_CORE X_NUC_135.L_CORE 0.003157
K_8186 X_NUC_84.L_CORE X_NUC_136.L_CORE 0.002366
K_8187 X_NUC_84.L_CORE X_NUC_137.L_CORE 0.010203
K_8188 X_NUC_84.L_CORE X_NUC_138.L_CORE 0.002561
K_8189 X_NUC_84.L_CORE X_NUC_139.L_CORE 0.003438
K_8190 X_NUC_84.L_CORE X_NUC_140.L_CORE 0.003993
K_8191 X_NUC_85.L_CORE X_NUC_86.L_CORE 0.207973
K_8192 X_NUC_85.L_CORE X_NUC_87.L_CORE 0.207973
K_8193 X_NUC_85.L_CORE X_NUC_88.L_CORE 0.207973
K_8194 X_NUC_85.L_CORE X_NUC_89.L_CORE 0.002492
K_8195 X_NUC_85.L_CORE X_NUC_90.L_CORE 0.002467
K_8196 X_NUC_85.L_CORE X_NUC_91.L_CORE 0.002470
K_8197 X_NUC_85.L_CORE X_NUC_92.L_CORE 0.002486
K_8198 X_NUC_85.L_CORE X_NUC_93.L_CORE 0.003512
K_8199 X_NUC_85.L_CORE X_NUC_94.L_CORE 0.003519
K_8200 X_NUC_85.L_CORE X_NUC_95.L_CORE 0.003481
K_8201 X_NUC_85.L_CORE X_NUC_96.L_CORE 0.003540
K_8202 X_NUC_85.L_CORE X_NUC_97.L_CORE 0.005300
K_8203 X_NUC_85.L_CORE X_NUC_98.L_CORE 0.005173
K_8204 X_NUC_85.L_CORE X_NUC_99.L_CORE 0.005209
K_8205 X_NUC_85.L_CORE X_NUC_100.L_CORE 0.005209
K_8206 X_NUC_85.L_CORE X_NUC_101.L_CORE 0.002570
K_8207 X_NUC_85.L_CORE X_NUC_102.L_CORE 0.002553
K_8208 X_NUC_85.L_CORE X_NUC_103.L_CORE 0.002545
K_8209 X_NUC_85.L_CORE X_NUC_104.L_CORE 0.002571
K_8210 X_NUC_85.L_CORE X_NUC_105.L_CORE 0.006522
K_8211 X_NUC_85.L_CORE X_NUC_106.L_CORE 0.006517
K_8212 X_NUC_85.L_CORE X_NUC_107.L_CORE 0.006358
K_8213 X_NUC_85.L_CORE X_NUC_108.L_CORE 0.006521
K_8214 X_NUC_85.L_CORE X_NUC_109.L_CORE 0.003439
K_8215 X_NUC_85.L_CORE X_NUC_110.L_CORE 0.003393
K_8216 X_NUC_85.L_CORE X_NUC_111.L_CORE 0.003389
K_8217 X_NUC_85.L_CORE X_NUC_112.L_CORE 0.003414
K_8218 X_NUC_85.L_CORE X_NUC_113.L_CORE 0.003516
K_8219 X_NUC_85.L_CORE X_NUC_114.L_CORE 0.003493
K_8220 X_NUC_85.L_CORE X_NUC_115.L_CORE 0.003463
K_8221 X_NUC_85.L_CORE X_NUC_116.L_CORE 0.003511
K_8222 X_NUC_85.L_CORE X_NUC_117.L_CORE 0.002408
K_8223 X_NUC_85.L_CORE X_NUC_118.L_CORE 0.002035
K_8224 X_NUC_85.L_CORE X_NUC_119.L_CORE 0.002239
K_8225 X_NUC_85.L_CORE X_NUC_120.L_CORE 0.002785
K_8226 X_NUC_85.L_CORE X_NUC_121.L_CORE 0.001880
K_8227 X_NUC_85.L_CORE X_NUC_122.L_CORE 0.003182
K_8228 X_NUC_85.L_CORE X_NUC_123.L_CORE 0.002298
K_8229 X_NUC_85.L_CORE X_NUC_124.L_CORE 0.002065
K_8230 X_NUC_85.L_CORE X_NUC_125.L_CORE 0.004654
K_8231 X_NUC_85.L_CORE X_NUC_126.L_CORE 0.001947
K_8232 X_NUC_85.L_CORE X_NUC_127.L_CORE 0.002969
K_8233 X_NUC_85.L_CORE X_NUC_128.L_CORE 0.003262
K_8234 X_NUC_85.L_CORE X_NUC_129.L_CORE 0.001978
K_8235 X_NUC_85.L_CORE X_NUC_130.L_CORE 0.007517
K_8236 X_NUC_85.L_CORE X_NUC_131.L_CORE 0.002316
K_8237 X_NUC_85.L_CORE X_NUC_132.L_CORE 0.002552
K_8238 X_NUC_85.L_CORE X_NUC_133.L_CORE 0.006993
K_8239 X_NUC_85.L_CORE X_NUC_134.L_CORE 0.002123
K_8240 X_NUC_85.L_CORE X_NUC_135.L_CORE 0.004890
K_8241 X_NUC_85.L_CORE X_NUC_136.L_CORE 0.003275
K_8242 X_NUC_85.L_CORE X_NUC_137.L_CORE 0.002500
K_8243 X_NUC_85.L_CORE X_NUC_138.L_CORE 0.008709
K_8244 X_NUC_85.L_CORE X_NUC_139.L_CORE 0.002783
K_8245 X_NUC_85.L_CORE X_NUC_140.L_CORE 0.003652
K_8246 X_NUC_86.L_CORE X_NUC_87.L_CORE 0.207973
K_8247 X_NUC_86.L_CORE X_NUC_88.L_CORE 0.207973
K_8248 X_NUC_86.L_CORE X_NUC_89.L_CORE 0.002517
K_8249 X_NUC_86.L_CORE X_NUC_90.L_CORE 0.002492
K_8250 X_NUC_86.L_CORE X_NUC_91.L_CORE 0.002495
K_8251 X_NUC_86.L_CORE X_NUC_92.L_CORE 0.002511
K_8252 X_NUC_86.L_CORE X_NUC_93.L_CORE 0.003505
K_8253 X_NUC_86.L_CORE X_NUC_94.L_CORE 0.003512
K_8254 X_NUC_86.L_CORE X_NUC_95.L_CORE 0.003474
K_8255 X_NUC_86.L_CORE X_NUC_96.L_CORE 0.003533
K_8256 X_NUC_86.L_CORE X_NUC_97.L_CORE 0.005433
K_8257 X_NUC_86.L_CORE X_NUC_98.L_CORE 0.005300
K_8258 X_NUC_86.L_CORE X_NUC_99.L_CORE 0.005337
K_8259 X_NUC_86.L_CORE X_NUC_100.L_CORE 0.005337
K_8260 X_NUC_86.L_CORE X_NUC_101.L_CORE 0.002587
K_8261 X_NUC_86.L_CORE X_NUC_102.L_CORE 0.002570
K_8262 X_NUC_86.L_CORE X_NUC_103.L_CORE 0.002562
K_8263 X_NUC_86.L_CORE X_NUC_104.L_CORE 0.002588
K_8264 X_NUC_86.L_CORE X_NUC_105.L_CORE 0.006520
K_8265 X_NUC_86.L_CORE X_NUC_106.L_CORE 0.006522
K_8266 X_NUC_86.L_CORE X_NUC_107.L_CORE 0.006360
K_8267 X_NUC_86.L_CORE X_NUC_108.L_CORE 0.006522
K_8268 X_NUC_86.L_CORE X_NUC_109.L_CORE 0.003486
K_8269 X_NUC_86.L_CORE X_NUC_110.L_CORE 0.003439
K_8270 X_NUC_86.L_CORE X_NUC_111.L_CORE 0.003434
K_8271 X_NUC_86.L_CORE X_NUC_112.L_CORE 0.003460
K_8272 X_NUC_86.L_CORE X_NUC_113.L_CORE 0.003538
K_8273 X_NUC_86.L_CORE X_NUC_114.L_CORE 0.003516
K_8274 X_NUC_86.L_CORE X_NUC_115.L_CORE 0.003484
K_8275 X_NUC_86.L_CORE X_NUC_116.L_CORE 0.003533
K_8276 X_NUC_86.L_CORE X_NUC_117.L_CORE 0.002413
K_8277 X_NUC_86.L_CORE X_NUC_118.L_CORE 0.002046
K_8278 X_NUC_86.L_CORE X_NUC_119.L_CORE 0.002239
K_8279 X_NUC_86.L_CORE X_NUC_120.L_CORE 0.002801
K_8280 X_NUC_86.L_CORE X_NUC_121.L_CORE 0.001888
K_8281 X_NUC_86.L_CORE X_NUC_122.L_CORE 0.003167
K_8282 X_NUC_86.L_CORE X_NUC_123.L_CORE 0.002318
K_8283 X_NUC_86.L_CORE X_NUC_124.L_CORE 0.002068
K_8284 X_NUC_86.L_CORE X_NUC_125.L_CORE 0.004664
K_8285 X_NUC_86.L_CORE X_NUC_126.L_CORE 0.001961
K_8286 X_NUC_86.L_CORE X_NUC_127.L_CORE 0.002953
K_8287 X_NUC_86.L_CORE X_NUC_128.L_CORE 0.003307
K_8288 X_NUC_86.L_CORE X_NUC_129.L_CORE 0.001986
K_8289 X_NUC_86.L_CORE X_NUC_130.L_CORE 0.007317
K_8290 X_NUC_86.L_CORE X_NUC_131.L_CORE 0.002340
K_8291 X_NUC_86.L_CORE X_NUC_132.L_CORE 0.002549
K_8292 X_NUC_86.L_CORE X_NUC_133.L_CORE 0.007183
K_8293 X_NUC_86.L_CORE X_NUC_134.L_CORE 0.002138
K_8294 X_NUC_86.L_CORE X_NUC_135.L_CORE 0.004833
K_8295 X_NUC_86.L_CORE X_NUC_136.L_CORE 0.003326
K_8296 X_NUC_86.L_CORE X_NUC_137.L_CORE 0.002509
K_8297 X_NUC_86.L_CORE X_NUC_138.L_CORE 0.008803
K_8298 X_NUC_86.L_CORE X_NUC_139.L_CORE 0.002812
K_8299 X_NUC_86.L_CORE X_NUC_140.L_CORE 0.003668
K_8300 X_NUC_87.L_CORE X_NUC_88.L_CORE 0.207973
K_8301 X_NUC_87.L_CORE X_NUC_89.L_CORE 0.002513
K_8302 X_NUC_87.L_CORE X_NUC_90.L_CORE 0.002488
K_8303 X_NUC_87.L_CORE X_NUC_91.L_CORE 0.002492
K_8304 X_NUC_87.L_CORE X_NUC_92.L_CORE 0.002507
K_8305 X_NUC_87.L_CORE X_NUC_93.L_CORE 0.003543
K_8306 X_NUC_87.L_CORE X_NUC_94.L_CORE 0.003550
K_8307 X_NUC_87.L_CORE X_NUC_95.L_CORE 0.003512
K_8308 X_NUC_87.L_CORE X_NUC_96.L_CORE 0.003572
K_8309 X_NUC_87.L_CORE X_NUC_97.L_CORE 0.005391
K_8310 X_NUC_87.L_CORE X_NUC_98.L_CORE 0.005260
K_8311 X_NUC_87.L_CORE X_NUC_99.L_CORE 0.005300
K_8312 X_NUC_87.L_CORE X_NUC_100.L_CORE 0.005298
K_8313 X_NUC_87.L_CORE X_NUC_101.L_CORE 0.002596
K_8314 X_NUC_87.L_CORE X_NUC_102.L_CORE 0.002579
K_8315 X_NUC_87.L_CORE X_NUC_103.L_CORE 0.002570
K_8316 X_NUC_87.L_CORE X_NUC_104.L_CORE 0.002597
K_8317 X_NUC_87.L_CORE X_NUC_105.L_CORE 0.006692
K_8318 X_NUC_87.L_CORE X_NUC_106.L_CORE 0.006691
K_8319 X_NUC_87.L_CORE X_NUC_107.L_CORE 0.006522
K_8320 X_NUC_87.L_CORE X_NUC_108.L_CORE 0.006694
K_8321 X_NUC_87.L_CORE X_NUC_109.L_CORE 0.003490
K_8322 X_NUC_87.L_CORE X_NUC_110.L_CORE 0.003443
K_8323 X_NUC_87.L_CORE X_NUC_111.L_CORE 0.003439
K_8324 X_NUC_87.L_CORE X_NUC_112.L_CORE 0.003465
K_8325 X_NUC_87.L_CORE X_NUC_113.L_CORE 0.003570
K_8326 X_NUC_87.L_CORE X_NUC_114.L_CORE 0.003547
K_8327 X_NUC_87.L_CORE X_NUC_115.L_CORE 0.003516
K_8328 X_NUC_87.L_CORE X_NUC_116.L_CORE 0.003565
K_8329 X_NUC_87.L_CORE X_NUC_117.L_CORE 0.002396
K_8330 X_NUC_87.L_CORE X_NUC_118.L_CORE 0.002033
K_8331 X_NUC_87.L_CORE X_NUC_119.L_CORE 0.002233
K_8332 X_NUC_87.L_CORE X_NUC_120.L_CORE 0.002768
K_8333 X_NUC_87.L_CORE X_NUC_121.L_CORE 0.001883
K_8334 X_NUC_87.L_CORE X_NUC_122.L_CORE 0.003155
K_8335 X_NUC_87.L_CORE X_NUC_123.L_CORE 0.002299
K_8336 X_NUC_87.L_CORE X_NUC_124.L_CORE 0.002069
K_8337 X_NUC_87.L_CORE X_NUC_125.L_CORE 0.004574
K_8338 X_NUC_87.L_CORE X_NUC_126.L_CORE 0.001955
K_8339 X_NUC_87.L_CORE X_NUC_127.L_CORE 0.002964
K_8340 X_NUC_87.L_CORE X_NUC_128.L_CORE 0.003262
K_8341 X_NUC_87.L_CORE X_NUC_129.L_CORE 0.001987
K_8342 X_NUC_87.L_CORE X_NUC_130.L_CORE 0.007321
K_8343 X_NUC_87.L_CORE X_NUC_131.L_CORE 0.002329
K_8344 X_NUC_87.L_CORE X_NUC_132.L_CORE 0.002564
K_8345 X_NUC_87.L_CORE X_NUC_133.L_CORE 0.006996
K_8346 X_NUC_87.L_CORE X_NUC_134.L_CORE 0.002138
K_8347 X_NUC_87.L_CORE X_NUC_135.L_CORE 0.004923
K_8348 X_NUC_87.L_CORE X_NUC_136.L_CORE 0.003310
K_8349 X_NUC_87.L_CORE X_NUC_137.L_CORE 0.002523
K_8350 X_NUC_87.L_CORE X_NUC_138.L_CORE 0.009065
K_8351 X_NUC_87.L_CORE X_NUC_139.L_CORE 0.002817
K_8352 X_NUC_87.L_CORE X_NUC_140.L_CORE 0.003712
K_8353 X_NUC_88.L_CORE X_NUC_89.L_CORE 0.002497
K_8354 X_NUC_88.L_CORE X_NUC_90.L_CORE 0.002472
K_8355 X_NUC_88.L_CORE X_NUC_91.L_CORE 0.002476
K_8356 X_NUC_88.L_CORE X_NUC_92.L_CORE 0.002492
K_8357 X_NUC_88.L_CORE X_NUC_93.L_CORE 0.003484
K_8358 X_NUC_88.L_CORE X_NUC_94.L_CORE 0.003491
K_8359 X_NUC_88.L_CORE X_NUC_95.L_CORE 0.003455
K_8360 X_NUC_88.L_CORE X_NUC_96.L_CORE 0.003512
K_8361 X_NUC_88.L_CORE X_NUC_97.L_CORE 0.005392
K_8362 X_NUC_88.L_CORE X_NUC_98.L_CORE 0.005260
K_8363 X_NUC_88.L_CORE X_NUC_99.L_CORE 0.005299
K_8364 X_NUC_88.L_CORE X_NUC_100.L_CORE 0.005300
K_8365 X_NUC_88.L_CORE X_NUC_101.L_CORE 0.002569
K_8366 X_NUC_88.L_CORE X_NUC_102.L_CORE 0.002553
K_8367 X_NUC_88.L_CORE X_NUC_103.L_CORE 0.002544
K_8368 X_NUC_88.L_CORE X_NUC_104.L_CORE 0.002570
K_8369 X_NUC_88.L_CORE X_NUC_105.L_CORE 0.006517
K_8370 X_NUC_88.L_CORE X_NUC_106.L_CORE 0.006516
K_8371 X_NUC_88.L_CORE X_NUC_107.L_CORE 0.006357
K_8372 X_NUC_88.L_CORE X_NUC_108.L_CORE 0.006522
K_8373 X_NUC_88.L_CORE X_NUC_109.L_CORE 0.003463
K_8374 X_NUC_88.L_CORE X_NUC_110.L_CORE 0.003417
K_8375 X_NUC_88.L_CORE X_NUC_111.L_CORE 0.003413
K_8376 X_NUC_88.L_CORE X_NUC_112.L_CORE 0.003439
K_8377 X_NUC_88.L_CORE X_NUC_113.L_CORE 0.003520
K_8378 X_NUC_88.L_CORE X_NUC_114.L_CORE 0.003498
K_8379 X_NUC_88.L_CORE X_NUC_115.L_CORE 0.003467
K_8380 X_NUC_88.L_CORE X_NUC_116.L_CORE 0.003516
K_8381 X_NUC_88.L_CORE X_NUC_117.L_CORE 0.002388
K_8382 X_NUC_88.L_CORE X_NUC_118.L_CORE 0.002026
K_8383 X_NUC_88.L_CORE X_NUC_119.L_CORE 0.002218
K_8384 X_NUC_88.L_CORE X_NUC_120.L_CORE 0.002771
K_8385 X_NUC_88.L_CORE X_NUC_121.L_CORE 0.001871
K_8386 X_NUC_88.L_CORE X_NUC_122.L_CORE 0.003136
K_8387 X_NUC_88.L_CORE X_NUC_123.L_CORE 0.002296
K_8388 X_NUC_88.L_CORE X_NUC_124.L_CORE 0.002051
K_8389 X_NUC_88.L_CORE X_NUC_125.L_CORE 0.004607
K_8390 X_NUC_88.L_CORE X_NUC_126.L_CORE 0.001945
K_8391 X_NUC_88.L_CORE X_NUC_127.L_CORE 0.002931
K_8392 X_NUC_88.L_CORE X_NUC_128.L_CORE 0.003275
K_8393 X_NUC_88.L_CORE X_NUC_129.L_CORE 0.001971
K_8394 X_NUC_88.L_CORE X_NUC_130.L_CORE 0.007276
K_8395 X_NUC_88.L_CORE X_NUC_131.L_CORE 0.002321
K_8396 X_NUC_88.L_CORE X_NUC_132.L_CORE 0.002533
K_8397 X_NUC_88.L_CORE X_NUC_133.L_CORE 0.007141
K_8398 X_NUC_88.L_CORE X_NUC_134.L_CORE 0.002122
K_8399 X_NUC_88.L_CORE X_NUC_135.L_CORE 0.004826
K_8400 X_NUC_88.L_CORE X_NUC_136.L_CORE 0.003305
K_8401 X_NUC_88.L_CORE X_NUC_137.L_CORE 0.002495
K_8402 X_NUC_88.L_CORE X_NUC_138.L_CORE 0.008932
K_8403 X_NUC_88.L_CORE X_NUC_139.L_CORE 0.002796
K_8404 X_NUC_88.L_CORE X_NUC_140.L_CORE 0.003659
K_8405 X_NUC_89.L_CORE X_NUC_90.L_CORE 0.207973
K_8406 X_NUC_89.L_CORE X_NUC_91.L_CORE 0.207973
K_8407 X_NUC_89.L_CORE X_NUC_92.L_CORE 0.207973
K_8408 X_NUC_89.L_CORE X_NUC_93.L_CORE 0.002633
K_8409 X_NUC_89.L_CORE X_NUC_94.L_CORE 0.002666
K_8410 X_NUC_89.L_CORE X_NUC_95.L_CORE 0.002645
K_8411 X_NUC_89.L_CORE X_NUC_96.L_CORE 0.002651
K_8412 X_NUC_89.L_CORE X_NUC_97.L_CORE 0.003733
K_8413 X_NUC_89.L_CORE X_NUC_98.L_CORE 0.003773
K_8414 X_NUC_89.L_CORE X_NUC_99.L_CORE 0.003774
K_8415 X_NUC_89.L_CORE X_NUC_100.L_CORE 0.003720
K_8416 X_NUC_89.L_CORE X_NUC_101.L_CORE 0.005612
K_8417 X_NUC_89.L_CORE X_NUC_102.L_CORE 0.005724
K_8418 X_NUC_89.L_CORE X_NUC_103.L_CORE 0.005588
K_8419 X_NUC_89.L_CORE X_NUC_104.L_CORE 0.005682
K_8420 X_NUC_89.L_CORE X_NUC_105.L_CORE 0.002804
K_8421 X_NUC_89.L_CORE X_NUC_106.L_CORE 0.002841
K_8422 X_NUC_89.L_CORE X_NUC_107.L_CORE 0.002821
K_8423 X_NUC_89.L_CORE X_NUC_108.L_CORE 0.002812
K_8424 X_NUC_89.L_CORE X_NUC_109.L_CORE 0.006387
K_8425 X_NUC_89.L_CORE X_NUC_110.L_CORE 0.006517
K_8426 X_NUC_89.L_CORE X_NUC_111.L_CORE 0.006421
K_8427 X_NUC_89.L_CORE X_NUC_112.L_CORE 0.006323
K_8428 X_NUC_89.L_CORE X_NUC_113.L_CORE 0.003884
K_8429 X_NUC_89.L_CORE X_NUC_114.L_CORE 0.003951
K_8430 X_NUC_89.L_CORE X_NUC_115.L_CORE 0.003892
K_8431 X_NUC_89.L_CORE X_NUC_116.L_CORE 0.003899
K_8432 X_NUC_89.L_CORE X_NUC_117.L_CORE 0.002028
K_8433 X_NUC_89.L_CORE X_NUC_118.L_CORE 0.002556
K_8434 X_NUC_89.L_CORE X_NUC_119.L_CORE 0.002006
K_8435 X_NUC_89.L_CORE X_NUC_120.L_CORE 0.002234
K_8436 X_NUC_89.L_CORE X_NUC_121.L_CORE 0.002829
K_8437 X_NUC_89.L_CORE X_NUC_122.L_CORE 0.001884
K_8438 X_NUC_89.L_CORE X_NUC_123.L_CORE 0.003202
K_8439 X_NUC_89.L_CORE X_NUC_124.L_CORE 0.002330
K_8440 X_NUC_89.L_CORE X_NUC_125.L_CORE 0.002091
K_8441 X_NUC_89.L_CORE X_NUC_126.L_CORE 0.004678
K_8442 X_NUC_89.L_CORE X_NUC_127.L_CORE 0.001994
K_8443 X_NUC_89.L_CORE X_NUC_128.L_CORE 0.003016
K_8444 X_NUC_89.L_CORE X_NUC_129.L_CORE 0.003362
K_8445 X_NUC_89.L_CORE X_NUC_130.L_CORE 0.002044
K_8446 X_NUC_89.L_CORE X_NUC_131.L_CORE 0.007482
K_8447 X_NUC_89.L_CORE X_NUC_132.L_CORE 0.002423
K_8448 X_NUC_89.L_CORE X_NUC_133.L_CORE 0.002664
K_8449 X_NUC_89.L_CORE X_NUC_134.L_CORE 0.007436
K_8450 X_NUC_89.L_CORE X_NUC_135.L_CORE 0.002256
K_8451 X_NUC_89.L_CORE X_NUC_136.L_CORE 0.005154
K_8452 X_NUC_89.L_CORE X_NUC_137.L_CORE 0.003552
K_8453 X_NUC_89.L_CORE X_NUC_138.L_CORE 0.002741
K_8454 X_NUC_89.L_CORE X_NUC_139.L_CORE 0.007652
K_8455 X_NUC_89.L_CORE X_NUC_140.L_CORE 0.003298
K_8456 X_NUC_90.L_CORE X_NUC_91.L_CORE 0.207973
K_8457 X_NUC_90.L_CORE X_NUC_92.L_CORE 0.207973
K_8458 X_NUC_90.L_CORE X_NUC_93.L_CORE 0.002600
K_8459 X_NUC_90.L_CORE X_NUC_94.L_CORE 0.002633
K_8460 X_NUC_90.L_CORE X_NUC_95.L_CORE 0.002612
K_8461 X_NUC_90.L_CORE X_NUC_96.L_CORE 0.002618
K_8462 X_NUC_90.L_CORE X_NUC_97.L_CORE 0.003694
K_8463 X_NUC_90.L_CORE X_NUC_98.L_CORE 0.003733
K_8464 X_NUC_90.L_CORE X_NUC_99.L_CORE 0.003733
K_8465 X_NUC_90.L_CORE X_NUC_100.L_CORE 0.003681
K_8466 X_NUC_90.L_CORE X_NUC_101.L_CORE 0.005501
K_8467 X_NUC_90.L_CORE X_NUC_102.L_CORE 0.005612
K_8468 X_NUC_90.L_CORE X_NUC_103.L_CORE 0.005481
K_8469 X_NUC_90.L_CORE X_NUC_104.L_CORE 0.005569
K_8470 X_NUC_90.L_CORE X_NUC_105.L_CORE 0.002769
K_8471 X_NUC_90.L_CORE X_NUC_106.L_CORE 0.002804
K_8472 X_NUC_90.L_CORE X_NUC_107.L_CORE 0.002786
K_8473 X_NUC_90.L_CORE X_NUC_108.L_CORE 0.002777
K_8474 X_NUC_90.L_CORE X_NUC_109.L_CORE 0.006258
K_8475 X_NUC_90.L_CORE X_NUC_110.L_CORE 0.006387
K_8476 X_NUC_90.L_CORE X_NUC_111.L_CORE 0.006294
K_8477 X_NUC_90.L_CORE X_NUC_112.L_CORE 0.006201
K_8478 X_NUC_90.L_CORE X_NUC_113.L_CORE 0.003819
K_8479 X_NUC_90.L_CORE X_NUC_114.L_CORE 0.003884
K_8480 X_NUC_90.L_CORE X_NUC_115.L_CORE 0.003827
K_8481 X_NUC_90.L_CORE X_NUC_116.L_CORE 0.003833
K_8482 X_NUC_90.L_CORE X_NUC_117.L_CORE 0.002018
K_8483 X_NUC_90.L_CORE X_NUC_118.L_CORE 0.002551
K_8484 X_NUC_90.L_CORE X_NUC_119.L_CORE 0.001993
K_8485 X_NUC_90.L_CORE X_NUC_120.L_CORE 0.002225
K_8486 X_NUC_90.L_CORE X_NUC_121.L_CORE 0.002821
K_8487 X_NUC_90.L_CORE X_NUC_122.L_CORE 0.001870
K_8488 X_NUC_90.L_CORE X_NUC_123.L_CORE 0.003204
K_8489 X_NUC_90.L_CORE X_NUC_124.L_CORE 0.002313
K_8490 X_NUC_90.L_CORE X_NUC_125.L_CORE 0.002077
K_8491 X_NUC_90.L_CORE X_NUC_126.L_CORE 0.004702
K_8492 X_NUC_90.L_CORE X_NUC_127.L_CORE 0.001976
K_8493 X_NUC_90.L_CORE X_NUC_128.L_CORE 0.003006
K_8494 X_NUC_90.L_CORE X_NUC_129.L_CORE 0.003338
K_8495 X_NUC_90.L_CORE X_NUC_130.L_CORE 0.002026
K_8496 X_NUC_90.L_CORE X_NUC_131.L_CORE 0.007618
K_8497 X_NUC_90.L_CORE X_NUC_132.L_CORE 0.002398
K_8498 X_NUC_90.L_CORE X_NUC_133.L_CORE 0.002644
K_8499 X_NUC_90.L_CORE X_NUC_134.L_CORE 0.007393
K_8500 X_NUC_90.L_CORE X_NUC_135.L_CORE 0.002232
K_8501 X_NUC_90.L_CORE X_NUC_136.L_CORE 0.005125
K_8502 X_NUC_90.L_CORE X_NUC_137.L_CORE 0.003504
K_8503 X_NUC_90.L_CORE X_NUC_138.L_CORE 0.002711
K_8504 X_NUC_90.L_CORE X_NUC_139.L_CORE 0.007501
K_8505 X_NUC_90.L_CORE X_NUC_140.L_CORE 0.003252
K_8506 X_NUC_91.L_CORE X_NUC_92.L_CORE 0.207973
K_8507 X_NUC_91.L_CORE X_NUC_93.L_CORE 0.002620
K_8508 X_NUC_91.L_CORE X_NUC_94.L_CORE 0.002653
K_8509 X_NUC_91.L_CORE X_NUC_95.L_CORE 0.002633
K_8510 X_NUC_91.L_CORE X_NUC_96.L_CORE 0.002638
K_8511 X_NUC_91.L_CORE X_NUC_97.L_CORE 0.003693
K_8512 X_NUC_91.L_CORE X_NUC_98.L_CORE 0.003732
K_8513 X_NUC_91.L_CORE X_NUC_99.L_CORE 0.003733
K_8514 X_NUC_91.L_CORE X_NUC_100.L_CORE 0.003681
K_8515 X_NUC_91.L_CORE X_NUC_101.L_CORE 0.005631
K_8516 X_NUC_91.L_CORE X_NUC_102.L_CORE 0.005748
K_8517 X_NUC_91.L_CORE X_NUC_103.L_CORE 0.005612
K_8518 X_NUC_91.L_CORE X_NUC_104.L_CORE 0.005704
K_8519 X_NUC_91.L_CORE X_NUC_105.L_CORE 0.002787
K_8520 X_NUC_91.L_CORE X_NUC_106.L_CORE 0.002823
K_8521 X_NUC_91.L_CORE X_NUC_107.L_CORE 0.002804
K_8522 X_NUC_91.L_CORE X_NUC_108.L_CORE 0.002795
K_8523 X_NUC_91.L_CORE X_NUC_109.L_CORE 0.006346
K_8524 X_NUC_91.L_CORE X_NUC_110.L_CORE 0.006477
K_8525 X_NUC_91.L_CORE X_NUC_111.L_CORE 0.006387
K_8526 X_NUC_91.L_CORE X_NUC_112.L_CORE 0.006287
K_8527 X_NUC_91.L_CORE X_NUC_113.L_CORE 0.003874
K_8528 X_NUC_91.L_CORE X_NUC_114.L_CORE 0.003941
K_8529 X_NUC_91.L_CORE X_NUC_115.L_CORE 0.003884
K_8530 X_NUC_91.L_CORE X_NUC_116.L_CORE 0.003889
K_8531 X_NUC_91.L_CORE X_NUC_117.L_CORE 0.002009
K_8532 X_NUC_91.L_CORE X_NUC_118.L_CORE 0.002531
K_8533 X_NUC_91.L_CORE X_NUC_119.L_CORE 0.001991
K_8534 X_NUC_91.L_CORE X_NUC_120.L_CORE 0.002211
K_8535 X_NUC_91.L_CORE X_NUC_121.L_CORE 0.002809
K_8536 X_NUC_91.L_CORE X_NUC_122.L_CORE 0.001869
K_8537 X_NUC_91.L_CORE X_NUC_123.L_CORE 0.003161
K_8538 X_NUC_91.L_CORE X_NUC_124.L_CORE 0.002317
K_8539 X_NUC_91.L_CORE X_NUC_125.L_CORE 0.002071
K_8540 X_NUC_91.L_CORE X_NUC_126.L_CORE 0.004639
K_8541 X_NUC_91.L_CORE X_NUC_127.L_CORE 0.001981
K_8542 X_NUC_91.L_CORE X_NUC_128.L_CORE 0.002979
K_8543 X_NUC_91.L_CORE X_NUC_129.L_CORE 0.003355
K_8544 X_NUC_91.L_CORE X_NUC_130.L_CORE 0.002028
K_8545 X_NUC_91.L_CORE X_NUC_131.L_CORE 0.007353
K_8546 X_NUC_91.L_CORE X_NUC_132.L_CORE 0.002414
K_8547 X_NUC_91.L_CORE X_NUC_133.L_CORE 0.002639
K_8548 X_NUC_91.L_CORE X_NUC_134.L_CORE 0.007534
K_8549 X_NUC_91.L_CORE X_NUC_135.L_CORE 0.002244
K_8550 X_NUC_91.L_CORE X_NUC_136.L_CORE 0.005097
K_8551 X_NUC_91.L_CORE X_NUC_137.L_CORE 0.003554
K_8552 X_NUC_91.L_CORE X_NUC_138.L_CORE 0.002723
K_8553 X_NUC_91.L_CORE X_NUC_139.L_CORE 0.007726
K_8554 X_NUC_91.L_CORE X_NUC_140.L_CORE 0.003291
K_8555 X_NUC_92.L_CORE X_NUC_93.L_CORE 0.002614
K_8556 X_NUC_92.L_CORE X_NUC_94.L_CORE 0.002647
K_8557 X_NUC_92.L_CORE X_NUC_95.L_CORE 0.002626
K_8558 X_NUC_92.L_CORE X_NUC_96.L_CORE 0.002633
K_8559 X_NUC_92.L_CORE X_NUC_97.L_CORE 0.003746
K_8560 X_NUC_92.L_CORE X_NUC_98.L_CORE 0.003786
K_8561 X_NUC_92.L_CORE X_NUC_99.L_CORE 0.003787
K_8562 X_NUC_92.L_CORE X_NUC_100.L_CORE 0.003733
K_8563 X_NUC_92.L_CORE X_NUC_101.L_CORE 0.005540
K_8564 X_NUC_92.L_CORE X_NUC_102.L_CORE 0.005651
K_8565 X_NUC_92.L_CORE X_NUC_103.L_CORE 0.005520
K_8566 X_NUC_92.L_CORE X_NUC_104.L_CORE 0.005612
K_8567 X_NUC_92.L_CORE X_NUC_105.L_CORE 0.002796
K_8568 X_NUC_92.L_CORE X_NUC_106.L_CORE 0.002832
K_8569 X_NUC_92.L_CORE X_NUC_107.L_CORE 0.002813
K_8570 X_NUC_92.L_CORE X_NUC_108.L_CORE 0.002804
K_8571 X_NUC_92.L_CORE X_NUC_109.L_CORE 0.006446
K_8572 X_NUC_92.L_CORE X_NUC_110.L_CORE 0.006584
K_8573 X_NUC_92.L_CORE X_NUC_111.L_CORE 0.006485
K_8574 X_NUC_92.L_CORE X_NUC_112.L_CORE 0.006387
K_8575 X_NUC_92.L_CORE X_NUC_113.L_CORE 0.003868
K_8576 X_NUC_92.L_CORE X_NUC_114.L_CORE 0.003935
K_8577 X_NUC_92.L_CORE X_NUC_115.L_CORE 0.003877
K_8578 X_NUC_92.L_CORE X_NUC_116.L_CORE 0.003884
K_8579 X_NUC_92.L_CORE X_NUC_117.L_CORE 0.002013
K_8580 X_NUC_92.L_CORE X_NUC_118.L_CORE 0.002533
K_8581 X_NUC_92.L_CORE X_NUC_119.L_CORE 0.001988
K_8582 X_NUC_92.L_CORE X_NUC_120.L_CORE 0.002223
K_8583 X_NUC_92.L_CORE X_NUC_121.L_CORE 0.002794
K_8584 X_NUC_92.L_CORE X_NUC_122.L_CORE 0.001872
K_8585 X_NUC_92.L_CORE X_NUC_123.L_CORE 0.003186
K_8586 X_NUC_92.L_CORE X_NUC_124.L_CORE 0.002305
K_8587 X_NUC_92.L_CORE X_NUC_125.L_CORE 0.002084
K_8588 X_NUC_92.L_CORE X_NUC_126.L_CORE 0.004606
K_8589 X_NUC_92.L_CORE X_NUC_127.L_CORE 0.001979
K_8590 X_NUC_92.L_CORE X_NUC_128.L_CORE 0.003016
K_8591 X_NUC_92.L_CORE X_NUC_129.L_CORE 0.003313
K_8592 X_NUC_92.L_CORE X_NUC_130.L_CORE 0.002036
K_8593 X_NUC_92.L_CORE X_NUC_131.L_CORE 0.007520
K_8594 X_NUC_92.L_CORE X_NUC_132.L_CORE 0.002402
K_8595 X_NUC_92.L_CORE X_NUC_133.L_CORE 0.002665
K_8596 X_NUC_92.L_CORE X_NUC_134.L_CORE 0.007275
K_8597 X_NUC_92.L_CORE X_NUC_135.L_CORE 0.002246
K_8598 X_NUC_92.L_CORE X_NUC_136.L_CORE 0.005219
K_8599 X_NUC_92.L_CORE X_NUC_137.L_CORE 0.003520
K_8600 X_NUC_92.L_CORE X_NUC_138.L_CORE 0.002740
K_8601 X_NUC_92.L_CORE X_NUC_139.L_CORE 0.007755
K_8602 X_NUC_92.L_CORE X_NUC_140.L_CORE 0.003290
K_8603 X_NUC_93.L_CORE X_NUC_94.L_CORE 0.207973
K_8604 X_NUC_93.L_CORE X_NUC_95.L_CORE 0.207973
K_8605 X_NUC_93.L_CORE X_NUC_96.L_CORE 0.207973
K_8606 X_NUC_93.L_CORE X_NUC_97.L_CORE 0.002824
K_8607 X_NUC_93.L_CORE X_NUC_98.L_CORE 0.002801
K_8608 X_NUC_93.L_CORE X_NUC_99.L_CORE 0.002826
K_8609 X_NUC_93.L_CORE X_NUC_100.L_CORE 0.002796
K_8610 X_NUC_93.L_CORE X_NUC_101.L_CORE 0.004038
K_8611 X_NUC_93.L_CORE X_NUC_102.L_CORE 0.003963
K_8612 X_NUC_93.L_CORE X_NUC_103.L_CORE 0.003986
K_8613 X_NUC_93.L_CORE X_NUC_104.L_CORE 0.003998
K_8614 X_NUC_93.L_CORE X_NUC_105.L_CORE 0.006012
K_8615 X_NUC_93.L_CORE X_NUC_106.L_CORE 0.005974
K_8616 X_NUC_93.L_CORE X_NUC_107.L_CORE 0.006034
K_8617 X_NUC_93.L_CORE X_NUC_108.L_CORE 0.005877
K_8618 X_NUC_93.L_CORE X_NUC_109.L_CORE 0.003171
K_8619 X_NUC_93.L_CORE X_NUC_110.L_CORE 0.003130
K_8620 X_NUC_93.L_CORE X_NUC_111.L_CORE 0.003154
K_8621 X_NUC_93.L_CORE X_NUC_112.L_CORE 0.003132
K_8622 X_NUC_93.L_CORE X_NUC_113.L_CORE 0.005880
K_8623 X_NUC_93.L_CORE X_NUC_114.L_CORE 0.005746
K_8624 X_NUC_93.L_CORE X_NUC_115.L_CORE 0.005775
K_8625 X_NUC_93.L_CORE X_NUC_116.L_CORE 0.005733
K_8626 X_NUC_93.L_CORE X_NUC_117.L_CORE 0.002134
K_8627 X_NUC_93.L_CORE X_NUC_118.L_CORE 0.001945
K_8628 X_NUC_93.L_CORE X_NUC_119.L_CORE 0.002634
K_8629 X_NUC_93.L_CORE X_NUC_120.L_CORE 0.001979
K_8630 X_NUC_93.L_CORE X_NUC_121.L_CORE 0.002223
K_8631 X_NUC_93.L_CORE X_NUC_122.L_CORE 0.002851
K_8632 X_NUC_93.L_CORE X_NUC_123.L_CORE 0.001879
K_8633 X_NUC_93.L_CORE X_NUC_124.L_CORE 0.003217
K_8634 X_NUC_93.L_CORE X_NUC_125.L_CORE 0.002345
K_8635 X_NUC_93.L_CORE X_NUC_126.L_CORE 0.002107
K_8636 X_NUC_93.L_CORE X_NUC_127.L_CORE 0.004716
K_8637 X_NUC_93.L_CORE X_NUC_128.L_CORE 0.002026
K_8638 X_NUC_93.L_CORE X_NUC_129.L_CORE 0.003062
K_8639 X_NUC_93.L_CORE X_NUC_130.L_CORE 0.003443
K_8640 X_NUC_93.L_CORE X_NUC_131.L_CORE 0.002099
K_8641 X_NUC_93.L_CORE X_NUC_132.L_CORE 0.007678
K_8642 X_NUC_93.L_CORE X_NUC_133.L_CORE 0.002516
K_8643 X_NUC_93.L_CORE X_NUC_134.L_CORE 0.002775
K_8644 X_NUC_93.L_CORE X_NUC_135.L_CORE 0.007933
K_8645 X_NUC_93.L_CORE X_NUC_136.L_CORE 0.002390
K_8646 X_NUC_93.L_CORE X_NUC_137.L_CORE 0.005459
K_8647 X_NUC_93.L_CORE X_NUC_138.L_CORE 0.003842
K_8648 X_NUC_93.L_CORE X_NUC_139.L_CORE 0.003052
K_8649 X_NUC_93.L_CORE X_NUC_140.L_CORE 0.006026
K_8650 X_NUC_94.L_CORE X_NUC_95.L_CORE 0.207973
K_8651 X_NUC_94.L_CORE X_NUC_96.L_CORE 0.207973
K_8652 X_NUC_94.L_CORE X_NUC_97.L_CORE 0.002847
K_8653 X_NUC_94.L_CORE X_NUC_98.L_CORE 0.002824
K_8654 X_NUC_94.L_CORE X_NUC_99.L_CORE 0.002849
K_8655 X_NUC_94.L_CORE X_NUC_100.L_CORE 0.002819
K_8656 X_NUC_94.L_CORE X_NUC_101.L_CORE 0.004116
K_8657 X_NUC_94.L_CORE X_NUC_102.L_CORE 0.004038
K_8658 X_NUC_94.L_CORE X_NUC_103.L_CORE 0.004061
K_8659 X_NUC_94.L_CORE X_NUC_104.L_CORE 0.004074
K_8660 X_NUC_94.L_CORE X_NUC_105.L_CORE 0.006045
K_8661 X_NUC_94.L_CORE X_NUC_106.L_CORE 0.006012
K_8662 X_NUC_94.L_CORE X_NUC_107.L_CORE 0.006070
K_8663 X_NUC_94.L_CORE X_NUC_108.L_CORE 0.005911
K_8664 X_NUC_94.L_CORE X_NUC_109.L_CORE 0.003213
K_8665 X_NUC_94.L_CORE X_NUC_110.L_CORE 0.003171
K_8666 X_NUC_94.L_CORE X_NUC_111.L_CORE 0.003195
K_8667 X_NUC_94.L_CORE X_NUC_112.L_CORE 0.003173
K_8668 X_NUC_94.L_CORE X_NUC_113.L_CORE 0.006018
K_8669 X_NUC_94.L_CORE X_NUC_114.L_CORE 0.005880
K_8670 X_NUC_94.L_CORE X_NUC_115.L_CORE 0.005908
K_8671 X_NUC_94.L_CORE X_NUC_116.L_CORE 0.005863
K_8672 X_NUC_94.L_CORE X_NUC_117.L_CORE 0.002140
K_8673 X_NUC_94.L_CORE X_NUC_118.L_CORE 0.001956
K_8674 X_NUC_94.L_CORE X_NUC_119.L_CORE 0.002637
K_8675 X_NUC_94.L_CORE X_NUC_120.L_CORE 0.001986
K_8676 X_NUC_94.L_CORE X_NUC_121.L_CORE 0.002239
K_8677 X_NUC_94.L_CORE X_NUC_122.L_CORE 0.002844
K_8678 X_NUC_94.L_CORE X_NUC_123.L_CORE 0.001892
K_8679 X_NUC_94.L_CORE X_NUC_124.L_CORE 0.003231
K_8680 X_NUC_94.L_CORE X_NUC_125.L_CORE 0.002349
K_8681 X_NUC_94.L_CORE X_NUC_126.L_CORE 0.002126
K_8682 X_NUC_94.L_CORE X_NUC_127.L_CORE 0.004668
K_8683 X_NUC_94.L_CORE X_NUC_128.L_CORE 0.002038
K_8684 X_NUC_94.L_CORE X_NUC_129.L_CORE 0.003096
K_8685 X_NUC_94.L_CORE X_NUC_130.L_CORE 0.003429
K_8686 X_NUC_94.L_CORE X_NUC_131.L_CORE 0.002119
K_8687 X_NUC_94.L_CORE X_NUC_132.L_CORE 0.007682
K_8688 X_NUC_94.L_CORE X_NUC_133.L_CORE 0.002527
K_8689 X_NUC_94.L_CORE X_NUC_134.L_CORE 0.002812
K_8690 X_NUC_94.L_CORE X_NUC_135.L_CORE 0.007769
K_8691 X_NUC_94.L_CORE X_NUC_136.L_CORE 0.002412
K_8692 X_NUC_94.L_CORE X_NUC_137.L_CORE 0.005579
K_8693 X_NUC_94.L_CORE X_NUC_138.L_CORE 0.003859
K_8694 X_NUC_94.L_CORE X_NUC_139.L_CORE 0.003094
K_8695 X_NUC_94.L_CORE X_NUC_140.L_CORE 0.006132
K_8696 X_NUC_95.L_CORE X_NUC_96.L_CORE 0.207973
K_8697 X_NUC_95.L_CORE X_NUC_97.L_CORE 0.002821
K_8698 X_NUC_95.L_CORE X_NUC_98.L_CORE 0.002798
K_8699 X_NUC_95.L_CORE X_NUC_99.L_CORE 0.002824
K_8700 X_NUC_95.L_CORE X_NUC_100.L_CORE 0.002794
K_8701 X_NUC_95.L_CORE X_NUC_101.L_CORE 0.004090
K_8702 X_NUC_95.L_CORE X_NUC_102.L_CORE 0.004013
K_8703 X_NUC_95.L_CORE X_NUC_103.L_CORE 0.004038
K_8704 X_NUC_95.L_CORE X_NUC_104.L_CORE 0.004050
K_8705 X_NUC_95.L_CORE X_NUC_105.L_CORE 0.005985
K_8706 X_NUC_95.L_CORE X_NUC_106.L_CORE 0.005950
K_8707 X_NUC_95.L_CORE X_NUC_107.L_CORE 0.006012
K_8708 X_NUC_95.L_CORE X_NUC_108.L_CORE 0.005855
K_8709 X_NUC_95.L_CORE X_NUC_109.L_CORE 0.003188
K_8710 X_NUC_95.L_CORE X_NUC_110.L_CORE 0.003146
K_8711 X_NUC_95.L_CORE X_NUC_111.L_CORE 0.003171
K_8712 X_NUC_95.L_CORE X_NUC_112.L_CORE 0.003148
K_8713 X_NUC_95.L_CORE X_NUC_113.L_CORE 0.005985
K_8714 X_NUC_95.L_CORE X_NUC_114.L_CORE 0.005847
K_8715 X_NUC_95.L_CORE X_NUC_115.L_CORE 0.005880
K_8716 X_NUC_95.L_CORE X_NUC_116.L_CORE 0.005833
K_8717 X_NUC_95.L_CORE X_NUC_117.L_CORE 0.002119
K_8718 X_NUC_95.L_CORE X_NUC_118.L_CORE 0.001938
K_8719 X_NUC_95.L_CORE X_NUC_119.L_CORE 0.002612
K_8720 X_NUC_95.L_CORE X_NUC_120.L_CORE 0.001967
K_8721 X_NUC_95.L_CORE X_NUC_121.L_CORE 0.002220
K_8722 X_NUC_95.L_CORE X_NUC_122.L_CORE 0.002815
K_8723 X_NUC_95.L_CORE X_NUC_123.L_CORE 0.001875
K_8724 X_NUC_95.L_CORE X_NUC_124.L_CORE 0.003206
K_8725 X_NUC_95.L_CORE X_NUC_125.L_CORE 0.002326
K_8726 X_NUC_95.L_CORE X_NUC_126.L_CORE 0.002110
K_8727 X_NUC_95.L_CORE X_NUC_127.L_CORE 0.004624
K_8728 X_NUC_95.L_CORE X_NUC_128.L_CORE 0.002020
K_8729 X_NUC_95.L_CORE X_NUC_129.L_CORE 0.003076
K_8730 X_NUC_95.L_CORE X_NUC_130.L_CORE 0.003395
K_8731 X_NUC_95.L_CORE X_NUC_131.L_CORE 0.002102
K_8732 X_NUC_95.L_CORE X_NUC_132.L_CORE 0.007684
K_8733 X_NUC_95.L_CORE X_NUC_133.L_CORE 0.002505
K_8734 X_NUC_95.L_CORE X_NUC_134.L_CORE 0.002795
K_8735 X_NUC_95.L_CORE X_NUC_135.L_CORE 0.007724
K_8736 X_NUC_95.L_CORE X_NUC_136.L_CORE 0.002393
K_8737 X_NUC_95.L_CORE X_NUC_137.L_CORE 0.005581
K_8738 X_NUC_95.L_CORE X_NUC_138.L_CORE 0.003830
K_8739 X_NUC_95.L_CORE X_NUC_139.L_CORE 0.003077
K_8740 X_NUC_95.L_CORE X_NUC_140.L_CORE 0.006133
K_8741 X_NUC_96.L_CORE X_NUC_97.L_CORE 0.002852
K_8742 X_NUC_96.L_CORE X_NUC_98.L_CORE 0.002828
K_8743 X_NUC_96.L_CORE X_NUC_99.L_CORE 0.002854
K_8744 X_NUC_96.L_CORE X_NUC_100.L_CORE 0.002824
K_8745 X_NUC_96.L_CORE X_NUC_101.L_CORE 0.004077
K_8746 X_NUC_96.L_CORE X_NUC_102.L_CORE 0.004001
K_8747 X_NUC_96.L_CORE X_NUC_103.L_CORE 0.004024
K_8748 X_NUC_96.L_CORE X_NUC_104.L_CORE 0.004038
K_8749 X_NUC_96.L_CORE X_NUC_105.L_CORE 0.006151
K_8750 X_NUC_96.L_CORE X_NUC_106.L_CORE 0.006113
K_8751 X_NUC_96.L_CORE X_NUC_107.L_CORE 0.006177
K_8752 X_NUC_96.L_CORE X_NUC_108.L_CORE 0.006012
K_8753 X_NUC_96.L_CORE X_NUC_109.L_CORE 0.003211
K_8754 X_NUC_96.L_CORE X_NUC_110.L_CORE 0.003169
K_8755 X_NUC_96.L_CORE X_NUC_111.L_CORE 0.003194
K_8756 X_NUC_96.L_CORE X_NUC_112.L_CORE 0.003171
K_8757 X_NUC_96.L_CORE X_NUC_113.L_CORE 0.006033
K_8758 X_NUC_96.L_CORE X_NUC_114.L_CORE 0.005892
K_8759 X_NUC_96.L_CORE X_NUC_115.L_CORE 0.005923
K_8760 X_NUC_96.L_CORE X_NUC_116.L_CORE 0.005880
K_8761 X_NUC_96.L_CORE X_NUC_117.L_CORE 0.002127
K_8762 X_NUC_96.L_CORE X_NUC_118.L_CORE 0.001942
K_8763 X_NUC_96.L_CORE X_NUC_119.L_CORE 0.002612
K_8764 X_NUC_96.L_CORE X_NUC_120.L_CORE 0.001978
K_8765 X_NUC_96.L_CORE X_NUC_121.L_CORE 0.002217
K_8766 X_NUC_96.L_CORE X_NUC_122.L_CORE 0.002832
K_8767 X_NUC_96.L_CORE X_NUC_123.L_CORE 0.001883
K_8768 X_NUC_96.L_CORE X_NUC_124.L_CORE 0.003184
K_8769 X_NUC_96.L_CORE X_NUC_125.L_CORE 0.002347
K_8770 X_NUC_96.L_CORE X_NUC_126.L_CORE 0.002110
K_8771 X_NUC_96.L_CORE X_NUC_127.L_CORE 0.004628
K_8772 X_NUC_96.L_CORE X_NUC_128.L_CORE 0.002034
K_8773 X_NUC_96.L_CORE X_NUC_129.L_CORE 0.003053
K_8774 X_NUC_96.L_CORE X_NUC_130.L_CORE 0.003444
K_8775 X_NUC_96.L_CORE X_NUC_131.L_CORE 0.002109
K_8776 X_NUC_96.L_CORE X_NUC_132.L_CORE 0.007458
K_8777 X_NUC_96.L_CORE X_NUC_133.L_CORE 0.002533
K_8778 X_NUC_96.L_CORE X_NUC_134.L_CORE 0.002788
K_8779 X_NUC_96.L_CORE X_NUC_135.L_CORE 0.007971
K_8780 X_NUC_96.L_CORE X_NUC_136.L_CORE 0.002410
K_8781 X_NUC_96.L_CORE X_NUC_137.L_CORE 0.005505
K_8782 X_NUC_96.L_CORE X_NUC_138.L_CORE 0.003898
K_8783 X_NUC_96.L_CORE X_NUC_139.L_CORE 0.003088
K_8784 X_NUC_96.L_CORE X_NUC_140.L_CORE 0.006203
K_8785 X_NUC_97.L_CORE X_NUC_98.L_CORE 0.207973
K_8786 X_NUC_97.L_CORE X_NUC_99.L_CORE 0.207973
K_8787 X_NUC_97.L_CORE X_NUC_100.L_CORE 0.207973
K_8788 X_NUC_97.L_CORE X_NUC_101.L_CORE 0.003095
K_8789 X_NUC_97.L_CORE X_NUC_102.L_CORE 0.003090
K_8790 X_NUC_97.L_CORE X_NUC_103.L_CORE 0.003068
K_8791 X_NUC_97.L_CORE X_NUC_104.L_CORE 0.003114
K_8792 X_NUC_97.L_CORE X_NUC_105.L_CORE 0.004479
K_8793 X_NUC_97.L_CORE X_NUC_106.L_CORE 0.004558
K_8794 X_NUC_97.L_CORE X_NUC_107.L_CORE 0.004479
K_8795 X_NUC_97.L_CORE X_NUC_108.L_CORE 0.004535
K_8796 X_NUC_97.L_CORE X_NUC_109.L_CORE 0.006507
K_8797 X_NUC_97.L_CORE X_NUC_110.L_CORE 0.006432
K_8798 X_NUC_97.L_CORE X_NUC_111.L_CORE 0.006337
K_8799 X_NUC_97.L_CORE X_NUC_112.L_CORE 0.006507
K_8800 X_NUC_97.L_CORE X_NUC_113.L_CORE 0.003898
K_8801 X_NUC_97.L_CORE X_NUC_114.L_CORE 0.003919
K_8802 X_NUC_97.L_CORE X_NUC_115.L_CORE 0.003861
K_8803 X_NUC_97.L_CORE X_NUC_116.L_CORE 0.003928
K_8804 X_NUC_97.L_CORE X_NUC_117.L_CORE 0.002131
K_8805 X_NUC_97.L_CORE X_NUC_118.L_CORE 0.002148
K_8806 X_NUC_97.L_CORE X_NUC_119.L_CORE 0.001925
K_8807 X_NUC_97.L_CORE X_NUC_120.L_CORE 0.002682
K_8808 X_NUC_97.L_CORE X_NUC_121.L_CORE 0.001981
K_8809 X_NUC_97.L_CORE X_NUC_122.L_CORE 0.002250
K_8810 X_NUC_97.L_CORE X_NUC_123.L_CORE 0.002853
K_8811 X_NUC_97.L_CORE X_NUC_124.L_CORE 0.001913
K_8812 X_NUC_97.L_CORE X_NUC_125.L_CORE 0.003250
K_8813 X_NUC_97.L_CORE X_NUC_126.L_CORE 0.002380
K_8814 X_NUC_97.L_CORE X_NUC_127.L_CORE 0.002174
K_8815 X_NUC_97.L_CORE X_NUC_128.L_CORE 0.004640
K_8816 X_NUC_97.L_CORE X_NUC_129.L_CORE 0.002097
K_8817 X_NUC_97.L_CORE X_NUC_130.L_CORE 0.003189
K_8818 X_NUC_97.L_CORE X_NUC_131.L_CORE 0.003522
K_8819 X_NUC_97.L_CORE X_NUC_132.L_CORE 0.002214
K_8820 X_NUC_97.L_CORE X_NUC_133.L_CORE 0.007877
K_8821 X_NUC_97.L_CORE X_NUC_134.L_CORE 0.002666
K_8822 X_NUC_97.L_CORE X_NUC_135.L_CORE 0.003003
K_8823 X_NUC_97.L_CORE X_NUC_136.L_CORE 0.008284
K_8824 X_NUC_97.L_CORE X_NUC_137.L_CORE 0.002628
K_8825 X_NUC_97.L_CORE X_NUC_138.L_CORE 0.006128
K_8826 X_NUC_97.L_CORE X_NUC_139.L_CORE 0.004321
K_8827 X_NUC_97.L_CORE X_NUC_140.L_CORE 0.003765
K_8828 X_NUC_98.L_CORE X_NUC_99.L_CORE 0.207973
K_8829 X_NUC_98.L_CORE X_NUC_100.L_CORE 0.207973
K_8830 X_NUC_98.L_CORE X_NUC_101.L_CORE 0.003098
K_8831 X_NUC_98.L_CORE X_NUC_102.L_CORE 0.003095
K_8832 X_NUC_98.L_CORE X_NUC_103.L_CORE 0.003072
K_8833 X_NUC_98.L_CORE X_NUC_104.L_CORE 0.003118
K_8834 X_NUC_98.L_CORE X_NUC_105.L_CORE 0.004402
K_8835 X_NUC_98.L_CORE X_NUC_106.L_CORE 0.004479
K_8836 X_NUC_98.L_CORE X_NUC_107.L_CORE 0.004403
K_8837 X_NUC_98.L_CORE X_NUC_108.L_CORE 0.004456
K_8838 X_NUC_98.L_CORE X_NUC_109.L_CORE 0.006579
K_8839 X_NUC_98.L_CORE X_NUC_110.L_CORE 0.006507
K_8840 X_NUC_98.L_CORE X_NUC_111.L_CORE 0.006406
K_8841 X_NUC_98.L_CORE X_NUC_112.L_CORE 0.006582
K_8842 X_NUC_98.L_CORE X_NUC_113.L_CORE 0.003876
K_8843 X_NUC_98.L_CORE X_NUC_114.L_CORE 0.003898
K_8844 X_NUC_98.L_CORE X_NUC_115.L_CORE 0.003841
K_8845 X_NUC_98.L_CORE X_NUC_116.L_CORE 0.003906
K_8846 X_NUC_98.L_CORE X_NUC_117.L_CORE 0.002126
K_8847 X_NUC_98.L_CORE X_NUC_118.L_CORE 0.002152
K_8848 X_NUC_98.L_CORE X_NUC_119.L_CORE 0.001919
K_8849 X_NUC_98.L_CORE X_NUC_120.L_CORE 0.002680
K_8850 X_NUC_98.L_CORE X_NUC_121.L_CORE 0.001984
K_8851 X_NUC_98.L_CORE X_NUC_122.L_CORE 0.002235
K_8852 X_NUC_98.L_CORE X_NUC_123.L_CORE 0.002872
K_8853 X_NUC_98.L_CORE X_NUC_124.L_CORE 0.001908
K_8854 X_NUC_98.L_CORE X_NUC_125.L_CORE 0.003224
K_8855 X_NUC_98.L_CORE X_NUC_126.L_CORE 0.002394
K_8856 X_NUC_98.L_CORE X_NUC_127.L_CORE 0.002158
K_8857 X_NUC_98.L_CORE X_NUC_128.L_CORE 0.004680
K_8858 X_NUC_98.L_CORE X_NUC_129.L_CORE 0.002098
K_8859 X_NUC_98.L_CORE X_NUC_130.L_CORE 0.003146
K_8860 X_NUC_98.L_CORE X_NUC_131.L_CORE 0.003570
K_8861 X_NUC_98.L_CORE X_NUC_132.L_CORE 0.002203
K_8862 X_NUC_98.L_CORE X_NUC_133.L_CORE 0.007718
K_8863 X_NUC_98.L_CORE X_NUC_134.L_CORE 0.002679
K_8864 X_NUC_98.L_CORE X_NUC_135.L_CORE 0.002966
K_8865 X_NUC_98.L_CORE X_NUC_136.L_CORE 0.008617
K_8866 X_NUC_98.L_CORE X_NUC_137.L_CORE 0.002622
K_8867 X_NUC_98.L_CORE X_NUC_138.L_CORE 0.005966
K_8868 X_NUC_98.L_CORE X_NUC_139.L_CORE 0.004355
K_8869 X_NUC_98.L_CORE X_NUC_140.L_CORE 0.003736
K_8870 X_NUC_99.L_CORE X_NUC_100.L_CORE 0.207973
K_8871 X_NUC_99.L_CORE X_NUC_101.L_CORE 0.003121
K_8872 X_NUC_99.L_CORE X_NUC_102.L_CORE 0.003117
K_8873 X_NUC_99.L_CORE X_NUC_103.L_CORE 0.003095
K_8874 X_NUC_99.L_CORE X_NUC_104.L_CORE 0.003141
K_8875 X_NUC_99.L_CORE X_NUC_105.L_CORE 0.004477
K_8876 X_NUC_99.L_CORE X_NUC_106.L_CORE 0.004557
K_8877 X_NUC_99.L_CORE X_NUC_107.L_CORE 0.004479
K_8878 X_NUC_99.L_CORE X_NUC_108.L_CORE 0.004534
K_8879 X_NUC_99.L_CORE X_NUC_109.L_CORE 0.006685
K_8880 X_NUC_99.L_CORE X_NUC_110.L_CORE 0.006607
K_8881 X_NUC_99.L_CORE X_NUC_111.L_CORE 0.006507
K_8882 X_NUC_99.L_CORE X_NUC_112.L_CORE 0.006688
K_8883 X_NUC_99.L_CORE X_NUC_113.L_CORE 0.003935
K_8884 X_NUC_99.L_CORE X_NUC_114.L_CORE 0.003957
K_8885 X_NUC_99.L_CORE X_NUC_115.L_CORE 0.003898
K_8886 X_NUC_99.L_CORE X_NUC_116.L_CORE 0.003966
K_8887 X_NUC_99.L_CORE X_NUC_117.L_CORE 0.002117
K_8888 X_NUC_99.L_CORE X_NUC_118.L_CORE 0.002140
K_8889 X_NUC_99.L_CORE X_NUC_119.L_CORE 0.001917
K_8890 X_NUC_99.L_CORE X_NUC_120.L_CORE 0.002656
K_8891 X_NUC_99.L_CORE X_NUC_121.L_CORE 0.001980
K_8892 X_NUC_99.L_CORE X_NUC_122.L_CORE 0.002233
K_8893 X_NUC_99.L_CORE X_NUC_123.L_CORE 0.002842
K_8894 X_NUC_99.L_CORE X_NUC_124.L_CORE 0.001911
K_8895 X_NUC_99.L_CORE X_NUC_125.L_CORE 0.003203
K_8896 X_NUC_99.L_CORE X_NUC_126.L_CORE 0.002386
K_8897 X_NUC_99.L_CORE X_NUC_127.L_CORE 0.002165
K_8898 X_NUC_99.L_CORE X_NUC_128.L_CORE 0.004580
K_8899 X_NUC_99.L_CORE X_NUC_129.L_CORE 0.002103
K_8900 X_NUC_99.L_CORE X_NUC_130.L_CORE 0.003154
K_8901 X_NUC_99.L_CORE X_NUC_131.L_CORE 0.003542
K_8902 X_NUC_99.L_CORE X_NUC_132.L_CORE 0.002215
K_8903 X_NUC_99.L_CORE X_NUC_133.L_CORE 0.007599
K_8904 X_NUC_99.L_CORE X_NUC_134.L_CORE 0.002685
K_8905 X_NUC_99.L_CORE X_NUC_135.L_CORE 0.002994
K_8906 X_NUC_99.L_CORE X_NUC_136.L_CORE 0.008491
K_8907 X_NUC_99.L_CORE X_NUC_137.L_CORE 0.002643
K_8908 X_NUC_99.L_CORE X_NUC_138.L_CORE 0.006104
K_8909 X_NUC_99.L_CORE X_NUC_139.L_CORE 0.004398
K_8910 X_NUC_99.L_CORE X_NUC_140.L_CORE 0.003797
K_8911 X_NUC_100.L_CORE X_NUC_101.L_CORE 0.003075
K_8912 X_NUC_100.L_CORE X_NUC_102.L_CORE 0.003072
K_8913 X_NUC_100.L_CORE X_NUC_103.L_CORE 0.003050
K_8914 X_NUC_100.L_CORE X_NUC_104.L_CORE 0.003095
K_8915 X_NUC_100.L_CORE X_NUC_105.L_CORE 0.004423
K_8916 X_NUC_100.L_CORE X_NUC_106.L_CORE 0.004500
K_8917 X_NUC_100.L_CORE X_NUC_107.L_CORE 0.004424
K_8918 X_NUC_100.L_CORE X_NUC_108.L_CORE 0.004479
K_8919 X_NUC_100.L_CORE X_NUC_109.L_CORE 0.006501
K_8920 X_NUC_100.L_CORE X_NUC_110.L_CORE 0.006429
K_8921 X_NUC_100.L_CORE X_NUC_111.L_CORE 0.006334
K_8922 X_NUC_100.L_CORE X_NUC_112.L_CORE 0.006507
K_8923 X_NUC_100.L_CORE X_NUC_113.L_CORE 0.003868
K_8924 X_NUC_100.L_CORE X_NUC_114.L_CORE 0.003889
K_8925 X_NUC_100.L_CORE X_NUC_115.L_CORE 0.003832
K_8926 X_NUC_100.L_CORE X_NUC_116.L_CORE 0.003898
K_8927 X_NUC_100.L_CORE X_NUC_117.L_CORE 0.002112
K_8928 X_NUC_100.L_CORE X_NUC_118.L_CORE 0.002132
K_8929 X_NUC_100.L_CORE X_NUC_119.L_CORE 0.001908
K_8930 X_NUC_100.L_CORE X_NUC_120.L_CORE 0.002658
K_8931 X_NUC_100.L_CORE X_NUC_121.L_CORE 0.001967
K_8932 X_NUC_100.L_CORE X_NUC_122.L_CORE 0.002227
K_8933 X_NUC_100.L_CORE X_NUC_123.L_CORE 0.002836
K_8934 X_NUC_100.L_CORE X_NUC_124.L_CORE 0.001897
K_8935 X_NUC_100.L_CORE X_NUC_125.L_CORE 0.003213
K_8936 X_NUC_100.L_CORE X_NUC_126.L_CORE 0.002367
K_8937 X_NUC_100.L_CORE X_NUC_127.L_CORE 0.002152
K_8938 X_NUC_100.L_CORE X_NUC_128.L_CORE 0.004615
K_8939 X_NUC_100.L_CORE X_NUC_129.L_CORE 0.002083
K_8940 X_NUC_100.L_CORE X_NUC_130.L_CORE 0.003150
K_8941 X_NUC_100.L_CORE X_NUC_131.L_CORE 0.003515
K_8942 X_NUC_100.L_CORE X_NUC_132.L_CORE 0.002195
K_8943 X_NUC_100.L_CORE X_NUC_133.L_CORE 0.007784
K_8944 X_NUC_100.L_CORE X_NUC_134.L_CORE 0.002654
K_8945 X_NUC_100.L_CORE X_NUC_135.L_CORE 0.002971
K_8946 X_NUC_100.L_CORE X_NUC_136.L_CORE 0.008412
K_8947 X_NUC_100.L_CORE X_NUC_137.L_CORE 0.002610
K_8948 X_NUC_100.L_CORE X_NUC_138.L_CORE 0.006062
K_8949 X_NUC_100.L_CORE X_NUC_139.L_CORE 0.004319
K_8950 X_NUC_100.L_CORE X_NUC_140.L_CORE 0.003740
K_8951 X_NUC_101.L_CORE X_NUC_102.L_CORE 0.207973
K_8952 X_NUC_101.L_CORE X_NUC_103.L_CORE 0.207973
K_8953 X_NUC_101.L_CORE X_NUC_104.L_CORE 0.207973
K_8954 X_NUC_101.L_CORE X_NUC_105.L_CORE 0.003508
K_8955 X_NUC_101.L_CORE X_NUC_106.L_CORE 0.003551
K_8956 X_NUC_101.L_CORE X_NUC_107.L_CORE 0.003547
K_8957 X_NUC_101.L_CORE X_NUC_108.L_CORE 0.003506
K_8958 X_NUC_101.L_CORE X_NUC_109.L_CORE 0.005178
K_8959 X_NUC_101.L_CORE X_NUC_110.L_CORE 0.005158
K_8960 X_NUC_101.L_CORE X_NUC_111.L_CORE 0.005213
K_8961 X_NUC_101.L_CORE X_NUC_112.L_CORE 0.005090
K_8962 X_NUC_101.L_CORE X_NUC_113.L_CORE 0.006933
K_8963 X_NUC_101.L_CORE X_NUC_114.L_CORE 0.007100
K_8964 X_NUC_101.L_CORE X_NUC_115.L_CORE 0.007024
K_8965 X_NUC_101.L_CORE X_NUC_116.L_CORE 0.006884
K_8966 X_NUC_101.L_CORE X_NUC_117.L_CORE 0.001928
K_8967 X_NUC_101.L_CORE X_NUC_118.L_CORE 0.002163
K_8968 X_NUC_101.L_CORE X_NUC_119.L_CORE 0.002165
K_8969 X_NUC_101.L_CORE X_NUC_120.L_CORE 0.001920
K_8970 X_NUC_101.L_CORE X_NUC_121.L_CORE 0.002695
K_8971 X_NUC_101.L_CORE X_NUC_122.L_CORE 0.002006
K_8972 X_NUC_101.L_CORE X_NUC_123.L_CORE 0.002260
K_8973 X_NUC_101.L_CORE X_NUC_124.L_CORE 0.002877
K_8974 X_NUC_101.L_CORE X_NUC_125.L_CORE 0.001958
K_8975 X_NUC_101.L_CORE X_NUC_126.L_CORE 0.003224
K_8976 X_NUC_101.L_CORE X_NUC_127.L_CORE 0.002456
K_8977 X_NUC_101.L_CORE X_NUC_128.L_CORE 0.002235
K_8978 X_NUC_101.L_CORE X_NUC_129.L_CORE 0.004586
K_8979 X_NUC_101.L_CORE X_NUC_130.L_CORE 0.002199
K_8980 X_NUC_101.L_CORE X_NUC_131.L_CORE 0.003263
K_8981 X_NUC_101.L_CORE X_NUC_132.L_CORE 0.003714
K_8982 X_NUC_101.L_CORE X_NUC_133.L_CORE 0.002350
K_8983 X_NUC_101.L_CORE X_NUC_134.L_CORE 0.007750
K_8984 X_NUC_101.L_CORE X_NUC_135.L_CORE 0.002901
K_8985 X_NUC_101.L_CORE X_NUC_136.L_CORE 0.003249
K_8986 X_NUC_101.L_CORE X_NUC_137.L_CORE 0.009482
K_8987 X_NUC_101.L_CORE X_NUC_138.L_CORE 0.002980
K_8988 X_NUC_101.L_CORE X_NUC_139.L_CORE 0.006756
K_8989 X_NUC_101.L_CORE X_NUC_140.L_CORE 0.005200
K_8990 X_NUC_102.L_CORE X_NUC_103.L_CORE 0.207973
K_8991 X_NUC_102.L_CORE X_NUC_104.L_CORE 0.207973
K_8992 X_NUC_102.L_CORE X_NUC_105.L_CORE 0.003465
K_8993 X_NUC_102.L_CORE X_NUC_106.L_CORE 0.003508
K_8994 X_NUC_102.L_CORE X_NUC_107.L_CORE 0.003504
K_8995 X_NUC_102.L_CORE X_NUC_108.L_CORE 0.003464
K_8996 X_NUC_102.L_CORE X_NUC_109.L_CORE 0.005195
K_8997 X_NUC_102.L_CORE X_NUC_110.L_CORE 0.005178
K_8998 X_NUC_102.L_CORE X_NUC_111.L_CORE 0.005233
K_8999 X_NUC_102.L_CORE X_NUC_112.L_CORE 0.005108
K_9000 X_NUC_102.L_CORE X_NUC_113.L_CORE 0.006770
K_9001 X_NUC_102.L_CORE X_NUC_114.L_CORE 0.006933
K_9002 X_NUC_102.L_CORE X_NUC_115.L_CORE 0.006858
K_9003 X_NUC_102.L_CORE X_NUC_116.L_CORE 0.006728
K_9004 X_NUC_102.L_CORE X_NUC_117.L_CORE 0.001923
K_9005 X_NUC_102.L_CORE X_NUC_118.L_CORE 0.002166
K_9006 X_NUC_102.L_CORE X_NUC_119.L_CORE 0.002155
K_9007 X_NUC_102.L_CORE X_NUC_120.L_CORE 0.001918
K_9008 X_NUC_102.L_CORE X_NUC_121.L_CORE 0.002700
K_9009 X_NUC_102.L_CORE X_NUC_122.L_CORE 0.001994
K_9010 X_NUC_102.L_CORE X_NUC_123.L_CORE 0.002268
K_9011 X_NUC_102.L_CORE X_NUC_124.L_CORE 0.002860
K_9012 X_NUC_102.L_CORE X_NUC_125.L_CORE 0.001951
K_9013 X_NUC_102.L_CORE X_NUC_126.L_CORE 0.003253
K_9014 X_NUC_102.L_CORE X_NUC_127.L_CORE 0.002432
K_9015 X_NUC_102.L_CORE X_NUC_128.L_CORE 0.002238
K_9016 X_NUC_102.L_CORE X_NUC_129.L_CORE 0.004584
K_9017 X_NUC_102.L_CORE X_NUC_130.L_CORE 0.002183
K_9018 X_NUC_102.L_CORE X_NUC_131.L_CORE 0.003296
K_9019 X_NUC_102.L_CORE X_NUC_132.L_CORE 0.003656
K_9020 X_NUC_102.L_CORE X_NUC_133.L_CORE 0.002344
K_9021 X_NUC_102.L_CORE X_NUC_134.L_CORE 0.008007
K_9022 X_NUC_102.L_CORE X_NUC_135.L_CORE 0.002865
K_9023 X_NUC_102.L_CORE X_NUC_136.L_CORE 0.003263
K_9024 X_NUC_102.L_CORE X_NUC_137.L_CORE 0.009122
K_9025 X_NUC_102.L_CORE X_NUC_138.L_CORE 0.002958
K_9026 X_NUC_102.L_CORE X_NUC_139.L_CORE 0.006845
K_9027 X_NUC_102.L_CORE X_NUC_140.L_CORE 0.005106
K_9028 X_NUC_103.L_CORE X_NUC_104.L_CORE 0.207973
K_9029 X_NUC_103.L_CORE X_NUC_105.L_CORE 0.003469
K_9030 X_NUC_103.L_CORE X_NUC_106.L_CORE 0.003511
K_9031 X_NUC_103.L_CORE X_NUC_107.L_CORE 0.003508
K_9032 X_NUC_103.L_CORE X_NUC_108.L_CORE 0.003468
K_9033 X_NUC_103.L_CORE X_NUC_109.L_CORE 0.005140
K_9034 X_NUC_103.L_CORE X_NUC_110.L_CORE 0.005121
K_9035 X_NUC_103.L_CORE X_NUC_111.L_CORE 0.005178
K_9036 X_NUC_103.L_CORE X_NUC_112.L_CORE 0.005055
K_9037 X_NUC_103.L_CORE X_NUC_113.L_CORE 0.006838
K_9038 X_NUC_103.L_CORE X_NUC_114.L_CORE 0.007002
K_9039 X_NUC_103.L_CORE X_NUC_115.L_CORE 0.006933
K_9040 X_NUC_103.L_CORE X_NUC_116.L_CORE 0.006795
K_9041 X_NUC_103.L_CORE X_NUC_117.L_CORE 0.001911
K_9042 X_NUC_103.L_CORE X_NUC_118.L_CORE 0.002146
K_9043 X_NUC_103.L_CORE X_NUC_119.L_CORE 0.002145
K_9044 X_NUC_103.L_CORE X_NUC_120.L_CORE 0.001904
K_9045 X_NUC_103.L_CORE X_NUC_121.L_CORE 0.002675
K_9046 X_NUC_103.L_CORE X_NUC_122.L_CORE 0.001987
K_9047 X_NUC_103.L_CORE X_NUC_123.L_CORE 0.002244
K_9048 X_NUC_103.L_CORE X_NUC_124.L_CORE 0.002851
K_9049 X_NUC_103.L_CORE X_NUC_125.L_CORE 0.001940
K_9050 X_NUC_103.L_CORE X_NUC_126.L_CORE 0.003207
K_9051 X_NUC_103.L_CORE X_NUC_127.L_CORE 0.002431
K_9052 X_NUC_103.L_CORE X_NUC_128.L_CORE 0.002218
K_9053 X_NUC_103.L_CORE X_NUC_129.L_CORE 0.004556
K_9054 X_NUC_103.L_CORE X_NUC_130.L_CORE 0.002178
K_9055 X_NUC_103.L_CORE X_NUC_131.L_CORE 0.003248
K_9056 X_NUC_103.L_CORE X_NUC_132.L_CORE 0.003675
K_9057 X_NUC_103.L_CORE X_NUC_133.L_CORE 0.002331
K_9058 X_NUC_103.L_CORE X_NUC_134.L_CORE 0.007802
K_9059 X_NUC_103.L_CORE X_NUC_135.L_CORE 0.002872
K_9060 X_NUC_103.L_CORE X_NUC_136.L_CORE 0.003230
K_9061 X_NUC_103.L_CORE X_NUC_137.L_CORE 0.009426
K_9062 X_NUC_103.L_CORE X_NUC_138.L_CORE 0.002954
K_9063 X_NUC_103.L_CORE X_NUC_139.L_CORE 0.006768
K_9064 X_NUC_103.L_CORE X_NUC_140.L_CORE 0.005156
K_9065 X_NUC_104.L_CORE X_NUC_105.L_CORE 0.003509
K_9066 X_NUC_104.L_CORE X_NUC_106.L_CORE 0.003553
K_9067 X_NUC_104.L_CORE X_NUC_107.L_CORE 0.003549
K_9068 X_NUC_104.L_CORE X_NUC_108.L_CORE 0.003508
K_9069 X_NUC_104.L_CORE X_NUC_109.L_CORE 0.005267
K_9070 X_NUC_104.L_CORE X_NUC_110.L_CORE 0.005247
K_9071 X_NUC_104.L_CORE X_NUC_111.L_CORE 0.005306
K_9072 X_NUC_104.L_CORE X_NUC_112.L_CORE 0.005178
K_9073 X_NUC_104.L_CORE X_NUC_113.L_CORE 0.006975
K_9074 X_NUC_104.L_CORE X_NUC_114.L_CORE 0.007149
K_9075 X_NUC_104.L_CORE X_NUC_115.L_CORE 0.007071
K_9076 X_NUC_104.L_CORE X_NUC_116.L_CORE 0.006933
K_9077 X_NUC_104.L_CORE X_NUC_117.L_CORE 0.001918
K_9078 X_NUC_104.L_CORE X_NUC_118.L_CORE 0.002153
K_9079 X_NUC_104.L_CORE X_NUC_119.L_CORE 0.002146
K_9080 X_NUC_104.L_CORE X_NUC_120.L_CORE 0.001916
K_9081 X_NUC_104.L_CORE X_NUC_121.L_CORE 0.002672
K_9082 X_NUC_104.L_CORE X_NUC_122.L_CORE 0.001995
K_9083 X_NUC_104.L_CORE X_NUC_123.L_CORE 0.002259
K_9084 X_NUC_104.L_CORE X_NUC_124.L_CORE 0.002839
K_9085 X_NUC_104.L_CORE X_NUC_125.L_CORE 0.001954
K_9086 X_NUC_104.L_CORE X_NUC_126.L_CORE 0.003213
K_9087 X_NUC_104.L_CORE X_NUC_127.L_CORE 0.002434
K_9088 X_NUC_104.L_CORE X_NUC_128.L_CORE 0.002239
K_9089 X_NUC_104.L_CORE X_NUC_129.L_CORE 0.004499
K_9090 X_NUC_104.L_CORE X_NUC_130.L_CORE 0.002193
K_9091 X_NUC_104.L_CORE X_NUC_131.L_CORE 0.003280
K_9092 X_NUC_104.L_CORE X_NUC_132.L_CORE 0.003658
K_9093 X_NUC_104.L_CORE X_NUC_133.L_CORE 0.002356
K_9094 X_NUC_104.L_CORE X_NUC_134.L_CORE 0.007748
K_9095 X_NUC_104.L_CORE X_NUC_135.L_CORE 0.002888
K_9096 X_NUC_104.L_CORE X_NUC_136.L_CORE 0.003279
K_9097 X_NUC_104.L_CORE X_NUC_137.L_CORE 0.009221
K_9098 X_NUC_104.L_CORE X_NUC_138.L_CORE 0.002990
K_9099 X_NUC_104.L_CORE X_NUC_139.L_CORE 0.006957
K_9100 X_NUC_104.L_CORE X_NUC_140.L_CORE 0.005225
K_9101 X_NUC_105.L_CORE X_NUC_106.L_CORE 0.207973
K_9102 X_NUC_105.L_CORE X_NUC_107.L_CORE 0.207973
K_9103 X_NUC_105.L_CORE X_NUC_108.L_CORE 0.207973
K_9104 X_NUC_105.L_CORE X_NUC_109.L_CORE 0.004230
K_9105 X_NUC_105.L_CORE X_NUC_110.L_CORE 0.004146
K_9106 X_NUC_105.L_CORE X_NUC_111.L_CORE 0.004182
K_9107 X_NUC_105.L_CORE X_NUC_112.L_CORE 0.004184
K_9108 X_NUC_105.L_CORE X_NUC_113.L_CORE 0.006479
K_9109 X_NUC_105.L_CORE X_NUC_114.L_CORE 0.006343
K_9110 X_NUC_105.L_CORE X_NUC_115.L_CORE 0.006311
K_9111 X_NUC_105.L_CORE X_NUC_116.L_CORE 0.006446
K_9112 X_NUC_105.L_CORE X_NUC_117.L_CORE 0.002069
K_9113 X_NUC_105.L_CORE X_NUC_118.L_CORE 0.001882
K_9114 X_NUC_105.L_CORE X_NUC_119.L_CORE 0.002181
K_9115 X_NUC_105.L_CORE X_NUC_120.L_CORE 0.002166
K_9116 X_NUC_105.L_CORE X_NUC_121.L_CORE 0.001934
K_9117 X_NUC_105.L_CORE X_NUC_122.L_CORE 0.002687
K_9118 X_NUC_105.L_CORE X_NUC_123.L_CORE 0.002030
K_9119 X_NUC_105.L_CORE X_NUC_124.L_CORE 0.002296
K_9120 X_NUC_105.L_CORE X_NUC_125.L_CORE 0.002860
K_9121 X_NUC_105.L_CORE X_NUC_126.L_CORE 0.002015
K_9122 X_NUC_105.L_CORE X_NUC_127.L_CORE 0.003232
K_9123 X_NUC_105.L_CORE X_NUC_128.L_CORE 0.002511
K_9124 X_NUC_105.L_CORE X_NUC_129.L_CORE 0.002330
K_9125 X_NUC_105.L_CORE X_NUC_130.L_CORE 0.004475
K_9126 X_NUC_105.L_CORE X_NUC_131.L_CORE 0.002310
K_9127 X_NUC_105.L_CORE X_NUC_132.L_CORE 0.003425
K_9128 X_NUC_105.L_CORE X_NUC_133.L_CORE 0.003842
K_9129 X_NUC_105.L_CORE X_NUC_134.L_CORE 0.002533
K_9130 X_NUC_105.L_CORE X_NUC_135.L_CORE 0.007991
K_9131 X_NUC_105.L_CORE X_NUC_136.L_CORE 0.003170
K_9132 X_NUC_105.L_CORE X_NUC_137.L_CORE 0.003656
K_9133 X_NUC_105.L_CORE X_NUC_138.L_CORE 0.010537
K_9134 X_NUC_105.L_CORE X_NUC_139.L_CORE 0.003546
K_9135 X_NUC_105.L_CORE X_NUC_140.L_CORE 0.007671
K_9136 X_NUC_106.L_CORE X_NUC_107.L_CORE 0.207973
K_9137 X_NUC_106.L_CORE X_NUC_108.L_CORE 0.207973
K_9138 X_NUC_106.L_CORE X_NUC_109.L_CORE 0.004318
K_9139 X_NUC_106.L_CORE X_NUC_110.L_CORE 0.004230
K_9140 X_NUC_106.L_CORE X_NUC_111.L_CORE 0.004267
K_9141 X_NUC_106.L_CORE X_NUC_112.L_CORE 0.004270
K_9142 X_NUC_106.L_CORE X_NUC_113.L_CORE 0.006617
K_9143 X_NUC_106.L_CORE X_NUC_114.L_CORE 0.006479
K_9144 X_NUC_106.L_CORE X_NUC_115.L_CORE 0.006442
K_9145 X_NUC_106.L_CORE X_NUC_116.L_CORE 0.006585
K_9146 X_NUC_106.L_CORE X_NUC_117.L_CORE 0.002072
K_9147 X_NUC_106.L_CORE X_NUC_118.L_CORE 0.001891
K_9148 X_NUC_106.L_CORE X_NUC_119.L_CORE 0.002181
K_9149 X_NUC_106.L_CORE X_NUC_120.L_CORE 0.002173
K_9150 X_NUC_106.L_CORE X_NUC_121.L_CORE 0.001943
K_9151 X_NUC_106.L_CORE X_NUC_122.L_CORE 0.002678
K_9152 X_NUC_106.L_CORE X_NUC_123.L_CORE 0.002044
K_9153 X_NUC_106.L_CORE X_NUC_124.L_CORE 0.002300
K_9154 X_NUC_106.L_CORE X_NUC_125.L_CORE 0.002862
K_9155 X_NUC_106.L_CORE X_NUC_126.L_CORE 0.002030
K_9156 X_NUC_106.L_CORE X_NUC_127.L_CORE 0.003211
K_9157 X_NUC_106.L_CORE X_NUC_128.L_CORE 0.002531
K_9158 X_NUC_106.L_CORE X_NUC_129.L_CORE 0.002343
K_9159 X_NUC_106.L_CORE X_NUC_130.L_CORE 0.004431
K_9160 X_NUC_106.L_CORE X_NUC_131.L_CORE 0.002335
K_9161 X_NUC_106.L_CORE X_NUC_132.L_CORE 0.003418
K_9162 X_NUC_106.L_CORE X_NUC_133.L_CORE 0.003873
K_9163 X_NUC_106.L_CORE X_NUC_134.L_CORE 0.002558
K_9164 X_NUC_106.L_CORE X_NUC_135.L_CORE 0.007746
K_9165 X_NUC_106.L_CORE X_NUC_136.L_CORE 0.003217
K_9166 X_NUC_106.L_CORE X_NUC_137.L_CORE 0.003683
K_9167 X_NUC_106.L_CORE X_NUC_138.L_CORE 0.010698
K_9168 X_NUC_106.L_CORE X_NUC_139.L_CORE 0.003605
K_9169 X_NUC_106.L_CORE X_NUC_140.L_CORE 0.007815
K_9170 X_NUC_107.L_CORE X_NUC_108.L_CORE 0.207973
K_9171 X_NUC_107.L_CORE X_NUC_109.L_CORE 0.004279
K_9172 X_NUC_107.L_CORE X_NUC_110.L_CORE 0.004193
K_9173 X_NUC_107.L_CORE X_NUC_111.L_CORE 0.004230
K_9174 X_NUC_107.L_CORE X_NUC_112.L_CORE 0.004232
K_9175 X_NUC_107.L_CORE X_NUC_113.L_CORE 0.006654
K_9176 X_NUC_107.L_CORE X_NUC_114.L_CORE 0.006510
K_9177 X_NUC_107.L_CORE X_NUC_115.L_CORE 0.006479
K_9178 X_NUC_107.L_CORE X_NUC_116.L_CORE 0.006621
K_9179 X_NUC_107.L_CORE X_NUC_117.L_CORE 0.002056
K_9180 X_NUC_107.L_CORE X_NUC_118.L_CORE 0.001877
K_9181 X_NUC_107.L_CORE X_NUC_119.L_CORE 0.002169
K_9182 X_NUC_107.L_CORE X_NUC_120.L_CORE 0.002152
K_9183 X_NUC_107.L_CORE X_NUC_121.L_CORE 0.001933
K_9184 X_NUC_107.L_CORE X_NUC_122.L_CORE 0.002659
K_9185 X_NUC_107.L_CORE X_NUC_123.L_CORE 0.002026
K_9186 X_NUC_107.L_CORE X_NUC_124.L_CORE 0.002294
K_9187 X_NUC_107.L_CORE X_NUC_125.L_CORE 0.002827
K_9188 X_NUC_107.L_CORE X_NUC_126.L_CORE 0.002018
K_9189 X_NUC_107.L_CORE X_NUC_127.L_CORE 0.003206
K_9190 X_NUC_107.L_CORE X_NUC_128.L_CORE 0.002502
K_9191 X_NUC_107.L_CORE X_NUC_129.L_CORE 0.002338
K_9192 X_NUC_107.L_CORE X_NUC_130.L_CORE 0.004381
K_9193 X_NUC_107.L_CORE X_NUC_131.L_CORE 0.002316
K_9194 X_NUC_107.L_CORE X_NUC_132.L_CORE 0.003430
K_9195 X_NUC_107.L_CORE X_NUC_133.L_CORE 0.003809
K_9196 X_NUC_107.L_CORE X_NUC_134.L_CORE 0.002550
K_9197 X_NUC_107.L_CORE X_NUC_135.L_CORE 0.007831
K_9198 X_NUC_107.L_CORE X_NUC_136.L_CORE 0.003182
K_9199 X_NUC_107.L_CORE X_NUC_137.L_CORE 0.003697
K_9200 X_NUC_107.L_CORE X_NUC_138.L_CORE 0.010429
K_9201 X_NUC_107.L_CORE X_NUC_139.L_CORE 0.003589
K_9202 X_NUC_107.L_CORE X_NUC_140.L_CORE 0.007951
K_9203 X_NUC_108.L_CORE X_NUC_109.L_CORE 0.004276
K_9204 X_NUC_108.L_CORE X_NUC_110.L_CORE 0.004190
K_9205 X_NUC_108.L_CORE X_NUC_111.L_CORE 0.004227
K_9206 X_NUC_108.L_CORE X_NUC_112.L_CORE 0.004230
K_9207 X_NUC_108.L_CORE X_NUC_113.L_CORE 0.006506
K_9208 X_NUC_108.L_CORE X_NUC_114.L_CORE 0.006371
K_9209 X_NUC_108.L_CORE X_NUC_115.L_CORE 0.006339
K_9210 X_NUC_108.L_CORE X_NUC_116.L_CORE 0.006479
K_9211 X_NUC_108.L_CORE X_NUC_117.L_CORE 0.002056
K_9212 X_NUC_108.L_CORE X_NUC_118.L_CORE 0.001875
K_9213 X_NUC_108.L_CORE X_NUC_119.L_CORE 0.002162
K_9214 X_NUC_108.L_CORE X_NUC_120.L_CORE 0.002159
K_9215 X_NUC_108.L_CORE X_NUC_121.L_CORE 0.001925
K_9216 X_NUC_108.L_CORE X_NUC_122.L_CORE 0.002659
K_9217 X_NUC_108.L_CORE X_NUC_123.L_CORE 0.002029
K_9218 X_NUC_108.L_CORE X_NUC_124.L_CORE 0.002277
K_9219 X_NUC_108.L_CORE X_NUC_125.L_CORE 0.002849
K_9220 X_NUC_108.L_CORE X_NUC_126.L_CORE 0.002012
K_9221 X_NUC_108.L_CORE X_NUC_127.L_CORE 0.003183
K_9222 X_NUC_108.L_CORE X_NUC_128.L_CORE 0.002517
K_9223 X_NUC_108.L_CORE X_NUC_129.L_CORE 0.002318
K_9224 X_NUC_108.L_CORE X_NUC_130.L_CORE 0.004423
K_9225 X_NUC_108.L_CORE X_NUC_131.L_CORE 0.002316
K_9226 X_NUC_108.L_CORE X_NUC_132.L_CORE 0.003380
K_9227 X_NUC_108.L_CORE X_NUC_133.L_CORE 0.003867
K_9228 X_NUC_108.L_CORE X_NUC_134.L_CORE 0.002533
K_9229 X_NUC_108.L_CORE X_NUC_135.L_CORE 0.007722
K_9230 X_NUC_108.L_CORE X_NUC_136.L_CORE 0.003198
K_9231 X_NUC_108.L_CORE X_NUC_137.L_CORE 0.003639
K_9232 X_NUC_108.L_CORE X_NUC_138.L_CORE 0.010947
K_9233 X_NUC_108.L_CORE X_NUC_139.L_CORE 0.003573
K_9234 X_NUC_108.L_CORE X_NUC_140.L_CORE 0.007738
K_9235 X_NUC_109.L_CORE X_NUC_110.L_CORE 0.207973
K_9236 X_NUC_109.L_CORE X_NUC_111.L_CORE 0.207973
K_9237 X_NUC_109.L_CORE X_NUC_112.L_CORE 0.207973
K_9238 X_NUC_109.L_CORE X_NUC_113.L_CORE 0.006000
K_9239 X_NUC_109.L_CORE X_NUC_114.L_CORE 0.006138
K_9240 X_NUC_109.L_CORE X_NUC_115.L_CORE 0.006000
K_9241 X_NUC_109.L_CORE X_NUC_116.L_CORE 0.006109
K_9242 X_NUC_109.L_CORE X_NUC_117.L_CORE 0.001927
K_9243 X_NUC_109.L_CORE X_NUC_118.L_CORE 0.002107
K_9244 X_NUC_109.L_CORE X_NUC_119.L_CORE 0.001898
K_9245 X_NUC_109.L_CORE X_NUC_120.L_CORE 0.002186
K_9246 X_NUC_109.L_CORE X_NUC_121.L_CORE 0.002180
K_9247 X_NUC_109.L_CORE X_NUC_122.L_CORE 0.001990
K_9248 X_NUC_109.L_CORE X_NUC_123.L_CORE 0.002624
K_9249 X_NUC_109.L_CORE X_NUC_124.L_CORE 0.002103
K_9250 X_NUC_109.L_CORE X_NUC_125.L_CORE 0.002352
K_9251 X_NUC_109.L_CORE X_NUC_126.L_CORE 0.002821
K_9252 X_NUC_109.L_CORE X_NUC_127.L_CORE 0.002139
K_9253 X_NUC_109.L_CORE X_NUC_128.L_CORE 0.003170
K_9254 X_NUC_109.L_CORE X_NUC_129.L_CORE 0.002628
K_9255 X_NUC_109.L_CORE X_NUC_130.L_CORE 0.002495
K_9256 X_NUC_109.L_CORE X_NUC_131.L_CORE 0.004204
K_9257 X_NUC_109.L_CORE X_NUC_132.L_CORE 0.002531
K_9258 X_NUC_109.L_CORE X_NUC_133.L_CORE 0.003610
K_9259 X_NUC_109.L_CORE X_NUC_134.L_CORE 0.004050
K_9260 X_NUC_109.L_CORE X_NUC_135.L_CORE 0.002875
K_9261 X_NUC_109.L_CORE X_NUC_136.L_CORE 0.007586
K_9262 X_NUC_109.L_CORE X_NUC_137.L_CORE 0.003712
K_9263 X_NUC_109.L_CORE X_NUC_138.L_CORE 0.004422
K_9264 X_NUC_109.L_CORE X_NUC_139.L_CORE 0.012825
K_9265 X_NUC_109.L_CORE X_NUC_140.L_CORE 0.005132
K_9266 X_NUC_110.L_CORE X_NUC_111.L_CORE 0.207973
K_9267 X_NUC_110.L_CORE X_NUC_112.L_CORE 0.207973
K_9268 X_NUC_110.L_CORE X_NUC_113.L_CORE 0.005866
K_9269 X_NUC_110.L_CORE X_NUC_114.L_CORE 0.006000
K_9270 X_NUC_110.L_CORE X_NUC_115.L_CORE 0.005869
K_9271 X_NUC_110.L_CORE X_NUC_116.L_CORE 0.005970
K_9272 X_NUC_110.L_CORE X_NUC_117.L_CORE 0.001921
K_9273 X_NUC_110.L_CORE X_NUC_118.L_CORE 0.002108
K_9274 X_NUC_110.L_CORE X_NUC_119.L_CORE 0.001890
K_9275 X_NUC_110.L_CORE X_NUC_120.L_CORE 0.002182
K_9276 X_NUC_110.L_CORE X_NUC_121.L_CORE 0.002181
K_9277 X_NUC_110.L_CORE X_NUC_122.L_CORE 0.001978
K_9278 X_NUC_110.L_CORE X_NUC_123.L_CORE 0.002634
K_9279 X_NUC_110.L_CORE X_NUC_124.L_CORE 0.002095
K_9280 X_NUC_110.L_CORE X_NUC_125.L_CORE 0.002339
K_9281 X_NUC_110.L_CORE X_NUC_126.L_CORE 0.002838
K_9282 X_NUC_110.L_CORE X_NUC_127.L_CORE 0.002122
K_9283 X_NUC_110.L_CORE X_NUC_128.L_CORE 0.003174
K_9284 X_NUC_110.L_CORE X_NUC_129.L_CORE 0.002625
K_9285 X_NUC_110.L_CORE X_NUC_130.L_CORE 0.002470
K_9286 X_NUC_110.L_CORE X_NUC_131.L_CORE 0.004265
K_9287 X_NUC_110.L_CORE X_NUC_132.L_CORE 0.002510
K_9288 X_NUC_110.L_CORE X_NUC_133.L_CORE 0.003582
K_9289 X_NUC_110.L_CORE X_NUC_134.L_CORE 0.004076
K_9290 X_NUC_110.L_CORE X_NUC_135.L_CORE 0.002837
K_9291 X_NUC_110.L_CORE X_NUC_136.L_CORE 0.007715
K_9292 X_NUC_110.L_CORE X_NUC_137.L_CORE 0.003683
K_9293 X_NUC_110.L_CORE X_NUC_138.L_CORE 0.004339
K_9294 X_NUC_110.L_CORE X_NUC_139.L_CORE 0.013156
K_9295 X_NUC_110.L_CORE X_NUC_140.L_CORE 0.005025
K_9296 X_NUC_111.L_CORE X_NUC_112.L_CORE 0.207973
K_9297 X_NUC_111.L_CORE X_NUC_113.L_CORE 0.005995
K_9298 X_NUC_111.L_CORE X_NUC_114.L_CORE 0.006136
K_9299 X_NUC_111.L_CORE X_NUC_115.L_CORE 0.006000
K_9300 X_NUC_111.L_CORE X_NUC_116.L_CORE 0.006106
K_9301 X_NUC_111.L_CORE X_NUC_117.L_CORE 0.001912
K_9302 X_NUC_111.L_CORE X_NUC_118.L_CORE 0.002094
K_9303 X_NUC_111.L_CORE X_NUC_119.L_CORE 0.001886
K_9304 X_NUC_111.L_CORE X_NUC_120.L_CORE 0.002166
K_9305 X_NUC_111.L_CORE X_NUC_121.L_CORE 0.002172
K_9306 X_NUC_111.L_CORE X_NUC_122.L_CORE 0.001974
K_9307 X_NUC_111.L_CORE X_NUC_123.L_CORE 0.002604
K_9308 X_NUC_111.L_CORE X_NUC_124.L_CORE 0.002095
K_9309 X_NUC_111.L_CORE X_NUC_125.L_CORE 0.002326
K_9310 X_NUC_111.L_CORE X_NUC_126.L_CORE 0.002816
K_9311 X_NUC_111.L_CORE X_NUC_127.L_CORE 0.002125
K_9312 X_NUC_111.L_CORE X_NUC_128.L_CORE 0.003131
K_9313 X_NUC_111.L_CORE X_NUC_129.L_CORE 0.002627
K_9314 X_NUC_111.L_CORE X_NUC_130.L_CORE 0.002469
K_9315 X_NUC_111.L_CORE X_NUC_131.L_CORE 0.004191
K_9316 X_NUC_111.L_CORE X_NUC_132.L_CORE 0.002523
K_9317 X_NUC_111.L_CORE X_NUC_133.L_CORE 0.003553
K_9318 X_NUC_111.L_CORE X_NUC_134.L_CORE 0.004075
K_9319 X_NUC_111.L_CORE X_NUC_135.L_CORE 0.002852
K_9320 X_NUC_111.L_CORE X_NUC_136.L_CORE 0.007467
K_9321 X_NUC_111.L_CORE X_NUC_137.L_CORE 0.003723
K_9322 X_NUC_111.L_CORE X_NUC_138.L_CORE 0.004360
K_9323 X_NUC_111.L_CORE X_NUC_139.L_CORE 0.013528
K_9324 X_NUC_111.L_CORE X_NUC_140.L_CORE 0.005125
K_9325 X_NUC_112.L_CORE X_NUC_113.L_CORE 0.005893
K_9326 X_NUC_112.L_CORE X_NUC_114.L_CORE 0.006026
K_9327 X_NUC_112.L_CORE X_NUC_115.L_CORE 0.005895
K_9328 X_NUC_112.L_CORE X_NUC_116.L_CORE 0.006000
K_9329 X_NUC_112.L_CORE X_NUC_117.L_CORE 0.001912
K_9330 X_NUC_112.L_CORE X_NUC_118.L_CORE 0.002092
K_9331 X_NUC_112.L_CORE X_NUC_119.L_CORE 0.001881
K_9332 X_NUC_112.L_CORE X_NUC_120.L_CORE 0.002173
K_9333 X_NUC_112.L_CORE X_NUC_121.L_CORE 0.002161
K_9334 X_NUC_112.L_CORE X_NUC_122.L_CORE 0.001974
K_9335 X_NUC_112.L_CORE X_NUC_123.L_CORE 0.002611
K_9336 X_NUC_112.L_CORE X_NUC_124.L_CORE 0.002083
K_9337 X_NUC_112.L_CORE X_NUC_125.L_CORE 0.002338
K_9338 X_NUC_112.L_CORE X_NUC_126.L_CORE 0.002800
K_9339 X_NUC_112.L_CORE X_NUC_127.L_CORE 0.002119
K_9340 X_NUC_112.L_CORE X_NUC_128.L_CORE 0.003162
K_9341 X_NUC_112.L_CORE X_NUC_129.L_CORE 0.002600
K_9342 X_NUC_112.L_CORE X_NUC_130.L_CORE 0.002477
K_9343 X_NUC_112.L_CORE X_NUC_131.L_CORE 0.004193
K_9344 X_NUC_112.L_CORE X_NUC_132.L_CORE 0.002503
K_9345 X_NUC_112.L_CORE X_NUC_133.L_CORE 0.003601
K_9346 X_NUC_112.L_CORE X_NUC_134.L_CORE 0.004008
K_9347 X_NUC_112.L_CORE X_NUC_135.L_CORE 0.002848
K_9348 X_NUC_112.L_CORE X_NUC_136.L_CORE 0.007689
K_9349 X_NUC_112.L_CORE X_NUC_137.L_CORE 0.003664
K_9350 X_NUC_112.L_CORE X_NUC_138.L_CORE 0.004399
K_9351 X_NUC_112.L_CORE X_NUC_139.L_CORE 0.012801
K_9352 X_NUC_112.L_CORE X_NUC_140.L_CORE 0.005071
K_9353 X_NUC_113.L_CORE X_NUC_114.L_CORE 0.207973
K_9354 X_NUC_113.L_CORE X_NUC_115.L_CORE 0.207973
K_9355 X_NUC_113.L_CORE X_NUC_116.L_CORE 0.207973
K_9356 X_NUC_113.L_CORE X_NUC_117.L_CORE 0.001903
K_9357 X_NUC_113.L_CORE X_NUC_118.L_CORE 0.001928
K_9358 X_NUC_113.L_CORE X_NUC_119.L_CORE 0.002090
K_9359 X_NUC_113.L_CORE X_NUC_120.L_CORE 0.001947
K_9360 X_NUC_113.L_CORE X_NUC_121.L_CORE 0.002164
K_9361 X_NUC_113.L_CORE X_NUC_122.L_CORE 0.002192
K_9362 X_NUC_113.L_CORE X_NUC_123.L_CORE 0.002073
K_9363 X_NUC_113.L_CORE X_NUC_124.L_CORE 0.002508
K_9364 X_NUC_113.L_CORE X_NUC_125.L_CORE 0.002214
K_9365 X_NUC_113.L_CORE X_NUC_126.L_CORE 0.002401
K_9366 X_NUC_113.L_CORE X_NUC_127.L_CORE 0.002752
K_9367 X_NUC_113.L_CORE X_NUC_128.L_CORE 0.002322
K_9368 X_NUC_113.L_CORE X_NUC_129.L_CORE 0.003033
K_9369 X_NUC_113.L_CORE X_NUC_130.L_CORE 0.002786
K_9370 X_NUC_113.L_CORE X_NUC_131.L_CORE 0.002712
K_9371 X_NUC_113.L_CORE X_NUC_132.L_CORE 0.003857
K_9372 X_NUC_113.L_CORE X_NUC_133.L_CORE 0.002878
K_9373 X_NUC_113.L_CORE X_NUC_134.L_CORE 0.003755
K_9374 X_NUC_113.L_CORE X_NUC_135.L_CORE 0.004295
K_9375 X_NUC_113.L_CORE X_NUC_136.L_CORE 0.003438
K_9376 X_NUC_113.L_CORE X_NUC_137.L_CORE 0.006865
K_9377 X_NUC_113.L_CORE X_NUC_138.L_CORE 0.004747
K_9378 X_NUC_113.L_CORE X_NUC_139.L_CORE 0.005932
K_9379 X_NUC_113.L_CORE X_NUC_140.L_CORE 0.019825
K_9380 X_NUC_114.L_CORE X_NUC_115.L_CORE 0.207973
K_9381 X_NUC_114.L_CORE X_NUC_116.L_CORE 0.207973
K_9382 X_NUC_114.L_CORE X_NUC_117.L_CORE 0.001902
K_9383 X_NUC_114.L_CORE X_NUC_118.L_CORE 0.001934
K_9384 X_NUC_114.L_CORE X_NUC_119.L_CORE 0.002086
K_9385 X_NUC_114.L_CORE X_NUC_120.L_CORE 0.001949
K_9386 X_NUC_114.L_CORE X_NUC_121.L_CORE 0.002171
K_9387 X_NUC_114.L_CORE X_NUC_122.L_CORE 0.002182
K_9388 X_NUC_114.L_CORE X_NUC_123.L_CORE 0.002084
K_9389 X_NUC_114.L_CORE X_NUC_124.L_CORE 0.002504
K_9390 X_NUC_114.L_CORE X_NUC_125.L_CORE 0.002209
K_9391 X_NUC_114.L_CORE X_NUC_126.L_CORE 0.002420
K_9392 X_NUC_114.L_CORE X_NUC_127.L_CORE 0.002729
K_9393 X_NUC_114.L_CORE X_NUC_128.L_CORE 0.002332
K_9394 X_NUC_114.L_CORE X_NUC_129.L_CORE 0.003047
K_9395 X_NUC_114.L_CORE X_NUC_130.L_CORE 0.002765
K_9396 X_NUC_114.L_CORE X_NUC_131.L_CORE 0.002741
K_9397 X_NUC_114.L_CORE X_NUC_132.L_CORE 0.003820
K_9398 X_NUC_114.L_CORE X_NUC_133.L_CORE 0.002878
K_9399 X_NUC_114.L_CORE X_NUC_134.L_CORE 0.003811
K_9400 X_NUC_114.L_CORE X_NUC_135.L_CORE 0.004218
K_9401 X_NUC_114.L_CORE X_NUC_136.L_CORE 0.003475
K_9402 X_NUC_114.L_CORE X_NUC_137.L_CORE 0.006880
K_9403 X_NUC_114.L_CORE X_NUC_138.L_CORE 0.004708
K_9404 X_NUC_114.L_CORE X_NUC_139.L_CORE 0.006102
K_9405 X_NUC_114.L_CORE X_NUC_140.L_CORE 0.018471
K_9406 X_NUC_115.L_CORE X_NUC_116.L_CORE 0.207973
K_9407 X_NUC_115.L_CORE X_NUC_117.L_CORE 0.001889
K_9408 X_NUC_115.L_CORE X_NUC_118.L_CORE 0.001918
K_9409 X_NUC_115.L_CORE X_NUC_119.L_CORE 0.002075
K_9410 X_NUC_115.L_CORE X_NUC_120.L_CORE 0.001933
K_9411 X_NUC_115.L_CORE X_NUC_121.L_CORE 0.002156
K_9412 X_NUC_115.L_CORE X_NUC_122.L_CORE 0.002170
K_9413 X_NUC_115.L_CORE X_NUC_123.L_CORE 0.002063
K_9414 X_NUC_115.L_CORE X_NUC_124.L_CORE 0.002495
K_9415 X_NUC_115.L_CORE X_NUC_125.L_CORE 0.002192
K_9416 X_NUC_115.L_CORE X_NUC_126.L_CORE 0.002397
K_9417 X_NUC_115.L_CORE X_NUC_127.L_CORE 0.002723
K_9418 X_NUC_115.L_CORE X_NUC_128.L_CORE 0.002307
K_9419 X_NUC_115.L_CORE X_NUC_129.L_CORE 0.003032
K_9420 X_NUC_115.L_CORE X_NUC_130.L_CORE 0.002750
K_9421 X_NUC_115.L_CORE X_NUC_131.L_CORE 0.002708
K_9422 X_NUC_115.L_CORE X_NUC_132.L_CORE 0.003828
K_9423 X_NUC_115.L_CORE X_NUC_133.L_CORE 0.002849
K_9424 X_NUC_115.L_CORE X_NUC_134.L_CORE 0.003776
K_9425 X_NUC_115.L_CORE X_NUC_135.L_CORE 0.004222
K_9426 X_NUC_115.L_CORE X_NUC_136.L_CORE 0.003427
K_9427 X_NUC_115.L_CORE X_NUC_137.L_CORE 0.006934
K_9428 X_NUC_115.L_CORE X_NUC_138.L_CORE 0.004671
K_9429 X_NUC_115.L_CORE X_NUC_139.L_CORE 0.006000
K_9430 X_NUC_115.L_CORE X_NUC_140.L_CORE 0.019506
K_9431 X_NUC_116.L_CORE X_NUC_117.L_CORE 0.001893
K_9432 X_NUC_116.L_CORE X_NUC_118.L_CORE 0.001920
K_9433 X_NUC_116.L_CORE X_NUC_119.L_CORE 0.002072
K_9434 X_NUC_116.L_CORE X_NUC_120.L_CORE 0.001942
K_9435 X_NUC_116.L_CORE X_NUC_121.L_CORE 0.002150
K_9436 X_NUC_116.L_CORE X_NUC_122.L_CORE 0.002176
K_9437 X_NUC_116.L_CORE X_NUC_123.L_CORE 0.002071
K_9438 X_NUC_116.L_CORE X_NUC_124.L_CORE 0.002481
K_9439 X_NUC_116.L_CORE X_NUC_125.L_CORE 0.002207
K_9440 X_NUC_116.L_CORE X_NUC_126.L_CORE 0.002394
K_9441 X_NUC_116.L_CORE X_NUC_127.L_CORE 0.002720
K_9442 X_NUC_116.L_CORE X_NUC_128.L_CORE 0.002325
K_9443 X_NUC_116.L_CORE X_NUC_129.L_CORE 0.003004
K_9444 X_NUC_116.L_CORE X_NUC_130.L_CORE 0.002771
K_9445 X_NUC_116.L_CORE X_NUC_131.L_CORE 0.002719
K_9446 X_NUC_116.L_CORE X_NUC_132.L_CORE 0.003787
K_9447 X_NUC_116.L_CORE X_NUC_133.L_CORE 0.002885
K_9448 X_NUC_116.L_CORE X_NUC_134.L_CORE 0.003748
K_9449 X_NUC_116.L_CORE X_NUC_135.L_CORE 0.004244
K_9450 X_NUC_116.L_CORE X_NUC_136.L_CORE 0.003468
K_9451 X_NUC_116.L_CORE X_NUC_137.L_CORE 0.006722
K_9452 X_NUC_116.L_CORE X_NUC_138.L_CORE 0.004771
K_9453 X_NUC_116.L_CORE X_NUC_139.L_CORE 0.006036
K_9454 X_NUC_116.L_CORE X_NUC_140.L_CORE 0.020109
K_9455 X_NUC_117.L_CORE X_NUC_118.L_CORE 0.004882
K_9456 X_NUC_117.L_CORE X_NUC_119.L_CORE 0.005270
K_9457 X_NUC_117.L_CORE X_NUC_120.L_CORE 0.005624
K_9458 X_NUC_117.L_CORE X_NUC_121.L_CORE 0.003181
K_9459 X_NUC_117.L_CORE X_NUC_122.L_CORE 0.004750
K_9460 X_NUC_117.L_CORE X_NUC_123.L_CORE 0.003165
K_9461 X_NUC_117.L_CORE X_NUC_124.L_CORE 0.002869
K_9462 X_NUC_117.L_CORE X_NUC_125.L_CORE 0.003679
K_9463 X_NUC_117.L_CORE X_NUC_126.L_CORE 0.002435
K_9464 X_NUC_117.L_CORE X_NUC_127.L_CORE 0.002874
K_9465 X_NUC_117.L_CORE X_NUC_128.L_CORE 0.002679
K_9466 X_NUC_117.L_CORE X_NUC_129.L_CORE 0.002209
K_9467 X_NUC_117.L_CORE X_NUC_130.L_CORE 0.002729
K_9468 X_NUC_117.L_CORE X_NUC_131.L_CORE 0.002148
K_9469 X_NUC_117.L_CORE X_NUC_132.L_CORE 0.002185
K_9470 X_NUC_117.L_CORE X_NUC_133.L_CORE 0.002330
K_9471 X_NUC_117.L_CORE X_NUC_134.L_CORE 0.001926
K_9472 X_NUC_117.L_CORE X_NUC_135.L_CORE 0.002157
K_9473 X_NUC_117.L_CORE X_NUC_136.L_CORE 0.001975
K_9474 X_NUC_117.L_CORE X_NUC_137.L_CORE 0.001863
K_9475 X_NUC_117.L_CORE X_NUC_138.L_CORE 0.001990
K_9476 X_NUC_117.L_CORE X_NUC_139.L_CORE 0.001793
K_9477 X_NUC_117.L_CORE X_NUC_140.L_CORE 0.001818
K_9478 X_NUC_118.L_CORE X_NUC_119.L_CORE 0.003457
K_9479 X_NUC_118.L_CORE X_NUC_120.L_CORE 0.004233
K_9480 X_NUC_118.L_CORE X_NUC_121.L_CORE 0.005304
K_9481 X_NUC_118.L_CORE X_NUC_122.L_CORE 0.002603
K_9482 X_NUC_118.L_CORE X_NUC_123.L_CORE 0.005159
K_9483 X_NUC_118.L_CORE X_NUC_124.L_CORE 0.002822
K_9484 X_NUC_118.L_CORE X_NUC_125.L_CORE 0.002560
K_9485 X_NUC_118.L_CORE X_NUC_126.L_CORE 0.004103
K_9486 X_NUC_118.L_CORE X_NUC_127.L_CORE 0.002169
K_9487 X_NUC_118.L_CORE X_NUC_128.L_CORE 0.002877
K_9488 X_NUC_118.L_CORE X_NUC_129.L_CORE 0.002654
K_9489 X_NUC_118.L_CORE X_NUC_130.L_CORE 0.002029
K_9490 X_NUC_118.L_CORE X_NUC_131.L_CORE 0.002953
K_9491 X_NUC_118.L_CORE X_NUC_132.L_CORE 0.002031
K_9492 X_NUC_118.L_CORE X_NUC_133.L_CORE 0.002129
K_9493 X_NUC_118.L_CORE X_NUC_134.L_CORE 0.002420
K_9494 X_NUC_118.L_CORE X_NUC_135.L_CORE 0.001827
K_9495 X_NUC_118.L_CORE X_NUC_136.L_CORE 0.002216
K_9496 X_NUC_118.L_CORE X_NUC_137.L_CORE 0.001959
K_9497 X_NUC_118.L_CORE X_NUC_138.L_CORE 0.001826
K_9498 X_NUC_118.L_CORE X_NUC_139.L_CORE 0.002024
K_9499 X_NUC_118.L_CORE X_NUC_140.L_CORE 0.001793
K_9500 X_NUC_119.L_CORE X_NUC_120.L_CORE 0.002879
K_9501 X_NUC_119.L_CORE X_NUC_121.L_CORE 0.003680
K_9502 X_NUC_119.L_CORE X_NUC_122.L_CORE 0.004926
K_9503 X_NUC_119.L_CORE X_NUC_123.L_CORE 0.002315
K_9504 X_NUC_119.L_CORE X_NUC_124.L_CORE 0.005280
K_9505 X_NUC_119.L_CORE X_NUC_125.L_CORE 0.002611
K_9506 X_NUC_119.L_CORE X_NUC_126.L_CORE 0.002378
K_9507 X_NUC_119.L_CORE X_NUC_127.L_CORE 0.004351
K_9508 X_NUC_119.L_CORE X_NUC_128.L_CORE 0.002025
K_9509 X_NUC_119.L_CORE X_NUC_129.L_CORE 0.002848
K_9510 X_NUC_119.L_CORE X_NUC_130.L_CORE 0.002616
K_9511 X_NUC_119.L_CORE X_NUC_131.L_CORE 0.001932
K_9512 X_NUC_119.L_CORE X_NUC_132.L_CORE 0.003084
K_9513 X_NUC_119.L_CORE X_NUC_133.L_CORE 0.001967
K_9514 X_NUC_119.L_CORE X_NUC_134.L_CORE 0.002093
K_9515 X_NUC_119.L_CORE X_NUC_135.L_CORE 0.002462
K_9516 X_NUC_119.L_CORE X_NUC_136.L_CORE 0.001785
K_9517 X_NUC_119.L_CORE X_NUC_137.L_CORE 0.002237
K_9518 X_NUC_119.L_CORE X_NUC_138.L_CORE 0.001954
K_9519 X_NUC_119.L_CORE X_NUC_139.L_CORE 0.001826
K_9520 X_NUC_119.L_CORE X_NUC_140.L_CORE 0.001990
K_9521 X_NUC_120.L_CORE X_NUC_121.L_CORE 0.002553
K_9522 X_NUC_120.L_CORE X_NUC_122.L_CORE 0.003335
K_9523 X_NUC_120.L_CORE X_NUC_123.L_CORE 0.004624
K_9524 X_NUC_120.L_CORE X_NUC_124.L_CORE 0.002134
K_9525 X_NUC_120.L_CORE X_NUC_125.L_CORE 0.005298
K_9526 X_NUC_120.L_CORE X_NUC_126.L_CORE 0.002467
K_9527 X_NUC_120.L_CORE X_NUC_127.L_CORE 0.002255
K_9528 X_NUC_120.L_CORE X_NUC_128.L_CORE 0.004515
K_9529 X_NUC_120.L_CORE X_NUC_129.L_CORE 0.001932
K_9530 X_NUC_120.L_CORE X_NUC_130.L_CORE 0.002816
K_9531 X_NUC_120.L_CORE X_NUC_131.L_CORE 0.002583
K_9532 X_NUC_120.L_CORE X_NUC_132.L_CORE 0.001872
K_9533 X_NUC_120.L_CORE X_NUC_133.L_CORE 0.003166
K_9534 X_NUC_120.L_CORE X_NUC_134.L_CORE 0.001930
K_9535 X_NUC_120.L_CORE X_NUC_135.L_CORE 0.002074
K_9536 X_NUC_120.L_CORE X_NUC_136.L_CORE 0.002479
K_9537 X_NUC_120.L_CORE X_NUC_137.L_CORE 0.001772
K_9538 X_NUC_120.L_CORE X_NUC_138.L_CORE 0.002237
K_9539 X_NUC_120.L_CORE X_NUC_139.L_CORE 0.001959
K_9540 X_NUC_120.L_CORE X_NUC_140.L_CORE 0.001863
K_9541 X_NUC_121.L_CORE X_NUC_122.L_CORE 0.002341
K_9542 X_NUC_121.L_CORE X_NUC_123.L_CORE 0.003101
K_9543 X_NUC_121.L_CORE X_NUC_124.L_CORE 0.004393
K_9544 X_NUC_121.L_CORE X_NUC_125.L_CORE 0.002011
K_9545 X_NUC_121.L_CORE X_NUC_126.L_CORE 0.005276
K_9546 X_NUC_121.L_CORE X_NUC_127.L_CORE 0.002365
K_9547 X_NUC_121.L_CORE X_NUC_128.L_CORE 0.002170
K_9548 X_NUC_121.L_CORE X_NUC_129.L_CORE 0.004626
K_9549 X_NUC_121.L_CORE X_NUC_130.L_CORE 0.001871
K_9550 X_NUC_121.L_CORE X_NUC_131.L_CORE 0.002790
K_9551 X_NUC_121.L_CORE X_NUC_132.L_CORE 0.002559
K_9552 X_NUC_121.L_CORE X_NUC_133.L_CORE 0.001837
K_9553 X_NUC_121.L_CORE X_NUC_134.L_CORE 0.003211
K_9554 X_NUC_121.L_CORE X_NUC_135.L_CORE 0.001913
K_9555 X_NUC_121.L_CORE X_NUC_136.L_CORE 0.002067
K_9556 X_NUC_121.L_CORE X_NUC_137.L_CORE 0.002479
K_9557 X_NUC_121.L_CORE X_NUC_138.L_CORE 0.001785
K_9558 X_NUC_121.L_CORE X_NUC_139.L_CORE 0.002216
K_9559 X_NUC_121.L_CORE X_NUC_140.L_CORE 0.001975
K_9560 X_NUC_122.L_CORE X_NUC_123.L_CORE 0.002195
K_9561 X_NUC_122.L_CORE X_NUC_124.L_CORE 0.002935
K_9562 X_NUC_122.L_CORE X_NUC_125.L_CORE 0.004219
K_9563 X_NUC_122.L_CORE X_NUC_126.L_CORE 0.001924
K_9564 X_NUC_122.L_CORE X_NUC_127.L_CORE 0.005241
K_9565 X_NUC_122.L_CORE X_NUC_128.L_CORE 0.002292
K_9566 X_NUC_122.L_CORE X_NUC_129.L_CORE 0.002110
K_9567 X_NUC_122.L_CORE X_NUC_130.L_CORE 0.004699
K_9568 X_NUC_122.L_CORE X_NUC_131.L_CORE 0.001831
K_9569 X_NUC_122.L_CORE X_NUC_132.L_CORE 0.002772
K_9570 X_NUC_122.L_CORE X_NUC_133.L_CORE 0.002544
K_9571 X_NUC_122.L_CORE X_NUC_134.L_CORE 0.001820
K_9572 X_NUC_122.L_CORE X_NUC_135.L_CORE 0.003226
K_9573 X_NUC_122.L_CORE X_NUC_136.L_CORE 0.001913
K_9574 X_NUC_122.L_CORE X_NUC_137.L_CORE 0.002074
K_9575 X_NUC_122.L_CORE X_NUC_138.L_CORE 0.002462
K_9576 X_NUC_122.L_CORE X_NUC_139.L_CORE 0.001827
K_9577 X_NUC_122.L_CORE X_NUC_140.L_CORE 0.002157
K_9578 X_NUC_123.L_CORE X_NUC_124.L_CORE 0.002091
K_9579 X_NUC_123.L_CORE X_NUC_125.L_CORE 0.002816
K_9580 X_NUC_123.L_CORE X_NUC_126.L_CORE 0.004088
K_9581 X_NUC_123.L_CORE X_NUC_127.L_CORE 0.001862
K_9582 X_NUC_123.L_CORE X_NUC_128.L_CORE 0.005206
K_9583 X_NUC_123.L_CORE X_NUC_129.L_CORE 0.002241
K_9584 X_NUC_123.L_CORE X_NUC_130.L_CORE 0.002071
K_9585 X_NUC_123.L_CORE X_NUC_131.L_CORE 0.004744
K_9586 X_NUC_123.L_CORE X_NUC_132.L_CORE 0.001809
K_9587 X_NUC_123.L_CORE X_NUC_133.L_CORE 0.002763
K_9588 X_NUC_123.L_CORE X_NUC_134.L_CORE 0.002539
K_9589 X_NUC_123.L_CORE X_NUC_135.L_CORE 0.001820
K_9590 X_NUC_123.L_CORE X_NUC_136.L_CORE 0.003211
K_9591 X_NUC_123.L_CORE X_NUC_137.L_CORE 0.001930
K_9592 X_NUC_123.L_CORE X_NUC_138.L_CORE 0.002093
K_9593 X_NUC_123.L_CORE X_NUC_139.L_CORE 0.002420
K_9594 X_NUC_123.L_CORE X_NUC_140.L_CORE 0.001926
K_9595 X_NUC_124.L_CORE X_NUC_125.L_CORE 0.002016
K_9596 X_NUC_124.L_CORE X_NUC_126.L_CORE 0.002730
K_9597 X_NUC_124.L_CORE X_NUC_127.L_CORE 0.003994
K_9598 X_NUC_124.L_CORE X_NUC_128.L_CORE 0.001820
K_9599 X_NUC_124.L_CORE X_NUC_129.L_CORE 0.005179
K_9600 X_NUC_124.L_CORE X_NUC_130.L_CORE 0.002210
K_9601 X_NUC_124.L_CORE X_NUC_131.L_CORE 0.002049
K_9602 X_NUC_124.L_CORE X_NUC_132.L_CORE 0.004766
K_9603 X_NUC_124.L_CORE X_NUC_133.L_CORE 0.001801
K_9604 X_NUC_124.L_CORE X_NUC_134.L_CORE 0.002763
K_9605 X_NUC_124.L_CORE X_NUC_135.L_CORE 0.002544
K_9606 X_NUC_124.L_CORE X_NUC_136.L_CORE 0.001837
K_9607 X_NUC_124.L_CORE X_NUC_137.L_CORE 0.003166
K_9608 X_NUC_124.L_CORE X_NUC_138.L_CORE 0.001967
K_9609 X_NUC_124.L_CORE X_NUC_139.L_CORE 0.002129
K_9610 X_NUC_124.L_CORE X_NUC_140.L_CORE 0.002330
K_9611 X_NUC_125.L_CORE X_NUC_126.L_CORE 0.001963
K_9612 X_NUC_125.L_CORE X_NUC_127.L_CORE 0.002670
K_9613 X_NUC_125.L_CORE X_NUC_128.L_CORE 0.003931
K_9614 X_NUC_125.L_CORE X_NUC_129.L_CORE 0.001793
K_9615 X_NUC_125.L_CORE X_NUC_130.L_CORE 0.005161
K_9616 X_NUC_125.L_CORE X_NUC_131.L_CORE 0.002195
K_9617 X_NUC_125.L_CORE X_NUC_132.L_CORE 0.002041
K_9618 X_NUC_125.L_CORE X_NUC_133.L_CORE 0.004766
K_9619 X_NUC_125.L_CORE X_NUC_134.L_CORE 0.001809
K_9620 X_NUC_125.L_CORE X_NUC_135.L_CORE 0.002772
K_9621 X_NUC_125.L_CORE X_NUC_136.L_CORE 0.002559
K_9622 X_NUC_125.L_CORE X_NUC_137.L_CORE 0.001872
K_9623 X_NUC_125.L_CORE X_NUC_138.L_CORE 0.003084
K_9624 X_NUC_125.L_CORE X_NUC_139.L_CORE 0.002031
K_9625 X_NUC_125.L_CORE X_NUC_140.L_CORE 0.002185
K_9626 X_NUC_126.L_CORE X_NUC_127.L_CORE 0.001928
K_9627 X_NUC_126.L_CORE X_NUC_128.L_CORE 0.002633
K_9628 X_NUC_126.L_CORE X_NUC_129.L_CORE 0.003894
K_9629 X_NUC_126.L_CORE X_NUC_130.L_CORE 0.001780
K_9630 X_NUC_126.L_CORE X_NUC_131.L_CORE 0.005155
K_9631 X_NUC_126.L_CORE X_NUC_132.L_CORE 0.002195
K_9632 X_NUC_126.L_CORE X_NUC_133.L_CORE 0.002049
K_9633 X_NUC_126.L_CORE X_NUC_134.L_CORE 0.004744
K_9634 X_NUC_126.L_CORE X_NUC_135.L_CORE 0.001831
K_9635 X_NUC_126.L_CORE X_NUC_136.L_CORE 0.002790
K_9636 X_NUC_126.L_CORE X_NUC_137.L_CORE 0.002583
K_9637 X_NUC_126.L_CORE X_NUC_138.L_CORE 0.001932
K_9638 X_NUC_126.L_CORE X_NUC_139.L_CORE 0.002953
K_9639 X_NUC_126.L_CORE X_NUC_140.L_CORE 0.002148
K_9640 X_NUC_127.L_CORE X_NUC_128.L_CORE 0.001907
K_9641 X_NUC_127.L_CORE X_NUC_129.L_CORE 0.002614
K_9642 X_NUC_127.L_CORE X_NUC_130.L_CORE 0.003882
K_9643 X_NUC_127.L_CORE X_NUC_131.L_CORE 0.001780
K_9644 X_NUC_127.L_CORE X_NUC_132.L_CORE 0.005161
K_9645 X_NUC_127.L_CORE X_NUC_133.L_CORE 0.002210
K_9646 X_NUC_127.L_CORE X_NUC_134.L_CORE 0.002071
K_9647 X_NUC_127.L_CORE X_NUC_135.L_CORE 0.004699
K_9648 X_NUC_127.L_CORE X_NUC_136.L_CORE 0.001871
K_9649 X_NUC_127.L_CORE X_NUC_137.L_CORE 0.002816
K_9650 X_NUC_127.L_CORE X_NUC_138.L_CORE 0.002616
K_9651 X_NUC_127.L_CORE X_NUC_139.L_CORE 0.002029
K_9652 X_NUC_127.L_CORE X_NUC_140.L_CORE 0.002729
K_9653 X_NUC_128.L_CORE X_NUC_129.L_CORE 0.001901
K_9654 X_NUC_128.L_CORE X_NUC_130.L_CORE 0.002614
K_9655 X_NUC_128.L_CORE X_NUC_131.L_CORE 0.003894
K_9656 X_NUC_128.L_CORE X_NUC_132.L_CORE 0.001793
K_9657 X_NUC_128.L_CORE X_NUC_133.L_CORE 0.005179
K_9658 X_NUC_128.L_CORE X_NUC_134.L_CORE 0.002241
K_9659 X_NUC_128.L_CORE X_NUC_135.L_CORE 0.002110
K_9660 X_NUC_128.L_CORE X_NUC_136.L_CORE 0.004626
K_9661 X_NUC_128.L_CORE X_NUC_137.L_CORE 0.001932
K_9662 X_NUC_128.L_CORE X_NUC_138.L_CORE 0.002848
K_9663 X_NUC_128.L_CORE X_NUC_139.L_CORE 0.002654
K_9664 X_NUC_128.L_CORE X_NUC_140.L_CORE 0.002209
K_9665 X_NUC_129.L_CORE X_NUC_130.L_CORE 0.001907
K_9666 X_NUC_129.L_CORE X_NUC_131.L_CORE 0.002633
K_9667 X_NUC_129.L_CORE X_NUC_132.L_CORE 0.003931
K_9668 X_NUC_129.L_CORE X_NUC_133.L_CORE 0.001820
K_9669 X_NUC_129.L_CORE X_NUC_134.L_CORE 0.005206
K_9670 X_NUC_129.L_CORE X_NUC_135.L_CORE 0.002292
K_9671 X_NUC_129.L_CORE X_NUC_136.L_CORE 0.002170
K_9672 X_NUC_129.L_CORE X_NUC_137.L_CORE 0.004515
K_9673 X_NUC_129.L_CORE X_NUC_138.L_CORE 0.002025
K_9674 X_NUC_129.L_CORE X_NUC_139.L_CORE 0.002877
K_9675 X_NUC_129.L_CORE X_NUC_140.L_CORE 0.002679
K_9676 X_NUC_130.L_CORE X_NUC_131.L_CORE 0.001928
K_9677 X_NUC_130.L_CORE X_NUC_132.L_CORE 0.002670
K_9678 X_NUC_130.L_CORE X_NUC_133.L_CORE 0.003994
K_9679 X_NUC_130.L_CORE X_NUC_134.L_CORE 0.001862
K_9680 X_NUC_130.L_CORE X_NUC_135.L_CORE 0.005241
K_9681 X_NUC_130.L_CORE X_NUC_136.L_CORE 0.002365
K_9682 X_NUC_130.L_CORE X_NUC_137.L_CORE 0.002255
K_9683 X_NUC_130.L_CORE X_NUC_138.L_CORE 0.004351
K_9684 X_NUC_130.L_CORE X_NUC_139.L_CORE 0.002169
K_9685 X_NUC_130.L_CORE X_NUC_140.L_CORE 0.002874
K_9686 X_NUC_131.L_CORE X_NUC_132.L_CORE 0.001963
K_9687 X_NUC_131.L_CORE X_NUC_133.L_CORE 0.002730
K_9688 X_NUC_131.L_CORE X_NUC_134.L_CORE 0.004088
K_9689 X_NUC_131.L_CORE X_NUC_135.L_CORE 0.001924
K_9690 X_NUC_131.L_CORE X_NUC_136.L_CORE 0.005276
K_9691 X_NUC_131.L_CORE X_NUC_137.L_CORE 0.002467
K_9692 X_NUC_131.L_CORE X_NUC_138.L_CORE 0.002378
K_9693 X_NUC_131.L_CORE X_NUC_139.L_CORE 0.004103
K_9694 X_NUC_131.L_CORE X_NUC_140.L_CORE 0.002435
K_9695 X_NUC_132.L_CORE X_NUC_133.L_CORE 0.002016
K_9696 X_NUC_132.L_CORE X_NUC_134.L_CORE 0.002816
K_9697 X_NUC_132.L_CORE X_NUC_135.L_CORE 0.004219
K_9698 X_NUC_132.L_CORE X_NUC_136.L_CORE 0.002011
K_9699 X_NUC_132.L_CORE X_NUC_137.L_CORE 0.005298
K_9700 X_NUC_132.L_CORE X_NUC_138.L_CORE 0.002611
K_9701 X_NUC_132.L_CORE X_NUC_139.L_CORE 0.002560
K_9702 X_NUC_132.L_CORE X_NUC_140.L_CORE 0.003679
K_9703 X_NUC_133.L_CORE X_NUC_134.L_CORE 0.002091
K_9704 X_NUC_133.L_CORE X_NUC_135.L_CORE 0.002935
K_9705 X_NUC_133.L_CORE X_NUC_136.L_CORE 0.004393
K_9706 X_NUC_133.L_CORE X_NUC_137.L_CORE 0.002134
K_9707 X_NUC_133.L_CORE X_NUC_138.L_CORE 0.005280
K_9708 X_NUC_133.L_CORE X_NUC_139.L_CORE 0.002822
K_9709 X_NUC_133.L_CORE X_NUC_140.L_CORE 0.002869
K_9710 X_NUC_134.L_CORE X_NUC_135.L_CORE 0.002195
K_9711 X_NUC_134.L_CORE X_NUC_136.L_CORE 0.003101
K_9712 X_NUC_134.L_CORE X_NUC_137.L_CORE 0.004624
K_9713 X_NUC_134.L_CORE X_NUC_138.L_CORE 0.002315
K_9714 X_NUC_134.L_CORE X_NUC_139.L_CORE 0.005159
K_9715 X_NUC_134.L_CORE X_NUC_140.L_CORE 0.003165
K_9716 X_NUC_135.L_CORE X_NUC_136.L_CORE 0.002341
K_9717 X_NUC_135.L_CORE X_NUC_137.L_CORE 0.003335
K_9718 X_NUC_135.L_CORE X_NUC_138.L_CORE 0.004926
K_9719 X_NUC_135.L_CORE X_NUC_139.L_CORE 0.002603
K_9720 X_NUC_135.L_CORE X_NUC_140.L_CORE 0.004750
K_9721 X_NUC_136.L_CORE X_NUC_137.L_CORE 0.002553
K_9722 X_NUC_136.L_CORE X_NUC_138.L_CORE 0.003680
K_9723 X_NUC_136.L_CORE X_NUC_139.L_CORE 0.005304
K_9724 X_NUC_136.L_CORE X_NUC_140.L_CORE 0.003181
K_9725 X_NUC_137.L_CORE X_NUC_138.L_CORE 0.002879
K_9726 X_NUC_137.L_CORE X_NUC_139.L_CORE 0.004233
K_9727 X_NUC_137.L_CORE X_NUC_140.L_CORE 0.005624
K_9728 X_NUC_138.L_CORE X_NUC_139.L_CORE 0.003457
K_9729 X_NUC_138.L_CORE X_NUC_140.L_CORE 0.005270
K_9730 X_NUC_139.L_CORE X_NUC_140.L_CORE 0.004882

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
