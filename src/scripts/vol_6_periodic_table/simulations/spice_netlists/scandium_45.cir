* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Scandium-45 (Z=21, A=45)
* Auto-generated topological mutual impedance array
* Nodes: 45

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.009302
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.008928
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.008996
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.009115
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.010017
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.010178
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.009761
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.010164
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.010429
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.010192
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.010248
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.009939
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.006229
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.006128
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.006055
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.006176
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.008464
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.008653
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.008340
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.008365
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.006136
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.006013
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.005993
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.005976
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.005652
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.005646
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.005520
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.005612
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.006228
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.006224
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.006118
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.006081
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.005111
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.005066
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.004996
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.005024
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.028342
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.006273
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.006295
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.005785
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.004387
K_45 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_46 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_47 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.009706
K_48 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.009302
K_49 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.009369
K_50 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.009504
K_51 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.009842
K_52 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.010017
K_53 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.009608
K_54 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.009992
K_55 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.010654
K_56 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.010429
K_57 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.010475
K_58 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.010146
K_59 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.006329
K_60 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.006229
K_61 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.006149
K_62 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.006276
K_63 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.008274
K_64 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.008464
K_65 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.008164
K_66 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.008187
K_67 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.006261
K_68 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.006136
K_69 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.006112
K_70 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.006094
K_71 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.005654
K_72 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.005652
K_73 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.005524
K_74 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.005616
K_75 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.006226
K_76 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.006228
K_77 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.006119
K_78 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.006082
K_79 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.005155
K_80 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.005111
K_81 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.005039
K_82 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.005068
K_83 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.026000
K_84 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.006456
K_85 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.006214
K_86 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.005828
K_87 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.004418
K_88 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_89 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.009621
K_90 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.009218
K_91 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.009302
K_92 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.009424
K_93 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.010270
K_94 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.010456
K_95 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.010017
K_96 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.010441
K_97 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.010592
K_98 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.010357
K_99 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.010429
K_100 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.010091
K_101 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.006413
K_102 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.006306
K_103 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.006229
K_104 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.006358
K_105 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.008580
K_106 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.008785
K_107 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.008464
K_108 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.008484
K_109 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.006283
K_110 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.006155
K_111 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.006136
K_112 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.006115
K_113 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.005789
K_114 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.005785
K_115 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.005652
K_116 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.005749
K_117 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.006338
K_118 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.006337
K_119 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.006228
K_120 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.006187
K_121 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.005232
K_122 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.005184
K_123 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.005111
K_124 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.005140
K_125 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.025166
K_126 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.006418
K_127 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.006399
K_128 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.005859
K_129 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.004479
K_130 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.009481
K_131 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.009095
K_132 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.009167
K_133 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.009302
K_134 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.009854
K_135 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.010019
K_136 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.009620
K_137 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.010017
K_138 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.010968
K_139 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.010708
K_140 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.010773
K_141 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.010429
K_142 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.006277
K_143 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.006177
K_144 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.006102
K_145 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.006229
K_146 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.008553
K_147 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.008756
K_148 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.008431
K_149 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.008464
K_150 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.006303
K_151 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.006173
K_152 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.006151
K_153 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.006136
K_154 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.005688
K_155 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.005684
K_156 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.005556
K_157 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.005652
K_158 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.006379
K_159 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006378
K_160 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.006264
K_161 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.006228
K_162 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.005200
K_163 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.005153
K_164 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.005080
K_165 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.005111
K_166 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.027271
K_167 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.006373
K_168 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.006261
K_169 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.005945
K_170 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.004439
K_171 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_172 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_173 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_174 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.006849
K_175 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.007063
K_176 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.006888
K_177 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.006971
K_178 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.008427
K_179 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.008591
K_180 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.008565
K_181 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.008289
K_182 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.010210
K_183 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.010270
K_184 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.009844
K_185 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.010217
K_186 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.005414
K_187 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.005543
K_188 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.005443
K_189 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.005424
K_190 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.009037
K_191 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.008990
K_192 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008857
K_193 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008695
K_194 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.005860
K_195 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.005953
K_196 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.005787
K_197 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.005861
K_198 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.005484
K_199 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.005563
K_200 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.005471
K_201 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.005419
K_202 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006228
K_203 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.006261
K_204 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.006109
K_205 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.006124
K_206 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.007190
K_207 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.018604
K_208 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.005066
K_209 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.005589
K_210 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.005403
K_211 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_212 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_213 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.006645
K_214 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.006849
K_215 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.006685
K_216 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.006761
K_217 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.008259
K_218 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.008427
K_219 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.008396
K_220 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.008135
K_221 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.010127
K_222 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.010210
K_223 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.009780
K_224 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.010146
K_225 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.005291
K_226 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.005414
K_227 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.005319
K_228 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.005301
K_229 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.009068
K_230 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.009037
K_231 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008894
K_232 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008730
K_233 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.005768
K_234 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.005860
K_235 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.005700
K_236 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.005771
K_237 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.005405
K_238 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.005484
K_239 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.005394
K_240 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.005344
K_241 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006190
K_242 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006228
K_243 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.006076
K_244 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.006091
K_245 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.006977
K_246 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.020290
K_247 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.004964
K_248 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.005544
K_249 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.005383
K_250 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_251 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.006802
K_252 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.007016
K_253 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.006849
K_254 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.006926
K_255 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.008283
K_256 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.008446
K_257 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.008427
K_258 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.008158
K_259 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.010592
K_260 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.010673
K_261 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.010210
K_262 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.010614
K_263 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.005383
K_264 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.005511
K_265 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.005414
K_266 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.005394
K_267 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.009211
K_268 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.009170
K_269 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.009037
K_270 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.008857
K_271 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.005931
K_272 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.006030
K_273 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.005860
K_274 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.005935
K_275 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.005493
K_276 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.005574
K_277 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.005484
K_278 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.005430
K_279 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006347
K_280 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006385
K_281 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006228
K_282 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006240
K_283 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.006992
K_284 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.019873
K_285 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.005068
K_286 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.005587
K_287 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.005511
K_288 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.006725
K_289 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.006932
K_290 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.006767
K_291 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.006849
K_292 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.008558
K_293 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.008738
K_294 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.008710
K_295 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.008427
K_296 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.010178
K_297 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.010250
K_298 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.009826
K_299 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.010210
K_300 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.005401
K_301 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.005531
K_302 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.005431
K_303 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.005414
K_304 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.009404
K_305 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.009360
K_306 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.009210
K_307 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.009037
K_308 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.005855
K_309 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.005949
K_310 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.005784
K_311 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.005860
K_312 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.005547
K_313 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.005631
K_314 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.005535
K_315 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.005484
K_316 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006331
K_317 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006368
K_318 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.006209
K_319 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006228
K_320 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.007089
K_321 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.019794
K_322 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.005019
K_323 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.005691
K_324 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.005463
K_325 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_326 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_327 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_328 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.005963
K_329 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.005883
K_330 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.005982
K_331 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.005836
K_332 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.007701
K_333 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.007444
K_334 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.007484
K_335 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.007535
K_336 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.009934
K_337 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.010067
K_338 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.009976
K_339 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.009633
K_340 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.005140
K_341 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.005046
K_342 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.005088
K_343 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.005025
K_344 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.009168
K_345 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.009017
K_346 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008803
K_347 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.008891
K_348 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.005860
K_349 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.005824
K_350 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.005818
K_351 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.005709
K_352 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.005652
K_353 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.005561
K_354 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.005540
K_355 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.005509
K_356 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.008210
K_357 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.005210
K_358 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.015182
K_359 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.004622
K_360 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.005253
K_361 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_362 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_363 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.006040
K_364 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.005963
K_365 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.006063
K_366 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.005911
K_367 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.007976
K_368 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.007701
K_369 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.007740
K_370 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.007798
K_371 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.009783
K_372 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.009934
K_373 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.009835
K_374 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.009505
K_375 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.005237
K_376 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.005140
K_377 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.005184
K_378 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.005117
K_379 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.009309
K_380 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.009168
K_381 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.008935
K_382 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.009027
K_383 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.005893
K_384 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.005860
K_385 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.005852
K_386 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.005741
K_387 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.005743
K_388 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.005652
K_389 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.005628
K_390 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.005595
K_391 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.008238
K_392 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.005339
K_393 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.014648
K_394 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.004660
K_395 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.005331
K_396 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_397 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.005939
K_398 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.005862
K_399 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.005963
K_400 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.005815
K_401 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.007927
K_402 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.007652
K_403 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.007701
K_404 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.007752
K_405 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.009869
K_406 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.010012
K_407 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.009934
K_408 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.009584
K_409 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.005190
K_410 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.005094
K_411 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.005140
K_412 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.005074
K_413 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009563
K_414 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.009401
K_415 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.009168
K_416 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.009258
K_417 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.005899
K_418 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.005864
K_419 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.005860
K_420 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.005747
K_421 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.005766
K_422 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.005672
K_423 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.005652
K_424 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.005617
K_425 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.007987
K_426 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.005255
K_427 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.015751
K_428 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.004634
K_429 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.005373
K_430 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.006093
K_431 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.006011
K_432 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.006116
K_433 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.005963
K_434 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.007867
K_435 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.007598
K_436 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.007641
K_437 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.007701
K_438 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.010240
K_439 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.010399
K_440 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.010299
K_441 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.009934
K_442 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.005260
K_443 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.005160
K_444 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.005206
K_445 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.005140
K_446 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.009453
K_447 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.009297
K_448 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.009063
K_449 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.009168
K_450 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.006019
K_451 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.005982
K_452 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.005976
K_453 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.005860
K_454 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.005802
K_455 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.005706
K_456 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.005683
K_457 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.005652
K_458 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.008269
K_459 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.005289
K_460 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.015248
K_461 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.004718
K_462 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.005367
K_463 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_464 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_465 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_466 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.005574
K_467 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.005536
K_468 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.005473
K_469 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.005614
K_470 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.007401
K_471 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.007615
K_472 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.007378
K_473 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.007520
K_474 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.009835
K_475 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.009524
K_476 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.009401
K_477 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.009591
K_478 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.005140
K_479 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.005163
K_480 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.005060
K_481 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.005172
K_482 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.009037
K_483 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.009180
K_484 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.008813
K_485 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.008911
K_486 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.006136
K_487 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.006103
K_488 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.005972
K_489 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.006087
K_490 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.009629
K_491 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.006789
K_492 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.004790
K_493 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.011587
K_494 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.004791
K_495 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_496 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_497 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.005608
K_498 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.005574
K_499 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.005508
K_500 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.005652
K_501 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.007196
K_502 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.007401
K_503 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.007178
K_504 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.007309
K_505 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.010154
K_506 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.009835
K_507 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.009689
K_508 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.009897
K_509 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.005114
K_510 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.005140
K_511 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.005036
K_512 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.005147
K_513 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.008884
K_514 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.009037
K_515 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008679
K_516 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.008772
K_517 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.006164
K_518 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.006136
K_519 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.006000
K_520 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.006116
K_521 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.009355
K_522 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.006954
K_523 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.004733
K_524 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.011611
K_525 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.004808
K_526 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_527 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.005676
K_528 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.005638
K_529 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.005574
K_530 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.005721
K_531 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.007416
K_532 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.007636
K_533 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.007401
K_534 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.007540
K_535 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.010310
K_536 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.009965
K_537 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.009835
K_538 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.010041
K_539 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.005221
K_540 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.005247
K_541 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.005140
K_542 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.005256
K_543 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.009261
K_544 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.009425
K_545 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.009037
K_546 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.009134
K_547 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.006308
K_548 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.006276
K_549 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.006136
K_550 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.006258
K_551 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.009357
K_552 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.006923
K_553 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.004818
K_554 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.011954
K_555 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.004893
K_556 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.005530
K_557 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.005495
K_558 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.005433
K_559 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.005574
K_560 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.007279
K_561 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.007487
K_562 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.007261
K_563 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.007401
K_564 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.010075
K_565 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.009753
K_566 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.009620
K_567 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.009835
K_568 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.005106
K_569 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.005130
K_570 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.005029
K_571 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.005140
K_572 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.009151
K_573 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.009309
K_574 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.008927
K_575 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.009037
K_576 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.006181
K_577 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.006150
K_578 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.006015
K_579 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.006136
K_580 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.009210
K_581 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.006771
K_582 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.004727
K_583 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.012157
K_584 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.004807
K_585 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_586 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_587 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_588 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.005460
K_589 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.005581
K_590 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.005548
K_591 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.005467
K_592 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.007401
K_593 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.007348
K_594 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.007442
K_595 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.007203
K_596 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.009934
K_597 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.010329
K_598 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.009916
K_599 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.009921
K_600 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.005414
K_601 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.005479
K_602 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.005458
K_603 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.005349
K_604 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.008464
K_605 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.008506
K_606 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.008373
K_607 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.008199
K_608 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.005115
K_609 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.009388
K_610 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.006548
K_611 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.004753
K_612 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.008611
K_613 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_614 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_615 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.005344
K_616 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.005460
K_617 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.005428
K_618 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.005352
K_619 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.007446
K_620 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.007401
K_621 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.007492
K_622 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.007248
K_623 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.009560
K_624 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.009934
K_625 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.009554
K_626 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.009558
K_627 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.005348
K_628 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.005414
K_629 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.005392
K_630 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.005287
K_631 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.008410
K_632 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.008464
K_633 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.008327
K_634 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.008156
K_635 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.005045
K_636 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.009645
K_637 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.006349
K_638 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.004733
K_639 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.008576
K_640 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_641 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.005373
K_642 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.005489
K_643 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.005460
K_644 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.005381
K_645 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.007352
K_646 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.007304
K_647 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.007401
K_648 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.007162
K_649 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.009929
K_650 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.010337
K_651 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.009934
K_652 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.009927
K_653 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.005368
K_654 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.005433
K_655 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.005414
K_656 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.005306
K_657 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.008544
K_658 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.008594
K_659 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.008464
K_660 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.008278
K_661 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.004998
K_662 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.009249
K_663 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.006457
K_664 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.004715
K_665 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.008820
K_666 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.005450
K_667 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.005571
K_668 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.005539
K_669 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.005460
K_670 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.007607
K_671 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.007554
K_672 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.007656
K_673 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.007401
K_674 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.009924
K_675 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.010331
K_676 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.009918
K_677 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.009934
K_678 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.005478
K_679 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.005547
K_680 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.005525
K_681 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.005414
K_682 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.008742
K_683 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.008795
K_684 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.008649
K_685 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.008464
K_686 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.005081
K_687 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.009547
K_688 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.006454
K_689 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.004818
K_690 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.008876
K_691 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_692 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_693 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_694 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.005574
K_695 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.005430
K_696 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.005499
K_697 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.005478
K_698 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.007701
K_699 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.007548
K_700 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.007458
K_701 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.007671
K_702 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.010210
K_703 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.009878
K_704 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.009936
K_705 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.009742
K_706 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.006229
K_707 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.006075
K_708 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.006068
K_709 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.006109
K_710 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.008077
K_711 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.004438
K_712 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.009590
K_713 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.006472
K_714 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.005247
K_715 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_716 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_717 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.005725
K_718 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.005574
K_719 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.005646
K_720 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.005624
K_721 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.007853
K_722 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.007701
K_723 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.007601
K_724 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.007827
K_725 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.010550
K_726 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.010210
K_727 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.010261
K_728 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.010048
K_729 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.006389
K_730 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.006229
K_731 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.006218
K_732 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.006262
K_733 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.008182
K_734 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.004531
K_735 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.009576
K_736 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.006621
K_737 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.005347
K_738 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_739 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.005648
K_740 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.005501
K_741 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.005574
K_742 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.005551
K_743 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.007958
K_744 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.007794
K_745 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.007701
K_746 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.007930
K_747 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.010481
K_748 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.010135
K_749 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.010210
K_750 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.009988
K_751 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.006397
K_752 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.006234
K_753 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.006229
K_754 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.006270
K_755 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.007891
K_756 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.004471
K_757 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.009779
K_758 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.006520
K_759 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.005375
K_760 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.005670
K_761 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.005521
K_762 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.005593
K_763 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.005574
K_764 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.007721
K_765 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.007571
K_766 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.007481
K_767 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.007701
K_768 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.010724
K_769 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.010354
K_770 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.010421
K_771 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.010210
K_772 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.006351
K_773 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.006191
K_774 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.006183
K_775 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.006229
K_776 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.007971
K_777 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.004460
K_778 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.009343
K_779 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.006652
K_780 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.005313
K_781 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_782 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_783 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_784 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.005963
K_785 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.006072
K_786 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.005935
K_787 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.006068
K_788 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.008427
K_789 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.008757
K_790 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.008526
K_791 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.008476
K_792 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.010429
K_793 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.010649
K_794 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.010142
K_795 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.010474
K_796 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.005349
K_797 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.009753
K_798 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.004517
K_799 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.010257
K_800 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.007261
K_801 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_802 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_803 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.005854
K_804 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.005963
K_805 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.005831
K_806 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.005957
K_807 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.008120
K_808 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.008427
K_809 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.008214
K_810 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.008169
K_811 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.010196
K_812 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.010429
K_813 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.009939
K_814 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.010252
K_815 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.005252
K_816 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.009921
K_817 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.004439
K_818 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.009933
K_819 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.007194
K_820 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_821 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.005985
K_822 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.006098
K_823 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.005963
K_824 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.006095
K_825 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.008319
K_826 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.008643
K_827 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.008427
K_828 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.008373
K_829 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.010713
K_830 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.010967
K_831 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.010429
K_832 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.010777
K_833 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.005231
K_834 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.009696
K_835 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.004497
K_836 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.009996
K_837 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.007429
K_838 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.005858
K_839 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.005964
K_840 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.005834
K_841 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.005963
K_842 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.008366
K_843 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.008696
K_844 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.008469
K_845 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.008427
K_846 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.010358
K_847 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.010587
K_848 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.010088
K_849 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.010429
K_850 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.005237
K_851 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.009476
K_852 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.004441
K_853 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.010351
K_854 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.007221
K_855 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_856 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_857 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_858 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.006849
K_859 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.006851
K_860 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.006940
K_861 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.006719
K_862 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.010017
K_863 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.009706
K_864 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.009873
K_865 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.009587
K_866 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.004894
K_867 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.005210
K_868 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.011756
K_869 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.004930
K_870 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.010757
K_871 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_872 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_873 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.006839
K_874 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.006849
K_875 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.006934
K_876 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.006713
K_877 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.010335
K_878 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.010017
K_879 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.010189
K_880 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.009876
K_881 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.004878
K_882 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.005310
K_883 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.011224
K_884 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.004954
K_885 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.011202
K_886 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_887 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.006754
K_888 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.006759
K_889 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.006849
K_890 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.006632
K_891 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.010143
K_892 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.009831
K_893 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.010017
K_894 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.009708
K_895 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.004791
K_896 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.005184
K_897 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.011242
K_898 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.004887
K_899 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.011164
K_900 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.006979
K_901 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.006985
K_902 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.007079
K_903 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.006849
K_904 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.010484
K_905 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.010141
K_906 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.010332
K_907 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.010017
K_908 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.004864
K_909 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.005236
K_910 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.011230
K_911 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.005002
K_912 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.011284
K_913 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_914 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_915 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_916 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.009302
K_917 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.009037
K_918 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.008969
K_919 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.009260
K_920 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.005821
K_921 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.004924
K_922 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.005740
K_923 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.013679
K_924 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.006564
K_925 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_926 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_927 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.009571
K_928 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.009302
K_929 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.009219
K_930 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.009536
K_931 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.005798
K_932 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.005011
K_933 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.005678
K_934 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.014269
K_935 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.006667
K_936 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_937 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.009654
K_938 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.009368
K_939 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.009302
K_940 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.009618
K_941 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.005702
K_942 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.004938
K_943 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.005731
K_944 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.013482
K_945 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.006740
K_946 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.009325
K_947 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.009067
K_948 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.008999
K_949 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.009302
K_950 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.005694
K_951 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.004898
K_952 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.005603
K_953 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.014159
K_954 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.006561
K_955 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_956 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_957 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_958 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.004497
K_959 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.006232
K_960 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.005741
K_961 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.007160
K_962 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.019929
K_963 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_964 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_965 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.004457
K_966 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.006326
K_967 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.005619
K_968 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.007117
K_969 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.020113
K_970 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_971 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.004405
K_972 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.006158
K_973 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.005653
K_974 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.006981
K_975 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.021468
K_976 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.004434
K_977 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.006170
K_978 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.005596
K_979 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.007211
K_980 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.019534
K_981 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.005270
K_982 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.005641
K_983 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.005532
K_984 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.003888
K_985 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.004242
K_986 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.005268
K_987 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.005532
K_988 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.004242
K_989 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.005641
K_990 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.005270

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
