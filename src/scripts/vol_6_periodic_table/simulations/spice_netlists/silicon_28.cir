* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Silicon-28 (Z=14, A=28)
* Auto-generated topological mutual impedance array
* Nodes: 28

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.003668
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.003668
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.003623
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.003623
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.005188
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.005252
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.005186
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.005123
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.005188
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.005270
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.005142
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.005183
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.005188
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.005172
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005073
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.005160
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.005188
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.005098
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.005073
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.005087
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.005188
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.005145
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.005142
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.005065
K_28 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_29 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_30 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.003668
K_31 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.003668
K_32 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.003623
K_33 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.003623
K_34 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.005123
K_35 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.005188
K_36 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.005123
K_37 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.005062
K_38 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.005107
K_39 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.005188
K_40 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.005065
K_41 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.005104
K_42 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.005201
K_43 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.005188
K_44 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.005087
K_45 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.005174
K_46 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.005279
K_47 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.005188
K_48 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.005160
K_49 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.005174
K_50 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.005228
K_51 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.005188
K_52 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.005183
K_53 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.005104
K_54 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_55 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.003715
K_56 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.003715
K_57 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.003668
K_58 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.003668
K_59 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.005186
K_60 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.005252
K_61 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.005188
K_62 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.005123
K_63 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.005232
K_64 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.005317
K_65 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.005188
K_66 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.005228
K_67 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.005307
K_68 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.005292
K_69 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.005188
K_70 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.005279
K_71 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.005307
K_72 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.005213
K_73 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.005188
K_74 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.005201
K_75 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.005232
K_76 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.005190
K_77 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.005188
K_78 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.005107
K_79 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.003715
K_80 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.003715
K_81 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.003668
K_82 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.003668
K_83 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.005252
K_84 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.005321
K_85 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.005252
K_86 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.005188
K_87 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.005190
K_88 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.005273
K_89 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.005145
K_90 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.005188
K_91 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.005213
K_92 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.005199
K_93 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.005098
K_94 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.005188
K_95 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.005292
K_96 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.005199
K_97 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.005172
K_98 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.005188
K_99 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.005317
K_100 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.005273
K_101 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.005270
K_102 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.005188
K_103 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_104 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_105 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_106 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.005188
K_107 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.005252
K_108 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.005321
K_109 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.005252
K_110 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.005188
K_111 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.005270
K_112 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.005273
K_113 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.005317
K_114 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.005188
K_115 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.005172
K_116 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.005199
K_117 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.005292
K_118 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.005188
K_119 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.005098
K_120 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.005199
K_121 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.005213
K_122 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.005188
K_123 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.005145
K_124 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.005273
K_125 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.005190
K_126 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_127 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_128 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.005123
K_129 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.005188
K_130 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.005252
K_131 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.005186
K_132 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.005107
K_133 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.005188
K_134 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.005190
K_135 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.005232
K_136 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.005201
K_137 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.005188
K_138 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.005213
K_139 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.005307
K_140 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.005279
K_141 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.005188
K_142 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.005292
K_143 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.005307
K_144 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.005228
K_145 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.005188
K_146 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.005317
K_147 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.005232
K_148 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_149 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.005062
K_150 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.005123
K_151 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.005188
K_152 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.005123
K_153 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.005104
K_154 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.005183
K_155 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.005188
K_156 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.005228
K_157 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.005174
K_158 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.005160
K_159 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.005188
K_160 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.005279
K_161 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.005174
K_162 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.005087
K_163 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.005188
K_164 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.005201
K_165 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.005104
K_166 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.005065
K_167 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.005188
K_168 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.005107
K_169 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.005123
K_170 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.005186
K_171 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.005252
K_172 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.005188
K_173 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.005065
K_174 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.005142
K_175 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.005145
K_176 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.005188
K_177 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.005087
K_178 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.005073
K_179 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.005098
K_180 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.005188
K_181 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.005160
K_182 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.005073
K_183 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.005172
K_184 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.005188
K_185 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.005183
K_186 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.005142
K_187 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.005270
K_188 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.005188
K_189 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_190 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_191 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_192 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.006241
K_193 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.006268
K_194 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.006162
K_195 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.006348
K_196 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.003857
K_197 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.003825
K_198 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.003809
K_199 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.003872
K_200 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.003857
K_201 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.003794
K_202 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.003809
K_203 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.003841
K_204 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.006241
K_205 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.006061
K_206 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.006162
K_207 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.006134
K_208 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_209 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_210 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.006209
K_211 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.006241
K_212 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.006134
K_213 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.006318
K_214 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.003889
K_215 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.003857
K_216 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.003841
K_217 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.003906
K_218 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.003922
K_219 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.003857
K_220 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.003872
K_221 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.003906
K_222 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.006432
K_223 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.006241
K_224 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.006348
K_225 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.006318
K_226 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_227 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.006318
K_228 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.006348
K_229 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.006241
K_230 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.006432
K_231 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.003906
K_232 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.003872
K_233 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.003857
K_234 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.003922
K_235 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.003906
K_236 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.003841
K_237 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.003857
K_238 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.003889
K_239 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.006318
K_240 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.006134
K_241 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.006241
K_242 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.006209
K_243 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.006134
K_244 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.006162
K_245 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.006061
K_246 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.006241
K_247 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.003841
K_248 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.003809
K_249 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.003794
K_250 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.003857
K_251 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.003872
K_252 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.003809
K_253 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.003825
K_254 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.003857
K_255 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.006348
K_256 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.006162
K_257 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.006268
K_258 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.006241
K_259 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_260 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_261 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_262 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.006241
K_263 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.006078
K_264 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.006116
K_265 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.006198
K_266 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.003857
K_267 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.003788
K_268 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.003827
K_269 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.003816
K_270 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.003857
K_271 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.003807
K_272 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.003857
K_273 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.003807
K_274 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_275 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_276 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.006412
K_277 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.006241
K_278 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.006280
K_279 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.006368
K_280 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.003929
K_281 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.003857
K_282 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.003898
K_283 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.003887
K_284 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.003908
K_285 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.003857
K_286 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.003908
K_287 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.003857
K_288 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_289 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.006368
K_290 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.006198
K_291 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.006241
K_292 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.006325
K_293 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.003887
K_294 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.003816
K_295 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.003857
K_296 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.003845
K_297 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.003857
K_298 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.003807
K_299 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.003857
K_300 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.003807
K_301 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.006280
K_302 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.006116
K_303 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.006155
K_304 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.006241
K_305 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.003898
K_306 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.003827
K_307 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.003868
K_308 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.003857
K_309 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.003908
K_310 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.003857
K_311 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.003908
K_312 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.003857
K_313 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_314 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_315 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_316 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.006241
K_317 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.006110
K_318 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.006238
K_319 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.006110
K_320 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.003857
K_321 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.003845
K_322 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.003887
K_323 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.003816
K_324 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_325 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_326 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.006375
K_327 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.006241
K_328 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.006375
K_329 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.006238
K_330 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.003868
K_331 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.003857
K_332 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.003898
K_333 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.003827
K_334 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_335 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.006238
K_336 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.006110
K_337 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.006241
K_338 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.006110
K_339 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.003827
K_340 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.003816
K_341 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.003857
K_342 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.003788
K_343 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.006375
K_344 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.006238
K_345 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.006375
K_346 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.006241
K_347 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.003898
K_348 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.003887
K_349 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.003929
K_350 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.003857
K_351 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_352 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_353 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_354 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.006241
K_355 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.006325
K_356 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.006368
K_357 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.006198
K_358 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_359 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_360 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.006155
K_361 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.006241
K_362 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.006280
K_363 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.006116
K_364 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_365 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.006116
K_366 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.006198
K_367 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.006241
K_368 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.006078
K_369 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.006280
K_370 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.006368
K_371 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.006412
K_372 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.006241
K_373 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_374 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_375 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_376 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_377 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_378 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
