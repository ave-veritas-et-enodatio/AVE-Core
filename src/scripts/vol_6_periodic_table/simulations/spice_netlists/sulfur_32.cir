* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Sulfur-32 (Z=16, A=32)
* Auto-generated topological mutual impedance array
* Nodes: 32

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.010710
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.010220
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.010299
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.010455
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.011519
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.011715
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.011157
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.011674
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.011844
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.011545
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.011560
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.011209
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.007283
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.007152
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.007042
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.007197
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.009403
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.009571
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.009193
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.009233
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.007143
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.007005
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.006939
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.006933
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.006693
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.006668
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.006505
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.006588
K_32 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_33 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_34 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.011245
K_35 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.010710
K_36 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.010786
K_37 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.010966
K_38 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.011299
K_39 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.011519
K_40 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.010972
K_41 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.011463
K_42 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.012126
K_43 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.011844
K_44 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.011841
K_45 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.011465
K_46 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.007413
K_47 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.007283
K_48 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.007163
K_49 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.007326
K_50 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.009225
K_51 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.009403
K_52 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.009034
K_53 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.009073
K_54 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.007281
K_55 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.007143
K_56 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.007069
K_57 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.007063
K_58 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.006712
K_59 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.006693
K_60 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.006525
K_61 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.006609
K_62 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_63 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.011143
K_64 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.010608
K_65 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.010710
K_66 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.010871
K_67 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.011879
K_68 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.012115
K_69 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.011519
K_70 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.012070
K_71 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.012108
K_72 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.011809
K_73 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.011844
K_74 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.011450
K_75 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.007541
K_76 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.007401
K_77 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.007283
K_78 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.007450
K_79 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.009607
K_80 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.009798
K_81 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.009403
K_82 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.009437
K_83 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.007358
K_84 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.007211
K_85 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.007143
K_86 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.007133
K_87 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.006892
K_88 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.006868
K_89 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.006693
K_90 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.006781
K_91 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.010954
K_92 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.010445
K_93 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.010529
K_94 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.010710
K_95 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.011336
K_96 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.011540
K_97 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.011005
K_98 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.011519
K_99 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.012554
K_100 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.012221
K_101 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.012239
K_102 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.011844
K_103 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.007364
K_104 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.007233
K_105 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.007119
K_106 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.007283
K_107 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.009561
K_108 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.009749
K_109 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.009350
K_110 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.009403
K_111 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.007365
K_112 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.007218
K_113 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.007146
K_114 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.007143
K_115 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.006796
K_116 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.006773
K_117 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.006602
K_118 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.006693
K_119 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_120 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_121 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_122 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.008038
K_123 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.008335
K_124 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.008088
K_125 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.008200
K_126 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.009913
K_127 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.010145
K_128 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.010080
K_129 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.009714
K_130 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.011761
K_131 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.011871
K_132 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.011281
K_133 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.011721
K_134 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.006566
K_135 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.006747
K_136 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.006589
K_137 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.006565
K_138 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.009786
K_139 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.009811
K_140 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.009567
K_141 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.009432
K_142 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.007143
K_143 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.007268
K_144 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.007032
K_145 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.007088
K_146 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_147 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_148 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.007760
K_149 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.008038
K_150 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.007810
K_151 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.007911
K_152 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.009676
K_153 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.009913
K_154 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.009841
K_155 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.009500
K_156 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.011617
K_157 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.011761
K_158 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.011170
K_159 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.011596
K_160 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.006393
K_161 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.006566
K_162 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.006418
K_163 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.006395
K_164 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.009740
K_165 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.009786
K_166 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.009534
K_167 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.009400
K_168 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.007017
K_169 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.007143
K_170 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.006915
K_171 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.006969
K_172 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_173 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.007977
K_174 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.008274
K_175 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.008038
K_176 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.008142
K_177 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.009733
K_178 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.009964
K_179 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.009913
K_180 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.009554
K_181 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.012264
K_182 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.012411
K_183 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.011761
K_184 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.012240
K_185 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.006536
K_186 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.006718
K_187 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.006566
K_188 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.006538
K_189 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.009998
K_190 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.010036
K_191 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.009786
K_192 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.009632
K_193 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.007251
K_194 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.007386
K_195 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.007143
K_196 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.007198
K_197 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.007873
K_198 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.008158
K_199 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.007926
K_200 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.008038
K_201 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.010101
K_202 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.010360
K_203 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.010290
K_204 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.009913
K_205 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.011763
K_206 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.011893
K_207 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.011300
K_208 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.011761
K_209 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.006561
K_210 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.006745
K_211 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.006588
K_212 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.006566
K_213 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.010159
K_214 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.010199
K_215 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.009926
K_216 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.009786
K_217 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.007192
K_218 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.007323
K_219 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.007082
K_220 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.007143
K_221 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_222 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_223 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_224 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.007173
K_225 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.007057
K_226 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.007195
K_227 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.006987
K_228 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.009319
K_229 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.008949
K_230 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.008997
K_231 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.009056
K_232 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.011657
K_233 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.011754
K_234 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.011618
K_235 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.011180
K_236 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.006566
K_237 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.006422
K_238 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.006470
K_239 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.006373
K_240 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.009403
K_241 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.009224
K_242 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.009072
K_243 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.009035
K_244 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_245 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_246 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.007287
K_247 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.007173
K_248 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.007314
K_249 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.007095
K_250 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.009718
K_251 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.009319
K_252 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.009364
K_253 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.009431
K_254 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.011526
K_255 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.011657
K_256 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.011507
K_257 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.011081
K_258 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.006713
K_259 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.006566
K_260 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.006614
K_261 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.006510
K_262 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.009571
K_263 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.009403
K_264 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.009233
K_265 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.009194
K_266 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_267 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.007143
K_268 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.007032
K_269 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.007173
K_270 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.006962
K_271 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.009659
K_272 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.009257
K_273 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.009319
K_274 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.009376
K_275 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.011659
K_276 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.011775
K_277 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.011657
K_278 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.011198
K_279 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.006660
K_280 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.006513
K_281 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.006566
K_282 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.006462
K_283 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009750
K_284 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.009562
K_285 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.009403
K_286 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.009352
K_287 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.007366
K_288 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.007245
K_289 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.007395
K_290 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.007173
K_291 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.009587
K_292 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.009194
K_293 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.009246
K_294 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.009319
K_295 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.012158
K_296 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.012290
K_297 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.012135
K_298 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.011657
K_299 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.006771
K_300 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.006617
K_301 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.006669
K_302 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.006566
K_303 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.009797
K_304 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.009606
K_305 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.009434
K_306 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.009403
K_307 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_308 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_309 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_310 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.006943
K_311 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.006885
K_312 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.006784
K_313 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.007002
K_314 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.009319
K_315 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.009636
K_316 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.009243
K_317 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.009481
K_318 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.011761
K_319 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.011427
K_320 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.011132
K_321 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.011449
K_322 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.007283
K_323 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.007319
K_324 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.007101
K_325 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.007301
K_326 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_327 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_328 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.006994
K_329 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.006943
K_330 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.006835
K_331 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.007058
K_332 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.009015
K_333 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.009319
K_334 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.008954
K_335 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.009170
K_336 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.012084
K_337 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.011761
K_338 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.011422
K_339 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.011766
K_340 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.007240
K_341 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.007283
K_342 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.007064
K_343 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.007261
K_344 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_345 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.007105
K_346 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.007047
K_347 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.006943
K_348 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.007173
K_349 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.009379
K_350 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.009713
K_351 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.009319
K_352 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.009554
K_353 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.012465
K_354 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.012089
K_355 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.011761
K_356 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.012116
K_357 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.007471
K_358 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.007514
K_359 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.007283
K_360 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.007495
K_361 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.006877
K_362 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.006825
K_363 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.006726
K_364 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.006943
K_365 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.009148
K_366 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.009457
K_367 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.009084
K_368 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.009319
K_369 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.012058
K_370 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.011718
K_371 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.011400
K_372 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.011761
K_373 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.007257
K_374 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.007296
K_375 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.007080
K_376 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.007283
K_377 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_378 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_379 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_380 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.007173
K_381 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.007379
K_382 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.007319
K_383 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.007176
K_384 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.009913
K_385 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.009863
K_386 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.009973
K_387 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.009557
K_388 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.011844
K_389 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.012289
K_390 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.011826
K_391 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.011616
K_392 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_393 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_394 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.006976
K_395 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.007173
K_396 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.007114
K_397 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.006982
K_398 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.009941
K_399 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.009913
K_400 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.010012
K_401 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.009592
K_402 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.011409
K_403 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.011844
K_404 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.011411
K_405 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.011222
K_406 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_407 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.007027
K_408 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.007225
K_409 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.007173
K_410 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.007034
K_411 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.009833
K_412 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.009795
K_413 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.009913
K_414 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.009495
K_415 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.011823
K_416 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.012287
K_417 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.011844
K_418 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.011615
K_419 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.007162
K_420 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.007371
K_421 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.007312
K_422 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.007173
K_423 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.010287
K_424 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.010243
K_425 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.010366
K_426 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.009913
K_427 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.012045
K_428 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.012537
K_429 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.012046
K_430 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.011844
K_431 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_432 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_433 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_434 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.008038
K_435 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.007744
K_436 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.007869
K_437 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.007835
K_438 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.011519
K_439 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.011095
K_440 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.010943
K_441 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.011281
K_442 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_443 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_444 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.008354
K_445 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.008038
K_446 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.008172
K_447 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.008134
K_448 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.011955
K_449 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.011519
K_450 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.011332
K_451 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.011708
K_452 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_453 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.008205
K_454 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.007899
K_455 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.008038
K_456 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.007996
K_457 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.012154
K_458 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.011678
K_459 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.011519
K_460 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.011895
K_461 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.008244
K_462 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.007934
K_463 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.008068
K_464 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.008038
K_465 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.011735
K_466 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.011304
K_467 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.011144
K_468 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.011519
K_469 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_470 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_471 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_472 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.010710
K_473 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.011090
K_474 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.010610
K_475 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.011009
K_476 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_477 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_478 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.010341
K_479 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.010710
K_480 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.010263
K_481 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.010623
K_482 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_483 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.010784
K_484 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.011188
K_485 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.010710
K_486 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.011105
K_487 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.010408
K_488 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.010770
K_489 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.010329
K_490 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.010710
K_491 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_492 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_493 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_494 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_495 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_496 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
