* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Potassium-39 (Z=19, A=39)
* Auto-generated topological mutual impedance array
* Nodes: 39

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.009843
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.009426
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.009498
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.009630
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.010593
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.010767
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.010298
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.010743
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.010970
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.010710
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.010750
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.010426
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.006634
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.006522
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.006435
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.006569
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.008821
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.009002
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.008664
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.008695
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.006521
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.006392
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.006356
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.006342
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.006041
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.006029
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.005888
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.005980
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.006332
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.006315
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.006195
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.006186
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.021475
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.005762
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.005405
K_39 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_40 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_41 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.010294
K_42 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.009843
K_43 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.009913
K_44 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.010064
K_45 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.010402
K_46 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.010593
K_47 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.010133
K_48 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.010557
K_49 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.011216
K_50 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.010970
K_51 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.010997
K_52 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.010650
K_53 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.006745
K_54 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.006634
K_55 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.006539
K_56 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.006680
K_57 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.008636
K_58 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.008821
K_59 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.008495
K_60 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.008524
K_61 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.006652
K_62 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.006521
K_63 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.006479
K_64 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.006465
K_65 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.006048
K_66 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.006041
K_67 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.005897
K_68 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.005989
K_69 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.006343
K_70 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.006332
K_71 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.006209
K_72 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.006199
K_73 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.020015
K_74 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.005903
K_75 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.005376
K_76 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_77 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.010203
K_78 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.009752
K_79 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.009843
K_80 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.009979
K_81 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.010886
K_82 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.011091
K_83 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.010593
K_84 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.011064
K_85 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.011171
K_86 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.010912
K_87 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.010970
K_88 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.010612
K_89 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.006845
K_90 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.006726
K_91 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.006634
K_92 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.006777
K_93 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.008971
K_94 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.009171
K_95 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.008821
K_96 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.008846
K_97 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.006694
K_98 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.006558
K_99 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.006521
K_100 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.006504
K_101 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.006201
K_102 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.006191
K_103 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.006041
K_104 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.006138
K_105 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.006471
K_106 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.006456
K_107 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.006332
K_108 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.006319
K_109 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.019995
K_110 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.005902
K_111 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.005511
K_112 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.010046
K_113 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.009614
K_114 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.009691
K_115 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.009843
K_116 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.010424
K_117 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.010603
K_118 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.010154
K_119 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.010593
K_120 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.011573
K_121 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.011286
K_122 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.011333
K_123 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.010970
K_124 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.006694
K_125 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.006582
K_126 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.006493
K_127 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.006634
K_128 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.008937
K_129 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.009134
K_130 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.008781
K_131 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.008821
K_132 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.006709
K_133 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.006572
K_134 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.006533
K_135 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.006521
K_136 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.006098
K_137 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.006089
K_138 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.005944
K_139 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.006041
K_140 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.006482
K_141 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006466
K_142 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.006339
K_143 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.006332
K_144 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.021451
K_145 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.005869
K_146 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.005443
K_147 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_148 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_149 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_150 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.007307
K_151 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.007552
K_152 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.007351
K_153 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.007444
K_154 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.009000
K_155 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.009189
K_156 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.009149
K_157 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.008840
K_158 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.010810
K_159 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.010888
K_160 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.010401
K_161 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.010799
K_162 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.005854
K_163 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.006001
K_164 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.005881
K_165 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.005860
K_166 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.009334
K_167 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.009314
K_168 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.009137
K_169 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008985
K_170 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.006340
K_171 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.006445
K_172 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.006253
K_173 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.006324
K_174 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.006041
K_175 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.006128
K_176 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.006001
K_177 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.005960
K_178 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006968
K_179 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.012156
K_180 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.005010
K_181 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_182 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_183 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.007076
K_184 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.007307
K_185 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.007120
K_186 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.007205
K_187 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.008807
K_188 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.009000
K_189 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.008954
K_190 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.008664
K_191 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.010705
K_192 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.010810
K_193 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.010320
K_194 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.010709
K_195 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.005712
K_196 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.005854
K_197 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.005739
K_198 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.005720
K_199 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.009336
K_200 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.009334
K_201 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.009147
K_202 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008995
K_203 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.006235
K_204 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.006340
K_205 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.006154
K_206 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.006223
K_207 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.005952
K_208 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.006041
K_209 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.005916
K_210 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.005877
K_211 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006767
K_212 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.012642
K_213 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.004931
K_214 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_215 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.007255
K_216 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.007500
K_217 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.007307
K_218 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.007394
K_219 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.008843
K_220 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.009030
K_221 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.009000
K_222 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.008698
K_223 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.011238
K_224 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.011343
K_225 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.010810
K_226 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.011243
K_227 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.005822
K_228 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.005970
K_229 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.005854
K_230 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.005831
K_231 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.009525
K_232 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.009513
K_233 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.009334
K_234 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.009164
K_235 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.006425
K_236 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.006538
K_237 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.006340
K_238 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.006412
K_239 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.006077
K_240 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.006168
K_241 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.006041
K_242 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.005997
K_243 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006793
K_244 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.012804
K_245 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.005045
K_246 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.007169
K_247 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.007404
K_248 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.007214
K_249 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.007307
K_250 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.009153
K_251 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.009361
K_252 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.009318
K_253 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.009000
K_254 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.010791
K_255 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.010884
K_256 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.010397
K_257 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.010810
K_258 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.005843
K_259 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.005992
K_260 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.005872
K_261 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.005854
K_262 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.009706
K_263 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.009694
K_264 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.009495
K_265 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.009334
K_266 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.006350
K_267 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.006458
K_268 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.006265
K_269 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.006340
K_270 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.006120
K_271 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.006214
K_272 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.006081
K_273 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.006041
K_274 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006894
K_275 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.012781
K_276 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.005012
K_277 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_278 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_279 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_280 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.006429
K_281 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.006336
K_282 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.006449
K_283 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.006280
K_284 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.008324
K_285 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.008025
K_286 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.008068
K_287 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.008123
K_288 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.010609
K_289 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.010733
K_290 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.010624
K_291 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.010243
K_292 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.005668
K_293 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.005556
K_294 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.005601
K_295 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.005526
K_296 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.009334
K_297 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.009170
K_298 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008972
K_299 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.009014
K_300 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.006521
K_301 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.006461
K_302 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.006438
K_303 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.006328
K_304 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.008334
K_305 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.005203
K_306 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.008287
K_307 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_308 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_309 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.006519
K_310 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.006429
K_311 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.006544
K_312 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.006367
K_313 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.008644
K_314 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.008324
K_315 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.008365
K_316 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.008426
K_317 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.010464
K_318 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.010609
K_319 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.010491
K_320 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.010124
K_321 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.005783
K_322 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.005668
K_323 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.005714
K_324 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.005635
K_325 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.009488
K_326 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.009334
K_327 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.009117
K_328 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.009161
K_329 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.006577
K_330 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.006521
K_331 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.006495
K_332 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.006382
K_333 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.008328
K_334 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.005329
K_335 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.008267
K_336 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_337 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.006402
K_338 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.006313
K_339 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.006429
K_340 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.006258
K_341 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.008591
K_342 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.008270
K_343 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.008324
K_344 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.008378
K_345 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.010568
K_346 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.010704
K_347 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.010609
K_348 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.010218
K_349 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.005733
K_350 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.005619
K_351 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.005668
K_352 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.005588
K_353 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009723
K_354 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.009547
K_355 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.009334
K_356 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.009372
K_357 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.006601
K_358 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.006542
K_359 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.006521
K_360 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.006404
K_361 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.008104
K_362 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.005269
K_363 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.008525
K_364 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.006582
K_365 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.006485
K_366 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.006607
K_367 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.006429
K_368 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.008526
K_369 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.008212
K_370 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.008258
K_371 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.008324
K_372 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.010987
K_373 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.011140
K_374 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.011018
K_375 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.010609
K_376 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.005817
K_377 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.005698
K_378 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.005747
K_379 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.005668
K_380 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.009671
K_381 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.009498
K_382 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.009279
K_383 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.009334
K_384 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.006726
K_385 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.006663
K_386 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.006638
K_387 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.006521
K_388 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.008411
K_389 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.005301
K_390 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.008507
K_391 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_392 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_393 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_394 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.006095
K_395 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.006050
K_396 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.005974
K_397 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.006143
K_398 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.008130
K_399 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.008381
K_400 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.008089
K_401 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.008264
K_402 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.010609
K_403 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.010282
K_404 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.010099
K_405 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.010334
K_406 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.005854
K_407 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.005882
K_408 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.005744
K_409 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.005884
K_410 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.008821
K_411 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.008908
K_412 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.008562
K_413 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.008713
K_414 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.010529
K_415 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.006932
K_416 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.005242
K_417 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_418 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_419 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.006136
K_420 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.006095
K_421 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.006014
K_422 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.006187
K_423 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.007888
K_424 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.008130
K_425 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.007856
K_426 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.008017
K_427 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.010940
K_428 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.010609
K_429 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.010396
K_430 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.010653
K_431 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.005821
K_432 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.005854
K_433 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.005716
K_434 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.005854
K_435 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.008721
K_436 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.008821
K_437 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008478
K_438 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.008624
K_439 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.010137
K_440 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.007112
K_441 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.005188
K_442 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_443 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.006219
K_444 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.006174
K_445 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.006095
K_446 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.006272
K_447 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.008158
K_448 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.008420
K_449 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.008130
K_450 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.008301
K_451 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.011174
K_452 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.010808
K_453 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.010609
K_454 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.010869
K_455 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.005964
K_456 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.005997
K_457 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.005854
K_458 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.006000
K_459 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.009088
K_460 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.009192
K_461 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.008821
K_462 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.008979
K_463 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.010168
K_464 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.007121
K_465 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.005314
K_466 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.006044
K_467 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.006002
K_468 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.005928
K_469 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.006095
K_470 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.007989
K_471 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.008234
K_472 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.007956
K_473 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.008130
K_474 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.010878
K_475 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.010539
K_476 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.010342
K_477 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.010609
K_478 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.005819
K_479 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.005848
K_480 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.005713
K_481 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.005854
K_482 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.008917
K_483 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.009015
K_484 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.008657
K_485 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.008821
K_486 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.010055
K_487 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.006969
K_488 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.005214
K_489 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_490 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_491 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_492 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.006095
K_493 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.006245
K_494 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.006203
K_495 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.006101
K_496 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.008324
K_497 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.008268
K_498 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.008371
K_499 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.008072
K_500 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.010810
K_501 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.011250
K_502 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.010786
K_503 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.010728
K_504 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.006634
K_505 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.006728
K_506 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.006677
K_507 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.006526
K_508 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.005222
K_509 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.010246
K_510 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.007011
K_511 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_512 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_513 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.005951
K_514 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.006095
K_515 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.006054
K_516 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.005959
K_517 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.008367
K_518 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.008324
K_519 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.008422
K_520 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.008118
K_521 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.010392
K_522 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.010810
K_523 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.010383
K_524 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.010332
K_525 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.006537
K_526 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.006634
K_527 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.006582
K_528 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.006437
K_529 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.005146
K_530 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.010619
K_531 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.006822
K_532 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_533 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.005987
K_534 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.006132
K_535 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.006095
K_536 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.005996
K_537 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.008264
K_538 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.008216
K_539 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.008324
K_540 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.008023
K_541 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.010805
K_542 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.011261
K_543 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.010810
K_544 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.010738
K_545 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.006585
K_546 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.006680
K_547 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.006634
K_548 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.006482
K_549 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.005103
K_550 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.010249
K_551 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.006993
K_552 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.006084
K_553 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.006236
K_554 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.006194
K_555 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.006095
K_556 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.008587
K_557 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.008532
K_558 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.008646
K_559 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.008324
K_560 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.010864
K_561 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.011327
K_562 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.010854
K_563 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.010810
K_564 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.006740
K_565 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.006842
K_566 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.006789
K_567 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.006634
K_568 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.005191
K_569 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.010616
K_570 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.007018
K_571 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_572 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_573 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_574 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.006429
K_575 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.006239
K_576 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.006326
K_577 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.006301
K_578 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.009000
K_579 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.008775
K_580 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.008659
K_581 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.008926
K_582 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.010970
K_583 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.010553
K_584 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.010558
K_585 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.010458
K_586 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.009134
K_587 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.004813
K_588 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.010071
K_589 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_590 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_591 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.006630
K_592 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.006429
K_593 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.006521
K_594 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.006493
K_595 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.009226
K_596 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.009000
K_597 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.008867
K_598 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.009154
K_599 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.011405
K_600 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.010970
K_601 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.010960
K_602 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.010847
K_603 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.009214
K_604 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.004926
K_605 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.010151
K_606 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_607 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.006530
K_608 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.006334
K_609 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.006429
K_610 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.006399
K_611 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.009367
K_612 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.009122
K_613 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.009000
K_614 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.009292
K_615 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.011399
K_616 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.010949
K_617 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.010970
K_618 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.010842
K_619 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.008850
K_620 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.004868
K_621 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.010534
K_622 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.006558
K_623 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.006360
K_624 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.006452
K_625 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.006429
K_626 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.009060
K_627 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.008838
K_628 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.008720
K_629 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.009000
K_630 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.011529
K_631 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.011065
K_632 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.011070
K_633 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.010970
K_634 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.009000
K_635 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.004854
K_636 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.010132
K_637 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_638 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_639 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_640 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.007307
K_641 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.007474
K_642 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.007264
K_643 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.007460
K_644 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.010593
K_645 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.011105
K_646 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.010658
K_647 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.010675
K_648 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.005691
K_649 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.012701
K_650 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.005861
K_651 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_652 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_653 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.007142
K_654 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.007307
K_655 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.007106
K_656 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.007290
K_657 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.010123
K_658 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.010593
K_659 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.010192
K_660 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.010206
K_661 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.005578
K_662 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.013228
K_663 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.005733
K_664 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_665 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.007342
K_666 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.007516
K_667 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.007307
K_668 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.007502
K_669 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.010503
K_670 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.011016
K_671 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.010593
K_672 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.010596
K_673 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.005553
K_674 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.012900
K_675 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.005869
K_676 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.007154
K_677 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.007316
K_678 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.007118
K_679 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.007307
K_680 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.010487
K_681 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.010998
K_682 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.010564
K_683 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.010593
K_684 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.005572
K_685 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.012462
K_686 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.005777
K_687 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_688 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_689 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_690 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.009843
K_691 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.009819
K_692 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.009993
K_693 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.009547
K_694 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.005263
K_695 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.006135
K_696 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.019565
K_697 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_698 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_699 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.009844
K_700 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.009843
K_701 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.010007
K_702 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.009559
K_703 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.005233
K_704 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.006296
K_705 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.018033
K_706 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_707 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.009678
K_708 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.009665
K_709 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.009843
K_710 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.009406
K_711 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.005140
K_712 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.006134
K_713 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.019128
K_714 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.010143
K_715 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.010129
K_716 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.010321
K_717 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.009843
K_718 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.005224
K_719 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.006199
K_720 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.019328
K_721 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_722 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_723 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_724 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.006087
K_725 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.006102
K_726 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.009467
K_727 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_728 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_729 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.006038
K_730 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.006256
K_731 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.009266
K_732 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_733 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.005933
K_734 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.006139
K_735 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.009558
K_736 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.005959
K_737 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.006093
K_738 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.009187
K_739 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.004770
K_740 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.005026
K_741 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.004770

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
