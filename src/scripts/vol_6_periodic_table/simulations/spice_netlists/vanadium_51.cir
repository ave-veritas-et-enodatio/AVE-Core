* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Vanadium-51 (Z=23, A=51)
* Auto-generated topological mutual impedance array
* Nodes: 51

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.008842
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.008503
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.008567
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.008675
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.009526
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.009675
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.009300
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.009668
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.009959
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.009741
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.009808
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.009514
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.005892
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.005800
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005737
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.005848
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.008141
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.008331
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.008041
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.008062
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.005813
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.005698
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.005688
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.005670
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.005336
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.005333
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.005220
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.005309
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.006066
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.006070
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.005977
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.005926
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.004724
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.004673
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.004623
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.004651
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.004951
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.004956
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.004861
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.004887
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.032102
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.006511
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.006761
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.006480
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.004415
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.005134
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.004191
K_51 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_52 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_53 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.009207
K_54 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.008842
K_55 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.008906
K_56 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.009027
K_57 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.009364
K_58 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.009526
K_59 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.009158
K_60 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.009509
K_61 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.010167
K_62 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.009959
K_63 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.010018
K_64 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.009705
K_65 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.005982
K_66 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.005892
K_67 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.005823
K_68 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.005939
K_69 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.007950
K_70 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.008141
K_71 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.007863
K_72 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.007883
K_73 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.005931
K_74 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.005813
K_75 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.005801
K_76 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.005781
K_77 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.005335
K_78 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.005336
K_79 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.005221
K_80 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.005310
K_81 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.006057
K_82 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.006066
K_83 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.005970
K_84 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.005920
K_85 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.004775
K_86 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.004724
K_87 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.004671
K_88 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.004701
K_89 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.004944
K_90 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.004951
K_91 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.004855
K_92 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.004881
K_93 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.029491
K_94 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.006712
K_95 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.006659
K_96 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.006546
K_97 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.004460
K_98 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.005083
K_99 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.004224
K_100 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_101 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.009127
K_102 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.008764
K_103 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.008842
K_104 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.008952
K_105 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.009747
K_106 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.009919
K_107 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.009526
K_108 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.009911
K_109 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.010093
K_110 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.009878
K_111 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.009959
K_112 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.009641
K_113 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.006054
K_114 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.005958
K_115 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.005892
K_116 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.006009
K_117 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.008231
K_118 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.008436
K_119 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.008141
K_120 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.008156
K_121 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.005942
K_122 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.005821
K_123 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.005813
K_124 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.005791
K_125 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.005456
K_126 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.005455
K_127 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.005336
K_128 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.005430
K_129 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.006154
K_130 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.006161
K_131 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.006066
K_132 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.006010
K_133 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.004830
K_134 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.004777
K_135 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.004724
K_136 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.004754
K_137 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.005044
K_138 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.005051
K_139 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.004951
K_140 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.004978
K_141 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.027842
K_142 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.006654
K_143 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.006859
K_144 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.006535
K_145 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.004510
K_146 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.005193
K_147 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.004263
K_148 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.009002
K_149 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.008652
K_150 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.008720
K_151 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.008842
K_152 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.009370
K_153 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.009522
K_154 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.009164
K_155 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.009526
K_156 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.010446
K_157 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.010209
K_158 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.010285
K_159 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.009959
K_160 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.005931
K_161 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.005840
K_162 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.005776
K_163 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.005892
K_164 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.008209
K_165 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.008412
K_166 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.008113
K_167 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.008141
K_168 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.005964
K_169 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.005841
K_170 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.005831
K_171 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.005813
K_172 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.005359
K_173 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.005358
K_174 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.005243
K_175 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.005336
K_176 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.006211
K_177 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006218
K_178 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.006118
K_179 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.006066
K_180 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.004798
K_181 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.004746
K_182 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.004693
K_183 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.004724
K_184 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.005015
K_185 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.005022
K_186 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.004923
K_187 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.004951
K_188 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.030007
K_189 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.006602
K_190 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.006685
K_191 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.006681
K_192 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.004449
K_193 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.005188
K_194 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.004264
K_195 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_196 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_197 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_198 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.006467
K_199 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.006659
K_200 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.006504
K_201 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.006578
K_202 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.007952
K_203 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.008097
K_204 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.008080
K_205 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.007831
K_206 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.009696
K_207 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.009743
K_208 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.009366
K_209 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.009715
K_210 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.005064
K_211 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.005178
K_212 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.005092
K_213 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.005075
K_214 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.008739
K_215 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.008674
K_216 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008574
K_217 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008409
K_218 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.005481
K_219 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.005564
K_220 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.005419
K_221 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.005491
K_222 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.005085
K_223 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.005156
K_224 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.005085
K_225 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.005032
K_226 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006289
K_227 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.006293
K_228 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.006147
K_229 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.006175
K_230 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.004724
K_231 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.004783
K_232 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.004687
K_233 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.004693
K_234 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.007208
K_235 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.023802
K_236 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.005104
K_237 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.005870
K_238 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.006265
K_239 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.004102
K_240 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.004930
K_241 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_242 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_243 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.006286
K_244 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.006467
K_245 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.006322
K_246 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.006390
K_247 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.007803
K_248 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.007952
K_249 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.007930
K_250 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.007694
K_251 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.009628
K_252 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.009696
K_253 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.009314
K_254 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.009658
K_255 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.004954
K_256 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.005064
K_257 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.004982
K_258 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.004966
K_259 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.008789
K_260 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.008739
K_261 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008629
K_262 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008461
K_263 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.005399
K_264 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.005481
K_265 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.005341
K_266 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.005410
K_267 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.005014
K_268 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.005085
K_269 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.005015
K_270 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.004964
K_271 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006280
K_272 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006289
K_273 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.006141
K_274 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.006169
K_275 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.004665
K_276 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.004724
K_277 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.004630
K_278 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.004636
K_279 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.006994
K_280 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.026874
K_281 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.004995
K_282 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.005816
K_283 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.006267
K_284 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.004042
K_285 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.004923
K_286 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_287 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.006425
K_288 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.006616
K_289 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.006467
K_290 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.006537
K_291 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.007819
K_292 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.007962
K_293 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.007952
K_294 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.007709
K_295 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.010040
K_296 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.010104
K_297 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.009696
K_298 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.010073
K_299 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.005033
K_300 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.005147
K_301 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.005064
K_302 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.005046
K_303 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.008896
K_304 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.008836
K_305 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.008739
K_306 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.008556
K_307 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.005541
K_308 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.005629
K_309 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.005481
K_310 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.005554
K_311 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.005083
K_312 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.005155
K_313 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.005085
K_314 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.005031
K_315 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006436
K_316 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006443
K_317 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006289
K_318 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006317
K_319 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.004760
K_320 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.004822
K_321 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.004724
K_322 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.004729
K_323 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.007005
K_324 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.025229
K_325 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.005092
K_326 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.005829
K_327 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.006434
K_328 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.004103
K_329 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.004997
K_330 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.006356
K_331 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.006541
K_332 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.006394
K_333 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.006467
K_334 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.008066
K_335 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.008224
K_336 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.008206
K_337 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.007952
K_338 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.009656
K_339 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.009713
K_340 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.009339
K_341 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.009696
K_342 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.005049
K_343 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.005164
K_344 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.005079
K_345 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.005064
K_346 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.009093
K_347 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.009028
K_348 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.008916
K_349 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.008739
K_350 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.005467
K_351 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.005551
K_352 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.005407
K_353 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.005481
K_354 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.005137
K_355 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.005212
K_356 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.005138
K_357 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.005085
K_358 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006404
K_359 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006411
K_360 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.006257
K_361 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006289
K_362 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.004754
K_363 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.004815
K_364 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.004717
K_365 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.004724
K_366 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.007096
K_367 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.025096
K_368 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.005041
K_369 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.005967
K_370 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.006303
K_371 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.004112
K_372 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.005021
K_373 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_374 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_375 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_376 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.005586
K_377 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.005516
K_378 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.005604
K_379 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.005475
K_380 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.007201
K_381 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.006974
K_382 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.007012
K_383 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.007060
K_384 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.009365
K_385 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.009500
K_386 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.009423
K_387 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.009112
K_388 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.004742
K_389 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.004661
K_390 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.004700
K_391 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.004646
K_392 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.008924
K_393 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.008786
K_394 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008570
K_395 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.008687
K_396 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.005389
K_397 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.005364
K_398 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.005365
K_399 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.005264
K_400 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.005085
K_401 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.004999
K_402 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.004991
K_403 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.004973
K_404 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006066
K_405 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006035
K_406 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.005956
K_407 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.005913
K_408 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.008004
K_409 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.005166
K_410 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.021937
K_411 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.004477
K_412 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.005391
K_413 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.005987
K_414 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.004127
K_415 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_416 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_417 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.005654
K_418 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.005586
K_419 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.005675
K_420 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.005541
K_421 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.007442
K_422 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.007201
K_423 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.007238
K_424 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.007291
K_425 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.009216
K_426 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.009365
K_427 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.009282
K_428 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.008983
K_429 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.004826
K_430 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.004742
K_431 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.004783
K_432 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.004726
K_433 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.009052
K_434 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.008924
K_435 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.008691
K_436 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.008812
K_437 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.005411
K_438 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.005389
K_439 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.005389
K_440 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.005286
K_441 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.005173
K_442 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.005085
K_443 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.005075
K_444 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.005057
K_445 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006093
K_446 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006066
K_447 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.005984
K_448 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.005940
K_449 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.008051
K_450 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.005292
K_451 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.020456
K_452 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.004515
K_453 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.005504
K_454 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.005945
K_455 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.004172
K_456 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_457 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.005564
K_458 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.005497
K_459 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.005586
K_460 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.005456
K_461 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.007397
K_462 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.007156
K_463 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.007201
K_464 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.007249
K_465 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.009288
K_466 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.009430
K_467 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.009365
K_468 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.009050
K_469 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.004783
K_470 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.004700
K_471 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.004742
K_472 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.004685
K_473 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009307
K_474 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.009160
K_475 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.008924
K_476 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.009048
K_477 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.005409
K_478 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.005385
K_479 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.005389
K_480 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.005285
K_481 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.005182
K_482 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.005092
K_483 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.005085
K_484 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.005065
K_485 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006177
K_486 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006147
K_487 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006066
K_488 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006018
K_489 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.007797
K_490 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.005200
K_491 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.022518
K_492 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.004471
K_493 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.005522
K_494 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.006024
K_495 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.004177
K_496 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.005699
K_497 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.005627
K_498 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.005721
K_499 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.005586
K_500 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.007341
K_501 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.007106
K_502 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.007145
K_503 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.007201
K_504 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.009619
K_505 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.009777
K_506 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.009693
K_507 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.009365
K_508 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.004843
K_509 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.004757
K_510 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.004799
K_511 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.004742
K_512 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.009165
K_513 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.009024
K_514 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.008790
K_515 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.008924
K_516 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.005519
K_517 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.005494
K_518 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.005495
K_519 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.005389
K_520 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.005202
K_521 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.005111
K_522 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.005103
K_523 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.005085
K_524 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006226
K_525 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006195
K_526 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006110
K_527 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006066
K_528 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.008057
K_529 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.005236
K_530 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.021160
K_531 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.004558
K_532 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.005481
K_533 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.006113
K_534 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.004210
K_535 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_536 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_537 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_538 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.005168
K_539 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.005135
K_540 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.005081
K_541 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.005203
K_542 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.006840
K_543 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.007026
K_544 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.006826
K_545 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.006946
K_546 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.009191
K_547 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.008902
K_548 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.008816
K_549 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.008974
K_550 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.004651
K_551 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.004671
K_552 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.004587
K_553 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.004681
K_554 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.008924
K_555 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.009096
K_556 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.008742
K_557 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.008800
K_558 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.005481
K_559 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.005436
K_560 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.005346
K_561 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.005443
K_562 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.005336
K_563 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.005375
K_564 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.005244
K_565 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.005325
K_566 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.009050
K_567 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006600
K_568 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.004621
K_569 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.017825
K_570 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.004297
K_571 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.005358
K_572 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.005575
K_573 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_574 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_575 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.005198
K_576 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.005168
K_577 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.005112
K_578 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.005236
K_579 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.006661
K_580 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.006840
K_581 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.006652
K_582 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.006762
K_583 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.009489
K_584 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.009191
K_585 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.009088
K_586 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.009261
K_587 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.004629
K_588 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.004651
K_589 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.004567
K_590 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.004660
K_591 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.008746
K_592 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.008924
K_593 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008582
K_594 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.008636
K_595 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.005523
K_596 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.005481
K_597 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.005387
K_598 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.005486
K_599 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.005294
K_600 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.005336
K_601 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.005206
K_602 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.005286
K_603 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.008832
K_604 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006743
K_605 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.004568
K_606 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.017962
K_607 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.004321
K_608 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.005269
K_609 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.005616
K_610 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_611 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.005255
K_612 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.005222
K_613 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.005168
K_614 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.005294
K_615 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.006846
K_616 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.007037
K_617 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.006840
K_618 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.006956
K_619 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.009596
K_620 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.009278
K_621 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.009191
K_622 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.009360
K_623 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.004715
K_624 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.004737
K_625 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.004651
K_626 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.004747
K_627 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.009101
K_628 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.009292
K_629 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.008924
K_630 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.008977
K_631 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.005623
K_632 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.005576
K_633 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.005481
K_634 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.005583
K_635 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.005429
K_636 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.005472
K_637 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.005336
K_638 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.005420
K_639 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.008832
K_640 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006705
K_641 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.004638
K_642 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.018144
K_643 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.004372
K_644 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.005402
K_645 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.005720
K_646 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.005129
K_647 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.005099
K_648 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.005047
K_649 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.005168
K_650 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.006732
K_651 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.006913
K_652 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.006722
K_653 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.006840
K_654 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.009404
K_655 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.009104
K_656 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.009013
K_657 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.009191
K_658 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.004619
K_659 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.004640
K_660 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.004558
K_661 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.004651
K_662 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.009038
K_663 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.009225
K_664 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.008857
K_665 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.008924
K_666 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.005517
K_667 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.005473
K_668 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.005381
K_669 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.005481
K_670 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.005343
K_671 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.005384
K_672 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.005252
K_673 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.005336
K_674 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.008674
K_675 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006558
K_676 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.004552
K_677 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.019333
K_678 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.004291
K_679 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.005346
K_680 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.005663
K_681 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_682 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_683 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_684 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.004991
K_685 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.005092
K_686 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.005066
K_687 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.004998
K_688 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.006731
K_689 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.006682
K_690 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.006767
K_691 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.006568
K_692 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.009191
K_693 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.009541
K_694 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.009180
K_695 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.009213
K_696 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.004742
K_697 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.004793
K_698 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.004782
K_699 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.004696
K_700 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.008739
K_701 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.008707
K_702 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.008594
K_703 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.008421
K_704 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.005813
K_705 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.005911
K_706 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.005815
K_707 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.005748
K_708 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.004988
K_709 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.008738
K_710 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.006207
K_711 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.004371
K_712 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.014918
K_713 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.004419
K_714 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.005374
K_715 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_716 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_717 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.004893
K_718 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.004991
K_719 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.004965
K_720 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.004901
K_721 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.006774
K_722 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.006731
K_723 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.006814
K_724 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.006610
K_725 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.008860
K_726 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.009191
K_727 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.008859
K_728 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.008888
K_729 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.004691
K_730 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.004742
K_731 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.004731
K_732 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.004647
K_733 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.008755
K_734 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.008739
K_735 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.008617
K_736 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.008442
K_737 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.005716
K_738 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.005813
K_739 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.005720
K_740 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.005657
K_741 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.004923
K_742 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.008912
K_743 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.006028
K_744 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.004354
K_745 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.015167
K_746 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.004350
K_747 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.005375
K_748 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_749 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.004917
K_750 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.005015
K_751 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.004991
K_752 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.004925
K_753 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.006689
K_754 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.006644
K_755 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.006731
K_756 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.006532
K_757 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.009183
K_758 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.009543
K_759 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.009191
K_760 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.009215
K_761 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.004702
K_762 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.004752
K_763 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.004742
K_764 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.004657
K_765 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.008875
K_766 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.008849
K_767 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.008739
K_768 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.008549
K_769 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.005807
K_770 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.005907
K_771 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.005813
K_772 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.005745
K_773 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.004876
K_774 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.008562
K_775 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.006099
K_776 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.004324
K_777 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.015986
K_778 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.004390
K_779 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.005402
K_780 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.004981
K_781 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.005083
K_782 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.005057
K_783 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.004991
K_784 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.006900
K_785 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.006851
K_786 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.006942
K_787 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.006731
K_788 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.009151
K_789 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.009506
K_790 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.009149
K_791 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.009191
K_792 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.004788
K_793 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.004841
K_794 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.004830
K_795 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.004742
K_796 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.009078
K_797 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.009051
K_798 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.008924
K_799 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.008739
K_800 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.005876
K_801 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.005979
K_802 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.005880
K_803 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.005813
K_804 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.004955
K_805 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.008820
K_806 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.006101
K_807 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.004414
K_808 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.015574
K_809 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.004436
K_810 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.005497
K_811 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_812 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_813 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_814 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.004991
K_815 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.004876
K_816 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.004932
K_817 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.004915
K_818 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.006840
K_819 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.006724
K_820 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.006652
K_821 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.006828
K_822 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.009365
K_823 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.009101
K_824 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.009179
K_825 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.008969
K_826 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.005064
K_827 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.004957
K_828 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.004961
K_829 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.004991
K_830 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.008141
K_831 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.007976
K_832 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.007840
K_833 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.007931
K_834 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.007518
K_835 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.004236
K_836 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.008677
K_837 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.005893
K_838 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.004347
K_839 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.012361
K_840 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.004802
K_841 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_842 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_843 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.005112
K_844 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.004991
K_845 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.005050
K_846 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.005032
K_847 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.006954
K_848 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.006840
K_849 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.006761
K_850 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.006945
K_851 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.009631
K_852 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.009365
K_853 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.009440
K_854 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.009212
K_855 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.005174
K_856 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.005064
K_857 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.005066
K_858 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.005099
K_859 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.008303
K_860 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.008141
K_861 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.007990
K_862 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.008087
K_863 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.007632
K_864 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.004318
K_865 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.008688
K_866 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.006018
K_867 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.004420
K_868 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.012311
K_869 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.004893
K_870 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_871 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.005049
K_872 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.004931
K_873 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.004991
K_874 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.004972
K_875 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.007036
K_876 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.006914
K_877 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.006840
K_878 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.007027
K_879 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.009541
K_880 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.009272
K_881 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.009365
K_882 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.009133
K_883 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.005171
K_884 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.005059
K_885 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.005064
K_886 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.005095
K_887 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.008464
K_888 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.008286
K_889 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.008141
K_890 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.008236
K_891 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.007379
K_892 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.004261
K_893 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.008767
K_894 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.005897
K_895 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.004421
K_896 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.012868
K_897 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.004890
K_898 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.005067
K_899 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.004948
K_900 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.005007
K_901 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.004991
K_902 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.006845
K_903 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.006732
K_904 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.006660
K_905 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.006840
K_906 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.009796
K_907 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.009505
K_908 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.009595
K_909 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.009365
K_910 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.005137
K_911 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.005027
K_912 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.005030
K_913 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.005064
K_914 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.008354
K_915 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.008182
K_916 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.008036
K_917 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.008141
K_918 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.007431
K_919 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.004250
K_920 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.008435
K_921 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.006013
K_922 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.004367
K_923 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.012881
K_924 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.004897
K_925 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_926 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_927 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_928 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.005168
K_929 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.005249
K_930 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.005148
K_931 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.005248
K_932 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.007201
K_933 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.007442
K_934 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.007291
K_935 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.007238
K_936 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.009696
K_937 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.009790
K_938 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.009391
K_939 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.009733
K_940 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.005892
K_941 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.006025
K_942 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.005867
K_943 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.005935
K_944 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.005113
K_945 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.008655
K_946 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.004119
K_947 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.008936
K_948 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.006109
K_949 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.004729
K_950 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.009439
K_951 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_952 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_953 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.005087
K_954 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.005168
K_955 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.005070
K_956 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.005166
K_957 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.006974
K_958 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.007201
K_959 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.007060
K_960 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.007012
K_961 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.009584
K_962 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.009696
K_963 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.009299
K_964 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.009630
K_965 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.005762
K_966 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.005892
K_967 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.005741
K_968 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.005804
K_969 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.005024
K_970 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.008723
K_971 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.004055
K_972 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.008693
K_973 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.006092
K_974 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.004629
K_975 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.009320
K_976 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_977 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.005184
K_978 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.005268
K_979 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.005168
K_980 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.005267
K_981 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.007106
K_982 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.007341
K_983 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.007201
K_984 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.007145
K_985 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.010009
K_986 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.010124
K_987 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.009696
K_988 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.010062
K_989 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.005911
K_990 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.006049
K_991 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.005892
K_992 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.005957
K_993 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.005009
K_994 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.008563
K_995 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.004095
K_996 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.008633
K_997 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.006207
K_998 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.004706
K_999 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.009708
K_1000 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.005087
K_1001 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.005166
K_1002 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.005070
K_1003 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.005168
K_1004 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.007156
K_1005 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.007397
K_1006 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.007249
K_1007 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.007201
K_1008 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.009638
K_1009 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.009741
K_1010 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.009348
K_1011 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.009696
K_1012 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.005845
K_1013 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.005978
K_1014 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.005823
K_1015 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.005892
K_1016 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.005007
K_1017 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.008393
K_1018 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.004050
K_1019 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.008907
K_1020 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.006029
K_1021 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.004692
K_1022 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.009632
K_1023 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_1024 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_1025 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_1026 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.005586
K_1027 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.005590
K_1028 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.005651
K_1029 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.005503
K_1030 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.007952
K_1031 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.007718
K_1032 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.007843
K_1033 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.007692
K_1034 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.009959
K_1035 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.010004
K_1036 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.009969
K_1037 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.009607
K_1038 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.004658
K_1039 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.004809
K_1040 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.009619
K_1041 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.004141
K_1042 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.009129
K_1043 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.006687
K_1044 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.005523
K_1045 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_1046 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_1047 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.005577
K_1048 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.005586
K_1049 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.005644
K_1050 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.005497
K_1051 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.008195
K_1052 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.007952
K_1053 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.008083
K_1054 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.007917
K_1055 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.009891
K_1056 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.009959
K_1057 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.009913
K_1058 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.009556
K_1059 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.004648
K_1060 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.004888
K_1061 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.009327
K_1062 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.004158
K_1063 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.009544
K_1064 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.006574
K_1065 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.005599
K_1066 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_1067 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.005519
K_1068 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.005525
K_1069 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.005586
K_1070 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.005441
K_1071 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.008053
K_1072 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.007816
K_1073 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.007952
K_1074 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.007788
K_1075 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.009926
K_1076 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.009982
K_1077 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.009959
K_1078 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.009587
K_1079 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.004566
K_1080 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.004779
K_1081 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.009230
K_1082 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.004101
K_1083 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.009356
K_1084 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.006586
K_1085 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.005552
K_1086 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.005668
K_1087 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.005675
K_1088 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.005739
K_1089 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.005586
K_1090 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.008227
K_1091 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.007975
K_1092 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.008114
K_1093 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.007952
K_1094 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.010327
K_1095 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.010391
K_1096 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.010352
K_1097 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.009959
K_1098 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.004634
K_1099 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.004827
K_1100 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.009270
K_1101 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.004180
K_1102 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.009305
K_1103 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.006758
K_1104 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.005664
K_1105 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_1106 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_1107 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_1108 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.006467
K_1109 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.006330
K_1110 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.006311
K_1111 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.006449
K_1112 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.009526
K_1113 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.009533
K_1114 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.009222
K_1115 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.009612
K_1116 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.005590
K_1117 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.004479
K_1118 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.004935
K_1119 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.010121
K_1120 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.004460
K_1121 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.010707
K_1122 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.007807
K_1123 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_1124 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_1125 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.006607
K_1126 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.006467
K_1127 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.006444
K_1128 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.006591
K_1129 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.009499
K_1130 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.009526
K_1131 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.009206
K_1132 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.009595
K_1133 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.005579
K_1134 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.004546
K_1135 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.004899
K_1136 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.010414
K_1137 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.004510
K_1138 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.010301
K_1139 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.008046
K_1140 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_1141 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.006629
K_1142 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.006485
K_1143 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.006467
K_1144 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.006612
K_1145 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.009839
K_1146 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.009858
K_1147 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.009526
K_1148 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.009946
K_1149 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.005495
K_1150 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.004488
K_1151 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.004925
K_1152 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.009922
K_1153 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.004521
K_1154 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.010746
K_1155 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.008085
K_1156 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.006480
K_1157 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.006345
K_1158 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.006325
K_1159 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.006467
K_1160 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.009422
K_1161 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.009439
K_1162 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.009137
K_1163 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.009526
K_1164 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.005470
K_1165 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.004451
K_1166 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.004832
K_1167 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.010192
K_1168 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.004438
K_1169 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.010419
K_1170 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.007970
K_1171 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_1172 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_1173 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_1174 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.008842
K_1175 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.009225
K_1176 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.008998
K_1177 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.008952
K_1178 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.004154
K_1179 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.006074
K_1180 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.004721
K_1181 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.005298
K_1182 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.011225
K_1183 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.005414
K_1184 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.013046
K_1185 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_1186 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_1187 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.008489
K_1188 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.008842
K_1189 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.008633
K_1190 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.008593
K_1191 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.004113
K_1192 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.006123
K_1193 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.004638
K_1194 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.005262
K_1195 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.011278
K_1196 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.005283
K_1197 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.012977
K_1198 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_1199 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.008679
K_1200 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.009049
K_1201 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.008842
K_1202 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.008791
K_1203 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.004074
K_1204 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.005968
K_1205 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.004652
K_1206 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.005185
K_1207 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.011339
K_1208 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.005328
K_1209 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.012974
K_1210 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.008721
K_1211 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.009096
K_1212 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.008878
K_1213 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.008842
K_1214 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.004100
K_1215 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.005992
K_1216 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.004625
K_1217 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.005299
K_1218 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.010815
K_1219 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.005367
K_1220 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.013703
K_1221 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_1222 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_1223 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_1224 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.004446
K_1225 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.004229
K_1226 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.006129
K_1227 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.005234
K_1228 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.006140
K_1229 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.012612
K_1230 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.008327
K_1231 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_1232 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_1233 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.004442
K_1234 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.004287
K_1235 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.006064
K_1236 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.005276
K_1237 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.006276
K_1238 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.011997
K_1239 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.008632
K_1240 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_1241 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.004367
K_1242 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.004210
K_1243 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.006030
K_1244 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.005156
K_1245 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.006213
K_1246 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.012005
K_1247 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.008444
K_1248 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.004394
K_1249 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.004214
K_1250 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.005957
K_1251 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.005259
K_1252 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.006108
K_1253 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.012352
K_1254 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.008595
K_1255 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.005633
K_1256 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.006052
K_1257 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.006163
K_1258 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.003882
K_1259 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.004797
K_1260 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.003803
K_1261 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.004291
K_1262 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.005300
K_1263 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.006171
K_1264 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.003620
K_1265 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.004797
K_1266 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.003909
K_1267 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.005103
K_1268 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.006171
K_1269 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.003882
K_1270 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.003909
K_1271 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.005300
K_1272 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.006163
K_1273 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.004291
K_1274 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.006052
K_1275 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.005633

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
