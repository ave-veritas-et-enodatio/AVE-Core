* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Radon-222 (Z=86, A=222)
* Auto-generated topological mutual impedance array
* Nodes: 222

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON
X_NUC_65 NODE_65 0 NUCLEON
X_NUC_66 NODE_66 0 NUCLEON
X_NUC_67 NODE_67 0 NUCLEON
X_NUC_68 NODE_68 0 NUCLEON
X_NUC_69 NODE_69 0 NUCLEON
X_NUC_70 NODE_70 0 NUCLEON
X_NUC_71 NODE_71 0 NUCLEON
X_NUC_72 NODE_72 0 NUCLEON
X_NUC_73 NODE_73 0 NUCLEON
X_NUC_74 NODE_74 0 NUCLEON
X_NUC_75 NODE_75 0 NUCLEON
X_NUC_76 NODE_76 0 NUCLEON
X_NUC_77 NODE_77 0 NUCLEON
X_NUC_78 NODE_78 0 NUCLEON
X_NUC_79 NODE_79 0 NUCLEON
X_NUC_80 NODE_80 0 NUCLEON
X_NUC_81 NODE_81 0 NUCLEON
X_NUC_82 NODE_82 0 NUCLEON
X_NUC_83 NODE_83 0 NUCLEON
X_NUC_84 NODE_84 0 NUCLEON
X_NUC_85 NODE_85 0 NUCLEON
X_NUC_86 NODE_86 0 NUCLEON
X_NUC_87 NODE_87 0 NUCLEON
X_NUC_88 NODE_88 0 NUCLEON
X_NUC_89 NODE_89 0 NUCLEON
X_NUC_90 NODE_90 0 NUCLEON
X_NUC_91 NODE_91 0 NUCLEON
X_NUC_92 NODE_92 0 NUCLEON
X_NUC_93 NODE_93 0 NUCLEON
X_NUC_94 NODE_94 0 NUCLEON
X_NUC_95 NODE_95 0 NUCLEON
X_NUC_96 NODE_96 0 NUCLEON
X_NUC_97 NODE_97 0 NUCLEON
X_NUC_98 NODE_98 0 NUCLEON
X_NUC_99 NODE_99 0 NUCLEON
X_NUC_100 NODE_100 0 NUCLEON
X_NUC_101 NODE_101 0 NUCLEON
X_NUC_102 NODE_102 0 NUCLEON
X_NUC_103 NODE_103 0 NUCLEON
X_NUC_104 NODE_104 0 NUCLEON
X_NUC_105 NODE_105 0 NUCLEON
X_NUC_106 NODE_106 0 NUCLEON
X_NUC_107 NODE_107 0 NUCLEON
X_NUC_108 NODE_108 0 NUCLEON
X_NUC_109 NODE_109 0 NUCLEON
X_NUC_110 NODE_110 0 NUCLEON
X_NUC_111 NODE_111 0 NUCLEON
X_NUC_112 NODE_112 0 NUCLEON
X_NUC_113 NODE_113 0 NUCLEON
X_NUC_114 NODE_114 0 NUCLEON
X_NUC_115 NODE_115 0 NUCLEON
X_NUC_116 NODE_116 0 NUCLEON
X_NUC_117 NODE_117 0 NUCLEON
X_NUC_118 NODE_118 0 NUCLEON
X_NUC_119 NODE_119 0 NUCLEON
X_NUC_120 NODE_120 0 NUCLEON
X_NUC_121 NODE_121 0 NUCLEON
X_NUC_122 NODE_122 0 NUCLEON
X_NUC_123 NODE_123 0 NUCLEON
X_NUC_124 NODE_124 0 NUCLEON
X_NUC_125 NODE_125 0 NUCLEON
X_NUC_126 NODE_126 0 NUCLEON
X_NUC_127 NODE_127 0 NUCLEON
X_NUC_128 NODE_128 0 NUCLEON
X_NUC_129 NODE_129 0 NUCLEON
X_NUC_130 NODE_130 0 NUCLEON
X_NUC_131 NODE_131 0 NUCLEON
X_NUC_132 NODE_132 0 NUCLEON
X_NUC_133 NODE_133 0 NUCLEON
X_NUC_134 NODE_134 0 NUCLEON
X_NUC_135 NODE_135 0 NUCLEON
X_NUC_136 NODE_136 0 NUCLEON
X_NUC_137 NODE_137 0 NUCLEON
X_NUC_138 NODE_138 0 NUCLEON
X_NUC_139 NODE_139 0 NUCLEON
X_NUC_140 NODE_140 0 NUCLEON
X_NUC_141 NODE_141 0 NUCLEON
X_NUC_142 NODE_142 0 NUCLEON
X_NUC_143 NODE_143 0 NUCLEON
X_NUC_144 NODE_144 0 NUCLEON
X_NUC_145 NODE_145 0 NUCLEON
X_NUC_146 NODE_146 0 NUCLEON
X_NUC_147 NODE_147 0 NUCLEON
X_NUC_148 NODE_148 0 NUCLEON
X_NUC_149 NODE_149 0 NUCLEON
X_NUC_150 NODE_150 0 NUCLEON
X_NUC_151 NODE_151 0 NUCLEON
X_NUC_152 NODE_152 0 NUCLEON
X_NUC_153 NODE_153 0 NUCLEON
X_NUC_154 NODE_154 0 NUCLEON
X_NUC_155 NODE_155 0 NUCLEON
X_NUC_156 NODE_156 0 NUCLEON
X_NUC_157 NODE_157 0 NUCLEON
X_NUC_158 NODE_158 0 NUCLEON
X_NUC_159 NODE_159 0 NUCLEON
X_NUC_160 NODE_160 0 NUCLEON
X_NUC_161 NODE_161 0 NUCLEON
X_NUC_162 NODE_162 0 NUCLEON
X_NUC_163 NODE_163 0 NUCLEON
X_NUC_164 NODE_164 0 NUCLEON
X_NUC_165 NODE_165 0 NUCLEON
X_NUC_166 NODE_166 0 NUCLEON
X_NUC_167 NODE_167 0 NUCLEON
X_NUC_168 NODE_168 0 NUCLEON
X_NUC_169 NODE_169 0 NUCLEON
X_NUC_170 NODE_170 0 NUCLEON
X_NUC_171 NODE_171 0 NUCLEON
X_NUC_172 NODE_172 0 NUCLEON
X_NUC_173 NODE_173 0 NUCLEON
X_NUC_174 NODE_174 0 NUCLEON
X_NUC_175 NODE_175 0 NUCLEON
X_NUC_176 NODE_176 0 NUCLEON
X_NUC_177 NODE_177 0 NUCLEON
X_NUC_178 NODE_178 0 NUCLEON
X_NUC_179 NODE_179 0 NUCLEON
X_NUC_180 NODE_180 0 NUCLEON
X_NUC_181 NODE_181 0 NUCLEON
X_NUC_182 NODE_182 0 NUCLEON
X_NUC_183 NODE_183 0 NUCLEON
X_NUC_184 NODE_184 0 NUCLEON
X_NUC_185 NODE_185 0 NUCLEON
X_NUC_186 NODE_186 0 NUCLEON
X_NUC_187 NODE_187 0 NUCLEON
X_NUC_188 NODE_188 0 NUCLEON
X_NUC_189 NODE_189 0 NUCLEON
X_NUC_190 NODE_190 0 NUCLEON
X_NUC_191 NODE_191 0 NUCLEON
X_NUC_192 NODE_192 0 NUCLEON
X_NUC_193 NODE_193 0 NUCLEON
X_NUC_194 NODE_194 0 NUCLEON
X_NUC_195 NODE_195 0 NUCLEON
X_NUC_196 NODE_196 0 NUCLEON
X_NUC_197 NODE_197 0 NUCLEON
X_NUC_198 NODE_198 0 NUCLEON
X_NUC_199 NODE_199 0 NUCLEON
X_NUC_200 NODE_200 0 NUCLEON
X_NUC_201 NODE_201 0 NUCLEON
X_NUC_202 NODE_202 0 NUCLEON
X_NUC_203 NODE_203 0 NUCLEON
X_NUC_204 NODE_204 0 NUCLEON
X_NUC_205 NODE_205 0 NUCLEON
X_NUC_206 NODE_206 0 NUCLEON
X_NUC_207 NODE_207 0 NUCLEON
X_NUC_208 NODE_208 0 NUCLEON
X_NUC_209 NODE_209 0 NUCLEON
X_NUC_210 NODE_210 0 NUCLEON
X_NUC_211 NODE_211 0 NUCLEON
X_NUC_212 NODE_212 0 NUCLEON
X_NUC_213 NODE_213 0 NUCLEON
X_NUC_214 NODE_214 0 NUCLEON
X_NUC_215 NODE_215 0 NUCLEON
X_NUC_216 NODE_216 0 NUCLEON
X_NUC_217 NODE_217 0 NUCLEON
X_NUC_218 NODE_218 0 NUCLEON
X_NUC_219 NODE_219 0 NUCLEON
X_NUC_220 NODE_220 0 NUCLEON
X_NUC_221 NODE_221 0 NUCLEON
X_NUC_222 NODE_222 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.004763
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.004662
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.004689
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.004721
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.005145
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.005197
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.005097
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.005211
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.005529
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.005458
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.005522
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.005404
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.003082
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.003055
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.003044
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.003079
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.004718
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.004817
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.004733
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.004735
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.003076
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.003035
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.003050
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.003039
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.002779
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.002782
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.002754
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.002789
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.003690
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.003707
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.003700
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.003648
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.002340
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.002318
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.002317
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.002327
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.002834
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.002861
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.002824
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.002843
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.002633
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.002614
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.002622
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.002601
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.002113
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.002106
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.002094
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.002111
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.002769
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.002794
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.002771
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.002758
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.002060
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.002043
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.002044
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.002044
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.002121
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.002128
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.002108
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.002124
K_64 X_NUC_1.L_CORE X_NUC_65.L_CORE 0.002351
K_65 X_NUC_1.L_CORE X_NUC_66.L_CORE 0.002349
K_66 X_NUC_1.L_CORE X_NUC_67.L_CORE 0.002347
K_67 X_NUC_1.L_CORE X_NUC_68.L_CORE 0.002328
K_68 X_NUC_1.L_CORE X_NUC_69.L_CORE 0.001815
K_69 X_NUC_1.L_CORE X_NUC_70.L_CORE 0.001806
K_70 X_NUC_1.L_CORE X_NUC_71.L_CORE 0.001800
K_71 X_NUC_1.L_CORE X_NUC_72.L_CORE 0.001809
K_72 X_NUC_1.L_CORE X_NUC_73.L_CORE 0.002180
K_73 X_NUC_1.L_CORE X_NUC_74.L_CORE 0.002196
K_74 X_NUC_1.L_CORE X_NUC_75.L_CORE 0.002175
K_75 X_NUC_1.L_CORE X_NUC_76.L_CORE 0.002178
K_76 X_NUC_1.L_CORE X_NUC_77.L_CORE 0.001921
K_77 X_NUC_1.L_CORE X_NUC_78.L_CORE 0.001909
K_78 X_NUC_1.L_CORE X_NUC_79.L_CORE 0.001910
K_79 X_NUC_1.L_CORE X_NUC_80.L_CORE 0.001903
K_80 X_NUC_1.L_CORE X_NUC_81.L_CORE 0.001762
K_81 X_NUC_1.L_CORE X_NUC_82.L_CORE 0.001761
K_82 X_NUC_1.L_CORE X_NUC_83.L_CORE 0.001750
K_83 X_NUC_1.L_CORE X_NUC_84.L_CORE 0.001761
K_84 X_NUC_1.L_CORE X_NUC_85.L_CORE 0.002075
K_85 X_NUC_1.L_CORE X_NUC_86.L_CORE 0.002082
K_86 X_NUC_1.L_CORE X_NUC_87.L_CORE 0.002072
K_87 X_NUC_1.L_CORE X_NUC_88.L_CORE 0.002062
K_88 X_NUC_1.L_CORE X_NUC_89.L_CORE 0.001666
K_89 X_NUC_1.L_CORE X_NUC_90.L_CORE 0.001657
K_90 X_NUC_1.L_CORE X_NUC_91.L_CORE 0.001654
K_91 X_NUC_1.L_CORE X_NUC_92.L_CORE 0.001657
K_92 X_NUC_1.L_CORE X_NUC_93.L_CORE 0.001802
K_93 X_NUC_1.L_CORE X_NUC_94.L_CORE 0.001809
K_94 X_NUC_1.L_CORE X_NUC_95.L_CORE 0.001794
K_95 X_NUC_1.L_CORE X_NUC_96.L_CORE 0.001801
K_96 X_NUC_1.L_CORE X_NUC_97.L_CORE 0.001814
K_97 X_NUC_1.L_CORE X_NUC_98.L_CORE 0.001809
K_98 X_NUC_1.L_CORE X_NUC_99.L_CORE 0.001807
K_99 X_NUC_1.L_CORE X_NUC_100.L_CORE 0.001798
K_100 X_NUC_1.L_CORE X_NUC_101.L_CORE 0.001566
K_101 X_NUC_1.L_CORE X_NUC_102.L_CORE 0.001562
K_102 X_NUC_1.L_CORE X_NUC_103.L_CORE 0.001555
K_103 X_NUC_1.L_CORE X_NUC_104.L_CORE 0.001562
K_104 X_NUC_1.L_CORE X_NUC_105.L_CORE 0.001807
K_105 X_NUC_1.L_CORE X_NUC_106.L_CORE 0.001816
K_106 X_NUC_1.L_CORE X_NUC_107.L_CORE 0.001803
K_107 X_NUC_1.L_CORE X_NUC_108.L_CORE 0.001801
K_108 X_NUC_1.L_CORE X_NUC_109.L_CORE 0.001584
K_109 X_NUC_1.L_CORE X_NUC_110.L_CORE 0.001576
K_110 X_NUC_1.L_CORE X_NUC_111.L_CORE 0.001574
K_111 X_NUC_1.L_CORE X_NUC_112.L_CORE 0.001572
K_112 X_NUC_1.L_CORE X_NUC_113.L_CORE 0.001564
K_113 X_NUC_1.L_CORE X_NUC_114.L_CORE 0.001565
K_114 X_NUC_1.L_CORE X_NUC_115.L_CORE 0.001555
K_115 X_NUC_1.L_CORE X_NUC_116.L_CORE 0.001562
K_116 X_NUC_1.L_CORE X_NUC_117.L_CORE 0.001690
K_117 X_NUC_1.L_CORE X_NUC_118.L_CORE 0.001691
K_118 X_NUC_1.L_CORE X_NUC_119.L_CORE 0.001685
K_119 X_NUC_1.L_CORE X_NUC_120.L_CORE 0.001679
K_120 X_NUC_1.L_CORE X_NUC_121.L_CORE 0.001457
K_121 X_NUC_1.L_CORE X_NUC_122.L_CORE 0.001452
K_122 X_NUC_1.L_CORE X_NUC_123.L_CORE 0.001447
K_123 X_NUC_1.L_CORE X_NUC_124.L_CORE 0.001450
K_124 X_NUC_1.L_CORE X_NUC_125.L_CORE 0.001584
K_125 X_NUC_1.L_CORE X_NUC_126.L_CORE 0.001589
K_126 X_NUC_1.L_CORE X_NUC_127.L_CORE 0.001578
K_127 X_NUC_1.L_CORE X_NUC_128.L_CORE 0.001580
K_128 X_NUC_1.L_CORE X_NUC_129.L_CORE 0.001519
K_129 X_NUC_1.L_CORE X_NUC_130.L_CORE 0.001515
K_130 X_NUC_1.L_CORE X_NUC_131.L_CORE 0.001512
K_131 X_NUC_1.L_CORE X_NUC_132.L_CORE 0.001509
K_132 X_NUC_1.L_CORE X_NUC_133.L_CORE 0.001418
K_133 X_NUC_1.L_CORE X_NUC_134.L_CORE 0.001417
K_134 X_NUC_1.L_CORE X_NUC_135.L_CORE 0.001409
K_135 X_NUC_1.L_CORE X_NUC_136.L_CORE 0.001414
K_136 X_NUC_1.L_CORE X_NUC_137.L_CORE 0.001545
K_137 X_NUC_1.L_CORE X_NUC_138.L_CORE 0.001548
K_138 X_NUC_1.L_CORE X_NUC_139.L_CORE 0.001540
K_139 X_NUC_1.L_CORE X_NUC_140.L_CORE 0.001538
K_140 X_NUC_1.L_CORE X_NUC_141.L_CORE 0.001393
K_141 X_NUC_1.L_CORE X_NUC_142.L_CORE 0.001389
K_142 X_NUC_1.L_CORE X_NUC_143.L_CORE 0.001385
K_143 X_NUC_1.L_CORE X_NUC_144.L_CORE 0.001386
K_144 X_NUC_1.L_CORE X_NUC_145.L_CORE 0.001420
K_145 X_NUC_1.L_CORE X_NUC_146.L_CORE 0.001422
K_146 X_NUC_1.L_CORE X_NUC_147.L_CORE 0.001413
K_147 X_NUC_1.L_CORE X_NUC_148.L_CORE 0.001417
K_148 X_NUC_1.L_CORE X_NUC_149.L_CORE 0.001442
K_149 X_NUC_1.L_CORE X_NUC_150.L_CORE 0.001441
K_150 X_NUC_1.L_CORE X_NUC_151.L_CORE 0.001436
K_151 X_NUC_1.L_CORE X_NUC_152.L_CORE 0.001433
K_152 X_NUC_1.L_CORE X_NUC_153.L_CORE 0.001335
K_153 X_NUC_1.L_CORE X_NUC_154.L_CORE 0.001332
K_154 X_NUC_1.L_CORE X_NUC_155.L_CORE 0.001327
K_155 X_NUC_1.L_CORE X_NUC_156.L_CORE 0.001329
K_156 X_NUC_1.L_CORE X_NUC_157.L_CORE 0.001402
K_157 X_NUC_1.L_CORE X_NUC_158.L_CORE 0.001404
K_158 X_NUC_1.L_CORE X_NUC_159.L_CORE 0.001396
K_159 X_NUC_1.L_CORE X_NUC_160.L_CORE 0.001397
K_160 X_NUC_1.L_CORE X_NUC_161.L_CORE 0.001342
K_161 X_NUC_1.L_CORE X_NUC_162.L_CORE 0.001340
K_162 X_NUC_1.L_CORE X_NUC_163.L_CORE 0.001336
K_163 X_NUC_1.L_CORE X_NUC_164.L_CORE 0.001335
K_164 X_NUC_1.L_CORE X_NUC_165.L_CORE 0.001318
K_165 X_NUC_1.L_CORE X_NUC_166.L_CORE 0.001318
K_166 X_NUC_1.L_CORE X_NUC_167.L_CORE 0.001311
K_167 X_NUC_1.L_CORE X_NUC_168.L_CORE 0.001314
K_168 X_NUC_1.L_CORE X_NUC_169.L_CORE 0.001332
K_169 X_NUC_1.L_CORE X_NUC_170.L_CORE 0.001332
K_170 X_NUC_1.L_CORE X_NUC_171.L_CORE 0.001326
K_171 X_NUC_1.L_CORE X_NUC_172.L_CORE 0.001326
K_172 X_NUC_1.L_CORE X_NUC_173.L_CORE 0.033753
K_173 X_NUC_1.L_CORE X_NUC_174.L_CORE 0.004709
K_174 X_NUC_1.L_CORE X_NUC_175.L_CORE 0.005236
K_175 X_NUC_1.L_CORE X_NUC_176.L_CORE 0.005664
K_176 X_NUC_1.L_CORE X_NUC_177.L_CORE 0.003103
K_177 X_NUC_1.L_CORE X_NUC_178.L_CORE 0.005002
K_178 X_NUC_1.L_CORE X_NUC_179.L_CORE 0.003119
K_179 X_NUC_1.L_CORE X_NUC_180.L_CORE 0.002837
K_180 X_NUC_1.L_CORE X_NUC_181.L_CORE 0.003895
K_181 X_NUC_1.L_CORE X_NUC_182.L_CORE 0.002369
K_182 X_NUC_1.L_CORE X_NUC_183.L_CORE 0.002954
K_183 X_NUC_1.L_CORE X_NUC_184.L_CORE 0.002714
K_184 X_NUC_1.L_CORE X_NUC_185.L_CORE 0.002150
K_185 X_NUC_1.L_CORE X_NUC_186.L_CORE 0.002930
K_186 X_NUC_1.L_CORE X_NUC_187.L_CORE 0.002098
K_187 X_NUC_1.L_CORE X_NUC_188.L_CORE 0.002186
K_188 X_NUC_1.L_CORE X_NUC_189.L_CORE 0.002458
K_189 X_NUC_1.L_CORE X_NUC_190.L_CORE 0.001845
K_190 X_NUC_1.L_CORE X_NUC_191.L_CORE 0.002288
K_191 X_NUC_1.L_CORE X_NUC_192.L_CORE 0.001974
K_192 X_NUC_1.L_CORE X_NUC_193.L_CORE 0.001803
K_193 X_NUC_1.L_CORE X_NUC_194.L_CORE 0.002187
K_194 X_NUC_1.L_CORE X_NUC_195.L_CORE 0.001697
K_195 X_NUC_1.L_CORE X_NUC_196.L_CORE 0.001871
K_196 X_NUC_1.L_CORE X_NUC_197.L_CORE 0.001885
K_197 X_NUC_1.L_CORE X_NUC_198.L_CORE 0.001595
K_198 X_NUC_1.L_CORE X_NUC_199.L_CORE 0.001904
K_199 X_NUC_1.L_CORE X_NUC_200.L_CORE 0.001622
K_200 X_NUC_1.L_CORE X_NUC_201.L_CORE 0.001608
K_201 X_NUC_1.L_CORE X_NUC_202.L_CORE 0.001776
K_202 X_NUC_1.L_CORE X_NUC_203.L_CORE 0.001481
K_203 X_NUC_1.L_CORE X_NUC_204.L_CORE 0.001656
K_204 X_NUC_1.L_CORE X_NUC_205.L_CORE 0.001572
K_205 X_NUC_1.L_CORE X_NUC_206.L_CORE 0.001446
K_206 X_NUC_1.L_CORE X_NUC_207.L_CORE 0.001632
K_207 X_NUC_1.L_CORE X_NUC_208.L_CORE 0.001420
K_208 X_NUC_1.L_CORE X_NUC_209.L_CORE 0.001469
K_209 X_NUC_1.L_CORE X_NUC_210.L_CORE 0.001512
K_210 X_NUC_1.L_CORE X_NUC_211.L_CORE 0.001351
K_211 X_NUC_1.L_CORE X_NUC_212.L_CORE 0.001480
K_212 X_NUC_1.L_CORE X_NUC_213.L_CORE 0.001379
K_213 X_NUC_1.L_CORE X_NUC_214.L_CORE 0.001343
K_214 X_NUC_1.L_CORE X_NUC_215.L_CORE 0.001426
K_215 X_NUC_1.L_CORE X_NUC_216.L_CORE 0.001297
K_216 X_NUC_1.L_CORE X_NUC_217.L_CORE 0.001350
K_217 X_NUC_1.L_CORE X_NUC_218.L_CORE 0.001333
K_218 X_NUC_1.L_CORE X_NUC_219.L_CORE 0.001268
K_219 X_NUC_1.L_CORE X_NUC_220.L_CORE 0.001321
K_220 X_NUC_1.L_CORE X_NUC_221.L_CORE 0.001263
K_221 X_NUC_1.L_CORE X_NUC_222.L_CORE 0.001260
K_222 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_223 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_224 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.004869
K_225 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.004763
K_226 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.004791
K_227 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.004825
K_228 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.005093
K_229 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.005145
K_230 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.005047
K_231 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.005158
K_232 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.005598
K_233 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.005529
K_234 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.005593
K_235 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.005471
K_236 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.003109
K_237 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.003082
K_238 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.003070
K_239 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.003106
K_240 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.004623
K_241 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.004718
K_242 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.004638
K_243 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.004639
K_244 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.003118
K_245 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.003076
K_246 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.003091
K_247 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.003080
K_248 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.002776
K_249 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.002779
K_250 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.002751
K_251 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.002786
K_252 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.003672
K_253 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.003690
K_254 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.003683
K_255 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.003631
K_256 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.002362
K_257 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.002340
K_258 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.002338
K_259 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.002349
K_260 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.002806
K_261 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.002834
K_262 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.002797
K_263 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.002815
K_264 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.002652
K_265 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.002633
K_266 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.002641
K_267 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.002620
K_268 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.002119
K_269 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.002113
K_270 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.002100
K_271 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.002118
K_272 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.002744
K_273 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.002769
K_274 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.002747
K_275 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.002733
K_276 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.002078
K_277 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.002060
K_278 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.002062
K_279 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.002062
K_280 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.002113
K_281 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.002121
K_282 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.002100
K_283 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.002116
K_284 X_NUC_2.L_CORE X_NUC_65.L_CORE 0.002352
K_285 X_NUC_2.L_CORE X_NUC_66.L_CORE 0.002351
K_286 X_NUC_2.L_CORE X_NUC_67.L_CORE 0.002349
K_287 X_NUC_2.L_CORE X_NUC_68.L_CORE 0.002330
K_288 X_NUC_2.L_CORE X_NUC_69.L_CORE 0.001825
K_289 X_NUC_2.L_CORE X_NUC_70.L_CORE 0.001815
K_290 X_NUC_2.L_CORE X_NUC_71.L_CORE 0.001809
K_291 X_NUC_2.L_CORE X_NUC_72.L_CORE 0.001818
K_292 X_NUC_2.L_CORE X_NUC_73.L_CORE 0.002164
K_293 X_NUC_2.L_CORE X_NUC_74.L_CORE 0.002180
K_294 X_NUC_2.L_CORE X_NUC_75.L_CORE 0.002160
K_295 X_NUC_2.L_CORE X_NUC_76.L_CORE 0.002162
K_296 X_NUC_2.L_CORE X_NUC_77.L_CORE 0.001932
K_297 X_NUC_2.L_CORE X_NUC_78.L_CORE 0.001921
K_298 X_NUC_2.L_CORE X_NUC_79.L_CORE 0.001922
K_299 X_NUC_2.L_CORE X_NUC_80.L_CORE 0.001915
K_300 X_NUC_2.L_CORE X_NUC_81.L_CORE 0.001763
K_301 X_NUC_2.L_CORE X_NUC_82.L_CORE 0.001762
K_302 X_NUC_2.L_CORE X_NUC_83.L_CORE 0.001750
K_303 X_NUC_2.L_CORE X_NUC_84.L_CORE 0.001762
K_304 X_NUC_2.L_CORE X_NUC_85.L_CORE 0.002067
K_305 X_NUC_2.L_CORE X_NUC_86.L_CORE 0.002075
K_306 X_NUC_2.L_CORE X_NUC_87.L_CORE 0.002065
K_307 X_NUC_2.L_CORE X_NUC_88.L_CORE 0.002055
K_308 X_NUC_2.L_CORE X_NUC_89.L_CORE 0.001676
K_309 X_NUC_2.L_CORE X_NUC_90.L_CORE 0.001666
K_310 X_NUC_2.L_CORE X_NUC_91.L_CORE 0.001663
K_311 X_NUC_2.L_CORE X_NUC_92.L_CORE 0.001666
K_312 X_NUC_2.L_CORE X_NUC_93.L_CORE 0.001795
K_313 X_NUC_2.L_CORE X_NUC_94.L_CORE 0.001802
K_314 X_NUC_2.L_CORE X_NUC_95.L_CORE 0.001787
K_315 X_NUC_2.L_CORE X_NUC_96.L_CORE 0.001794
K_316 X_NUC_2.L_CORE X_NUC_97.L_CORE 0.001818
K_317 X_NUC_2.L_CORE X_NUC_98.L_CORE 0.001814
K_318 X_NUC_2.L_CORE X_NUC_99.L_CORE 0.001812
K_319 X_NUC_2.L_CORE X_NUC_100.L_CORE 0.001803
K_320 X_NUC_2.L_CORE X_NUC_101.L_CORE 0.001570
K_321 X_NUC_2.L_CORE X_NUC_102.L_CORE 0.001566
K_322 X_NUC_2.L_CORE X_NUC_103.L_CORE 0.001559
K_323 X_NUC_2.L_CORE X_NUC_104.L_CORE 0.001566
K_324 X_NUC_2.L_CORE X_NUC_105.L_CORE 0.001799
K_325 X_NUC_2.L_CORE X_NUC_106.L_CORE 0.001807
K_326 X_NUC_2.L_CORE X_NUC_107.L_CORE 0.001795
K_327 X_NUC_2.L_CORE X_NUC_108.L_CORE 0.001793
K_328 X_NUC_2.L_CORE X_NUC_109.L_CORE 0.001591
K_329 X_NUC_2.L_CORE X_NUC_110.L_CORE 0.001584
K_330 X_NUC_2.L_CORE X_NUC_111.L_CORE 0.001582
K_331 X_NUC_2.L_CORE X_NUC_112.L_CORE 0.001580
K_332 X_NUC_2.L_CORE X_NUC_113.L_CORE 0.001562
K_333 X_NUC_2.L_CORE X_NUC_114.L_CORE 0.001564
K_334 X_NUC_2.L_CORE X_NUC_115.L_CORE 0.001553
K_335 X_NUC_2.L_CORE X_NUC_116.L_CORE 0.001560
K_336 X_NUC_2.L_CORE X_NUC_117.L_CORE 0.001689
K_337 X_NUC_2.L_CORE X_NUC_118.L_CORE 0.001690
K_338 X_NUC_2.L_CORE X_NUC_119.L_CORE 0.001684
K_339 X_NUC_2.L_CORE X_NUC_120.L_CORE 0.001678
K_340 X_NUC_2.L_CORE X_NUC_121.L_CORE 0.001462
K_341 X_NUC_2.L_CORE X_NUC_122.L_CORE 0.001457
K_342 X_NUC_2.L_CORE X_NUC_123.L_CORE 0.001452
K_343 X_NUC_2.L_CORE X_NUC_124.L_CORE 0.001456
K_344 X_NUC_2.L_CORE X_NUC_125.L_CORE 0.001579
K_345 X_NUC_2.L_CORE X_NUC_126.L_CORE 0.001584
K_346 X_NUC_2.L_CORE X_NUC_127.L_CORE 0.001572
K_347 X_NUC_2.L_CORE X_NUC_128.L_CORE 0.001575
K_348 X_NUC_2.L_CORE X_NUC_129.L_CORE 0.001524
K_349 X_NUC_2.L_CORE X_NUC_130.L_CORE 0.001519
K_350 X_NUC_2.L_CORE X_NUC_131.L_CORE 0.001516
K_351 X_NUC_2.L_CORE X_NUC_132.L_CORE 0.001513
K_352 X_NUC_2.L_CORE X_NUC_133.L_CORE 0.001419
K_353 X_NUC_2.L_CORE X_NUC_134.L_CORE 0.001418
K_354 X_NUC_2.L_CORE X_NUC_135.L_CORE 0.001411
K_355 X_NUC_2.L_CORE X_NUC_136.L_CORE 0.001416
K_356 X_NUC_2.L_CORE X_NUC_137.L_CORE 0.001542
K_357 X_NUC_2.L_CORE X_NUC_138.L_CORE 0.001545
K_358 X_NUC_2.L_CORE X_NUC_139.L_CORE 0.001537
K_359 X_NUC_2.L_CORE X_NUC_140.L_CORE 0.001535
K_360 X_NUC_2.L_CORE X_NUC_141.L_CORE 0.001398
K_361 X_NUC_2.L_CORE X_NUC_142.L_CORE 0.001393
K_362 X_NUC_2.L_CORE X_NUC_143.L_CORE 0.001389
K_363 X_NUC_2.L_CORE X_NUC_144.L_CORE 0.001390
K_364 X_NUC_2.L_CORE X_NUC_145.L_CORE 0.001418
K_365 X_NUC_2.L_CORE X_NUC_146.L_CORE 0.001420
K_366 X_NUC_2.L_CORE X_NUC_147.L_CORE 0.001411
K_367 X_NUC_2.L_CORE X_NUC_148.L_CORE 0.001415
K_368 X_NUC_2.L_CORE X_NUC_149.L_CORE 0.001443
K_369 X_NUC_2.L_CORE X_NUC_150.L_CORE 0.001442
K_370 X_NUC_2.L_CORE X_NUC_151.L_CORE 0.001437
K_371 X_NUC_2.L_CORE X_NUC_152.L_CORE 0.001434
K_372 X_NUC_2.L_CORE X_NUC_153.L_CORE 0.001337
K_373 X_NUC_2.L_CORE X_NUC_154.L_CORE 0.001335
K_374 X_NUC_2.L_CORE X_NUC_155.L_CORE 0.001329
K_375 X_NUC_2.L_CORE X_NUC_156.L_CORE 0.001332
K_376 X_NUC_2.L_CORE X_NUC_157.L_CORE 0.001400
K_377 X_NUC_2.L_CORE X_NUC_158.L_CORE 0.001402
K_378 X_NUC_2.L_CORE X_NUC_159.L_CORE 0.001395
K_379 X_NUC_2.L_CORE X_NUC_160.L_CORE 0.001395
K_380 X_NUC_2.L_CORE X_NUC_161.L_CORE 0.001345
K_381 X_NUC_2.L_CORE X_NUC_162.L_CORE 0.001342
K_382 X_NUC_2.L_CORE X_NUC_163.L_CORE 0.001338
K_383 X_NUC_2.L_CORE X_NUC_164.L_CORE 0.001338
K_384 X_NUC_2.L_CORE X_NUC_165.L_CORE 0.001319
K_385 X_NUC_2.L_CORE X_NUC_166.L_CORE 0.001318
K_386 X_NUC_2.L_CORE X_NUC_167.L_CORE 0.001312
K_387 X_NUC_2.L_CORE X_NUC_168.L_CORE 0.001314
K_388 X_NUC_2.L_CORE X_NUC_169.L_CORE 0.001333
K_389 X_NUC_2.L_CORE X_NUC_170.L_CORE 0.001332
K_390 X_NUC_2.L_CORE X_NUC_171.L_CORE 0.001327
K_391 X_NUC_2.L_CORE X_NUC_172.L_CORE 0.001326
K_392 X_NUC_2.L_CORE X_NUC_173.L_CORE 0.033731
K_393 X_NUC_2.L_CORE X_NUC_174.L_CORE 0.004812
K_394 X_NUC_2.L_CORE X_NUC_175.L_CORE 0.005181
K_395 X_NUC_2.L_CORE X_NUC_176.L_CORE 0.005740
K_396 X_NUC_2.L_CORE X_NUC_177.L_CORE 0.003131
K_397 X_NUC_2.L_CORE X_NUC_178.L_CORE 0.004889
K_398 X_NUC_2.L_CORE X_NUC_179.L_CORE 0.003163
K_399 X_NUC_2.L_CORE X_NUC_180.L_CORE 0.002833
K_400 X_NUC_2.L_CORE X_NUC_181.L_CORE 0.003874
K_401 X_NUC_2.L_CORE X_NUC_182.L_CORE 0.002392
K_402 X_NUC_2.L_CORE X_NUC_183.L_CORE 0.002922
K_403 X_NUC_2.L_CORE X_NUC_184.L_CORE 0.002735
K_404 X_NUC_2.L_CORE X_NUC_185.L_CORE 0.002157
K_405 X_NUC_2.L_CORE X_NUC_186.L_CORE 0.002900
K_406 X_NUC_2.L_CORE X_NUC_187.L_CORE 0.002118
K_407 X_NUC_2.L_CORE X_NUC_188.L_CORE 0.002177
K_408 X_NUC_2.L_CORE X_NUC_189.L_CORE 0.002460
K_409 X_NUC_2.L_CORE X_NUC_190.L_CORE 0.001856
K_410 X_NUC_2.L_CORE X_NUC_191.L_CORE 0.002268
K_411 X_NUC_2.L_CORE X_NUC_192.L_CORE 0.001987
K_412 X_NUC_2.L_CORE X_NUC_193.L_CORE 0.001804
K_413 X_NUC_2.L_CORE X_NUC_194.L_CORE 0.002178
K_414 X_NUC_2.L_CORE X_NUC_195.L_CORE 0.001708
K_415 X_NUC_2.L_CORE X_NUC_196.L_CORE 0.001862
K_416 X_NUC_2.L_CORE X_NUC_197.L_CORE 0.001891
K_417 X_NUC_2.L_CORE X_NUC_198.L_CORE 0.001600
K_418 X_NUC_2.L_CORE X_NUC_199.L_CORE 0.001893
K_419 X_NUC_2.L_CORE X_NUC_200.L_CORE 0.001631
K_420 X_NUC_2.L_CORE X_NUC_201.L_CORE 0.001606
K_421 X_NUC_2.L_CORE X_NUC_202.L_CORE 0.001774
K_422 X_NUC_2.L_CORE X_NUC_203.L_CORE 0.001488
K_423 X_NUC_2.L_CORE X_NUC_204.L_CORE 0.001649
K_424 X_NUC_2.L_CORE X_NUC_205.L_CORE 0.001577
K_425 X_NUC_2.L_CORE X_NUC_206.L_CORE 0.001448
K_426 X_NUC_2.L_CORE X_NUC_207.L_CORE 0.001627
K_427 X_NUC_2.L_CORE X_NUC_208.L_CORE 0.001426
K_428 X_NUC_2.L_CORE X_NUC_209.L_CORE 0.001466
K_429 X_NUC_2.L_CORE X_NUC_210.L_CORE 0.001513
K_430 X_NUC_2.L_CORE X_NUC_211.L_CORE 0.001354
K_431 X_NUC_2.L_CORE X_NUC_212.L_CORE 0.001476
K_432 X_NUC_2.L_CORE X_NUC_213.L_CORE 0.001384
K_433 X_NUC_2.L_CORE X_NUC_214.L_CORE 0.001343
K_434 X_NUC_2.L_CORE X_NUC_215.L_CORE 0.001425
K_435 X_NUC_2.L_CORE X_NUC_216.L_CORE 0.001301
K_436 X_NUC_2.L_CORE X_NUC_217.L_CORE 0.001348
K_437 X_NUC_2.L_CORE X_NUC_218.L_CORE 0.001335
K_438 X_NUC_2.L_CORE X_NUC_219.L_CORE 0.001270
K_439 X_NUC_2.L_CORE X_NUC_220.L_CORE 0.001320
K_440 X_NUC_2.L_CORE X_NUC_221.L_CORE 0.001265
K_441 X_NUC_2.L_CORE X_NUC_222.L_CORE 0.001260
K_442 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_443 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.004839
K_444 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.004734
K_445 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.004763
K_446 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.004796
K_447 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.005192
K_448 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.005246
K_449 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.005145
K_450 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.005261
K_451 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.005531
K_452 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.005463
K_453 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.005529
K_454 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.005409
K_455 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.003121
K_456 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.003093
K_457 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.003082
K_458 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.003117
K_459 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.004701
K_460 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.004800
K_461 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.004718
K_462 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.004719
K_463 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.003101
K_464 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.003060
K_465 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.003076
K_466 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.003064
K_467 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.002804
K_468 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.002807
K_469 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.002779
K_470 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.002814
K_471 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.003679
K_472 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.003696
K_473 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.003690
K_474 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.003638
K_475 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.002363
K_476 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.002341
K_477 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.002340
K_478 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.002351
K_479 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.002843
K_480 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.002871
K_481 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.002834
K_482 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.002852
K_483 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.002644
K_484 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.002625
K_485 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.002633
K_486 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.002612
K_487 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.002132
K_488 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.002125
K_489 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.002113
K_490 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.002131
K_491 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.002766
K_492 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.002791
K_493 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.002769
K_494 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.002755
K_495 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.002077
K_496 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.002059
K_497 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.002060
K_498 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.002060
K_499 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.002134
K_500 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.002141
K_501 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.002121
K_502 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.002137
K_503 X_NUC_3.L_CORE X_NUC_65.L_CORE 0.002354
K_504 X_NUC_3.L_CORE X_NUC_66.L_CORE 0.002353
K_505 X_NUC_3.L_CORE X_NUC_67.L_CORE 0.002351
K_506 X_NUC_3.L_CORE X_NUC_68.L_CORE 0.002331
K_507 X_NUC_3.L_CORE X_NUC_69.L_CORE 0.001831
K_508 X_NUC_3.L_CORE X_NUC_70.L_CORE 0.001821
K_509 X_NUC_3.L_CORE X_NUC_71.L_CORE 0.001815
K_510 X_NUC_3.L_CORE X_NUC_72.L_CORE 0.001824
K_511 X_NUC_3.L_CORE X_NUC_73.L_CORE 0.002185
K_512 X_NUC_3.L_CORE X_NUC_74.L_CORE 0.002201
K_513 X_NUC_3.L_CORE X_NUC_75.L_CORE 0.002180
K_514 X_NUC_3.L_CORE X_NUC_76.L_CORE 0.002183
K_515 X_NUC_3.L_CORE X_NUC_77.L_CORE 0.001931
K_516 X_NUC_3.L_CORE X_NUC_78.L_CORE 0.001920
K_517 X_NUC_3.L_CORE X_NUC_79.L_CORE 0.001921
K_518 X_NUC_3.L_CORE X_NUC_80.L_CORE 0.001914
K_519 X_NUC_3.L_CORE X_NUC_81.L_CORE 0.001775
K_520 X_NUC_3.L_CORE X_NUC_82.L_CORE 0.001774
K_521 X_NUC_3.L_CORE X_NUC_83.L_CORE 0.001762
K_522 X_NUC_3.L_CORE X_NUC_84.L_CORE 0.001774
K_523 X_NUC_3.L_CORE X_NUC_85.L_CORE 0.002077
K_524 X_NUC_3.L_CORE X_NUC_86.L_CORE 0.002085
K_525 X_NUC_3.L_CORE X_NUC_87.L_CORE 0.002075
K_526 X_NUC_3.L_CORE X_NUC_88.L_CORE 0.002064
K_527 X_NUC_3.L_CORE X_NUC_89.L_CORE 0.001679
K_528 X_NUC_3.L_CORE X_NUC_90.L_CORE 0.001669
K_529 X_NUC_3.L_CORE X_NUC_91.L_CORE 0.001666
K_530 X_NUC_3.L_CORE X_NUC_92.L_CORE 0.001669
K_531 X_NUC_3.L_CORE X_NUC_93.L_CORE 0.001810
K_532 X_NUC_3.L_CORE X_NUC_94.L_CORE 0.001818
K_533 X_NUC_3.L_CORE X_NUC_95.L_CORE 0.001802
K_534 X_NUC_3.L_CORE X_NUC_96.L_CORE 0.001809
K_535 X_NUC_3.L_CORE X_NUC_97.L_CORE 0.001820
K_536 X_NUC_3.L_CORE X_NUC_98.L_CORE 0.001816
K_537 X_NUC_3.L_CORE X_NUC_99.L_CORE 0.001814
K_538 X_NUC_3.L_CORE X_NUC_100.L_CORE 0.001805
K_539 X_NUC_3.L_CORE X_NUC_101.L_CORE 0.001578
K_540 X_NUC_3.L_CORE X_NUC_102.L_CORE 0.001573
K_541 X_NUC_3.L_CORE X_NUC_103.L_CORE 0.001566
K_542 X_NUC_3.L_CORE X_NUC_104.L_CORE 0.001573
K_543 X_NUC_3.L_CORE X_NUC_105.L_CORE 0.001812
K_544 X_NUC_3.L_CORE X_NUC_106.L_CORE 0.001820
K_545 X_NUC_3.L_CORE X_NUC_107.L_CORE 0.001807
K_546 X_NUC_3.L_CORE X_NUC_108.L_CORE 0.001805
K_547 X_NUC_3.L_CORE X_NUC_109.L_CORE 0.001593
K_548 X_NUC_3.L_CORE X_NUC_110.L_CORE 0.001585
K_549 X_NUC_3.L_CORE X_NUC_111.L_CORE 0.001584
K_550 X_NUC_3.L_CORE X_NUC_112.L_CORE 0.001582
K_551 X_NUC_3.L_CORE X_NUC_113.L_CORE 0.001573
K_552 X_NUC_3.L_CORE X_NUC_114.L_CORE 0.001575
K_553 X_NUC_3.L_CORE X_NUC_115.L_CORE 0.001564
K_554 X_NUC_3.L_CORE X_NUC_116.L_CORE 0.001571
K_555 X_NUC_3.L_CORE X_NUC_117.L_CORE 0.001694
K_556 X_NUC_3.L_CORE X_NUC_118.L_CORE 0.001696
K_557 X_NUC_3.L_CORE X_NUC_119.L_CORE 0.001690
K_558 X_NUC_3.L_CORE X_NUC_120.L_CORE 0.001683
K_559 X_NUC_3.L_CORE X_NUC_121.L_CORE 0.001467
K_560 X_NUC_3.L_CORE X_NUC_122.L_CORE 0.001462
K_561 X_NUC_3.L_CORE X_NUC_123.L_CORE 0.001457
K_562 X_NUC_3.L_CORE X_NUC_124.L_CORE 0.001460
K_563 X_NUC_3.L_CORE X_NUC_125.L_CORE 0.001590
K_564 X_NUC_3.L_CORE X_NUC_126.L_CORE 0.001595
K_565 X_NUC_3.L_CORE X_NUC_127.L_CORE 0.001584
K_566 X_NUC_3.L_CORE X_NUC_128.L_CORE 0.001586
K_567 X_NUC_3.L_CORE X_NUC_129.L_CORE 0.001527
K_568 X_NUC_3.L_CORE X_NUC_130.L_CORE 0.001522
K_569 X_NUC_3.L_CORE X_NUC_131.L_CORE 0.001519
K_570 X_NUC_3.L_CORE X_NUC_132.L_CORE 0.001516
K_571 X_NUC_3.L_CORE X_NUC_133.L_CORE 0.001427
K_572 X_NUC_3.L_CORE X_NUC_134.L_CORE 0.001426
K_573 X_NUC_3.L_CORE X_NUC_135.L_CORE 0.001418
K_574 X_NUC_3.L_CORE X_NUC_136.L_CORE 0.001423
K_575 X_NUC_3.L_CORE X_NUC_137.L_CORE 0.001550
K_576 X_NUC_3.L_CORE X_NUC_138.L_CORE 0.001553
K_577 X_NUC_3.L_CORE X_NUC_139.L_CORE 0.001545
K_578 X_NUC_3.L_CORE X_NUC_140.L_CORE 0.001542
K_579 X_NUC_3.L_CORE X_NUC_141.L_CORE 0.001402
K_580 X_NUC_3.L_CORE X_NUC_142.L_CORE 0.001397
K_581 X_NUC_3.L_CORE X_NUC_143.L_CORE 0.001393
K_582 X_NUC_3.L_CORE X_NUC_144.L_CORE 0.001394
K_583 X_NUC_3.L_CORE X_NUC_145.L_CORE 0.001427
K_584 X_NUC_3.L_CORE X_NUC_146.L_CORE 0.001429
K_585 X_NUC_3.L_CORE X_NUC_147.L_CORE 0.001420
K_586 X_NUC_3.L_CORE X_NUC_148.L_CORE 0.001424
K_587 X_NUC_3.L_CORE X_NUC_149.L_CORE 0.001448
K_588 X_NUC_3.L_CORE X_NUC_150.L_CORE 0.001447
K_589 X_NUC_3.L_CORE X_NUC_151.L_CORE 0.001442
K_590 X_NUC_3.L_CORE X_NUC_152.L_CORE 0.001439
K_591 X_NUC_3.L_CORE X_NUC_153.L_CORE 0.001343
K_592 X_NUC_3.L_CORE X_NUC_154.L_CORE 0.001340
K_593 X_NUC_3.L_CORE X_NUC_155.L_CORE 0.001335
K_594 X_NUC_3.L_CORE X_NUC_156.L_CORE 0.001337
K_595 X_NUC_3.L_CORE X_NUC_157.L_CORE 0.001408
K_596 X_NUC_3.L_CORE X_NUC_158.L_CORE 0.001410
K_597 X_NUC_3.L_CORE X_NUC_159.L_CORE 0.001402
K_598 X_NUC_3.L_CORE X_NUC_160.L_CORE 0.001403
K_599 X_NUC_3.L_CORE X_NUC_161.L_CORE 0.001349
K_600 X_NUC_3.L_CORE X_NUC_162.L_CORE 0.001347
K_601 X_NUC_3.L_CORE X_NUC_163.L_CORE 0.001342
K_602 X_NUC_3.L_CORE X_NUC_164.L_CORE 0.001342
K_603 X_NUC_3.L_CORE X_NUC_165.L_CORE 0.001325
K_604 X_NUC_3.L_CORE X_NUC_166.L_CORE 0.001325
K_605 X_NUC_3.L_CORE X_NUC_167.L_CORE 0.001318
K_606 X_NUC_3.L_CORE X_NUC_168.L_CORE 0.001321
K_607 X_NUC_3.L_CORE X_NUC_169.L_CORE 0.001338
K_608 X_NUC_3.L_CORE X_NUC_170.L_CORE 0.001338
K_609 X_NUC_3.L_CORE X_NUC_171.L_CORE 0.001332
K_610 X_NUC_3.L_CORE X_NUC_172.L_CORE 0.001332
K_611 X_NUC_3.L_CORE X_NUC_173.L_CORE 0.030271
K_612 X_NUC_3.L_CORE X_NUC_174.L_CORE 0.004771
K_613 X_NUC_3.L_CORE X_NUC_175.L_CORE 0.005270
K_614 X_NUC_3.L_CORE X_NUC_176.L_CORE 0.005647
K_615 X_NUC_3.L_CORE X_NUC_177.L_CORE 0.003139
K_616 X_NUC_3.L_CORE X_NUC_178.L_CORE 0.004966
K_617 X_NUC_3.L_CORE X_NUC_179.L_CORE 0.003142
K_618 X_NUC_3.L_CORE X_NUC_180.L_CORE 0.002860
K_619 X_NUC_3.L_CORE X_NUC_181.L_CORE 0.003873
K_620 X_NUC_3.L_CORE X_NUC_182.L_CORE 0.002392
K_621 X_NUC_3.L_CORE X_NUC_183.L_CORE 0.002960
K_622 X_NUC_3.L_CORE X_NUC_184.L_CORE 0.002722
K_623 X_NUC_3.L_CORE X_NUC_185.L_CORE 0.002169
K_624 X_NUC_3.L_CORE X_NUC_186.L_CORE 0.002922
K_625 X_NUC_3.L_CORE X_NUC_187.L_CORE 0.002114
K_626 X_NUC_3.L_CORE X_NUC_188.L_CORE 0.002199
K_627 X_NUC_3.L_CORE X_NUC_189.L_CORE 0.002459
K_628 X_NUC_3.L_CORE X_NUC_190.L_CORE 0.001861
K_629 X_NUC_3.L_CORE X_NUC_191.L_CORE 0.002290
K_630 X_NUC_3.L_CORE X_NUC_192.L_CORE 0.001984
K_631 X_NUC_3.L_CORE X_NUC_193.L_CORE 0.001816
K_632 X_NUC_3.L_CORE X_NUC_194.L_CORE 0.002187
K_633 X_NUC_3.L_CORE X_NUC_195.L_CORE 0.001709
K_634 X_NUC_3.L_CORE X_NUC_196.L_CORE 0.001879
K_635 X_NUC_3.L_CORE X_NUC_197.L_CORE 0.001891
K_636 X_NUC_3.L_CORE X_NUC_198.L_CORE 0.001607
K_637 X_NUC_3.L_CORE X_NUC_199.L_CORE 0.001906
K_638 X_NUC_3.L_CORE X_NUC_200.L_CORE 0.001631
K_639 X_NUC_3.L_CORE X_NUC_201.L_CORE 0.001617
K_640 X_NUC_3.L_CORE X_NUC_202.L_CORE 0.001779
K_641 X_NUC_3.L_CORE X_NUC_203.L_CORE 0.001492
K_642 X_NUC_3.L_CORE X_NUC_204.L_CORE 0.001661
K_643 X_NUC_3.L_CORE X_NUC_205.L_CORE 0.001579
K_644 X_NUC_3.L_CORE X_NUC_206.L_CORE 0.001455
K_645 X_NUC_3.L_CORE X_NUC_207.L_CORE 0.001636
K_646 X_NUC_3.L_CORE X_NUC_208.L_CORE 0.001428
K_647 X_NUC_3.L_CORE X_NUC_209.L_CORE 0.001476
K_648 X_NUC_3.L_CORE X_NUC_210.L_CORE 0.001517
K_649 X_NUC_3.L_CORE X_NUC_211.L_CORE 0.001360
K_650 X_NUC_3.L_CORE X_NUC_212.L_CORE 0.001485
K_651 X_NUC_3.L_CORE X_NUC_213.L_CORE 0.001386
K_652 X_NUC_3.L_CORE X_NUC_214.L_CORE 0.001351
K_653 X_NUC_3.L_CORE X_NUC_215.L_CORE 0.001430
K_654 X_NUC_3.L_CORE X_NUC_216.L_CORE 0.001305
K_655 X_NUC_3.L_CORE X_NUC_217.L_CORE 0.001356
K_656 X_NUC_3.L_CORE X_NUC_218.L_CORE 0.001339
K_657 X_NUC_3.L_CORE X_NUC_219.L_CORE 0.001275
K_658 X_NUC_3.L_CORE X_NUC_220.L_CORE 0.001326
K_659 X_NUC_3.L_CORE X_NUC_221.L_CORE 0.001269
K_660 X_NUC_3.L_CORE X_NUC_222.L_CORE 0.001266
K_661 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.004804
K_662 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.004702
K_663 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.004729
K_664 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.004763
K_665 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.005079
K_666 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.005130
K_667 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.005034
K_668 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.005145
K_669 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.005658
K_670 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.005584
K_671 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.005653
K_672 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.005529
K_673 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.003085
K_674 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.003058
K_675 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.003047
K_676 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.003082
K_677 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.004700
K_678 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.004799
K_679 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.004716
K_680 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.004718
K_681 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.003113
K_682 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.003071
K_683 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.003086
K_684 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.003076
K_685 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.002769
K_686 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.002772
K_687 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.002745
K_688 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.002779
K_689 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.003732
K_690 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.003750
K_691 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.003743
K_692 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.003690
K_693 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.002352
K_694 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.002330
K_695 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.002329
K_696 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.002340
K_697 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.002824
K_698 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.002852
K_699 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.002815
K_700 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.002834
K_701 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.002666
K_702 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.002647
K_703 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.002655
K_704 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.002633
K_705 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.002114
K_706 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.002107
K_707 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.002095
K_708 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.002113
K_709 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.002780
K_710 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.002805
K_711 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.002782
K_712 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.002769
K_713 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.002077
K_714 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.002059
K_715 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.002061
K_716 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.002060
K_717 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.002117
K_718 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.002125
K_719 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.002105
K_720 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.002121
K_721 X_NUC_4.L_CORE X_NUC_65.L_CORE 0.002374
K_722 X_NUC_4.L_CORE X_NUC_66.L_CORE 0.002373
K_723 X_NUC_4.L_CORE X_NUC_67.L_CORE 0.002371
K_724 X_NUC_4.L_CORE X_NUC_68.L_CORE 0.002351
K_725 X_NUC_4.L_CORE X_NUC_69.L_CORE 0.001822
K_726 X_NUC_4.L_CORE X_NUC_70.L_CORE 0.001812
K_727 X_NUC_4.L_CORE X_NUC_71.L_CORE 0.001806
K_728 X_NUC_4.L_CORE X_NUC_72.L_CORE 0.001815
K_729 X_NUC_4.L_CORE X_NUC_73.L_CORE 0.002182
K_730 X_NUC_4.L_CORE X_NUC_74.L_CORE 0.002198
K_731 X_NUC_4.L_CORE X_NUC_75.L_CORE 0.002177
K_732 X_NUC_4.L_CORE X_NUC_76.L_CORE 0.002180
K_733 X_NUC_4.L_CORE X_NUC_77.L_CORE 0.001938
K_734 X_NUC_4.L_CORE X_NUC_78.L_CORE 0.001926
K_735 X_NUC_4.L_CORE X_NUC_79.L_CORE 0.001927
K_736 X_NUC_4.L_CORE X_NUC_80.L_CORE 0.001921
K_737 X_NUC_4.L_CORE X_NUC_81.L_CORE 0.001763
K_738 X_NUC_4.L_CORE X_NUC_82.L_CORE 0.001763
K_739 X_NUC_4.L_CORE X_NUC_83.L_CORE 0.001751
K_740 X_NUC_4.L_CORE X_NUC_84.L_CORE 0.001762
K_741 X_NUC_4.L_CORE X_NUC_85.L_CORE 0.002088
K_742 X_NUC_4.L_CORE X_NUC_86.L_CORE 0.002096
K_743 X_NUC_4.L_CORE X_NUC_87.L_CORE 0.002085
K_744 X_NUC_4.L_CORE X_NUC_88.L_CORE 0.002075
K_745 X_NUC_4.L_CORE X_NUC_89.L_CORE 0.001676
K_746 X_NUC_4.L_CORE X_NUC_90.L_CORE 0.001666
K_747 X_NUC_4.L_CORE X_NUC_91.L_CORE 0.001663
K_748 X_NUC_4.L_CORE X_NUC_92.L_CORE 0.001666
K_749 X_NUC_4.L_CORE X_NUC_93.L_CORE 0.001803
K_750 X_NUC_4.L_CORE X_NUC_94.L_CORE 0.001810
K_751 X_NUC_4.L_CORE X_NUC_95.L_CORE 0.001795
K_752 X_NUC_4.L_CORE X_NUC_96.L_CORE 0.001802
K_753 X_NUC_4.L_CORE X_NUC_97.L_CORE 0.001829
K_754 X_NUC_4.L_CORE X_NUC_98.L_CORE 0.001825
K_755 X_NUC_4.L_CORE X_NUC_99.L_CORE 0.001822
K_756 X_NUC_4.L_CORE X_NUC_100.L_CORE 0.001814
K_757 X_NUC_4.L_CORE X_NUC_101.L_CORE 0.001570
K_758 X_NUC_4.L_CORE X_NUC_102.L_CORE 0.001566
K_759 X_NUC_4.L_CORE X_NUC_103.L_CORE 0.001559
K_760 X_NUC_4.L_CORE X_NUC_104.L_CORE 0.001566
K_761 X_NUC_4.L_CORE X_NUC_105.L_CORE 0.001814
K_762 X_NUC_4.L_CORE X_NUC_106.L_CORE 0.001822
K_763 X_NUC_4.L_CORE X_NUC_107.L_CORE 0.001809
K_764 X_NUC_4.L_CORE X_NUC_108.L_CORE 0.001807
K_765 X_NUC_4.L_CORE X_NUC_109.L_CORE 0.001595
K_766 X_NUC_4.L_CORE X_NUC_110.L_CORE 0.001587
K_767 X_NUC_4.L_CORE X_NUC_111.L_CORE 0.001585
K_768 X_NUC_4.L_CORE X_NUC_112.L_CORE 0.001584
K_769 X_NUC_4.L_CORE X_NUC_113.L_CORE 0.001566
K_770 X_NUC_4.L_CORE X_NUC_114.L_CORE 0.001567
K_771 X_NUC_4.L_CORE X_NUC_115.L_CORE 0.001557
K_772 X_NUC_4.L_CORE X_NUC_116.L_CORE 0.001564
K_773 X_NUC_4.L_CORE X_NUC_117.L_CORE 0.001701
K_774 X_NUC_4.L_CORE X_NUC_118.L_CORE 0.001702
K_775 X_NUC_4.L_CORE X_NUC_119.L_CORE 0.001696
K_776 X_NUC_4.L_CORE X_NUC_120.L_CORE 0.001690
K_777 X_NUC_4.L_CORE X_NUC_121.L_CORE 0.001464
K_778 X_NUC_4.L_CORE X_NUC_122.L_CORE 0.001458
K_779 X_NUC_4.L_CORE X_NUC_123.L_CORE 0.001453
K_780 X_NUC_4.L_CORE X_NUC_124.L_CORE 0.001457
K_781 X_NUC_4.L_CORE X_NUC_125.L_CORE 0.001587
K_782 X_NUC_4.L_CORE X_NUC_126.L_CORE 0.001593
K_783 X_NUC_4.L_CORE X_NUC_127.L_CORE 0.001581
K_784 X_NUC_4.L_CORE X_NUC_128.L_CORE 0.001584
K_785 X_NUC_4.L_CORE X_NUC_129.L_CORE 0.001530
K_786 X_NUC_4.L_CORE X_NUC_130.L_CORE 0.001526
K_787 X_NUC_4.L_CORE X_NUC_131.L_CORE 0.001523
K_788 X_NUC_4.L_CORE X_NUC_132.L_CORE 0.001519
K_789 X_NUC_4.L_CORE X_NUC_133.L_CORE 0.001422
K_790 X_NUC_4.L_CORE X_NUC_134.L_CORE 0.001421
K_791 X_NUC_4.L_CORE X_NUC_135.L_CORE 0.001413
K_792 X_NUC_4.L_CORE X_NUC_136.L_CORE 0.001418
K_793 X_NUC_4.L_CORE X_NUC_137.L_CORE 0.001552
K_794 X_NUC_4.L_CORE X_NUC_138.L_CORE 0.001555
K_795 X_NUC_4.L_CORE X_NUC_139.L_CORE 0.001547
K_796 X_NUC_4.L_CORE X_NUC_140.L_CORE 0.001545
K_797 X_NUC_4.L_CORE X_NUC_141.L_CORE 0.001401
K_798 X_NUC_4.L_CORE X_NUC_142.L_CORE 0.001396
K_799 X_NUC_4.L_CORE X_NUC_143.L_CORE 0.001393
K_800 X_NUC_4.L_CORE X_NUC_144.L_CORE 0.001393
K_801 X_NUC_4.L_CORE X_NUC_145.L_CORE 0.001424
K_802 X_NUC_4.L_CORE X_NUC_146.L_CORE 0.001426
K_803 X_NUC_4.L_CORE X_NUC_147.L_CORE 0.001417
K_804 X_NUC_4.L_CORE X_NUC_148.L_CORE 0.001420
K_805 X_NUC_4.L_CORE X_NUC_149.L_CORE 0.001451
K_806 X_NUC_4.L_CORE X_NUC_150.L_CORE 0.001450
K_807 X_NUC_4.L_CORE X_NUC_151.L_CORE 0.001445
K_808 X_NUC_4.L_CORE X_NUC_152.L_CORE 0.001442
K_809 X_NUC_4.L_CORE X_NUC_153.L_CORE 0.001340
K_810 X_NUC_4.L_CORE X_NUC_154.L_CORE 0.001338
K_811 X_NUC_4.L_CORE X_NUC_155.L_CORE 0.001332
K_812 X_NUC_4.L_CORE X_NUC_156.L_CORE 0.001335
K_813 X_NUC_4.L_CORE X_NUC_157.L_CORE 0.001408
K_814 X_NUC_4.L_CORE X_NUC_158.L_CORE 0.001410
K_815 X_NUC_4.L_CORE X_NUC_159.L_CORE 0.001402
K_816 X_NUC_4.L_CORE X_NUC_160.L_CORE 0.001402
K_817 X_NUC_4.L_CORE X_NUC_161.L_CORE 0.001350
K_818 X_NUC_4.L_CORE X_NUC_162.L_CORE 0.001347
K_819 X_NUC_4.L_CORE X_NUC_163.L_CORE 0.001343
K_820 X_NUC_4.L_CORE X_NUC_164.L_CORE 0.001342
K_821 X_NUC_4.L_CORE X_NUC_165.L_CORE 0.001323
K_822 X_NUC_4.L_CORE X_NUC_166.L_CORE 0.001323
K_823 X_NUC_4.L_CORE X_NUC_167.L_CORE 0.001316
K_824 X_NUC_4.L_CORE X_NUC_168.L_CORE 0.001318
K_825 X_NUC_4.L_CORE X_NUC_169.L_CORE 0.001339
K_826 X_NUC_4.L_CORE X_NUC_170.L_CORE 0.001338
K_827 X_NUC_4.L_CORE X_NUC_171.L_CORE 0.001333
K_828 X_NUC_4.L_CORE X_NUC_172.L_CORE 0.001332
K_829 X_NUC_4.L_CORE X_NUC_173.L_CORE 0.030287
K_830 X_NUC_4.L_CORE X_NUC_174.L_CORE 0.004738
K_831 X_NUC_4.L_CORE X_NUC_175.L_CORE 0.005151
K_832 X_NUC_4.L_CORE X_NUC_176.L_CORE 0.005782
K_833 X_NUC_4.L_CORE X_NUC_177.L_CORE 0.003102
K_834 X_NUC_4.L_CORE X_NUC_178.L_CORE 0.004965
K_835 X_NUC_4.L_CORE X_NUC_179.L_CORE 0.003154
K_836 X_NUC_4.L_CORE X_NUC_180.L_CORE 0.002823
K_837 X_NUC_4.L_CORE X_NUC_181.L_CORE 0.003937
K_838 X_NUC_4.L_CORE X_NUC_182.L_CORE 0.002380
K_839 X_NUC_4.L_CORE X_NUC_183.L_CORE 0.002939
K_840 X_NUC_4.L_CORE X_NUC_184.L_CORE 0.002747
K_841 X_NUC_4.L_CORE X_NUC_185.L_CORE 0.002150
K_842 X_NUC_4.L_CORE X_NUC_186.L_CORE 0.002939
K_843 X_NUC_4.L_CORE X_NUC_187.L_CORE 0.002114
K_844 X_NUC_4.L_CORE X_NUC_188.L_CORE 0.002181
K_845 X_NUC_4.L_CORE X_NUC_189.L_CORE 0.002483
K_846 X_NUC_4.L_CORE X_NUC_190.L_CORE 0.001851
K_847 X_NUC_4.L_CORE X_NUC_191.L_CORE 0.002287
K_848 X_NUC_4.L_CORE X_NUC_192.L_CORE 0.001992
K_849 X_NUC_4.L_CORE X_NUC_193.L_CORE 0.001803
K_850 X_NUC_4.L_CORE X_NUC_194.L_CORE 0.002201
K_851 X_NUC_4.L_CORE X_NUC_195.L_CORE 0.001706
K_852 X_NUC_4.L_CORE X_NUC_196.L_CORE 0.001870
K_853 X_NUC_4.L_CORE X_NUC_197.L_CORE 0.001902
K_854 X_NUC_4.L_CORE X_NUC_198.L_CORE 0.001598
K_855 X_NUC_4.L_CORE X_NUC_199.L_CORE 0.001909
K_856 X_NUC_4.L_CORE X_NUC_200.L_CORE 0.001633
K_857 X_NUC_4.L_CORE X_NUC_201.L_CORE 0.001609
K_858 X_NUC_4.L_CORE X_NUC_202.L_CORE 0.001788
K_859 X_NUC_4.L_CORE X_NUC_203.L_CORE 0.001488
K_860 X_NUC_4.L_CORE X_NUC_204.L_CORE 0.001658
K_861 X_NUC_4.L_CORE X_NUC_205.L_CORE 0.001584
K_862 X_NUC_4.L_CORE X_NUC_206.L_CORE 0.001449
K_863 X_NUC_4.L_CORE X_NUC_207.L_CORE 0.001640
K_864 X_NUC_4.L_CORE X_NUC_208.L_CORE 0.001428
K_865 X_NUC_4.L_CORE X_NUC_209.L_CORE 0.001472
K_866 X_NUC_4.L_CORE X_NUC_210.L_CORE 0.001522
K_867 X_NUC_4.L_CORE X_NUC_211.L_CORE 0.001356
K_868 X_NUC_4.L_CORE X_NUC_212.L_CORE 0.001485
K_869 X_NUC_4.L_CORE X_NUC_213.L_CORE 0.001388
K_870 X_NUC_4.L_CORE X_NUC_214.L_CORE 0.001346
K_871 X_NUC_4.L_CORE X_NUC_215.L_CORE 0.001433
K_872 X_NUC_4.L_CORE X_NUC_216.L_CORE 0.001303
K_873 X_NUC_4.L_CORE X_NUC_217.L_CORE 0.001354
K_874 X_NUC_4.L_CORE X_NUC_218.L_CORE 0.001340
K_875 X_NUC_4.L_CORE X_NUC_219.L_CORE 0.001273
K_876 X_NUC_4.L_CORE X_NUC_220.L_CORE 0.001327
K_877 X_NUC_4.L_CORE X_NUC_221.L_CORE 0.001269
K_878 X_NUC_4.L_CORE X_NUC_222.L_CORE 0.001265
K_879 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_880 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_881 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_882 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.003336
K_883 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.003387
K_884 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.003349
K_885 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.003369
K_886 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.004080
K_887 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.004117
K_888 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.004125
K_889 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.004055
K_890 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.005151
K_891 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.005153
K_892 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.005067
K_893 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.005188
K_894 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.002485
K_895 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.002514
K_896 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.002498
K_897 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.002493
K_898 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.005123
K_899 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.005060
K_900 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.005096
K_901 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.005007
K_902 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.002696
K_903 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.002717
K_904 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.002686
K_905 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.002712
K_906 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.002434
K_907 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.002453
K_908 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.002447
K_909 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.002427
K_910 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.004172
K_911 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.004119
K_912 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.004091
K_913 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.004130
K_914 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.002039
K_915 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.002057
K_916 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.002041
K_917 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.002046
K_918 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.002809
K_919 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.002807
K_920 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.002811
K_921 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.002779
K_922 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.002576
K_923 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.002580
K_924 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.002553
K_925 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.002580
K_926 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.001891
K_927 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.001905
K_928 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.001896
K_929 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.001889
K_930 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.003076
K_931 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.003046
K_932 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.003043
K_933 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.003034
K_934 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.001896
K_935 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.001908
K_936 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.001891
K_937 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.001901
K_938 X_NUC_5.L_CORE X_NUC_65.L_CORE 0.002022
K_939 X_NUC_5.L_CORE X_NUC_66.L_CORE 0.002028
K_940 X_NUC_5.L_CORE X_NUC_67.L_CORE 0.002025
K_941 X_NUC_5.L_CORE X_NUC_68.L_CORE 0.002010
K_942 X_NUC_5.L_CORE X_NUC_69.L_CORE 0.002480
K_943 X_NUC_5.L_CORE X_NUC_70.L_CORE 0.002470
K_944 X_NUC_5.L_CORE X_NUC_71.L_CORE 0.002451
K_945 X_NUC_5.L_CORE X_NUC_72.L_CORE 0.002469
K_946 X_NUC_5.L_CORE X_NUC_73.L_CORE 0.001658
K_947 X_NUC_5.L_CORE X_NUC_74.L_CORE 0.001670
K_948 X_NUC_5.L_CORE X_NUC_75.L_CORE 0.001659
K_949 X_NUC_5.L_CORE X_NUC_76.L_CORE 0.001659
K_950 X_NUC_5.L_CORE X_NUC_77.L_CORE 0.002276
K_951 X_NUC_5.L_CORE X_NUC_78.L_CORE 0.002268
K_952 X_NUC_5.L_CORE X_NUC_79.L_CORE 0.002266
K_953 X_NUC_5.L_CORE X_NUC_80.L_CORE 0.002252
K_954 X_NUC_5.L_CORE X_NUC_81.L_CORE 0.001866
K_955 X_NUC_5.L_CORE X_NUC_82.L_CORE 0.001871
K_956 X_NUC_5.L_CORE X_NUC_83.L_CORE 0.001855
K_957 X_NUC_5.L_CORE X_NUC_84.L_CORE 0.001867
K_958 X_NUC_5.L_CORE X_NUC_85.L_CORE 0.001657
K_959 X_NUC_5.L_CORE X_NUC_86.L_CORE 0.001665
K_960 X_NUC_5.L_CORE X_NUC_87.L_CORE 0.001659
K_961 X_NUC_5.L_CORE X_NUC_88.L_CORE 0.001652
K_962 X_NUC_5.L_CORE X_NUC_89.L_CORE 0.002233
K_963 X_NUC_5.L_CORE X_NUC_90.L_CORE 0.002220
K_964 X_NUC_5.L_CORE X_NUC_91.L_CORE 0.002211
K_965 X_NUC_5.L_CORE X_NUC_92.L_CORE 0.002214
K_966 X_NUC_5.L_CORE X_NUC_93.L_CORE 0.001564
K_967 X_NUC_5.L_CORE X_NUC_94.L_CORE 0.001572
K_968 X_NUC_5.L_CORE X_NUC_95.L_CORE 0.001561
K_969 X_NUC_5.L_CORE X_NUC_96.L_CORE 0.001565
K_970 X_NUC_5.L_CORE X_NUC_97.L_CORE 0.001797
K_971 X_NUC_5.L_CORE X_NUC_98.L_CORE 0.001798
K_972 X_NUC_5.L_CORE X_NUC_99.L_CORE 0.001794
K_973 X_NUC_5.L_CORE X_NUC_100.L_CORE 0.001784
K_974 X_NUC_5.L_CORE X_NUC_101.L_CORE 0.001847
K_975 X_NUC_5.L_CORE X_NUC_102.L_CORE 0.001846
K_976 X_NUC_5.L_CORE X_NUC_103.L_CORE 0.001832
K_977 X_NUC_5.L_CORE X_NUC_104.L_CORE 0.001842
K_978 X_NUC_5.L_CORE X_NUC_105.L_CORE 0.001476
K_979 X_NUC_5.L_CORE X_NUC_106.L_CORE 0.001484
K_980 X_NUC_5.L_CORE X_NUC_107.L_CORE 0.001476
K_981 X_NUC_5.L_CORE X_NUC_108.L_CORE 0.001474
K_982 X_NUC_5.L_CORE X_NUC_109.L_CORE 0.001899
K_983 X_NUC_5.L_CORE X_NUC_110.L_CORE 0.001893
K_984 X_NUC_5.L_CORE X_NUC_111.L_CORE 0.001888
K_985 X_NUC_5.L_CORE X_NUC_112.L_CORE 0.001883
K_986 X_NUC_5.L_CORE X_NUC_113.L_CORE 0.001536
K_987 X_NUC_5.L_CORE X_NUC_114.L_CORE 0.001541
K_988 X_NUC_5.L_CORE X_NUC_115.L_CORE 0.001530
K_989 X_NUC_5.L_CORE X_NUC_116.L_CORE 0.001535
K_990 X_NUC_5.L_CORE X_NUC_117.L_CORE 0.001523
K_991 X_NUC_5.L_CORE X_NUC_118.L_CORE 0.001527
K_992 X_NUC_5.L_CORE X_NUC_119.L_CORE 0.001522
K_993 X_NUC_5.L_CORE X_NUC_120.L_CORE 0.001516
K_994 X_NUC_5.L_CORE X_NUC_121.L_CORE 0.001760
K_995 X_NUC_5.L_CORE X_NUC_122.L_CORE 0.001756
K_996 X_NUC_5.L_CORE X_NUC_123.L_CORE 0.001746
K_997 X_NUC_5.L_CORE X_NUC_124.L_CORE 0.001751
K_998 X_NUC_5.L_CORE X_NUC_125.L_CORE 0.001393
K_999 X_NUC_5.L_CORE X_NUC_126.L_CORE 0.001399
K_1000 X_NUC_5.L_CORE X_NUC_127.L_CORE 0.001391
K_1001 X_NUC_5.L_CORE X_NUC_128.L_CORE 0.001392
K_1002 X_NUC_5.L_CORE X_NUC_129.L_CORE 0.001612
K_1003 X_NUC_5.L_CORE X_NUC_130.L_CORE 0.001611
K_1004 X_NUC_5.L_CORE X_NUC_131.L_CORE 0.001606
K_1005 X_NUC_5.L_CORE X_NUC_132.L_CORE 0.001600
K_1006 X_NUC_5.L_CORE X_NUC_133.L_CORE 0.001520
K_1007 X_NUC_5.L_CORE X_NUC_134.L_CORE 0.001522
K_1008 X_NUC_5.L_CORE X_NUC_135.L_CORE 0.001511
K_1009 X_NUC_5.L_CORE X_NUC_136.L_CORE 0.001517
K_1010 X_NUC_5.L_CORE X_NUC_137.L_CORE 0.001375
K_1011 X_NUC_5.L_CORE X_NUC_138.L_CORE 0.001380
K_1012 X_NUC_5.L_CORE X_NUC_139.L_CORE 0.001373
K_1013 X_NUC_5.L_CORE X_NUC_140.L_CORE 0.001371
K_1014 X_NUC_5.L_CORE X_NUC_141.L_CORE 0.001598
K_1015 X_NUC_5.L_CORE X_NUC_142.L_CORE 0.001595
K_1016 X_NUC_5.L_CORE X_NUC_143.L_CORE 0.001588
K_1017 X_NUC_5.L_CORE X_NUC_144.L_CORE 0.001588
K_1018 X_NUC_5.L_CORE X_NUC_145.L_CORE 0.001362
K_1019 X_NUC_5.L_CORE X_NUC_146.L_CORE 0.001366
K_1020 X_NUC_5.L_CORE X_NUC_147.L_CORE 0.001358
K_1021 X_NUC_5.L_CORE X_NUC_148.L_CORE 0.001360
K_1022 X_NUC_5.L_CORE X_NUC_149.L_CORE 0.001416
K_1023 X_NUC_5.L_CORE X_NUC_150.L_CORE 0.001418
K_1024 X_NUC_5.L_CORE X_NUC_151.L_CORE 0.001412
K_1025 X_NUC_5.L_CORE X_NUC_152.L_CORE 0.001409
K_1026 X_NUC_5.L_CORE X_NUC_153.L_CORE 0.001463
K_1027 X_NUC_5.L_CORE X_NUC_154.L_CORE 0.001463
K_1028 X_NUC_5.L_CORE X_NUC_155.L_CORE 0.001454
K_1029 X_NUC_5.L_CORE X_NUC_156.L_CORE 0.001457
K_1030 X_NUC_5.L_CORE X_NUC_157.L_CORE 0.001309
K_1031 X_NUC_5.L_CORE X_NUC_158.L_CORE 0.001313
K_1032 X_NUC_5.L_CORE X_NUC_159.L_CORE 0.001306
K_1033 X_NUC_5.L_CORE X_NUC_160.L_CORE 0.001305
K_1034 X_NUC_5.L_CORE X_NUC_161.L_CORE 0.001418
K_1035 X_NUC_5.L_CORE X_NUC_162.L_CORE 0.001418
K_1036 X_NUC_5.L_CORE X_NUC_163.L_CORE 0.001412
K_1037 X_NUC_5.L_CORE X_NUC_164.L_CORE 0.001411
K_1038 X_NUC_5.L_CORE X_NUC_165.L_CORE 0.001340
K_1039 X_NUC_5.L_CORE X_NUC_166.L_CORE 0.001341
K_1040 X_NUC_5.L_CORE X_NUC_167.L_CORE 0.001334
K_1041 X_NUC_5.L_CORE X_NUC_168.L_CORE 0.001335
K_1042 X_NUC_5.L_CORE X_NUC_169.L_CORE 0.001318
K_1043 X_NUC_5.L_CORE X_NUC_170.L_CORE 0.001320
K_1044 X_NUC_5.L_CORE X_NUC_171.L_CORE 0.001314
K_1045 X_NUC_5.L_CORE X_NUC_172.L_CORE 0.001313
K_1046 X_NUC_5.L_CORE X_NUC_173.L_CORE 0.004708
K_1047 X_NUC_5.L_CORE X_NUC_174.L_CORE 0.032305
K_1048 X_NUC_5.L_CORE X_NUC_175.L_CORE 0.003353
K_1049 X_NUC_5.L_CORE X_NUC_176.L_CORE 0.004121
K_1050 X_NUC_5.L_CORE X_NUC_177.L_CORE 0.005283
K_1051 X_NUC_5.L_CORE X_NUC_178.L_CORE 0.002511
K_1052 X_NUC_5.L_CORE X_NUC_179.L_CORE 0.005382
K_1053 X_NUC_5.L_CORE X_NUC_180.L_CORE 0.002744
K_1054 X_NUC_5.L_CORE X_NUC_181.L_CORE 0.002474
K_1055 X_NUC_5.L_CORE X_NUC_182.L_CORE 0.004441
K_1056 X_NUC_5.L_CORE X_NUC_183.L_CORE 0.002068
K_1057 X_NUC_5.L_CORE X_NUC_184.L_CORE 0.002907
K_1058 X_NUC_5.L_CORE X_NUC_185.L_CORE 0.002661
K_1059 X_NUC_5.L_CORE X_NUC_186.L_CORE 0.001920
K_1060 X_NUC_5.L_CORE X_NUC_187.L_CORE 0.003277
K_1061 X_NUC_5.L_CORE X_NUC_188.L_CORE 0.001932
K_1062 X_NUC_5.L_CORE X_NUC_189.L_CORE 0.002073
K_1063 X_NUC_5.L_CORE X_NUC_190.L_CORE 0.002610
K_1064 X_NUC_5.L_CORE X_NUC_191.L_CORE 0.001682
K_1065 X_NUC_5.L_CORE X_NUC_192.L_CORE 0.002390
K_1066 X_NUC_5.L_CORE X_NUC_193.L_CORE 0.001919
K_1067 X_NUC_5.L_CORE X_NUC_194.L_CORE 0.001687
K_1068 X_NUC_5.L_CORE X_NUC_195.L_CORE 0.002378
K_1069 X_NUC_5.L_CORE X_NUC_196.L_CORE 0.001589
K_1070 X_NUC_5.L_CORE X_NUC_197.L_CORE 0.001861
K_1071 X_NUC_5.L_CORE X_NUC_198.L_CORE 0.001929
K_1072 X_NUC_5.L_CORE X_NUC_199.L_CORE 0.001496
K_1073 X_NUC_5.L_CORE X_NUC_200.L_CORE 0.002016
K_1074 X_NUC_5.L_CORE X_NUC_201.L_CORE 0.001570
K_1075 X_NUC_5.L_CORE X_NUC_202.L_CORE 0.001558
K_1076 X_NUC_5.L_CORE X_NUC_203.L_CORE 0.001869
K_1077 X_NUC_5.L_CORE X_NUC_204.L_CORE 0.001408
K_1078 X_NUC_5.L_CORE X_NUC_205.L_CORE 0.001690
K_1079 X_NUC_5.L_CORE X_NUC_206.L_CORE 0.001576
K_1080 X_NUC_5.L_CORE X_NUC_207.L_CORE 0.001391
K_1081 X_NUC_5.L_CORE X_NUC_208.L_CORE 0.001712
K_1082 X_NUC_5.L_CORE X_NUC_209.L_CORE 0.001379
K_1083 X_NUC_5.L_CORE X_NUC_210.L_CORE 0.001461
K_1084 X_NUC_5.L_CORE X_NUC_211.L_CORE 0.001551
K_1085 X_NUC_5.L_CORE X_NUC_212.L_CORE 0.001307
K_1086 X_NUC_5.L_CORE X_NUC_213.L_CORE 0.001520
K_1087 X_NUC_5.L_CORE X_NUC_214.L_CORE 0.001371
K_1088 X_NUC_5.L_CORE X_NUC_215.L_CORE 0.001322
K_1089 X_NUC_5.L_CORE X_NUC_216.L_CORE 0.001465
K_1090 X_NUC_5.L_CORE X_NUC_217.L_CORE 0.001274
K_1091 X_NUC_5.L_CORE X_NUC_218.L_CORE 0.001359
K_1092 X_NUC_5.L_CORE X_NUC_219.L_CORE 0.001344
K_1093 X_NUC_5.L_CORE X_NUC_220.L_CORE 0.001257
K_1094 X_NUC_5.L_CORE X_NUC_221.L_CORE 0.001334
K_1095 X_NUC_5.L_CORE X_NUC_222.L_CORE 0.001267
K_1096 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_1097 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_1098 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.003287
K_1099 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.003336
K_1100 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.003300
K_1101 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.003319
K_1102 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.004043
K_1103 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.004080
K_1104 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.004088
K_1105 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.004019
K_1106 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.005146
K_1107 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.005151
K_1108 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.005064
K_1109 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.005184
K_1110 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.002456
K_1111 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.002485
K_1112 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.002469
K_1113 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.002464
K_1114 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.005186
K_1115 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.005123
K_1116 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.005159
K_1117 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.005067
K_1118 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.002674
K_1119 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.002696
K_1120 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.002665
K_1121 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.002690
K_1122 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.002415
K_1123 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.002434
K_1124 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.002428
K_1125 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.002409
K_1126 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.004226
K_1127 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.004172
K_1128 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.004143
K_1129 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.004183
K_1130 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.002021
K_1131 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.002039
K_1132 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.002023
K_1133 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.002027
K_1134 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.002811
K_1135 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.002809
K_1136 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.002813
K_1137 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.002780
K_1138 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.002572
K_1139 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.002576
K_1140 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.002549
K_1141 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.002576
K_1142 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.001876
K_1143 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.001891
K_1144 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.001882
K_1145 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.001875
K_1146 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.003107
K_1147 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.003076
K_1148 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.003073
K_1149 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.003063
K_1150 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.001884
K_1151 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.001896
K_1152 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.001880
K_1153 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.001889
K_1154 X_NUC_6.L_CORE X_NUC_65.L_CORE 0.002015
K_1155 X_NUC_6.L_CORE X_NUC_66.L_CORE 0.002022
K_1156 X_NUC_6.L_CORE X_NUC_67.L_CORE 0.002018
K_1157 X_NUC_6.L_CORE X_NUC_68.L_CORE 0.002003
K_1158 X_NUC_6.L_CORE X_NUC_69.L_CORE 0.002490
K_1159 X_NUC_6.L_CORE X_NUC_70.L_CORE 0.002480
K_1160 X_NUC_6.L_CORE X_NUC_71.L_CORE 0.002461
K_1161 X_NUC_6.L_CORE X_NUC_72.L_CORE 0.002479
K_1162 X_NUC_6.L_CORE X_NUC_73.L_CORE 0.001647
K_1163 X_NUC_6.L_CORE X_NUC_74.L_CORE 0.001658
K_1164 X_NUC_6.L_CORE X_NUC_75.L_CORE 0.001648
K_1165 X_NUC_6.L_CORE X_NUC_76.L_CORE 0.001648
K_1166 X_NUC_6.L_CORE X_NUC_77.L_CORE 0.002284
K_1167 X_NUC_6.L_CORE X_NUC_78.L_CORE 0.002276
K_1168 X_NUC_6.L_CORE X_NUC_79.L_CORE 0.002274
K_1169 X_NUC_6.L_CORE X_NUC_80.L_CORE 0.002260
K_1170 X_NUC_6.L_CORE X_NUC_81.L_CORE 0.001860
K_1171 X_NUC_6.L_CORE X_NUC_82.L_CORE 0.001866
K_1172 X_NUC_6.L_CORE X_NUC_83.L_CORE 0.001850
K_1173 X_NUC_6.L_CORE X_NUC_84.L_CORE 0.001862
K_1174 X_NUC_6.L_CORE X_NUC_85.L_CORE 0.001649
K_1175 X_NUC_6.L_CORE X_NUC_86.L_CORE 0.001657
K_1176 X_NUC_6.L_CORE X_NUC_87.L_CORE 0.001651
K_1177 X_NUC_6.L_CORE X_NUC_88.L_CORE 0.001644
K_1178 X_NUC_6.L_CORE X_NUC_89.L_CORE 0.002246
K_1179 X_NUC_6.L_CORE X_NUC_90.L_CORE 0.002233
K_1180 X_NUC_6.L_CORE X_NUC_91.L_CORE 0.002223
K_1181 X_NUC_6.L_CORE X_NUC_92.L_CORE 0.002227
K_1182 X_NUC_6.L_CORE X_NUC_93.L_CORE 0.001555
K_1183 X_NUC_6.L_CORE X_NUC_94.L_CORE 0.001564
K_1184 X_NUC_6.L_CORE X_NUC_95.L_CORE 0.001553
K_1185 X_NUC_6.L_CORE X_NUC_96.L_CORE 0.001556
K_1186 X_NUC_6.L_CORE X_NUC_97.L_CORE 0.001796
K_1187 X_NUC_6.L_CORE X_NUC_98.L_CORE 0.001797
K_1188 X_NUC_6.L_CORE X_NUC_99.L_CORE 0.001793
K_1189 X_NUC_6.L_CORE X_NUC_100.L_CORE 0.001783
K_1190 X_NUC_6.L_CORE X_NUC_101.L_CORE 0.001848
K_1191 X_NUC_6.L_CORE X_NUC_102.L_CORE 0.001847
K_1192 X_NUC_6.L_CORE X_NUC_103.L_CORE 0.001833
K_1193 X_NUC_6.L_CORE X_NUC_104.L_CORE 0.001843
K_1194 X_NUC_6.L_CORE X_NUC_105.L_CORE 0.001468
K_1195 X_NUC_6.L_CORE X_NUC_106.L_CORE 0.001476
K_1196 X_NUC_6.L_CORE X_NUC_107.L_CORE 0.001468
K_1197 X_NUC_6.L_CORE X_NUC_108.L_CORE 0.001466
K_1198 X_NUC_6.L_CORE X_NUC_109.L_CORE 0.001906
K_1199 X_NUC_6.L_CORE X_NUC_110.L_CORE 0.001899
K_1200 X_NUC_6.L_CORE X_NUC_111.L_CORE 0.001894
K_1201 X_NUC_6.L_CORE X_NUC_112.L_CORE 0.001890
K_1202 X_NUC_6.L_CORE X_NUC_113.L_CORE 0.001531
K_1203 X_NUC_6.L_CORE X_NUC_114.L_CORE 0.001536
K_1204 X_NUC_6.L_CORE X_NUC_115.L_CORE 0.001525
K_1205 X_NUC_6.L_CORE X_NUC_116.L_CORE 0.001530
K_1206 X_NUC_6.L_CORE X_NUC_117.L_CORE 0.001519
K_1207 X_NUC_6.L_CORE X_NUC_118.L_CORE 0.001523
K_1208 X_NUC_6.L_CORE X_NUC_119.L_CORE 0.001518
K_1209 X_NUC_6.L_CORE X_NUC_120.L_CORE 0.001512
K_1210 X_NUC_6.L_CORE X_NUC_121.L_CORE 0.001764
K_1211 X_NUC_6.L_CORE X_NUC_122.L_CORE 0.001760
K_1212 X_NUC_6.L_CORE X_NUC_123.L_CORE 0.001750
K_1213 X_NUC_6.L_CORE X_NUC_124.L_CORE 0.001755
K_1214 X_NUC_6.L_CORE X_NUC_125.L_CORE 0.001387
K_1215 X_NUC_6.L_CORE X_NUC_126.L_CORE 0.001393
K_1216 X_NUC_6.L_CORE X_NUC_127.L_CORE 0.001385
K_1217 X_NUC_6.L_CORE X_NUC_128.L_CORE 0.001386
K_1218 X_NUC_6.L_CORE X_NUC_129.L_CORE 0.001613
K_1219 X_NUC_6.L_CORE X_NUC_130.L_CORE 0.001612
K_1220 X_NUC_6.L_CORE X_NUC_131.L_CORE 0.001607
K_1221 X_NUC_6.L_CORE X_NUC_132.L_CORE 0.001601
K_1222 X_NUC_6.L_CORE X_NUC_133.L_CORE 0.001518
K_1223 X_NUC_6.L_CORE X_NUC_134.L_CORE 0.001520
K_1224 X_NUC_6.L_CORE X_NUC_135.L_CORE 0.001510
K_1225 X_NUC_6.L_CORE X_NUC_136.L_CORE 0.001515
K_1226 X_NUC_6.L_CORE X_NUC_137.L_CORE 0.001370
K_1227 X_NUC_6.L_CORE X_NUC_138.L_CORE 0.001375
K_1228 X_NUC_6.L_CORE X_NUC_139.L_CORE 0.001369
K_1229 X_NUC_6.L_CORE X_NUC_140.L_CORE 0.001366
K_1230 X_NUC_6.L_CORE X_NUC_141.L_CORE 0.001601
K_1231 X_NUC_6.L_CORE X_NUC_142.L_CORE 0.001598
K_1232 X_NUC_6.L_CORE X_NUC_143.L_CORE 0.001591
K_1233 X_NUC_6.L_CORE X_NUC_144.L_CORE 0.001591
K_1234 X_NUC_6.L_CORE X_NUC_145.L_CORE 0.001358
K_1235 X_NUC_6.L_CORE X_NUC_146.L_CORE 0.001362
K_1236 X_NUC_6.L_CORE X_NUC_147.L_CORE 0.001354
K_1237 X_NUC_6.L_CORE X_NUC_148.L_CORE 0.001356
K_1238 X_NUC_6.L_CORE X_NUC_149.L_CORE 0.001414
K_1239 X_NUC_6.L_CORE X_NUC_150.L_CORE 0.001416
K_1240 X_NUC_6.L_CORE X_NUC_151.L_CORE 0.001411
K_1241 X_NUC_6.L_CORE X_NUC_152.L_CORE 0.001407
K_1242 X_NUC_6.L_CORE X_NUC_153.L_CORE 0.001463
K_1243 X_NUC_6.L_CORE X_NUC_154.L_CORE 0.001463
K_1244 X_NUC_6.L_CORE X_NUC_155.L_CORE 0.001454
K_1245 X_NUC_6.L_CORE X_NUC_156.L_CORE 0.001457
K_1246 X_NUC_6.L_CORE X_NUC_157.L_CORE 0.001305
K_1247 X_NUC_6.L_CORE X_NUC_158.L_CORE 0.001309
K_1248 X_NUC_6.L_CORE X_NUC_159.L_CORE 0.001302
K_1249 X_NUC_6.L_CORE X_NUC_160.L_CORE 0.001302
K_1250 X_NUC_6.L_CORE X_NUC_161.L_CORE 0.001418
K_1251 X_NUC_6.L_CORE X_NUC_162.L_CORE 0.001418
K_1252 X_NUC_6.L_CORE X_NUC_163.L_CORE 0.001412
K_1253 X_NUC_6.L_CORE X_NUC_164.L_CORE 0.001411
K_1254 X_NUC_6.L_CORE X_NUC_165.L_CORE 0.001338
K_1255 X_NUC_6.L_CORE X_NUC_166.L_CORE 0.001340
K_1256 X_NUC_6.L_CORE X_NUC_167.L_CORE 0.001332
K_1257 X_NUC_6.L_CORE X_NUC_168.L_CORE 0.001333
K_1258 X_NUC_6.L_CORE X_NUC_169.L_CORE 0.001316
K_1259 X_NUC_6.L_CORE X_NUC_170.L_CORE 0.001318
K_1260 X_NUC_6.L_CORE X_NUC_171.L_CORE 0.001312
K_1261 X_NUC_6.L_CORE X_NUC_172.L_CORE 0.001311
K_1262 X_NUC_6.L_CORE X_NUC_173.L_CORE 0.004611
K_1263 X_NUC_6.L_CORE X_NUC_174.L_CORE 0.032392
K_1264 X_NUC_6.L_CORE X_NUC_175.L_CORE 0.003303
K_1265 X_NUC_6.L_CORE X_NUC_176.L_CORE 0.004084
K_1266 X_NUC_6.L_CORE X_NUC_177.L_CORE 0.005280
K_1267 X_NUC_6.L_CORE X_NUC_178.L_CORE 0.002482
K_1268 X_NUC_6.L_CORE X_NUC_179.L_CORE 0.005460
K_1269 X_NUC_6.L_CORE X_NUC_180.L_CORE 0.002721
K_1270 X_NUC_6.L_CORE X_NUC_181.L_CORE 0.002455
K_1271 X_NUC_6.L_CORE X_NUC_182.L_CORE 0.004509
K_1272 X_NUC_6.L_CORE X_NUC_183.L_CORE 0.002049
K_1273 X_NUC_6.L_CORE X_NUC_184.L_CORE 0.002910
K_1274 X_NUC_6.L_CORE X_NUC_185.L_CORE 0.002656
K_1275 X_NUC_6.L_CORE X_NUC_186.L_CORE 0.001905
K_1276 X_NUC_6.L_CORE X_NUC_187.L_CORE 0.003316
K_1277 X_NUC_6.L_CORE X_NUC_188.L_CORE 0.001919
K_1278 X_NUC_6.L_CORE X_NUC_189.L_CORE 0.002066
K_1279 X_NUC_6.L_CORE X_NUC_190.L_CORE 0.002623
K_1280 X_NUC_6.L_CORE X_NUC_191.L_CORE 0.001670
K_1281 X_NUC_6.L_CORE X_NUC_192.L_CORE 0.002400
K_1282 X_NUC_6.L_CORE X_NUC_193.L_CORE 0.001913
K_1283 X_NUC_6.L_CORE X_NUC_194.L_CORE 0.001678
K_1284 X_NUC_6.L_CORE X_NUC_195.L_CORE 0.002395
K_1285 X_NUC_6.L_CORE X_NUC_196.L_CORE 0.001579
K_1286 X_NUC_6.L_CORE X_NUC_197.L_CORE 0.001860
K_1287 X_NUC_6.L_CORE X_NUC_198.L_CORE 0.001931
K_1288 X_NUC_6.L_CORE X_NUC_199.L_CORE 0.001487
K_1289 X_NUC_6.L_CORE X_NUC_200.L_CORE 0.002026
K_1290 X_NUC_6.L_CORE X_NUC_201.L_CORE 0.001565
K_1291 X_NUC_6.L_CORE X_NUC_202.L_CORE 0.001553
K_1292 X_NUC_6.L_CORE X_NUC_203.L_CORE 0.001876
K_1293 X_NUC_6.L_CORE X_NUC_204.L_CORE 0.001401
K_1294 X_NUC_6.L_CORE X_NUC_205.L_CORE 0.001692
K_1295 X_NUC_6.L_CORE X_NUC_206.L_CORE 0.001574
K_1296 X_NUC_6.L_CORE X_NUC_207.L_CORE 0.001385
K_1297 X_NUC_6.L_CORE X_NUC_208.L_CORE 0.001718
K_1298 X_NUC_6.L_CORE X_NUC_209.L_CORE 0.001374
K_1299 X_NUC_6.L_CORE X_NUC_210.L_CORE 0.001459
K_1300 X_NUC_6.L_CORE X_NUC_211.L_CORE 0.001553
K_1301 X_NUC_6.L_CORE X_NUC_212.L_CORE 0.001302
K_1302 X_NUC_6.L_CORE X_NUC_213.L_CORE 0.001522
K_1303 X_NUC_6.L_CORE X_NUC_214.L_CORE 0.001369
K_1304 X_NUC_6.L_CORE X_NUC_215.L_CORE 0.001319
K_1305 X_NUC_6.L_CORE X_NUC_216.L_CORE 0.001467
K_1306 X_NUC_6.L_CORE X_NUC_217.L_CORE 0.001270
K_1307 X_NUC_6.L_CORE X_NUC_218.L_CORE 0.001359
K_1308 X_NUC_6.L_CORE X_NUC_219.L_CORE 0.001343
K_1309 X_NUC_6.L_CORE X_NUC_220.L_CORE 0.001254
K_1310 X_NUC_6.L_CORE X_NUC_221.L_CORE 0.001334
K_1311 X_NUC_6.L_CORE X_NUC_222.L_CORE 0.001265
K_1312 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_1313 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.003323
K_1314 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.003373
K_1315 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.003336
K_1316 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.003356
K_1317 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.004035
K_1318 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.004071
K_1319 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.004080
K_1320 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.004011
K_1321 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.005236
K_1322 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.005240
K_1323 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.005151
K_1324 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.005276
K_1325 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.002472
K_1326 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.002501
K_1327 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.002485
K_1328 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.002480
K_1329 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.005148
K_1330 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.005085
K_1331 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.005123
K_1332 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.005031
K_1333 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.002705
K_1334 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.002727
K_1335 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.002696
K_1336 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.002721
K_1337 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.002421
K_1338 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.002440
K_1339 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.002434
K_1340 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.002414
K_1341 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.004256
K_1342 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.004200
K_1343 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.004172
K_1344 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.004212
K_1345 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.002036
K_1346 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.002055
K_1347 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.002039
K_1348 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.002043
K_1349 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.002807
K_1350 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.002805
K_1351 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.002809
K_1352 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.002777
K_1353 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.002599
K_1354 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.002603
K_1355 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.002576
K_1356 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.002604
K_1357 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.001885
K_1358 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.001899
K_1359 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.001891
K_1360 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.001884
K_1361 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.003110
K_1362 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.003079
K_1363 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.003076
K_1364 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.003066
K_1365 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.001900
K_1366 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.001913
K_1367 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.001896
K_1368 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.001905
K_1369 X_NUC_7.L_CORE X_NUC_65.L_CORE 0.002018
K_1370 X_NUC_7.L_CORE X_NUC_66.L_CORE 0.002025
K_1371 X_NUC_7.L_CORE X_NUC_67.L_CORE 0.002022
K_1372 X_NUC_7.L_CORE X_NUC_68.L_CORE 0.002007
K_1373 X_NUC_7.L_CORE X_NUC_69.L_CORE 0.002509
K_1374 X_NUC_7.L_CORE X_NUC_70.L_CORE 0.002499
K_1375 X_NUC_7.L_CORE X_NUC_71.L_CORE 0.002480
K_1376 X_NUC_7.L_CORE X_NUC_72.L_CORE 0.002498
K_1377 X_NUC_7.L_CORE X_NUC_73.L_CORE 0.001657
K_1378 X_NUC_7.L_CORE X_NUC_74.L_CORE 0.001668
K_1379 X_NUC_7.L_CORE X_NUC_75.L_CORE 0.001658
K_1380 X_NUC_7.L_CORE X_NUC_76.L_CORE 0.001658
K_1381 X_NUC_7.L_CORE X_NUC_77.L_CORE 0.002285
K_1382 X_NUC_7.L_CORE X_NUC_78.L_CORE 0.002277
K_1383 X_NUC_7.L_CORE X_NUC_79.L_CORE 0.002276
K_1384 X_NUC_7.L_CORE X_NUC_80.L_CORE 0.002261
K_1385 X_NUC_7.L_CORE X_NUC_81.L_CORE 0.001877
K_1386 X_NUC_7.L_CORE X_NUC_82.L_CORE 0.001882
K_1387 X_NUC_7.L_CORE X_NUC_83.L_CORE 0.001866
K_1388 X_NUC_7.L_CORE X_NUC_84.L_CORE 0.001878
K_1389 X_NUC_7.L_CORE X_NUC_85.L_CORE 0.001655
K_1390 X_NUC_7.L_CORE X_NUC_86.L_CORE 0.001663
K_1391 X_NUC_7.L_CORE X_NUC_87.L_CORE 0.001657
K_1392 X_NUC_7.L_CORE X_NUC_88.L_CORE 0.001650
K_1393 X_NUC_7.L_CORE X_NUC_89.L_CORE 0.002255
K_1394 X_NUC_7.L_CORE X_NUC_90.L_CORE 0.002242
K_1395 X_NUC_7.L_CORE X_NUC_91.L_CORE 0.002233
K_1396 X_NUC_7.L_CORE X_NUC_92.L_CORE 0.002236
K_1397 X_NUC_7.L_CORE X_NUC_93.L_CORE 0.001566
K_1398 X_NUC_7.L_CORE X_NUC_94.L_CORE 0.001575
K_1399 X_NUC_7.L_CORE X_NUC_95.L_CORE 0.001564
K_1400 X_NUC_7.L_CORE X_NUC_96.L_CORE 0.001567
K_1401 X_NUC_7.L_CORE X_NUC_97.L_CORE 0.001799
K_1402 X_NUC_7.L_CORE X_NUC_98.L_CORE 0.001800
K_1403 X_NUC_7.L_CORE X_NUC_99.L_CORE 0.001797
K_1404 X_NUC_7.L_CORE X_NUC_100.L_CORE 0.001786
K_1405 X_NUC_7.L_CORE X_NUC_101.L_CORE 0.001862
K_1406 X_NUC_7.L_CORE X_NUC_102.L_CORE 0.001861
K_1407 X_NUC_7.L_CORE X_NUC_103.L_CORE 0.001847
K_1408 X_NUC_7.L_CORE X_NUC_104.L_CORE 0.001857
K_1409 X_NUC_7.L_CORE X_NUC_105.L_CORE 0.001476
K_1410 X_NUC_7.L_CORE X_NUC_106.L_CORE 0.001484
K_1411 X_NUC_7.L_CORE X_NUC_107.L_CORE 0.001476
K_1412 X_NUC_7.L_CORE X_NUC_108.L_CORE 0.001474
K_1413 X_NUC_7.L_CORE X_NUC_109.L_CORE 0.001911
K_1414 X_NUC_7.L_CORE X_NUC_110.L_CORE 0.001904
K_1415 X_NUC_7.L_CORE X_NUC_111.L_CORE 0.001899
K_1416 X_NUC_7.L_CORE X_NUC_112.L_CORE 0.001895
K_1417 X_NUC_7.L_CORE X_NUC_113.L_CORE 0.001542
K_1418 X_NUC_7.L_CORE X_NUC_114.L_CORE 0.001548
K_1419 X_NUC_7.L_CORE X_NUC_115.L_CORE 0.001536
K_1420 X_NUC_7.L_CORE X_NUC_116.L_CORE 0.001542
K_1421 X_NUC_7.L_CORE X_NUC_117.L_CORE 0.001524
K_1422 X_NUC_7.L_CORE X_NUC_118.L_CORE 0.001528
K_1423 X_NUC_7.L_CORE X_NUC_119.L_CORE 0.001523
K_1424 X_NUC_7.L_CORE X_NUC_120.L_CORE 0.001517
K_1425 X_NUC_7.L_CORE X_NUC_121.L_CORE 0.001774
K_1426 X_NUC_7.L_CORE X_NUC_122.L_CORE 0.001770
K_1427 X_NUC_7.L_CORE X_NUC_123.L_CORE 0.001760
K_1428 X_NUC_7.L_CORE X_NUC_124.L_CORE 0.001764
K_1429 X_NUC_7.L_CORE X_NUC_125.L_CORE 0.001395
K_1430 X_NUC_7.L_CORE X_NUC_126.L_CORE 0.001402
K_1431 X_NUC_7.L_CORE X_NUC_127.L_CORE 0.001393
K_1432 X_NUC_7.L_CORE X_NUC_128.L_CORE 0.001394
K_1433 X_NUC_7.L_CORE X_NUC_129.L_CORE 0.001617
K_1434 X_NUC_7.L_CORE X_NUC_130.L_CORE 0.001616
K_1435 X_NUC_7.L_CORE X_NUC_131.L_CORE 0.001612
K_1436 X_NUC_7.L_CORE X_NUC_132.L_CORE 0.001606
K_1437 X_NUC_7.L_CORE X_NUC_133.L_CORE 0.001529
K_1438 X_NUC_7.L_CORE X_NUC_134.L_CORE 0.001530
K_1439 X_NUC_7.L_CORE X_NUC_135.L_CORE 0.001520
K_1440 X_NUC_7.L_CORE X_NUC_136.L_CORE 0.001525
K_1441 X_NUC_7.L_CORE X_NUC_137.L_CORE 0.001376
K_1442 X_NUC_7.L_CORE X_NUC_138.L_CORE 0.001381
K_1443 X_NUC_7.L_CORE X_NUC_139.L_CORE 0.001375
K_1444 X_NUC_7.L_CORE X_NUC_140.L_CORE 0.001372
K_1445 X_NUC_7.L_CORE X_NUC_141.L_CORE 0.001607
K_1446 X_NUC_7.L_CORE X_NUC_142.L_CORE 0.001604
K_1447 X_NUC_7.L_CORE X_NUC_143.L_CORE 0.001598
K_1448 X_NUC_7.L_CORE X_NUC_144.L_CORE 0.001597
K_1449 X_NUC_7.L_CORE X_NUC_145.L_CORE 0.001366
K_1450 X_NUC_7.L_CORE X_NUC_146.L_CORE 0.001371
K_1451 X_NUC_7.L_CORE X_NUC_147.L_CORE 0.001362
K_1452 X_NUC_7.L_CORE X_NUC_148.L_CORE 0.001364
K_1453 X_NUC_7.L_CORE X_NUC_149.L_CORE 0.001419
K_1454 X_NUC_7.L_CORE X_NUC_150.L_CORE 0.001421
K_1455 X_NUC_7.L_CORE X_NUC_151.L_CORE 0.001416
K_1456 X_NUC_7.L_CORE X_NUC_152.L_CORE 0.001412
K_1457 X_NUC_7.L_CORE X_NUC_153.L_CORE 0.001471
K_1458 X_NUC_7.L_CORE X_NUC_154.L_CORE 0.001471
K_1459 X_NUC_7.L_CORE X_NUC_155.L_CORE 0.001463
K_1460 X_NUC_7.L_CORE X_NUC_156.L_CORE 0.001465
K_1461 X_NUC_7.L_CORE X_NUC_157.L_CORE 0.001312
K_1462 X_NUC_7.L_CORE X_NUC_158.L_CORE 0.001316
K_1463 X_NUC_7.L_CORE X_NUC_159.L_CORE 0.001309
K_1464 X_NUC_7.L_CORE X_NUC_160.L_CORE 0.001309
K_1465 X_NUC_7.L_CORE X_NUC_161.L_CORE 0.001424
K_1466 X_NUC_7.L_CORE X_NUC_162.L_CORE 0.001424
K_1467 X_NUC_7.L_CORE X_NUC_163.L_CORE 0.001418
K_1468 X_NUC_7.L_CORE X_NUC_164.L_CORE 0.001417
K_1469 X_NUC_7.L_CORE X_NUC_165.L_CORE 0.001345
K_1470 X_NUC_7.L_CORE X_NUC_166.L_CORE 0.001347
K_1471 X_NUC_7.L_CORE X_NUC_167.L_CORE 0.001340
K_1472 X_NUC_7.L_CORE X_NUC_168.L_CORE 0.001341
K_1473 X_NUC_7.L_CORE X_NUC_169.L_CORE 0.001323
K_1474 X_NUC_7.L_CORE X_NUC_170.L_CORE 0.001325
K_1475 X_NUC_7.L_CORE X_NUC_171.L_CORE 0.001318
K_1476 X_NUC_7.L_CORE X_NUC_172.L_CORE 0.001318
K_1477 X_NUC_7.L_CORE X_NUC_173.L_CORE 0.004627
K_1478 X_NUC_7.L_CORE X_NUC_174.L_CORE 0.029153
K_1479 X_NUC_7.L_CORE X_NUC_175.L_CORE 0.003336
K_1480 X_NUC_7.L_CORE X_NUC_176.L_CORE 0.004067
K_1481 X_NUC_7.L_CORE X_NUC_177.L_CORE 0.005359
K_1482 X_NUC_7.L_CORE X_NUC_178.L_CORE 0.002496
K_1483 X_NUC_7.L_CORE X_NUC_179.L_CORE 0.005392
K_1484 X_NUC_7.L_CORE X_NUC_180.L_CORE 0.002751
K_1485 X_NUC_7.L_CORE X_NUC_181.L_CORE 0.002458
K_1486 X_NUC_7.L_CORE X_NUC_182.L_CORE 0.004532
K_1487 X_NUC_7.L_CORE X_NUC_183.L_CORE 0.002064
K_1488 X_NUC_7.L_CORE X_NUC_184.L_CORE 0.002901
K_1489 X_NUC_7.L_CORE X_NUC_185.L_CORE 0.002684
K_1490 X_NUC_7.L_CORE X_NUC_186.L_CORE 0.001913
K_1491 X_NUC_7.L_CORE X_NUC_187.L_CORE 0.003313
K_1492 X_NUC_7.L_CORE X_NUC_188.L_CORE 0.001936
K_1493 X_NUC_7.L_CORE X_NUC_189.L_CORE 0.002067
K_1494 X_NUC_7.L_CORE X_NUC_190.L_CORE 0.002642
K_1495 X_NUC_7.L_CORE X_NUC_191.L_CORE 0.001680
K_1496 X_NUC_7.L_CORE X_NUC_192.L_CORE 0.002398
K_1497 X_NUC_7.L_CORE X_NUC_193.L_CORE 0.001930
K_1498 X_NUC_7.L_CORE X_NUC_194.L_CORE 0.001684
K_1499 X_NUC_7.L_CORE X_NUC_195.L_CORE 0.002403
K_1500 X_NUC_7.L_CORE X_NUC_196.L_CORE 0.001591
K_1501 X_NUC_7.L_CORE X_NUC_197.L_CORE 0.001861
K_1502 X_NUC_7.L_CORE X_NUC_198.L_CORE 0.001945
K_1503 X_NUC_7.L_CORE X_NUC_199.L_CORE 0.001494
K_1504 X_NUC_7.L_CORE X_NUC_200.L_CORE 0.002029
K_1505 X_NUC_7.L_CORE X_NUC_201.L_CORE 0.001576
K_1506 X_NUC_7.L_CORE X_NUC_202.L_CORE 0.001558
K_1507 X_NUC_7.L_CORE X_NUC_203.L_CORE 0.001886
K_1508 X_NUC_7.L_CORE X_NUC_204.L_CORE 0.001409
K_1509 X_NUC_7.L_CORE X_NUC_205.L_CORE 0.001695
K_1510 X_NUC_7.L_CORE X_NUC_206.L_CORE 0.001585
K_1511 X_NUC_7.L_CORE X_NUC_207.L_CORE 0.001391
K_1512 X_NUC_7.L_CORE X_NUC_208.L_CORE 0.001724
K_1513 X_NUC_7.L_CORE X_NUC_209.L_CORE 0.001383
K_1514 X_NUC_7.L_CORE X_NUC_210.L_CORE 0.001464
K_1515 X_NUC_7.L_CORE X_NUC_211.L_CORE 0.001562
K_1516 X_NUC_7.L_CORE X_NUC_212.L_CORE 0.001308
K_1517 X_NUC_7.L_CORE X_NUC_213.L_CORE 0.001527
K_1518 X_NUC_7.L_CORE X_NUC_214.L_CORE 0.001377
K_1519 X_NUC_7.L_CORE X_NUC_215.L_CORE 0.001324
K_1520 X_NUC_7.L_CORE X_NUC_216.L_CORE 0.001474
K_1521 X_NUC_7.L_CORE X_NUC_217.L_CORE 0.001278
K_1522 X_NUC_7.L_CORE X_NUC_218.L_CORE 0.001364
K_1523 X_NUC_7.L_CORE X_NUC_219.L_CORE 0.001350
K_1524 X_NUC_7.L_CORE X_NUC_220.L_CORE 0.001260
K_1525 X_NUC_7.L_CORE X_NUC_221.L_CORE 0.001339
K_1526 X_NUC_7.L_CORE X_NUC_222.L_CORE 0.001271
K_1527 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.003304
K_1528 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.003353
K_1529 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.003317
K_1530 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.003336
K_1531 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.004104
K_1532 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.004142
K_1533 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.004151
K_1534 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.004080
K_1535 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.005112
K_1536 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.005115
K_1537 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.005031
K_1538 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.005151
K_1539 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.002476
K_1540 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.002505
K_1541 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.002489
K_1542 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.002485
K_1543 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.005244
K_1544 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.005178
K_1545 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.005217
K_1546 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.005123
K_1547 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.002679
K_1548 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.002701
K_1549 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.002670
K_1550 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.002696
K_1551 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.002440
K_1552 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.002460
K_1553 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.002454
K_1554 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.002434
K_1555 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.004214
K_1556 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.004159
K_1557 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.004131
K_1558 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.004172
K_1559 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.002032
K_1560 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.002051
K_1561 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.002035
K_1562 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.002039
K_1563 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.002840
K_1564 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.002838
K_1565 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.002842
K_1566 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.002809
K_1567 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.002572
K_1568 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.002576
K_1569 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.002549
K_1570 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.002576
K_1571 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.001891
K_1572 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.001906
K_1573 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.001897
K_1574 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.001891
K_1575 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.003120
K_1576 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.003089
K_1577 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.003086
K_1578 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.003076
K_1579 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.001891
K_1580 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.001903
K_1581 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.001887
K_1582 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.001896
K_1583 X_NUC_8.L_CORE X_NUC_65.L_CORE 0.002033
K_1584 X_NUC_8.L_CORE X_NUC_66.L_CORE 0.002040
K_1585 X_NUC_8.L_CORE X_NUC_67.L_CORE 0.002037
K_1586 X_NUC_8.L_CORE X_NUC_68.L_CORE 0.002022
K_1587 X_NUC_8.L_CORE X_NUC_69.L_CORE 0.002491
K_1588 X_NUC_8.L_CORE X_NUC_70.L_CORE 0.002480
K_1589 X_NUC_8.L_CORE X_NUC_71.L_CORE 0.002462
K_1590 X_NUC_8.L_CORE X_NUC_72.L_CORE 0.002480
K_1591 X_NUC_8.L_CORE X_NUC_73.L_CORE 0.001657
K_1592 X_NUC_8.L_CORE X_NUC_74.L_CORE 0.001669
K_1593 X_NUC_8.L_CORE X_NUC_75.L_CORE 0.001658
K_1594 X_NUC_8.L_CORE X_NUC_76.L_CORE 0.001658
K_1595 X_NUC_8.L_CORE X_NUC_77.L_CORE 0.002301
K_1596 X_NUC_8.L_CORE X_NUC_78.L_CORE 0.002292
K_1597 X_NUC_8.L_CORE X_NUC_79.L_CORE 0.002291
K_1598 X_NUC_8.L_CORE X_NUC_80.L_CORE 0.002276
K_1599 X_NUC_8.L_CORE X_NUC_81.L_CORE 0.001865
K_1600 X_NUC_8.L_CORE X_NUC_82.L_CORE 0.001870
K_1601 X_NUC_8.L_CORE X_NUC_83.L_CORE 0.001854
K_1602 X_NUC_8.L_CORE X_NUC_84.L_CORE 0.001866
K_1603 X_NUC_8.L_CORE X_NUC_85.L_CORE 0.001662
K_1604 X_NUC_8.L_CORE X_NUC_86.L_CORE 0.001670
K_1605 X_NUC_8.L_CORE X_NUC_87.L_CORE 0.001664
K_1606 X_NUC_8.L_CORE X_NUC_88.L_CORE 0.001657
K_1607 X_NUC_8.L_CORE X_NUC_89.L_CORE 0.002252
K_1608 X_NUC_8.L_CORE X_NUC_90.L_CORE 0.002239
K_1609 X_NUC_8.L_CORE X_NUC_91.L_CORE 0.002230
K_1610 X_NUC_8.L_CORE X_NUC_92.L_CORE 0.002233
K_1611 X_NUC_8.L_CORE X_NUC_93.L_CORE 0.001563
K_1612 X_NUC_8.L_CORE X_NUC_94.L_CORE 0.001571
K_1613 X_NUC_8.L_CORE X_NUC_95.L_CORE 0.001560
K_1614 X_NUC_8.L_CORE X_NUC_96.L_CORE 0.001564
K_1615 X_NUC_8.L_CORE X_NUC_97.L_CORE 0.001810
K_1616 X_NUC_8.L_CORE X_NUC_98.L_CORE 0.001811
K_1617 X_NUC_8.L_CORE X_NUC_99.L_CORE 0.001807
K_1618 X_NUC_8.L_CORE X_NUC_100.L_CORE 0.001797
K_1619 X_NUC_8.L_CORE X_NUC_101.L_CORE 0.001852
K_1620 X_NUC_8.L_CORE X_NUC_102.L_CORE 0.001851
K_1621 X_NUC_8.L_CORE X_NUC_103.L_CORE 0.001837
K_1622 X_NUC_8.L_CORE X_NUC_104.L_CORE 0.001847
K_1623 X_NUC_8.L_CORE X_NUC_105.L_CORE 0.001478
K_1624 X_NUC_8.L_CORE X_NUC_106.L_CORE 0.001486
K_1625 X_NUC_8.L_CORE X_NUC_107.L_CORE 0.001478
K_1626 X_NUC_8.L_CORE X_NUC_108.L_CORE 0.001476
K_1627 X_NUC_8.L_CORE X_NUC_109.L_CORE 0.001916
K_1628 X_NUC_8.L_CORE X_NUC_110.L_CORE 0.001909
K_1629 X_NUC_8.L_CORE X_NUC_111.L_CORE 0.001904
K_1630 X_NUC_8.L_CORE X_NUC_112.L_CORE 0.001899
K_1631 X_NUC_8.L_CORE X_NUC_113.L_CORE 0.001537
K_1632 X_NUC_8.L_CORE X_NUC_114.L_CORE 0.001542
K_1633 X_NUC_8.L_CORE X_NUC_115.L_CORE 0.001530
K_1634 X_NUC_8.L_CORE X_NUC_116.L_CORE 0.001536
K_1635 X_NUC_8.L_CORE X_NUC_117.L_CORE 0.001530
K_1636 X_NUC_8.L_CORE X_NUC_118.L_CORE 0.001534
K_1637 X_NUC_8.L_CORE X_NUC_119.L_CORE 0.001529
K_1638 X_NUC_8.L_CORE X_NUC_120.L_CORE 0.001523
K_1639 X_NUC_8.L_CORE X_NUC_121.L_CORE 0.001770
K_1640 X_NUC_8.L_CORE X_NUC_122.L_CORE 0.001765
K_1641 X_NUC_8.L_CORE X_NUC_123.L_CORE 0.001756
K_1642 X_NUC_8.L_CORE X_NUC_124.L_CORE 0.001760
K_1643 X_NUC_8.L_CORE X_NUC_125.L_CORE 0.001395
K_1644 X_NUC_8.L_CORE X_NUC_126.L_CORE 0.001401
K_1645 X_NUC_8.L_CORE X_NUC_127.L_CORE 0.001392
K_1646 X_NUC_8.L_CORE X_NUC_128.L_CORE 0.001393
K_1647 X_NUC_8.L_CORE X_NUC_129.L_CORE 0.001623
K_1648 X_NUC_8.L_CORE X_NUC_130.L_CORE 0.001622
K_1649 X_NUC_8.L_CORE X_NUC_131.L_CORE 0.001617
K_1650 X_NUC_8.L_CORE X_NUC_132.L_CORE 0.001612
K_1651 X_NUC_8.L_CORE X_NUC_133.L_CORE 0.001523
K_1652 X_NUC_8.L_CORE X_NUC_134.L_CORE 0.001525
K_1653 X_NUC_8.L_CORE X_NUC_135.L_CORE 0.001515
K_1654 X_NUC_8.L_CORE X_NUC_136.L_CORE 0.001520
K_1655 X_NUC_8.L_CORE X_NUC_137.L_CORE 0.001379
K_1656 X_NUC_8.L_CORE X_NUC_138.L_CORE 0.001384
K_1657 X_NUC_8.L_CORE X_NUC_139.L_CORE 0.001377
K_1658 X_NUC_8.L_CORE X_NUC_140.L_CORE 0.001375
K_1659 X_NUC_8.L_CORE X_NUC_141.L_CORE 0.001608
K_1660 X_NUC_8.L_CORE X_NUC_142.L_CORE 0.001605
K_1661 X_NUC_8.L_CORE X_NUC_143.L_CORE 0.001598
K_1662 X_NUC_8.L_CORE X_NUC_144.L_CORE 0.001598
K_1663 X_NUC_8.L_CORE X_NUC_145.L_CORE 0.001364
K_1664 X_NUC_8.L_CORE X_NUC_146.L_CORE 0.001368
K_1665 X_NUC_8.L_CORE X_NUC_147.L_CORE 0.001360
K_1666 X_NUC_8.L_CORE X_NUC_148.L_CORE 0.001362
K_1667 X_NUC_8.L_CORE X_NUC_149.L_CORE 0.001423
K_1668 X_NUC_8.L_CORE X_NUC_150.L_CORE 0.001425
K_1669 X_NUC_8.L_CORE X_NUC_151.L_CORE 0.001419
K_1670 X_NUC_8.L_CORE X_NUC_152.L_CORE 0.001416
K_1671 X_NUC_8.L_CORE X_NUC_153.L_CORE 0.001469
K_1672 X_NUC_8.L_CORE X_NUC_154.L_CORE 0.001468
K_1673 X_NUC_8.L_CORE X_NUC_155.L_CORE 0.001460
K_1674 X_NUC_8.L_CORE X_NUC_156.L_CORE 0.001463
K_1675 X_NUC_8.L_CORE X_NUC_157.L_CORE 0.001312
K_1676 X_NUC_8.L_CORE X_NUC_158.L_CORE 0.001316
K_1677 X_NUC_8.L_CORE X_NUC_159.L_CORE 0.001309
K_1678 X_NUC_8.L_CORE X_NUC_160.L_CORE 0.001309
K_1679 X_NUC_8.L_CORE X_NUC_161.L_CORE 0.001426
K_1680 X_NUC_8.L_CORE X_NUC_162.L_CORE 0.001426
K_1681 X_NUC_8.L_CORE X_NUC_163.L_CORE 0.001420
K_1682 X_NUC_8.L_CORE X_NUC_164.L_CORE 0.001418
K_1683 X_NUC_8.L_CORE X_NUC_165.L_CORE 0.001344
K_1684 X_NUC_8.L_CORE X_NUC_166.L_CORE 0.001346
K_1685 X_NUC_8.L_CORE X_NUC_167.L_CORE 0.001338
K_1686 X_NUC_8.L_CORE X_NUC_168.L_CORE 0.001340
K_1687 X_NUC_8.L_CORE X_NUC_169.L_CORE 0.001324
K_1688 X_NUC_8.L_CORE X_NUC_170.L_CORE 0.001326
K_1689 X_NUC_8.L_CORE X_NUC_171.L_CORE 0.001319
K_1690 X_NUC_8.L_CORE X_NUC_172.L_CORE 0.001318
K_1691 X_NUC_8.L_CORE X_NUC_173.L_CORE 0.004658
K_1692 X_NUC_8.L_CORE X_NUC_174.L_CORE 0.029150
K_1693 X_NUC_8.L_CORE X_NUC_175.L_CORE 0.003316
K_1694 X_NUC_8.L_CORE X_NUC_176.L_CORE 0.004139
K_1695 X_NUC_8.L_CORE X_NUC_177.L_CORE 0.005225
K_1696 X_NUC_8.L_CORE X_NUC_178.L_CORE 0.002501
K_1697 X_NUC_8.L_CORE X_NUC_179.L_CORE 0.005505
K_1698 X_NUC_8.L_CORE X_NUC_180.L_CORE 0.002724
K_1699 X_NUC_8.L_CORE X_NUC_181.L_CORE 0.002479
K_1700 X_NUC_8.L_CORE X_NUC_182.L_CORE 0.004479
K_1701 X_NUC_8.L_CORE X_NUC_183.L_CORE 0.002060
K_1702 X_NUC_8.L_CORE X_NUC_184.L_CORE 0.002939
K_1703 X_NUC_8.L_CORE X_NUC_185.L_CORE 0.002653
K_1704 X_NUC_8.L_CORE X_NUC_186.L_CORE 0.001920
K_1705 X_NUC_8.L_CORE X_NUC_187.L_CORE 0.003325
K_1706 X_NUC_8.L_CORE X_NUC_188.L_CORE 0.001925
K_1707 X_NUC_8.L_CORE X_NUC_189.L_CORE 0.002084
K_1708 X_NUC_8.L_CORE X_NUC_190.L_CORE 0.002619
K_1709 X_NUC_8.L_CORE X_NUC_191.L_CORE 0.001680
K_1710 X_NUC_8.L_CORE X_NUC_192.L_CORE 0.002417
K_1711 X_NUC_8.L_CORE X_NUC_193.L_CORE 0.001916
K_1712 X_NUC_8.L_CORE X_NUC_194.L_CORE 0.001692
K_1713 X_NUC_8.L_CORE X_NUC_195.L_CORE 0.002399
K_1714 X_NUC_8.L_CORE X_NUC_196.L_CORE 0.001587
K_1715 X_NUC_8.L_CORE X_NUC_197.L_CORE 0.001874
K_1716 X_NUC_8.L_CORE X_NUC_198.L_CORE 0.001933
K_1717 X_NUC_8.L_CORE X_NUC_199.L_CORE 0.001497
K_1718 X_NUC_8.L_CORE X_NUC_200.L_CORE 0.002036
K_1719 X_NUC_8.L_CORE X_NUC_201.L_CORE 0.001570
K_1720 X_NUC_8.L_CORE X_NUC_202.L_CORE 0.001565
K_1721 X_NUC_8.L_CORE X_NUC_203.L_CORE 0.001879
K_1722 X_NUC_8.L_CORE X_NUC_204.L_CORE 0.001408
K_1723 X_NUC_8.L_CORE X_NUC_205.L_CORE 0.001703
K_1724 X_NUC_8.L_CORE X_NUC_206.L_CORE 0.001578
K_1725 X_NUC_8.L_CORE X_NUC_207.L_CORE 0.001394
K_1726 X_NUC_8.L_CORE X_NUC_208.L_CORE 0.001725
K_1727 X_NUC_8.L_CORE X_NUC_209.L_CORE 0.001379
K_1728 X_NUC_8.L_CORE X_NUC_210.L_CORE 0.001469
K_1729 X_NUC_8.L_CORE X_NUC_211.L_CORE 0.001557
K_1730 X_NUC_8.L_CORE X_NUC_212.L_CORE 0.001309
K_1731 X_NUC_8.L_CORE X_NUC_213.L_CORE 0.001530
K_1732 X_NUC_8.L_CORE X_NUC_214.L_CORE 0.001374
K_1733 X_NUC_8.L_CORE X_NUC_215.L_CORE 0.001327
K_1734 X_NUC_8.L_CORE X_NUC_216.L_CORE 0.001473
K_1735 X_NUC_8.L_CORE X_NUC_217.L_CORE 0.001276
K_1736 X_NUC_8.L_CORE X_NUC_218.L_CORE 0.001366
K_1737 X_NUC_8.L_CORE X_NUC_219.L_CORE 0.001348
K_1738 X_NUC_8.L_CORE X_NUC_220.L_CORE 0.001261
K_1739 X_NUC_8.L_CORE X_NUC_221.L_CORE 0.001340
K_1740 X_NUC_8.L_CORE X_NUC_222.L_CORE 0.001271
K_1741 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_1742 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_1743 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_1744 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.002748
K_1745 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.002732
K_1746 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.002755
K_1747 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.002723
K_1748 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.003504
K_1749 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.003448
K_1750 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.003462
K_1751 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.003478
K_1752 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.004721
K_1753 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.004777
K_1754 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.004773
K_1755 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.004686
K_1756 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.002180
K_1757 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.002161
K_1758 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.002174
K_1759 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.002162
K_1760 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.005211
K_1761 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.005176
K_1762 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.005098
K_1763 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.005205
K_1764 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.002455
K_1765 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.002454
K_1766 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.002463
K_1767 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.002436
K_1768 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.002224
K_1769 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.002201
K_1770 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.002207
K_1771 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.002208
K_1772 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.004464
K_1773 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.004538
K_1774 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.004457
K_1775 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.004456
K_1776 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.001868
K_1777 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.001858
K_1778 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.001866
K_1779 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.001853
K_1780 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.002745
K_1781 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.002722
K_1782 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.002711
K_1783 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.002732
K_1784 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.002503
K_1785 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.002515
K_1786 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.002510
K_1787 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.002487
K_1788 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.001759
K_1789 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.001747
K_1790 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.001751
K_1791 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.001747
K_1792 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.003284
K_1793 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.003298
K_1794 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.003248
K_1795 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.003278
K_1796 X_NUC_9.L_CORE X_NUC_65.L_CORE 0.001792
K_1797 X_NUC_9.L_CORE X_NUC_66.L_CORE 0.001789
K_1798 X_NUC_9.L_CORE X_NUC_67.L_CORE 0.001792
K_1799 X_NUC_9.L_CORE X_NUC_68.L_CORE 0.001779
K_1800 X_NUC_9.L_CORE X_NUC_69.L_CORE 0.001947
K_1801 X_NUC_9.L_CORE X_NUC_70.L_CORE 0.001932
K_1802 X_NUC_9.L_CORE X_NUC_71.L_CORE 0.001930
K_1803 X_NUC_9.L_CORE X_NUC_72.L_CORE 0.001935
K_1804 X_NUC_9.L_CORE X_NUC_73.L_CORE 0.002548
K_1805 X_NUC_9.L_CORE X_NUC_74.L_CORE 0.002567
K_1806 X_NUC_9.L_CORE X_NUC_75.L_CORE 0.002546
K_1807 X_NUC_9.L_CORE X_NUC_76.L_CORE 0.002537
K_1808 X_NUC_9.L_CORE X_NUC_77.L_CORE 0.001565
K_1809 X_NUC_9.L_CORE X_NUC_78.L_CORE 0.001558
K_1810 X_NUC_9.L_CORE X_NUC_79.L_CORE 0.001561
K_1811 X_NUC_9.L_CORE X_NUC_80.L_CORE 0.001554
K_1812 X_NUC_9.L_CORE X_NUC_81.L_CORE 0.002324
K_1813 X_NUC_9.L_CORE X_NUC_82.L_CORE 0.002318
K_1814 X_NUC_9.L_CORE X_NUC_83.L_CORE 0.002300
K_1815 X_NUC_9.L_CORE X_NUC_84.L_CORE 0.002315
K_1816 X_NUC_9.L_CORE X_NUC_85.L_CORE 0.001822
K_1817 X_NUC_9.L_CORE X_NUC_86.L_CORE 0.001824
K_1818 X_NUC_9.L_CORE X_NUC_87.L_CORE 0.001822
K_1819 X_NUC_9.L_CORE X_NUC_88.L_CORE 0.001810
K_1820 X_NUC_9.L_CORE X_NUC_89.L_CORE 0.001590
K_1821 X_NUC_9.L_CORE X_NUC_90.L_CORE 0.001580
K_1822 X_NUC_9.L_CORE X_NUC_91.L_CORE 0.001581
K_1823 X_NUC_9.L_CORE X_NUC_92.L_CORE 0.001580
K_1824 X_NUC_9.L_CORE X_NUC_93.L_CORE 0.002338
K_1825 X_NUC_9.L_CORE X_NUC_94.L_CORE 0.002349
K_1826 X_NUC_9.L_CORE X_NUC_95.L_CORE 0.002324
K_1827 X_NUC_9.L_CORE X_NUC_96.L_CORE 0.002330
K_1828 X_NUC_9.L_CORE X_NUC_97.L_CORE 0.001502
K_1829 X_NUC_9.L_CORE X_NUC_98.L_CORE 0.001498
K_1830 X_NUC_9.L_CORE X_NUC_99.L_CORE 0.001499
K_1831 X_NUC_9.L_CORE X_NUC_100.L_CORE 0.001491
K_1832 X_NUC_9.L_CORE X_NUC_101.L_CORE 0.001785
K_1833 X_NUC_9.L_CORE X_NUC_102.L_CORE 0.001777
K_1834 X_NUC_9.L_CORE X_NUC_103.L_CORE 0.001770
K_1835 X_NUC_9.L_CORE X_NUC_104.L_CORE 0.001776
K_1836 X_NUC_9.L_CORE X_NUC_105.L_CORE 0.001861
K_1837 X_NUC_9.L_CORE X_NUC_106.L_CORE 0.001867
K_1838 X_NUC_9.L_CORE X_NUC_107.L_CORE 0.001858
K_1839 X_NUC_9.L_CORE X_NUC_108.L_CORE 0.001851
K_1840 X_NUC_9.L_CORE X_NUC_109.L_CORE 0.001423
K_1841 X_NUC_9.L_CORE X_NUC_110.L_CORE 0.001416
K_1842 X_NUC_9.L_CORE X_NUC_111.L_CORE 0.001417
K_1843 X_NUC_9.L_CORE X_NUC_112.L_CORE 0.001413
K_1844 X_NUC_9.L_CORE X_NUC_113.L_CORE 0.001956
K_1845 X_NUC_9.L_CORE X_NUC_114.L_CORE 0.001957
K_1846 X_NUC_9.L_CORE X_NUC_115.L_CORE 0.001941
K_1847 X_NUC_9.L_CORE X_NUC_116.L_CORE 0.001948
K_1848 X_NUC_9.L_CORE X_NUC_117.L_CORE 0.001505
K_1849 X_NUC_9.L_CORE X_NUC_118.L_CORE 0.001505
K_1850 X_NUC_9.L_CORE X_NUC_119.L_CORE 0.001503
K_1851 X_NUC_9.L_CORE X_NUC_120.L_CORE 0.001496
K_1852 X_NUC_9.L_CORE X_NUC_121.L_CORE 0.001497
K_1853 X_NUC_9.L_CORE X_NUC_122.L_CORE 0.001489
K_1854 X_NUC_9.L_CORE X_NUC_123.L_CORE 0.001487
K_1855 X_NUC_9.L_CORE X_NUC_124.L_CORE 0.001488
K_1856 X_NUC_9.L_CORE X_NUC_125.L_CORE 0.001802
K_1857 X_NUC_9.L_CORE X_NUC_126.L_CORE 0.001807
K_1858 X_NUC_9.L_CORE X_NUC_127.L_CORE 0.001795
K_1859 X_NUC_9.L_CORE X_NUC_128.L_CORE 0.001794
K_1860 X_NUC_9.L_CORE X_NUC_129.L_CORE 0.001357
K_1861 X_NUC_9.L_CORE X_NUC_130.L_CORE 0.001353
K_1862 X_NUC_9.L_CORE X_NUC_131.L_CORE 0.001353
K_1863 X_NUC_9.L_CORE X_NUC_132.L_CORE 0.001348
K_1864 X_NUC_9.L_CORE X_NUC_133.L_CORE 0.001625
K_1865 X_NUC_9.L_CORE X_NUC_134.L_CORE 0.001622
K_1866 X_NUC_9.L_CORE X_NUC_135.L_CORE 0.001614
K_1867 X_NUC_9.L_CORE X_NUC_136.L_CORE 0.001618
K_1868 X_NUC_9.L_CORE X_NUC_137.L_CORE 0.001518
K_1869 X_NUC_9.L_CORE X_NUC_138.L_CORE 0.001520
K_1870 X_NUC_9.L_CORE X_NUC_139.L_CORE 0.001515
K_1871 X_NUC_9.L_CORE X_NUC_140.L_CORE 0.001509
K_1872 X_NUC_9.L_CORE X_NUC_141.L_CORE 0.001351
K_1873 X_NUC_9.L_CORE X_NUC_142.L_CORE 0.001346
K_1874 X_NUC_9.L_CORE X_NUC_143.L_CORE 0.001345
K_1875 X_NUC_9.L_CORE X_NUC_144.L_CORE 0.001343
K_1876 X_NUC_9.L_CORE X_NUC_145.L_CORE 0.001626
K_1877 X_NUC_9.L_CORE X_NUC_146.L_CORE 0.001627
K_1878 X_NUC_9.L_CORE X_NUC_147.L_CORE 0.001617
K_1879 X_NUC_9.L_CORE X_NUC_148.L_CORE 0.001618
K_1880 X_NUC_9.L_CORE X_NUC_149.L_CORE 0.001346
K_1881 X_NUC_9.L_CORE X_NUC_150.L_CORE 0.001345
K_1882 X_NUC_9.L_CORE X_NUC_151.L_CORE 0.001343
K_1883 X_NUC_9.L_CORE X_NUC_152.L_CORE 0.001338
K_1884 X_NUC_9.L_CORE X_NUC_153.L_CORE 0.001413
K_1885 X_NUC_9.L_CORE X_NUC_154.L_CORE 0.001409
K_1886 X_NUC_9.L_CORE X_NUC_155.L_CORE 0.001405
K_1887 X_NUC_9.L_CORE X_NUC_156.L_CORE 0.001406
K_1888 X_NUC_9.L_CORE X_NUC_157.L_CORE 0.001470
K_1889 X_NUC_9.L_CORE X_NUC_158.L_CORE 0.001472
K_1890 X_NUC_9.L_CORE X_NUC_159.L_CORE 0.001465
K_1891 X_NUC_9.L_CORE X_NUC_160.L_CORE 0.001463
K_1892 X_NUC_9.L_CORE X_NUC_161.L_CORE 0.001302
K_1893 X_NUC_9.L_CORE X_NUC_162.L_CORE 0.001299
K_1894 X_NUC_9.L_CORE X_NUC_163.L_CORE 0.001297
K_1895 X_NUC_9.L_CORE X_NUC_164.L_CORE 0.001295
K_1896 X_NUC_9.L_CORE X_NUC_165.L_CORE 0.001418
K_1897 X_NUC_9.L_CORE X_NUC_166.L_CORE 0.001417
K_1898 X_NUC_9.L_CORE X_NUC_167.L_CORE 0.001411
K_1899 X_NUC_9.L_CORE X_NUC_168.L_CORE 0.001411
K_1900 X_NUC_9.L_CORE X_NUC_169.L_CORE 0.001342
K_1901 X_NUC_9.L_CORE X_NUC_170.L_CORE 0.001341
K_1902 X_NUC_9.L_CORE X_NUC_171.L_CORE 0.001337
K_1903 X_NUC_9.L_CORE X_NUC_172.L_CORE 0.001335
K_1904 X_NUC_9.L_CORE X_NUC_173.L_CORE 0.004929
K_1905 X_NUC_9.L_CORE X_NUC_174.L_CORE 0.003270
K_1906 X_NUC_9.L_CORE X_NUC_175.L_CORE 0.031114
K_1907 X_NUC_9.L_CORE X_NUC_176.L_CORE 0.002730
K_1908 X_NUC_9.L_CORE X_NUC_177.L_CORE 0.003482
K_1909 X_NUC_9.L_CORE X_NUC_178.L_CORE 0.004843
K_1910 X_NUC_9.L_CORE X_NUC_179.L_CORE 0.002173
K_1911 X_NUC_9.L_CORE X_NUC_180.L_CORE 0.005505
K_1912 X_NUC_9.L_CORE X_NUC_181.L_CORE 0.002477
K_1913 X_NUC_9.L_CORE X_NUC_182.L_CORE 0.002229
K_1914 X_NUC_9.L_CORE X_NUC_183.L_CORE 0.004903
K_1915 X_NUC_9.L_CORE X_NUC_184.L_CORE 0.001872
K_1916 X_NUC_9.L_CORE X_NUC_185.L_CORE 0.002822
K_1917 X_NUC_9.L_CORE X_NUC_186.L_CORE 0.002582
K_1918 X_NUC_9.L_CORE X_NUC_187.L_CORE 0.001764
K_1919 X_NUC_9.L_CORE X_NUC_188.L_CORE 0.003581
K_1920 X_NUC_9.L_CORE X_NUC_189.L_CORE 0.001809
K_1921 X_NUC_9.L_CORE X_NUC_190.L_CORE 0.001976
K_1922 X_NUC_9.L_CORE X_NUC_191.L_CORE 0.002715
K_1923 X_NUC_9.L_CORE X_NUC_192.L_CORE 0.001570
K_1924 X_NUC_9.L_CORE X_NUC_193.L_CORE 0.002453
K_1925 X_NUC_9.L_CORE X_NUC_194.L_CORE 0.001866
K_1926 X_NUC_9.L_CORE X_NUC_195.L_CORE 0.001601
K_1927 X_NUC_9.L_CORE X_NUC_196.L_CORE 0.002539
K_1928 X_NUC_9.L_CORE X_NUC_197.L_CORE 0.001510
K_1929 X_NUC_9.L_CORE X_NUC_198.L_CORE 0.001841
K_1930 X_NUC_9.L_CORE X_NUC_199.L_CORE 0.001952
K_1931 X_NUC_9.L_CORE X_NUC_200.L_CORE 0.001425
K_1932 X_NUC_9.L_CORE X_NUC_201.L_CORE 0.002103
K_1933 X_NUC_9.L_CORE X_NUC_202.L_CORE 0.001528
K_1934 X_NUC_9.L_CORE X_NUC_203.L_CORE 0.001517
K_1935 X_NUC_9.L_CORE X_NUC_204.L_CORE 0.001941
K_1936 X_NUC_9.L_CORE X_NUC_205.L_CORE 0.001355
K_1937 X_NUC_9.L_CORE X_NUC_206.L_CORE 0.001710
K_1938 X_NUC_9.L_CORE X_NUC_207.L_CORE 0.001573
K_1939 X_NUC_9.L_CORE X_NUC_208.L_CORE 0.001350
K_1940 X_NUC_9.L_CORE X_NUC_209.L_CORE 0.001773
K_1941 X_NUC_9.L_CORE X_NUC_210.L_CORE 0.001348
K_1942 X_NUC_9.L_CORE X_NUC_211.L_CORE 0.001452
K_1943 X_NUC_9.L_CORE X_NUC_212.L_CORE 0.001577
K_1944 X_NUC_9.L_CORE X_NUC_213.L_CORE 0.001276
K_1945 X_NUC_9.L_CORE X_NUC_214.L_CORE 0.001546
K_1946 X_NUC_9.L_CORE X_NUC_215.L_CORE 0.001364
K_1947 X_NUC_9.L_CORE X_NUC_216.L_CORE 0.001307
K_1948 X_NUC_9.L_CORE X_NUC_217.L_CORE 0.001489
K_1949 X_NUC_9.L_CORE X_NUC_218.L_CORE 0.001260
K_1950 X_NUC_9.L_CORE X_NUC_219.L_CORE 0.001363
K_1951 X_NUC_9.L_CORE X_NUC_220.L_CORE 0.001348
K_1952 X_NUC_9.L_CORE X_NUC_221.L_CORE 0.001256
K_1953 X_NUC_9.L_CORE X_NUC_222.L_CORE 0.001325
K_1954 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_1955 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_1956 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.002765
K_1957 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.002748
K_1958 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.002771
K_1959 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.002739
K_1960 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.003561
K_1961 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.003504
K_1962 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.003518
K_1963 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.003534
K_1964 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.004663
K_1965 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.004721
K_1966 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.004715
K_1967 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.004631
K_1968 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.002198
K_1969 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.002180
K_1970 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.002193
K_1971 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.002180
K_1972 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.005243
K_1973 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.005211
K_1974 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.005130
K_1975 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.005239
K_1976 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.002456
K_1977 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.002455
K_1978 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.002464
K_1979 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.002436
K_1980 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.002247
K_1981 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.002224
K_1982 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.002230
K_1983 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.002230
K_1984 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.004391
K_1985 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.004464
K_1986 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.004386
K_1987 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.004384
K_1988 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.001877
K_1989 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.001868
K_1990 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.001875
K_1991 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.001862
K_1992 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.002768
K_1993 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.002745
K_1994 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.002733
K_1995 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.002755
K_1996 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.002491
K_1997 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.002503
K_1998 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.002498
K_1999 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.002475
K_2000 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.001773
K_2001 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.001759
K_2002 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.001764
K_2003 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.001760
K_2004 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.003268
K_2005 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.003284
K_2006 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.003234
K_2007 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.003263
K_2008 X_NUC_10.L_CORE X_NUC_65.L_CORE 0.001794
K_2009 X_NUC_10.L_CORE X_NUC_66.L_CORE 0.001792
K_2010 X_NUC_10.L_CORE X_NUC_67.L_CORE 0.001795
K_2011 X_NUC_10.L_CORE X_NUC_68.L_CORE 0.001781
K_2012 X_NUC_10.L_CORE X_NUC_69.L_CORE 0.001961
K_2013 X_NUC_10.L_CORE X_NUC_70.L_CORE 0.001947
K_2014 X_NUC_10.L_CORE X_NUC_71.L_CORE 0.001945
K_2015 X_NUC_10.L_CORE X_NUC_72.L_CORE 0.001950
K_2016 X_NUC_10.L_CORE X_NUC_73.L_CORE 0.002528
K_2017 X_NUC_10.L_CORE X_NUC_74.L_CORE 0.002548
K_2018 X_NUC_10.L_CORE X_NUC_75.L_CORE 0.002527
K_2019 X_NUC_10.L_CORE X_NUC_76.L_CORE 0.002518
K_2020 X_NUC_10.L_CORE X_NUC_77.L_CORE 0.001573
K_2021 X_NUC_10.L_CORE X_NUC_78.L_CORE 0.001565
K_2022 X_NUC_10.L_CORE X_NUC_79.L_CORE 0.001569
K_2023 X_NUC_10.L_CORE X_NUC_80.L_CORE 0.001562
K_2024 X_NUC_10.L_CORE X_NUC_81.L_CORE 0.002330
K_2025 X_NUC_10.L_CORE X_NUC_82.L_CORE 0.002324
K_2026 X_NUC_10.L_CORE X_NUC_83.L_CORE 0.002306
K_2027 X_NUC_10.L_CORE X_NUC_84.L_CORE 0.002322
K_2028 X_NUC_10.L_CORE X_NUC_85.L_CORE 0.001819
K_2029 X_NUC_10.L_CORE X_NUC_86.L_CORE 0.001822
K_2030 X_NUC_10.L_CORE X_NUC_87.L_CORE 0.001819
K_2031 X_NUC_10.L_CORE X_NUC_88.L_CORE 0.001807
K_2032 X_NUC_10.L_CORE X_NUC_89.L_CORE 0.001600
K_2033 X_NUC_10.L_CORE X_NUC_90.L_CORE 0.001590
K_2034 X_NUC_10.L_CORE X_NUC_91.L_CORE 0.001591
K_2035 X_NUC_10.L_CORE X_NUC_92.L_CORE 0.001590
K_2036 X_NUC_10.L_CORE X_NUC_93.L_CORE 0.002326
K_2037 X_NUC_10.L_CORE X_NUC_94.L_CORE 0.002338
K_2038 X_NUC_10.L_CORE X_NUC_95.L_CORE 0.002313
K_2039 X_NUC_10.L_CORE X_NUC_96.L_CORE 0.002319
K_2040 X_NUC_10.L_CORE X_NUC_97.L_CORE 0.001505
K_2041 X_NUC_10.L_CORE X_NUC_98.L_CORE 0.001502
K_2042 X_NUC_10.L_CORE X_NUC_99.L_CORE 0.001503
K_2043 X_NUC_10.L_CORE X_NUC_100.L_CORE 0.001495
K_2044 X_NUC_10.L_CORE X_NUC_101.L_CORE 0.001794
K_2045 X_NUC_10.L_CORE X_NUC_102.L_CORE 0.001785
K_2046 X_NUC_10.L_CORE X_NUC_103.L_CORE 0.001779
K_2047 X_NUC_10.L_CORE X_NUC_104.L_CORE 0.001785
K_2048 X_NUC_10.L_CORE X_NUC_105.L_CORE 0.001854
K_2049 X_NUC_10.L_CORE X_NUC_106.L_CORE 0.001861
K_2050 X_NUC_10.L_CORE X_NUC_107.L_CORE 0.001852
K_2051 X_NUC_10.L_CORE X_NUC_108.L_CORE 0.001844
K_2052 X_NUC_10.L_CORE X_NUC_109.L_CORE 0.001429
K_2053 X_NUC_10.L_CORE X_NUC_110.L_CORE 0.001423
K_2054 X_NUC_10.L_CORE X_NUC_111.L_CORE 0.001423
K_2055 X_NUC_10.L_CORE X_NUC_112.L_CORE 0.001420
K_2056 X_NUC_10.L_CORE X_NUC_113.L_CORE 0.001955
K_2057 X_NUC_10.L_CORE X_NUC_114.L_CORE 0.001956
K_2058 X_NUC_10.L_CORE X_NUC_115.L_CORE 0.001940
K_2059 X_NUC_10.L_CORE X_NUC_116.L_CORE 0.001948
K_2060 X_NUC_10.L_CORE X_NUC_117.L_CORE 0.001506
K_2061 X_NUC_10.L_CORE X_NUC_118.L_CORE 0.001505
K_2062 X_NUC_10.L_CORE X_NUC_119.L_CORE 0.001504
K_2063 X_NUC_10.L_CORE X_NUC_120.L_CORE 0.001496
K_2064 X_NUC_10.L_CORE X_NUC_121.L_CORE 0.001504
K_2065 X_NUC_10.L_CORE X_NUC_122.L_CORE 0.001497
K_2066 X_NUC_10.L_CORE X_NUC_123.L_CORE 0.001494
K_2067 X_NUC_10.L_CORE X_NUC_124.L_CORE 0.001495
K_2068 X_NUC_10.L_CORE X_NUC_125.L_CORE 0.001796
K_2069 X_NUC_10.L_CORE X_NUC_126.L_CORE 0.001802
K_2070 X_NUC_10.L_CORE X_NUC_127.L_CORE 0.001789
K_2071 X_NUC_10.L_CORE X_NUC_128.L_CORE 0.001788
K_2072 X_NUC_10.L_CORE X_NUC_129.L_CORE 0.001361
K_2073 X_NUC_10.L_CORE X_NUC_130.L_CORE 0.001357
K_2074 X_NUC_10.L_CORE X_NUC_131.L_CORE 0.001357
K_2075 X_NUC_10.L_CORE X_NUC_132.L_CORE 0.001352
K_2076 X_NUC_10.L_CORE X_NUC_133.L_CORE 0.001629
K_2077 X_NUC_10.L_CORE X_NUC_134.L_CORE 0.001625
K_2078 X_NUC_10.L_CORE X_NUC_135.L_CORE 0.001617
K_2079 X_NUC_10.L_CORE X_NUC_136.L_CORE 0.001621
K_2080 X_NUC_10.L_CORE X_NUC_137.L_CORE 0.001516
K_2081 X_NUC_10.L_CORE X_NUC_138.L_CORE 0.001518
K_2082 X_NUC_10.L_CORE X_NUC_139.L_CORE 0.001513
K_2083 X_NUC_10.L_CORE X_NUC_140.L_CORE 0.001508
K_2084 X_NUC_10.L_CORE X_NUC_141.L_CORE 0.001357
K_2085 X_NUC_10.L_CORE X_NUC_142.L_CORE 0.001351
K_2086 X_NUC_10.L_CORE X_NUC_143.L_CORE 0.001350
K_2087 X_NUC_10.L_CORE X_NUC_144.L_CORE 0.001348
K_2088 X_NUC_10.L_CORE X_NUC_145.L_CORE 0.001625
K_2089 X_NUC_10.L_CORE X_NUC_146.L_CORE 0.001626
K_2090 X_NUC_10.L_CORE X_NUC_147.L_CORE 0.001616
K_2091 X_NUC_10.L_CORE X_NUC_148.L_CORE 0.001617
K_2092 X_NUC_10.L_CORE X_NUC_149.L_CORE 0.001348
K_2093 X_NUC_10.L_CORE X_NUC_150.L_CORE 0.001346
K_2094 X_NUC_10.L_CORE X_NUC_151.L_CORE 0.001344
K_2095 X_NUC_10.L_CORE X_NUC_152.L_CORE 0.001340
K_2096 X_NUC_10.L_CORE X_NUC_153.L_CORE 0.001417
K_2097 X_NUC_10.L_CORE X_NUC_154.L_CORE 0.001413
K_2098 X_NUC_10.L_CORE X_NUC_155.L_CORE 0.001409
K_2099 X_NUC_10.L_CORE X_NUC_156.L_CORE 0.001410
K_2100 X_NUC_10.L_CORE X_NUC_157.L_CORE 0.001469
K_2101 X_NUC_10.L_CORE X_NUC_158.L_CORE 0.001470
K_2102 X_NUC_10.L_CORE X_NUC_159.L_CORE 0.001464
K_2103 X_NUC_10.L_CORE X_NUC_160.L_CORE 0.001462
K_2104 X_NUC_10.L_CORE X_NUC_161.L_CORE 0.001305
K_2105 X_NUC_10.L_CORE X_NUC_162.L_CORE 0.001302
K_2106 X_NUC_10.L_CORE X_NUC_163.L_CORE 0.001300
K_2107 X_NUC_10.L_CORE X_NUC_164.L_CORE 0.001298
K_2108 X_NUC_10.L_CORE X_NUC_165.L_CORE 0.001420
K_2109 X_NUC_10.L_CORE X_NUC_166.L_CORE 0.001418
K_2110 X_NUC_10.L_CORE X_NUC_167.L_CORE 0.001412
K_2111 X_NUC_10.L_CORE X_NUC_168.L_CORE 0.001412
K_2112 X_NUC_10.L_CORE X_NUC_169.L_CORE 0.001344
K_2113 X_NUC_10.L_CORE X_NUC_170.L_CORE 0.001342
K_2114 X_NUC_10.L_CORE X_NUC_171.L_CORE 0.001338
K_2115 X_NUC_10.L_CORE X_NUC_172.L_CORE 0.001336
K_2116 X_NUC_10.L_CORE X_NUC_173.L_CORE 0.004975
K_2117 X_NUC_10.L_CORE X_NUC_174.L_CORE 0.003318
K_2118 X_NUC_10.L_CORE X_NUC_175.L_CORE 0.031004
K_2119 X_NUC_10.L_CORE X_NUC_176.L_CORE 0.002746
K_2120 X_NUC_10.L_CORE X_NUC_177.L_CORE 0.003539
K_2121 X_NUC_10.L_CORE X_NUC_178.L_CORE 0.004781
K_2122 X_NUC_10.L_CORE X_NUC_179.L_CORE 0.002192
K_2123 X_NUC_10.L_CORE X_NUC_180.L_CORE 0.005544
K_2124 X_NUC_10.L_CORE X_NUC_181.L_CORE 0.002477
K_2125 X_NUC_10.L_CORE X_NUC_182.L_CORE 0.002253
K_2126 X_NUC_10.L_CORE X_NUC_183.L_CORE 0.004804
K_2127 X_NUC_10.L_CORE X_NUC_184.L_CORE 0.001882
K_2128 X_NUC_10.L_CORE X_NUC_185.L_CORE 0.002848
K_2129 X_NUC_10.L_CORE X_NUC_186.L_CORE 0.002568
K_2130 X_NUC_10.L_CORE X_NUC_187.L_CORE 0.001778
K_2131 X_NUC_10.L_CORE X_NUC_188.L_CORE 0.003560
K_2132 X_NUC_10.L_CORE X_NUC_189.L_CORE 0.001812
K_2133 X_NUC_10.L_CORE X_NUC_190.L_CORE 0.001992
K_2134 X_NUC_10.L_CORE X_NUC_191.L_CORE 0.002690
K_2135 X_NUC_10.L_CORE X_NUC_192.L_CORE 0.001578
K_2136 X_NUC_10.L_CORE X_NUC_193.L_CORE 0.002460
K_2137 X_NUC_10.L_CORE X_NUC_194.L_CORE 0.001862
K_2138 X_NUC_10.L_CORE X_NUC_195.L_CORE 0.001612
K_2139 X_NUC_10.L_CORE X_NUC_196.L_CORE 0.002522
K_2140 X_NUC_10.L_CORE X_NUC_197.L_CORE 0.001514
K_2141 X_NUC_10.L_CORE X_NUC_198.L_CORE 0.001851
K_2142 X_NUC_10.L_CORE X_NUC_199.L_CORE 0.001943
K_2143 X_NUC_10.L_CORE X_NUC_200.L_CORE 0.001432
K_2144 X_NUC_10.L_CORE X_NUC_201.L_CORE 0.002102
K_2145 X_NUC_10.L_CORE X_NUC_202.L_CORE 0.001529
K_2146 X_NUC_10.L_CORE X_NUC_203.L_CORE 0.001526
K_2147 X_NUC_10.L_CORE X_NUC_204.L_CORE 0.001932
K_2148 X_NUC_10.L_CORE X_NUC_205.L_CORE 0.001359
K_2149 X_NUC_10.L_CORE X_NUC_206.L_CORE 0.001715
K_2150 X_NUC_10.L_CORE X_NUC_207.L_CORE 0.001571
K_2151 X_NUC_10.L_CORE X_NUC_208.L_CORE 0.001356
K_2152 X_NUC_10.L_CORE X_NUC_209.L_CORE 0.001769
K_2153 X_NUC_10.L_CORE X_NUC_210.L_CORE 0.001350
K_2154 X_NUC_10.L_CORE X_NUC_211.L_CORE 0.001457
K_2155 X_NUC_10.L_CORE X_NUC_212.L_CORE 0.001573
K_2156 X_NUC_10.L_CORE X_NUC_213.L_CORE 0.001280
K_2157 X_NUC_10.L_CORE X_NUC_214.L_CORE 0.001547
K_2158 X_NUC_10.L_CORE X_NUC_215.L_CORE 0.001364
K_2159 X_NUC_10.L_CORE X_NUC_216.L_CORE 0.001312
K_2160 X_NUC_10.L_CORE X_NUC_217.L_CORE 0.001488
K_2161 X_NUC_10.L_CORE X_NUC_218.L_CORE 0.001263
K_2162 X_NUC_10.L_CORE X_NUC_219.L_CORE 0.001365
K_2163 X_NUC_10.L_CORE X_NUC_220.L_CORE 0.001348
K_2164 X_NUC_10.L_CORE X_NUC_221.L_CORE 0.001259
K_2165 X_NUC_10.L_CORE X_NUC_222.L_CORE 0.001326
K_2166 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_2167 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.002741
K_2168 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.002725
K_2169 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.002748
K_2170 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.002716
K_2171 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.003545
K_2172 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.003488
K_2173 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.003504
K_2174 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.003519
K_2175 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.004668
K_2176 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.004724
K_2177 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.004721
K_2178 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.004635
K_2179 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.002185
K_2180 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.002167
K_2181 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.002180
K_2182 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.002167
K_2183 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.005328
K_2184 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.005292
K_2185 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.005211
K_2186 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.005323
K_2187 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.002447
K_2188 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.002446
K_2189 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.002455
K_2190 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.002428
K_2191 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.002240
K_2192 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.002217
K_2193 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.002224
K_2194 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.002224
K_2195 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.004469
K_2196 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.004544
K_2197 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.004464
K_2198 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.004462
K_2199 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.001869
K_2200 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.001860
K_2201 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.001868
K_2202 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.001855
K_2203 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.002780
K_2204 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.002757
K_2205 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.002745
K_2206 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.002767
K_2207 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.002496
K_2208 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.002508
K_2209 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.002503
K_2210 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.002480
K_2211 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.001768
K_2212 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.001755
K_2213 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.001759
K_2214 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.001755
K_2215 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.003319
K_2216 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.003335
K_2217 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.003284
K_2218 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.003314
K_2219 X_NUC_11.L_CORE X_NUC_65.L_CORE 0.001791
K_2220 X_NUC_11.L_CORE X_NUC_66.L_CORE 0.001788
K_2221 X_NUC_11.L_CORE X_NUC_67.L_CORE 0.001792
K_2222 X_NUC_11.L_CORE X_NUC_68.L_CORE 0.001778
K_2223 X_NUC_11.L_CORE X_NUC_69.L_CORE 0.001963
K_2224 X_NUC_11.L_CORE X_NUC_70.L_CORE 0.001948
K_2225 X_NUC_11.L_CORE X_NUC_71.L_CORE 0.001947
K_2226 X_NUC_11.L_CORE X_NUC_72.L_CORE 0.001952
K_2227 X_NUC_11.L_CORE X_NUC_73.L_CORE 0.002549
K_2228 X_NUC_11.L_CORE X_NUC_74.L_CORE 0.002569
K_2229 X_NUC_11.L_CORE X_NUC_75.L_CORE 0.002548
K_2230 X_NUC_11.L_CORE X_NUC_76.L_CORE 0.002538
K_2231 X_NUC_11.L_CORE X_NUC_77.L_CORE 0.001570
K_2232 X_NUC_11.L_CORE X_NUC_78.L_CORE 0.001562
K_2233 X_NUC_11.L_CORE X_NUC_79.L_CORE 0.001565
K_2234 X_NUC_11.L_CORE X_NUC_80.L_CORE 0.001559
K_2235 X_NUC_11.L_CORE X_NUC_81.L_CORE 0.002350
K_2236 X_NUC_11.L_CORE X_NUC_82.L_CORE 0.002343
K_2237 X_NUC_11.L_CORE X_NUC_83.L_CORE 0.002324
K_2238 X_NUC_11.L_CORE X_NUC_84.L_CORE 0.002341
K_2239 X_NUC_11.L_CORE X_NUC_85.L_CORE 0.001821
K_2240 X_NUC_11.L_CORE X_NUC_86.L_CORE 0.001824
K_2241 X_NUC_11.L_CORE X_NUC_87.L_CORE 0.001822
K_2242 X_NUC_11.L_CORE X_NUC_88.L_CORE 0.001810
K_2243 X_NUC_11.L_CORE X_NUC_89.L_CORE 0.001600
K_2244 X_NUC_11.L_CORE X_NUC_90.L_CORE 0.001590
K_2245 X_NUC_11.L_CORE X_NUC_91.L_CORE 0.001590
K_2246 X_NUC_11.L_CORE X_NUC_92.L_CORE 0.001589
K_2247 X_NUC_11.L_CORE X_NUC_93.L_CORE 0.002351
K_2248 X_NUC_11.L_CORE X_NUC_94.L_CORE 0.002363
K_2249 X_NUC_11.L_CORE X_NUC_95.L_CORE 0.002338
K_2250 X_NUC_11.L_CORE X_NUC_96.L_CORE 0.002343
K_2251 X_NUC_11.L_CORE X_NUC_97.L_CORE 0.001504
K_2252 X_NUC_11.L_CORE X_NUC_98.L_CORE 0.001500
K_2253 X_NUC_11.L_CORE X_NUC_99.L_CORE 0.001502
K_2254 X_NUC_11.L_CORE X_NUC_100.L_CORE 0.001494
K_2255 X_NUC_11.L_CORE X_NUC_101.L_CORE 0.001801
K_2256 X_NUC_11.L_CORE X_NUC_102.L_CORE 0.001792
K_2257 X_NUC_11.L_CORE X_NUC_103.L_CORE 0.001785
K_2258 X_NUC_11.L_CORE X_NUC_104.L_CORE 0.001791
K_2259 X_NUC_11.L_CORE X_NUC_105.L_CORE 0.001863
K_2260 X_NUC_11.L_CORE X_NUC_106.L_CORE 0.001870
K_2261 X_NUC_11.L_CORE X_NUC_107.L_CORE 0.001861
K_2262 X_NUC_11.L_CORE X_NUC_108.L_CORE 0.001853
K_2263 X_NUC_11.L_CORE X_NUC_109.L_CORE 0.001429
K_2264 X_NUC_11.L_CORE X_NUC_110.L_CORE 0.001422
K_2265 X_NUC_11.L_CORE X_NUC_111.L_CORE 0.001423
K_2266 X_NUC_11.L_CORE X_NUC_112.L_CORE 0.001419
K_2267 X_NUC_11.L_CORE X_NUC_113.L_CORE 0.001972
K_2268 X_NUC_11.L_CORE X_NUC_114.L_CORE 0.001972
K_2269 X_NUC_11.L_CORE X_NUC_115.L_CORE 0.001956
K_2270 X_NUC_11.L_CORE X_NUC_116.L_CORE 0.001964
K_2271 X_NUC_11.L_CORE X_NUC_117.L_CORE 0.001507
K_2272 X_NUC_11.L_CORE X_NUC_118.L_CORE 0.001507
K_2273 X_NUC_11.L_CORE X_NUC_119.L_CORE 0.001505
K_2274 X_NUC_11.L_CORE X_NUC_120.L_CORE 0.001498
K_2275 X_NUC_11.L_CORE X_NUC_121.L_CORE 0.001506
K_2276 X_NUC_11.L_CORE X_NUC_122.L_CORE 0.001499
K_2277 X_NUC_11.L_CORE X_NUC_123.L_CORE 0.001497
K_2278 X_NUC_11.L_CORE X_NUC_124.L_CORE 0.001497
K_2279 X_NUC_11.L_CORE X_NUC_125.L_CORE 0.001809
K_2280 X_NUC_11.L_CORE X_NUC_126.L_CORE 0.001814
K_2281 X_NUC_11.L_CORE X_NUC_127.L_CORE 0.001802
K_2282 X_NUC_11.L_CORE X_NUC_128.L_CORE 0.001801
K_2283 X_NUC_11.L_CORE X_NUC_129.L_CORE 0.001361
K_2284 X_NUC_11.L_CORE X_NUC_130.L_CORE 0.001357
K_2285 X_NUC_11.L_CORE X_NUC_131.L_CORE 0.001357
K_2286 X_NUC_11.L_CORE X_NUC_132.L_CORE 0.001352
K_2287 X_NUC_11.L_CORE X_NUC_133.L_CORE 0.001638
K_2288 X_NUC_11.L_CORE X_NUC_134.L_CORE 0.001634
K_2289 X_NUC_11.L_CORE X_NUC_135.L_CORE 0.001625
K_2290 X_NUC_11.L_CORE X_NUC_136.L_CORE 0.001630
K_2291 X_NUC_11.L_CORE X_NUC_137.L_CORE 0.001521
K_2292 X_NUC_11.L_CORE X_NUC_138.L_CORE 0.001523
K_2293 X_NUC_11.L_CORE X_NUC_139.L_CORE 0.001518
K_2294 X_NUC_11.L_CORE X_NUC_140.L_CORE 0.001513
K_2295 X_NUC_11.L_CORE X_NUC_141.L_CORE 0.001358
K_2296 X_NUC_11.L_CORE X_NUC_142.L_CORE 0.001353
K_2297 X_NUC_11.L_CORE X_NUC_143.L_CORE 0.001351
K_2298 X_NUC_11.L_CORE X_NUC_144.L_CORE 0.001350
K_2299 X_NUC_11.L_CORE X_NUC_145.L_CORE 0.001635
K_2300 X_NUC_11.L_CORE X_NUC_146.L_CORE 0.001636
K_2301 X_NUC_11.L_CORE X_NUC_147.L_CORE 0.001626
K_2302 X_NUC_11.L_CORE X_NUC_148.L_CORE 0.001628
K_2303 X_NUC_11.L_CORE X_NUC_149.L_CORE 0.001350
K_2304 X_NUC_11.L_CORE X_NUC_150.L_CORE 0.001349
K_2305 X_NUC_11.L_CORE X_NUC_151.L_CORE 0.001346
K_2306 X_NUC_11.L_CORE X_NUC_152.L_CORE 0.001342
K_2307 X_NUC_11.L_CORE X_NUC_153.L_CORE 0.001422
K_2308 X_NUC_11.L_CORE X_NUC_154.L_CORE 0.001418
K_2309 X_NUC_11.L_CORE X_NUC_155.L_CORE 0.001413
K_2310 X_NUC_11.L_CORE X_NUC_156.L_CORE 0.001414
K_2311 X_NUC_11.L_CORE X_NUC_157.L_CORE 0.001476
K_2312 X_NUC_11.L_CORE X_NUC_158.L_CORE 0.001477
K_2313 X_NUC_11.L_CORE X_NUC_159.L_CORE 0.001470
K_2314 X_NUC_11.L_CORE X_NUC_160.L_CORE 0.001468
K_2315 X_NUC_11.L_CORE X_NUC_161.L_CORE 0.001308
K_2316 X_NUC_11.L_CORE X_NUC_162.L_CORE 0.001305
K_2317 X_NUC_11.L_CORE X_NUC_163.L_CORE 0.001302
K_2318 X_NUC_11.L_CORE X_NUC_164.L_CORE 0.001300
K_2319 X_NUC_11.L_CORE X_NUC_165.L_CORE 0.001426
K_2320 X_NUC_11.L_CORE X_NUC_166.L_CORE 0.001425
K_2321 X_NUC_11.L_CORE X_NUC_167.L_CORE 0.001418
K_2322 X_NUC_11.L_CORE X_NUC_168.L_CORE 0.001419
K_2323 X_NUC_11.L_CORE X_NUC_169.L_CORE 0.001348
K_2324 X_NUC_11.L_CORE X_NUC_170.L_CORE 0.001347
K_2325 X_NUC_11.L_CORE X_NUC_171.L_CORE 0.001342
K_2326 X_NUC_11.L_CORE X_NUC_172.L_CORE 0.001340
K_2327 X_NUC_11.L_CORE X_NUC_173.L_CORE 0.004875
K_2328 X_NUC_11.L_CORE X_NUC_174.L_CORE 0.003278
K_2329 X_NUC_11.L_CORE X_NUC_175.L_CORE 0.028134
K_2330 X_NUC_11.L_CORE X_NUC_176.L_CORE 0.002721
K_2331 X_NUC_11.L_CORE X_NUC_177.L_CORE 0.003518
K_2332 X_NUC_11.L_CORE X_NUC_178.L_CORE 0.004772
K_2333 X_NUC_11.L_CORE X_NUC_179.L_CORE 0.002177
K_2334 X_NUC_11.L_CORE X_NUC_180.L_CORE 0.005623
K_2335 X_NUC_11.L_CORE X_NUC_181.L_CORE 0.002466
K_2336 X_NUC_11.L_CORE X_NUC_182.L_CORE 0.002245
K_2337 X_NUC_11.L_CORE X_NUC_183.L_CORE 0.004891
K_2338 X_NUC_11.L_CORE X_NUC_184.L_CORE 0.001873
K_2339 X_NUC_11.L_CORE X_NUC_185.L_CORE 0.002858
K_2340 X_NUC_11.L_CORE X_NUC_186.L_CORE 0.002570
K_2341 X_NUC_11.L_CORE X_NUC_187.L_CORE 0.001772
K_2342 X_NUC_11.L_CORE X_NUC_188.L_CORE 0.003620
K_2343 X_NUC_11.L_CORE X_NUC_189.L_CORE 0.001808
K_2344 X_NUC_11.L_CORE X_NUC_190.L_CORE 0.001993
K_2345 X_NUC_11.L_CORE X_NUC_191.L_CORE 0.002712
K_2346 X_NUC_11.L_CORE X_NUC_192.L_CORE 0.001574
K_2347 X_NUC_11.L_CORE X_NUC_193.L_CORE 0.002480
K_2348 X_NUC_11.L_CORE X_NUC_194.L_CORE 0.001863
K_2349 X_NUC_11.L_CORE X_NUC_195.L_CORE 0.001611
K_2350 X_NUC_11.L_CORE X_NUC_196.L_CORE 0.002552
K_2351 X_NUC_11.L_CORE X_NUC_197.L_CORE 0.001512
K_2352 X_NUC_11.L_CORE X_NUC_198.L_CORE 0.001857
K_2353 X_NUC_11.L_CORE X_NUC_199.L_CORE 0.001952
K_2354 X_NUC_11.L_CORE X_NUC_200.L_CORE 0.001430
K_2355 X_NUC_11.L_CORE X_NUC_201.L_CORE 0.002121
K_2356 X_NUC_11.L_CORE X_NUC_202.L_CORE 0.001529
K_2357 X_NUC_11.L_CORE X_NUC_203.L_CORE 0.001527
K_2358 X_NUC_11.L_CORE X_NUC_204.L_CORE 0.001947
K_2359 X_NUC_11.L_CORE X_NUC_205.L_CORE 0.001359
K_2360 X_NUC_11.L_CORE X_NUC_206.L_CORE 0.001724
K_2361 X_NUC_11.L_CORE X_NUC_207.L_CORE 0.001575
K_2362 X_NUC_11.L_CORE X_NUC_208.L_CORE 0.001357
K_2363 X_NUC_11.L_CORE X_NUC_209.L_CORE 0.001783
K_2364 X_NUC_11.L_CORE X_NUC_210.L_CORE 0.001351
K_2365 X_NUC_11.L_CORE X_NUC_211.L_CORE 0.001462
K_2366 X_NUC_11.L_CORE X_NUC_212.L_CORE 0.001581
K_2367 X_NUC_11.L_CORE X_NUC_213.L_CORE 0.001281
K_2368 X_NUC_11.L_CORE X_NUC_214.L_CORE 0.001556
K_2369 X_NUC_11.L_CORE X_NUC_215.L_CORE 0.001367
K_2370 X_NUC_11.L_CORE X_NUC_216.L_CORE 0.001314
K_2371 X_NUC_11.L_CORE X_NUC_217.L_CORE 0.001496
K_2372 X_NUC_11.L_CORE X_NUC_218.L_CORE 0.001265
K_2373 X_NUC_11.L_CORE X_NUC_219.L_CORE 0.001371
K_2374 X_NUC_11.L_CORE X_NUC_220.L_CORE 0.001352
K_2375 X_NUC_11.L_CORE X_NUC_221.L_CORE 0.001262
K_2376 X_NUC_11.L_CORE X_NUC_222.L_CORE 0.001331
K_2377 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.002774
K_2378 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.002757
K_2379 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.002781
K_2380 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.002748
K_2381 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.003529
K_2382 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.003473
K_2383 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.003487
K_2384 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.003504
K_2385 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.004754
K_2386 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.004813
K_2387 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.004808
K_2388 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.004721
K_2389 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.002198
K_2390 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.002179
K_2391 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.002192
K_2392 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.002180
K_2393 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.005214
K_2394 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.005180
K_2395 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.005102
K_2396 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.005211
K_2397 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.002475
K_2398 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.002474
K_2399 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.002483
K_2400 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.002455
K_2401 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.002239
K_2402 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.002216
K_2403 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.002223
K_2404 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.002224
K_2405 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.004470
K_2406 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.004546
K_2407 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.004464
K_2408 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.004464
K_2409 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.001882
K_2410 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.001873
K_2411 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.001881
K_2412 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.001868
K_2413 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.002758
K_2414 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.002735
K_2415 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.002723
K_2416 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.002745
K_2417 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.002519
K_2418 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.002531
K_2419 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.002526
K_2420 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.002503
K_2421 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.001772
K_2422 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.001759
K_2423 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.001764
K_2424 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.001759
K_2425 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.003289
K_2426 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.003304
K_2427 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.003254
K_2428 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.003284
K_2429 X_NUC_12.L_CORE X_NUC_65.L_CORE 0.001805
K_2430 X_NUC_12.L_CORE X_NUC_66.L_CORE 0.001802
K_2431 X_NUC_12.L_CORE X_NUC_67.L_CORE 0.001805
K_2432 X_NUC_12.L_CORE X_NUC_68.L_CORE 0.001792
K_2433 X_NUC_12.L_CORE X_NUC_69.L_CORE 0.001958
K_2434 X_NUC_12.L_CORE X_NUC_70.L_CORE 0.001943
K_2435 X_NUC_12.L_CORE X_NUC_71.L_CORE 0.001942
K_2436 X_NUC_12.L_CORE X_NUC_72.L_CORE 0.001947
K_2437 X_NUC_12.L_CORE X_NUC_73.L_CORE 0.002559
K_2438 X_NUC_12.L_CORE X_NUC_74.L_CORE 0.002578
K_2439 X_NUC_12.L_CORE X_NUC_75.L_CORE 0.002557
K_2440 X_NUC_12.L_CORE X_NUC_76.L_CORE 0.002548
K_2441 X_NUC_12.L_CORE X_NUC_77.L_CORE 0.001577
K_2442 X_NUC_12.L_CORE X_NUC_78.L_CORE 0.001569
K_2443 X_NUC_12.L_CORE X_NUC_79.L_CORE 0.001572
K_2444 X_NUC_12.L_CORE X_NUC_80.L_CORE 0.001565
K_2445 X_NUC_12.L_CORE X_NUC_81.L_CORE 0.002333
K_2446 X_NUC_12.L_CORE X_NUC_82.L_CORE 0.002327
K_2447 X_NUC_12.L_CORE X_NUC_83.L_CORE 0.002308
K_2448 X_NUC_12.L_CORE X_NUC_84.L_CORE 0.002324
K_2449 X_NUC_12.L_CORE X_NUC_85.L_CORE 0.001833
K_2450 X_NUC_12.L_CORE X_NUC_86.L_CORE 0.001836
K_2451 X_NUC_12.L_CORE X_NUC_87.L_CORE 0.001834
K_2452 X_NUC_12.L_CORE X_NUC_88.L_CORE 0.001822
K_2453 X_NUC_12.L_CORE X_NUC_89.L_CORE 0.001601
K_2454 X_NUC_12.L_CORE X_NUC_90.L_CORE 0.001591
K_2455 X_NUC_12.L_CORE X_NUC_91.L_CORE 0.001591
K_2456 X_NUC_12.L_CORE X_NUC_92.L_CORE 0.001590
K_2457 X_NUC_12.L_CORE X_NUC_93.L_CORE 0.002345
K_2458 X_NUC_12.L_CORE X_NUC_94.L_CORE 0.002357
K_2459 X_NUC_12.L_CORE X_NUC_95.L_CORE 0.002332
K_2460 X_NUC_12.L_CORE X_NUC_96.L_CORE 0.002338
K_2461 X_NUC_12.L_CORE X_NUC_97.L_CORE 0.001512
K_2462 X_NUC_12.L_CORE X_NUC_98.L_CORE 0.001508
K_2463 X_NUC_12.L_CORE X_NUC_99.L_CORE 0.001509
K_2464 X_NUC_12.L_CORE X_NUC_100.L_CORE 0.001502
K_2465 X_NUC_12.L_CORE X_NUC_101.L_CORE 0.001795
K_2466 X_NUC_12.L_CORE X_NUC_102.L_CORE 0.001786
K_2467 X_NUC_12.L_CORE X_NUC_103.L_CORE 0.001779
K_2468 X_NUC_12.L_CORE X_NUC_104.L_CORE 0.001785
K_2469 X_NUC_12.L_CORE X_NUC_105.L_CORE 0.001871
K_2470 X_NUC_12.L_CORE X_NUC_106.L_CORE 0.001877
K_2471 X_NUC_12.L_CORE X_NUC_107.L_CORE 0.001868
K_2472 X_NUC_12.L_CORE X_NUC_108.L_CORE 0.001861
K_2473 X_NUC_12.L_CORE X_NUC_109.L_CORE 0.001432
K_2474 X_NUC_12.L_CORE X_NUC_110.L_CORE 0.001426
K_2475 X_NUC_12.L_CORE X_NUC_111.L_CORE 0.001426
K_2476 X_NUC_12.L_CORE X_NUC_112.L_CORE 0.001423
K_2477 X_NUC_12.L_CORE X_NUC_113.L_CORE 0.001964
K_2478 X_NUC_12.L_CORE X_NUC_114.L_CORE 0.001964
K_2479 X_NUC_12.L_CORE X_NUC_115.L_CORE 0.001948
K_2480 X_NUC_12.L_CORE X_NUC_116.L_CORE 0.001956
K_2481 X_NUC_12.L_CORE X_NUC_117.L_CORE 0.001515
K_2482 X_NUC_12.L_CORE X_NUC_118.L_CORE 0.001514
K_2483 X_NUC_12.L_CORE X_NUC_119.L_CORE 0.001513
K_2484 X_NUC_12.L_CORE X_NUC_120.L_CORE 0.001505
K_2485 X_NUC_12.L_CORE X_NUC_121.L_CORE 0.001505
K_2486 X_NUC_12.L_CORE X_NUC_122.L_CORE 0.001498
K_2487 X_NUC_12.L_CORE X_NUC_123.L_CORE 0.001496
K_2488 X_NUC_12.L_CORE X_NUC_124.L_CORE 0.001497
K_2489 X_NUC_12.L_CORE X_NUC_125.L_CORE 0.001810
K_2490 X_NUC_12.L_CORE X_NUC_126.L_CORE 0.001816
K_2491 X_NUC_12.L_CORE X_NUC_127.L_CORE 0.001803
K_2492 X_NUC_12.L_CORE X_NUC_128.L_CORE 0.001802
K_2493 X_NUC_12.L_CORE X_NUC_129.L_CORE 0.001366
K_2494 X_NUC_12.L_CORE X_NUC_130.L_CORE 0.001362
K_2495 X_NUC_12.L_CORE X_NUC_131.L_CORE 0.001362
K_2496 X_NUC_12.L_CORE X_NUC_132.L_CORE 0.001357
K_2497 X_NUC_12.L_CORE X_NUC_133.L_CORE 0.001633
K_2498 X_NUC_12.L_CORE X_NUC_134.L_CORE 0.001630
K_2499 X_NUC_12.L_CORE X_NUC_135.L_CORE 0.001621
K_2500 X_NUC_12.L_CORE X_NUC_136.L_CORE 0.001625
K_2501 X_NUC_12.L_CORE X_NUC_137.L_CORE 0.001527
K_2502 X_NUC_12.L_CORE X_NUC_138.L_CORE 0.001528
K_2503 X_NUC_12.L_CORE X_NUC_139.L_CORE 0.001523
K_2504 X_NUC_12.L_CORE X_NUC_140.L_CORE 0.001518
K_2505 X_NUC_12.L_CORE X_NUC_141.L_CORE 0.001360
K_2506 X_NUC_12.L_CORE X_NUC_142.L_CORE 0.001355
K_2507 X_NUC_12.L_CORE X_NUC_143.L_CORE 0.001353
K_2508 X_NUC_12.L_CORE X_NUC_144.L_CORE 0.001351
K_2509 X_NUC_12.L_CORE X_NUC_145.L_CORE 0.001633
K_2510 X_NUC_12.L_CORE X_NUC_146.L_CORE 0.001635
K_2511 X_NUC_12.L_CORE X_NUC_147.L_CORE 0.001624
K_2512 X_NUC_12.L_CORE X_NUC_148.L_CORE 0.001626
K_2513 X_NUC_12.L_CORE X_NUC_149.L_CORE 0.001355
K_2514 X_NUC_12.L_CORE X_NUC_150.L_CORE 0.001353
K_2515 X_NUC_12.L_CORE X_NUC_151.L_CORE 0.001351
K_2516 X_NUC_12.L_CORE X_NUC_152.L_CORE 0.001346
K_2517 X_NUC_12.L_CORE X_NUC_153.L_CORE 0.001421
K_2518 X_NUC_12.L_CORE X_NUC_154.L_CORE 0.001417
K_2519 X_NUC_12.L_CORE X_NUC_155.L_CORE 0.001412
K_2520 X_NUC_12.L_CORE X_NUC_156.L_CORE 0.001413
K_2521 X_NUC_12.L_CORE X_NUC_157.L_CORE 0.001478
K_2522 X_NUC_12.L_CORE X_NUC_158.L_CORE 0.001479
K_2523 X_NUC_12.L_CORE X_NUC_159.L_CORE 0.001473
K_2524 X_NUC_12.L_CORE X_NUC_160.L_CORE 0.001470
K_2525 X_NUC_12.L_CORE X_NUC_161.L_CORE 0.001310
K_2526 X_NUC_12.L_CORE X_NUC_162.L_CORE 0.001307
K_2527 X_NUC_12.L_CORE X_NUC_163.L_CORE 0.001305
K_2528 X_NUC_12.L_CORE X_NUC_164.L_CORE 0.001302
K_2529 X_NUC_12.L_CORE X_NUC_165.L_CORE 0.001426
K_2530 X_NUC_12.L_CORE X_NUC_166.L_CORE 0.001424
K_2531 X_NUC_12.L_CORE X_NUC_167.L_CORE 0.001418
K_2532 X_NUC_12.L_CORE X_NUC_168.L_CORE 0.001418
K_2533 X_NUC_12.L_CORE X_NUC_169.L_CORE 0.001350
K_2534 X_NUC_12.L_CORE X_NUC_170.L_CORE 0.001349
K_2535 X_NUC_12.L_CORE X_NUC_171.L_CORE 0.001345
K_2536 X_NUC_12.L_CORE X_NUC_172.L_CORE 0.001342
K_2537 X_NUC_12.L_CORE X_NUC_173.L_CORE 0.004975
K_2538 X_NUC_12.L_CORE X_NUC_174.L_CORE 0.003297
K_2539 X_NUC_12.L_CORE X_NUC_175.L_CORE 0.028066
K_2540 X_NUC_12.L_CORE X_NUC_176.L_CORE 0.002753
K_2541 X_NUC_12.L_CORE X_NUC_177.L_CORE 0.003502
K_2542 X_NUC_12.L_CORE X_NUC_178.L_CORE 0.004864
K_2543 X_NUC_12.L_CORE X_NUC_179.L_CORE 0.002190
K_2544 X_NUC_12.L_CORE X_NUC_180.L_CORE 0.005486
K_2545 X_NUC_12.L_CORE X_NUC_181.L_CORE 0.002495
K_2546 X_NUC_12.L_CORE X_NUC_182.L_CORE 0.002244
K_2547 X_NUC_12.L_CORE X_NUC_183.L_CORE 0.004892
K_2548 X_NUC_12.L_CORE X_NUC_184.L_CORE 0.001887
K_2549 X_NUC_12.L_CORE X_NUC_185.L_CORE 0.002832
K_2550 X_NUC_12.L_CORE X_NUC_186.L_CORE 0.002597
K_2551 X_NUC_12.L_CORE X_NUC_187.L_CORE 0.001777
K_2552 X_NUC_12.L_CORE X_NUC_188.L_CORE 0.003578
K_2553 X_NUC_12.L_CORE X_NUC_189.L_CORE 0.001822
K_2554 X_NUC_12.L_CORE X_NUC_190.L_CORE 0.001987
K_2555 X_NUC_12.L_CORE X_NUC_191.L_CORE 0.002723
K_2556 X_NUC_12.L_CORE X_NUC_192.L_CORE 0.001581
K_2557 X_NUC_12.L_CORE X_NUC_193.L_CORE 0.002459
K_2558 X_NUC_12.L_CORE X_NUC_194.L_CORE 0.001877
K_2559 X_NUC_12.L_CORE X_NUC_195.L_CORE 0.001612
K_2560 X_NUC_12.L_CORE X_NUC_196.L_CORE 0.002544
K_2561 X_NUC_12.L_CORE X_NUC_197.L_CORE 0.001521
K_2562 X_NUC_12.L_CORE X_NUC_198.L_CORE 0.001849
K_2563 X_NUC_12.L_CORE X_NUC_199.L_CORE 0.001962
K_2564 X_NUC_12.L_CORE X_NUC_200.L_CORE 0.001434
K_2565 X_NUC_12.L_CORE X_NUC_201.L_CORE 0.002110
K_2566 X_NUC_12.L_CORE X_NUC_202.L_CORE 0.001538
K_2567 X_NUC_12.L_CORE X_NUC_203.L_CORE 0.001526
K_2568 X_NUC_12.L_CORE X_NUC_204.L_CORE 0.001948
K_2569 X_NUC_12.L_CORE X_NUC_205.L_CORE 0.001364
K_2570 X_NUC_12.L_CORE X_NUC_206.L_CORE 0.001718
K_2571 X_NUC_12.L_CORE X_NUC_207.L_CORE 0.001582
K_2572 X_NUC_12.L_CORE X_NUC_208.L_CORE 0.001358
K_2573 X_NUC_12.L_CORE X_NUC_209.L_CORE 0.001779
K_2574 X_NUC_12.L_CORE X_NUC_210.L_CORE 0.001356
K_2575 X_NUC_12.L_CORE X_NUC_211.L_CORE 0.001459
K_2576 X_NUC_12.L_CORE X_NUC_212.L_CORE 0.001584
K_2577 X_NUC_12.L_CORE X_NUC_213.L_CORE 0.001284
K_2578 X_NUC_12.L_CORE X_NUC_214.L_CORE 0.001553
K_2579 X_NUC_12.L_CORE X_NUC_215.L_CORE 0.001372
K_2580 X_NUC_12.L_CORE X_NUC_216.L_CORE 0.001315
K_2581 X_NUC_12.L_CORE X_NUC_217.L_CORE 0.001496
K_2582 X_NUC_12.L_CORE X_NUC_218.L_CORE 0.001268
K_2583 X_NUC_12.L_CORE X_NUC_219.L_CORE 0.001370
K_2584 X_NUC_12.L_CORE X_NUC_220.L_CORE 0.001355
K_2585 X_NUC_12.L_CORE X_NUC_221.L_CORE 0.001263
K_2586 X_NUC_12.L_CORE X_NUC_222.L_CORE 0.001331
K_2587 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_2588 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_2589 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_2590 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.002408
K_2591 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.002400
K_2592 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.002390
K_2593 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.002416
K_2594 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.003135
K_2595 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.003176
K_2596 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.003140
K_2597 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.003163
K_2598 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.004370
K_2599 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.004287
K_2600 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.004299
K_2601 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.004327
K_2602 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.001981
K_2603 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.001986
K_2604 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.001973
K_2605 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.001991
K_2606 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.005182
K_2607 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.005288
K_2608 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.005214
K_2609 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.005167
K_2610 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.002283
K_2611 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.002268
K_2612 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.002262
K_2613 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.002280
K_2614 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.002074
K_2615 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.002088
K_2616 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.002070
K_2617 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.002084
K_2618 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.004664
K_2619 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.004601
K_2620 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.004606
K_2621 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.004563
K_2622 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.001749
K_2623 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.001747
K_2624 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.001738
K_2625 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.001752
K_2626 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.002676
K_2627 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.002707
K_2628 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.002679
K_2629 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.002680
K_2630 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.002433
K_2631 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.002410
K_2632 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.002407
K_2633 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.002417
K_2634 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.001667
K_2635 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.001672
K_2636 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.001660
K_2637 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.001671
K_2638 X_NUC_13.L_CORE X_NUC_65.L_CORE 0.003444
K_2639 X_NUC_13.L_CORE X_NUC_66.L_CORE 0.003455
K_2640 X_NUC_13.L_CORE X_NUC_67.L_CORE 0.003433
K_2641 X_NUC_13.L_CORE X_NUC_68.L_CORE 0.003402
K_2642 X_NUC_13.L_CORE X_NUC_69.L_CORE 0.001715
K_2643 X_NUC_13.L_CORE X_NUC_70.L_CORE 0.001708
K_2644 X_NUC_13.L_CORE X_NUC_71.L_CORE 0.001702
K_2645 X_NUC_13.L_CORE X_NUC_72.L_CORE 0.001713
K_2646 X_NUC_13.L_CORE X_NUC_73.L_CORE 0.001886
K_2647 X_NUC_13.L_CORE X_NUC_74.L_CORE 0.001900
K_2648 X_NUC_13.L_CORE X_NUC_75.L_CORE 0.001883
K_2649 X_NUC_13.L_CORE X_NUC_76.L_CORE 0.001890
K_2650 X_NUC_13.L_CORE X_NUC_77.L_CORE 0.002589
K_2651 X_NUC_13.L_CORE X_NUC_78.L_CORE 0.002568
K_2652 X_NUC_13.L_CORE X_NUC_79.L_CORE 0.002564
K_2653 X_NUC_13.L_CORE X_NUC_80.L_CORE 0.002560
K_2654 X_NUC_13.L_CORE X_NUC_81.L_CORE 0.001500
K_2655 X_NUC_13.L_CORE X_NUC_82.L_CORE 0.001501
K_2656 X_NUC_13.L_CORE X_NUC_83.L_CORE 0.001492
K_2657 X_NUC_13.L_CORE X_NUC_84.L_CORE 0.001502
K_2658 X_NUC_13.L_CORE X_NUC_85.L_CORE 0.002353
K_2659 X_NUC_13.L_CORE X_NUC_86.L_CORE 0.002369
K_2660 X_NUC_13.L_CORE X_NUC_87.L_CORE 0.002350
K_2661 X_NUC_13.L_CORE X_NUC_88.L_CORE 0.002344
K_2662 X_NUC_13.L_CORE X_NUC_89.L_CORE 0.001785
K_2663 X_NUC_13.L_CORE X_NUC_90.L_CORE 0.001775
K_2664 X_NUC_13.L_CORE X_NUC_91.L_CORE 0.001770
K_2665 X_NUC_13.L_CORE X_NUC_92.L_CORE 0.001777
K_2666 X_NUC_13.L_CORE X_NUC_93.L_CORE 0.001542
K_2667 X_NUC_13.L_CORE X_NUC_94.L_CORE 0.001548
K_2668 X_NUC_13.L_CORE X_NUC_95.L_CORE 0.001536
K_2669 X_NUC_13.L_CORE X_NUC_96.L_CORE 0.001544
K_2670 X_NUC_13.L_CORE X_NUC_97.L_CORE 0.002417
K_2671 X_NUC_13.L_CORE X_NUC_98.L_CORE 0.002412
K_2672 X_NUC_13.L_CORE X_NUC_99.L_CORE 0.002402
K_2673 X_NUC_13.L_CORE X_NUC_100.L_CORE 0.002392
K_2674 X_NUC_13.L_CORE X_NUC_101.L_CORE 0.001457
K_2675 X_NUC_13.L_CORE X_NUC_102.L_CORE 0.001455
K_2676 X_NUC_13.L_CORE X_NUC_103.L_CORE 0.001448
K_2677 X_NUC_13.L_CORE X_NUC_104.L_CORE 0.001456
K_2678 X_NUC_13.L_CORE X_NUC_105.L_CORE 0.001773
K_2679 X_NUC_13.L_CORE X_NUC_106.L_CORE 0.001784
K_2680 X_NUC_13.L_CORE X_NUC_107.L_CORE 0.001770
K_2681 X_NUC_13.L_CORE X_NUC_108.L_CORE 0.001772
K_2682 X_NUC_13.L_CORE X_NUC_109.L_CORE 0.001867
K_2683 X_NUC_13.L_CORE X_NUC_110.L_CORE 0.001857
K_2684 X_NUC_13.L_CORE X_NUC_111.L_CORE 0.001852
K_2685 X_NUC_13.L_CORE X_NUC_112.L_CORE 0.001854
K_2686 X_NUC_13.L_CORE X_NUC_113.L_CORE 0.001386
K_2687 X_NUC_13.L_CORE X_NUC_114.L_CORE 0.001388
K_2688 X_NUC_13.L_CORE X_NUC_115.L_CORE 0.001380
K_2689 X_NUC_13.L_CORE X_NUC_116.L_CORE 0.001386
K_2690 X_NUC_13.L_CORE X_NUC_117.L_CORE 0.001996
K_2691 X_NUC_13.L_CORE X_NUC_118.L_CORE 0.002001
K_2692 X_NUC_13.L_CORE X_NUC_119.L_CORE 0.001989
K_2693 X_NUC_13.L_CORE X_NUC_120.L_CORE 0.001984
K_2694 X_NUC_13.L_CORE X_NUC_121.L_CORE 0.001483
K_2695 X_NUC_13.L_CORE X_NUC_122.L_CORE 0.001478
K_2696 X_NUC_13.L_CORE X_NUC_123.L_CORE 0.001472
K_2697 X_NUC_13.L_CORE X_NUC_124.L_CORE 0.001478
K_2698 X_NUC_13.L_CORE X_NUC_125.L_CORE 0.001477
K_2699 X_NUC_13.L_CORE X_NUC_126.L_CORE 0.001483
K_2700 X_NUC_13.L_CORE X_NUC_127.L_CORE 0.001473
K_2701 X_NUC_13.L_CORE X_NUC_128.L_CORE 0.001477
K_2702 X_NUC_13.L_CORE X_NUC_129.L_CORE 0.001830
K_2703 X_NUC_13.L_CORE X_NUC_130.L_CORE 0.001825
K_2704 X_NUC_13.L_CORE X_NUC_131.L_CORE 0.001818
K_2705 X_NUC_13.L_CORE X_NUC_132.L_CORE 0.001816
K_2706 X_NUC_13.L_CORE X_NUC_133.L_CORE 0.001334
K_2707 X_NUC_13.L_CORE X_NUC_134.L_CORE 0.001334
K_2708 X_NUC_13.L_CORE X_NUC_135.L_CORE 0.001326
K_2709 X_NUC_13.L_CORE X_NUC_136.L_CORE 0.001332
K_2710 X_NUC_13.L_CORE X_NUC_137.L_CORE 0.001633
K_2711 X_NUC_13.L_CORE X_NUC_138.L_CORE 0.001639
K_2712 X_NUC_13.L_CORE X_NUC_139.L_CORE 0.001628
K_2713 X_NUC_13.L_CORE X_NUC_140.L_CORE 0.001628
K_2714 X_NUC_13.L_CORE X_NUC_141.L_CORE 0.001516
K_2715 X_NUC_13.L_CORE X_NUC_142.L_CORE 0.001512
K_2716 X_NUC_13.L_CORE X_NUC_143.L_CORE 0.001506
K_2717 X_NUC_13.L_CORE X_NUC_144.L_CORE 0.001509
K_2718 X_NUC_13.L_CORE X_NUC_145.L_CORE 0.001338
K_2719 X_NUC_13.L_CORE X_NUC_146.L_CORE 0.001341
K_2720 X_NUC_13.L_CORE X_NUC_147.L_CORE 0.001332
K_2721 X_NUC_13.L_CORE X_NUC_148.L_CORE 0.001337
K_2722 X_NUC_13.L_CORE X_NUC_149.L_CORE 0.001641
K_2723 X_NUC_13.L_CORE X_NUC_150.L_CORE 0.001641
K_2724 X_NUC_13.L_CORE X_NUC_151.L_CORE 0.001633
K_2725 X_NUC_13.L_CORE X_NUC_152.L_CORE 0.001632
K_2726 X_NUC_13.L_CORE X_NUC_153.L_CORE 0.001340
K_2727 X_NUC_13.L_CORE X_NUC_154.L_CORE 0.001338
K_2728 X_NUC_13.L_CORE X_NUC_155.L_CORE 0.001332
K_2729 X_NUC_13.L_CORE X_NUC_156.L_CORE 0.001336
K_2730 X_NUC_13.L_CORE X_NUC_157.L_CORE 0.001412
K_2731 X_NUC_13.L_CORE X_NUC_158.L_CORE 0.001416
K_2732 X_NUC_13.L_CORE X_NUC_159.L_CORE 0.001407
K_2733 X_NUC_13.L_CORE X_NUC_160.L_CORE 0.001409
K_2734 X_NUC_13.L_CORE X_NUC_161.L_CORE 0.001470
K_2735 X_NUC_13.L_CORE X_NUC_162.L_CORE 0.001469
K_2736 X_NUC_13.L_CORE X_NUC_163.L_CORE 0.001462
K_2737 X_NUC_13.L_CORE X_NUC_164.L_CORE 0.001463
K_2738 X_NUC_13.L_CORE X_NUC_165.L_CORE 0.001309
K_2739 X_NUC_13.L_CORE X_NUC_166.L_CORE 0.001310
K_2740 X_NUC_13.L_CORE X_NUC_167.L_CORE 0.001302
K_2741 X_NUC_13.L_CORE X_NUC_168.L_CORE 0.001306
K_2742 X_NUC_13.L_CORE X_NUC_169.L_CORE 0.001402
K_2743 X_NUC_13.L_CORE X_NUC_170.L_CORE 0.001403
K_2744 X_NUC_13.L_CORE X_NUC_171.L_CORE 0.001395
K_2745 X_NUC_13.L_CORE X_NUC_172.L_CORE 0.001397
K_2746 X_NUC_13.L_CORE X_NUC_173.L_CORE 0.005246
K_2747 X_NUC_13.L_CORE X_NUC_174.L_CORE 0.003956
K_2748 X_NUC_13.L_CORE X_NUC_175.L_CORE 0.002727
K_2749 X_NUC_13.L_CORE X_NUC_176.L_CORE 0.029845
K_2750 X_NUC_13.L_CORE X_NUC_177.L_CORE 0.002392
K_2751 X_NUC_13.L_CORE X_NUC_178.L_CORE 0.003153
K_2752 X_NUC_13.L_CORE X_NUC_179.L_CORE 0.004389
K_2753 X_NUC_13.L_CORE X_NUC_180.L_CORE 0.001981
K_2754 X_NUC_13.L_CORE X_NUC_181.L_CORE 0.005552
K_2755 X_NUC_13.L_CORE X_NUC_182.L_CORE 0.002287
K_2756 X_NUC_13.L_CORE X_NUC_183.L_CORE 0.002091
K_2757 X_NUC_13.L_CORE X_NUC_184.L_CORE 0.005082
K_2758 X_NUC_13.L_CORE X_NUC_185.L_CORE 0.001751
K_2759 X_NUC_13.L_CORE X_NUC_186.L_CORE 0.002773
K_2760 X_NUC_13.L_CORE X_NUC_187.L_CORE 0.002482
K_2761 X_NUC_13.L_CORE X_NUC_188.L_CORE 0.001674
K_2762 X_NUC_13.L_CORE X_NUC_189.L_CORE 0.003804
K_2763 X_NUC_13.L_CORE X_NUC_190.L_CORE 0.001723
K_2764 X_NUC_13.L_CORE X_NUC_191.L_CORE 0.001923
K_2765 X_NUC_13.L_CORE X_NUC_192.L_CORE 0.002743
K_2766 X_NUC_13.L_CORE X_NUC_193.L_CORE 0.001502
K_2767 X_NUC_13.L_CORE X_NUC_194.L_CORE 0.002505
K_2768 X_NUC_13.L_CORE X_NUC_195.L_CORE 0.001815
K_2769 X_NUC_13.L_CORE X_NUC_196.L_CORE 0.001554
K_2770 X_NUC_13.L_CORE X_NUC_197.L_CORE 0.002645
K_2771 X_NUC_13.L_CORE X_NUC_198.L_CORE 0.001459
K_2772 X_NUC_13.L_CORE X_NUC_199.L_CORE 0.001837
K_2773 X_NUC_13.L_CORE X_NUC_200.L_CORE 0.001951
K_2774 X_NUC_13.L_CORE X_NUC_201.L_CORE 0.001385
K_2775 X_NUC_13.L_CORE X_NUC_202.L_CORE 0.002169
K_2776 X_NUC_13.L_CORE X_NUC_203.L_CORE 0.001496
K_2777 X_NUC_13.L_CORE X_NUC_204.L_CORE 0.001499
K_2778 X_NUC_13.L_CORE X_NUC_205.L_CORE 0.001981
K_2779 X_NUC_13.L_CORE X_NUC_206.L_CORE 0.001324
K_2780 X_NUC_13.L_CORE X_NUC_207.L_CORE 0.001731
K_2781 X_NUC_13.L_CORE X_NUC_208.L_CORE 0.001566
K_2782 X_NUC_13.L_CORE X_NUC_209.L_CORE 0.001331
K_2783 X_NUC_13.L_CORE X_NUC_210.L_CORE 0.001813
K_2784 X_NUC_13.L_CORE X_NUC_211.L_CORE 0.001330
K_2785 X_NUC_13.L_CORE X_NUC_212.L_CORE 0.001453
K_2786 X_NUC_13.L_CORE X_NUC_213.L_CORE 0.001589
K_2787 X_NUC_13.L_CORE X_NUC_214.L_CORE 0.001263
K_2788 X_NUC_13.L_CORE X_NUC_215.L_CORE 0.001565
K_2789 X_NUC_13.L_CORE X_NUC_216.L_CORE 0.001360
K_2790 X_NUC_13.L_CORE X_NUC_217.L_CORE 0.001306
K_2791 X_NUC_13.L_CORE X_NUC_218.L_CORE 0.001500
K_2792 X_NUC_13.L_CORE X_NUC_219.L_CORE 0.001260
K_2793 X_NUC_13.L_CORE X_NUC_220.L_CORE 0.001368
K_2794 X_NUC_13.L_CORE X_NUC_221.L_CORE 0.001348
K_2795 X_NUC_13.L_CORE X_NUC_222.L_CORE 0.001276
K_2796 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_2797 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_2798 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.002415
K_2799 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.002408
K_2800 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.002397
K_2801 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.002424
K_2802 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.003094
K_2803 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.003135
K_2804 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.003099
K_2805 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.003121
K_2806 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.004456
K_2807 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.004370
K_2808 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.004382
K_2809 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.004411
K_2810 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.001977
K_2811 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.001981
K_2812 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.001968
K_2813 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.001986
K_2814 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.005079
K_2815 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.005182
K_2816 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.005110
K_2817 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.005067
K_2818 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.002298
K_2819 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.002283
K_2820 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.002277
K_2821 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.002296
K_2822 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.002059
K_2823 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.002074
K_2824 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.002056
K_2825 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.002070
K_2826 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.004728
K_2827 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.004664
K_2828 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.004668
K_2829 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.004623
K_2830 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.001750
K_2831 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.001749
K_2832 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.001740
K_2833 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.001754
K_2834 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.002646
K_2835 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.002676
K_2836 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.002649
K_2837 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.002650
K_2838 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.002456
K_2839 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.002433
K_2840 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.002430
K_2841 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.002440
K_2842 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.001661
K_2843 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.001667
K_2844 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.001655
K_2845 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.001666
K_2846 X_NUC_14.L_CORE X_NUC_65.L_CORE 0.003432
K_2847 X_NUC_14.L_CORE X_NUC_66.L_CORE 0.003444
K_2848 X_NUC_14.L_CORE X_NUC_67.L_CORE 0.003422
K_2849 X_NUC_14.L_CORE X_NUC_68.L_CORE 0.003391
K_2850 X_NUC_14.L_CORE X_NUC_69.L_CORE 0.001721
K_2851 X_NUC_14.L_CORE X_NUC_70.L_CORE 0.001715
K_2852 X_NUC_14.L_CORE X_NUC_71.L_CORE 0.001708
K_2853 X_NUC_14.L_CORE X_NUC_72.L_CORE 0.001719
K_2854 X_NUC_14.L_CORE X_NUC_73.L_CORE 0.001873
K_2855 X_NUC_14.L_CORE X_NUC_74.L_CORE 0.001886
K_2856 X_NUC_14.L_CORE X_NUC_75.L_CORE 0.001870
K_2857 X_NUC_14.L_CORE X_NUC_76.L_CORE 0.001877
K_2858 X_NUC_14.L_CORE X_NUC_77.L_CORE 0.002610
K_2859 X_NUC_14.L_CORE X_NUC_78.L_CORE 0.002589
K_2860 X_NUC_14.L_CORE X_NUC_79.L_CORE 0.002585
K_2861 X_NUC_14.L_CORE X_NUC_80.L_CORE 0.002581
K_2862 X_NUC_14.L_CORE X_NUC_81.L_CORE 0.001499
K_2863 X_NUC_14.L_CORE X_NUC_82.L_CORE 0.001500
K_2864 X_NUC_14.L_CORE X_NUC_83.L_CORE 0.001491
K_2865 X_NUC_14.L_CORE X_NUC_84.L_CORE 0.001501
K_2866 X_NUC_14.L_CORE X_NUC_85.L_CORE 0.002337
K_2867 X_NUC_14.L_CORE X_NUC_86.L_CORE 0.002353
K_2868 X_NUC_14.L_CORE X_NUC_87.L_CORE 0.002334
K_2869 X_NUC_14.L_CORE X_NUC_88.L_CORE 0.002328
K_2870 X_NUC_14.L_CORE X_NUC_89.L_CORE 0.001794
K_2871 X_NUC_14.L_CORE X_NUC_90.L_CORE 0.001785
K_2872 X_NUC_14.L_CORE X_NUC_91.L_CORE 0.001779
K_2873 X_NUC_14.L_CORE X_NUC_92.L_CORE 0.001787
K_2874 X_NUC_14.L_CORE X_NUC_93.L_CORE 0.001535
K_2875 X_NUC_14.L_CORE X_NUC_94.L_CORE 0.001542
K_2876 X_NUC_14.L_CORE X_NUC_95.L_CORE 0.001530
K_2877 X_NUC_14.L_CORE X_NUC_96.L_CORE 0.001538
K_2878 X_NUC_14.L_CORE X_NUC_97.L_CORE 0.002422
K_2879 X_NUC_14.L_CORE X_NUC_98.L_CORE 0.002417
K_2880 X_NUC_14.L_CORE X_NUC_99.L_CORE 0.002407
K_2881 X_NUC_14.L_CORE X_NUC_100.L_CORE 0.002397
K_2882 X_NUC_14.L_CORE X_NUC_101.L_CORE 0.001459
K_2883 X_NUC_14.L_CORE X_NUC_102.L_CORE 0.001457
K_2884 X_NUC_14.L_CORE X_NUC_103.L_CORE 0.001450
K_2885 X_NUC_14.L_CORE X_NUC_104.L_CORE 0.001458
K_2886 X_NUC_14.L_CORE X_NUC_105.L_CORE 0.001763
K_2887 X_NUC_14.L_CORE X_NUC_106.L_CORE 0.001773
K_2888 X_NUC_14.L_CORE X_NUC_107.L_CORE 0.001760
K_2889 X_NUC_14.L_CORE X_NUC_108.L_CORE 0.001762
K_2890 X_NUC_14.L_CORE X_NUC_109.L_CORE 0.001877
K_2891 X_NUC_14.L_CORE X_NUC_110.L_CORE 0.001867
K_2892 X_NUC_14.L_CORE X_NUC_111.L_CORE 0.001861
K_2893 X_NUC_14.L_CORE X_NUC_112.L_CORE 0.001864
K_2894 X_NUC_14.L_CORE X_NUC_113.L_CORE 0.001384
K_2895 X_NUC_14.L_CORE X_NUC_114.L_CORE 0.001386
K_2896 X_NUC_14.L_CORE X_NUC_115.L_CORE 0.001377
K_2897 X_NUC_14.L_CORE X_NUC_116.L_CORE 0.001384
K_2898 X_NUC_14.L_CORE X_NUC_117.L_CORE 0.001991
K_2899 X_NUC_14.L_CORE X_NUC_118.L_CORE 0.001996
K_2900 X_NUC_14.L_CORE X_NUC_119.L_CORE 0.001984
K_2901 X_NUC_14.L_CORE X_NUC_120.L_CORE 0.001979
K_2902 X_NUC_14.L_CORE X_NUC_121.L_CORE 0.001487
K_2903 X_NUC_14.L_CORE X_NUC_122.L_CORE 0.001483
K_2904 X_NUC_14.L_CORE X_NUC_123.L_CORE 0.001476
K_2905 X_NUC_14.L_CORE X_NUC_124.L_CORE 0.001482
K_2906 X_NUC_14.L_CORE X_NUC_125.L_CORE 0.001472
K_2907 X_NUC_14.L_CORE X_NUC_126.L_CORE 0.001477
K_2908 X_NUC_14.L_CORE X_NUC_127.L_CORE 0.001467
K_2909 X_NUC_14.L_CORE X_NUC_128.L_CORE 0.001471
K_2910 X_NUC_14.L_CORE X_NUC_129.L_CORE 0.001835
K_2911 X_NUC_14.L_CORE X_NUC_130.L_CORE 0.001830
K_2912 X_NUC_14.L_CORE X_NUC_131.L_CORE 0.001822
K_2913 X_NUC_14.L_CORE X_NUC_132.L_CORE 0.001821
K_2914 X_NUC_14.L_CORE X_NUC_133.L_CORE 0.001334
K_2915 X_NUC_14.L_CORE X_NUC_134.L_CORE 0.001334
K_2916 X_NUC_14.L_CORE X_NUC_135.L_CORE 0.001326
K_2917 X_NUC_14.L_CORE X_NUC_136.L_CORE 0.001332
K_2918 X_NUC_14.L_CORE X_NUC_137.L_CORE 0.001628
K_2919 X_NUC_14.L_CORE X_NUC_138.L_CORE 0.001633
K_2920 X_NUC_14.L_CORE X_NUC_139.L_CORE 0.001622
K_2921 X_NUC_14.L_CORE X_NUC_140.L_CORE 0.001623
K_2922 X_NUC_14.L_CORE X_NUC_141.L_CORE 0.001521
K_2923 X_NUC_14.L_CORE X_NUC_142.L_CORE 0.001516
K_2924 X_NUC_14.L_CORE X_NUC_143.L_CORE 0.001510
K_2925 X_NUC_14.L_CORE X_NUC_144.L_CORE 0.001513
K_2926 X_NUC_14.L_CORE X_NUC_145.L_CORE 0.001335
K_2927 X_NUC_14.L_CORE X_NUC_146.L_CORE 0.001338
K_2928 X_NUC_14.L_CORE X_NUC_147.L_CORE 0.001330
K_2929 X_NUC_14.L_CORE X_NUC_148.L_CORE 0.001334
K_2930 X_NUC_14.L_CORE X_NUC_149.L_CORE 0.001641
K_2931 X_NUC_14.L_CORE X_NUC_150.L_CORE 0.001641
K_2932 X_NUC_14.L_CORE X_NUC_151.L_CORE 0.001632
K_2933 X_NUC_14.L_CORE X_NUC_152.L_CORE 0.001631
K_2934 X_NUC_14.L_CORE X_NUC_153.L_CORE 0.001341
K_2935 X_NUC_14.L_CORE X_NUC_154.L_CORE 0.001340
K_2936 X_NUC_14.L_CORE X_NUC_155.L_CORE 0.001333
K_2937 X_NUC_14.L_CORE X_NUC_156.L_CORE 0.001337
K_2938 X_NUC_14.L_CORE X_NUC_157.L_CORE 0.001409
K_2939 X_NUC_14.L_CORE X_NUC_158.L_CORE 0.001412
K_2940 X_NUC_14.L_CORE X_NUC_159.L_CORE 0.001404
K_2941 X_NUC_14.L_CORE X_NUC_160.L_CORE 0.001406
K_2942 X_NUC_14.L_CORE X_NUC_161.L_CORE 0.001472
K_2943 X_NUC_14.L_CORE X_NUC_162.L_CORE 0.001470
K_2944 X_NUC_14.L_CORE X_NUC_163.L_CORE 0.001463
K_2945 X_NUC_14.L_CORE X_NUC_164.L_CORE 0.001465
K_2946 X_NUC_14.L_CORE X_NUC_165.L_CORE 0.001308
K_2947 X_NUC_14.L_CORE X_NUC_166.L_CORE 0.001309
K_2948 X_NUC_14.L_CORE X_NUC_167.L_CORE 0.001302
K_2949 X_NUC_14.L_CORE X_NUC_168.L_CORE 0.001305
K_2950 X_NUC_14.L_CORE X_NUC_169.L_CORE 0.001401
K_2951 X_NUC_14.L_CORE X_NUC_170.L_CORE 0.001402
K_2952 X_NUC_14.L_CORE X_NUC_171.L_CORE 0.001394
K_2953 X_NUC_14.L_CORE X_NUC_172.L_CORE 0.001396
K_2954 X_NUC_14.L_CORE X_NUC_173.L_CORE 0.005188
K_2955 X_NUC_14.L_CORE X_NUC_174.L_CORE 0.003990
K_2956 X_NUC_14.L_CORE X_NUC_175.L_CORE 0.002711
K_2957 X_NUC_14.L_CORE X_NUC_176.L_CORE 0.029872
K_2958 X_NUC_14.L_CORE X_NUC_177.L_CORE 0.002399
K_2959 X_NUC_14.L_CORE X_NUC_178.L_CORE 0.003112
K_2960 X_NUC_14.L_CORE X_NUC_179.L_CORE 0.004479
K_2961 X_NUC_14.L_CORE X_NUC_180.L_CORE 0.001977
K_2962 X_NUC_14.L_CORE X_NUC_181.L_CORE 0.005426
K_2963 X_NUC_14.L_CORE X_NUC_182.L_CORE 0.002303
K_2964 X_NUC_14.L_CORE X_NUC_183.L_CORE 0.002076
K_2965 X_NUC_14.L_CORE X_NUC_184.L_CORE 0.005169
K_2966 X_NUC_14.L_CORE X_NUC_185.L_CORE 0.001753
K_2967 X_NUC_14.L_CORE X_NUC_186.L_CORE 0.002739
K_2968 X_NUC_14.L_CORE X_NUC_187.L_CORE 0.002508
K_2969 X_NUC_14.L_CORE X_NUC_188.L_CORE 0.001668
K_2970 X_NUC_14.L_CORE X_NUC_189.L_CORE 0.003788
K_2971 X_NUC_14.L_CORE X_NUC_190.L_CORE 0.001729
K_2972 X_NUC_14.L_CORE X_NUC_191.L_CORE 0.001909
K_2973 X_NUC_14.L_CORE X_NUC_192.L_CORE 0.002770
K_2974 X_NUC_14.L_CORE X_NUC_193.L_CORE 0.001501
K_2975 X_NUC_14.L_CORE X_NUC_194.L_CORE 0.002484
K_2976 X_NUC_14.L_CORE X_NUC_195.L_CORE 0.001826
K_2977 X_NUC_14.L_CORE X_NUC_196.L_CORE 0.001547
K_2978 X_NUC_14.L_CORE X_NUC_197.L_CORE 0.002652
K_2979 X_NUC_14.L_CORE X_NUC_198.L_CORE 0.001462
K_2980 X_NUC_14.L_CORE X_NUC_199.L_CORE 0.001824
K_2981 X_NUC_14.L_CORE X_NUC_200.L_CORE 0.001963
K_2982 X_NUC_14.L_CORE X_NUC_201.L_CORE 0.001382
K_2983 X_NUC_14.L_CORE X_NUC_202.L_CORE 0.002162
K_2984 X_NUC_14.L_CORE X_NUC_203.L_CORE 0.001502
K_2985 X_NUC_14.L_CORE X_NUC_204.L_CORE 0.001492
K_2986 X_NUC_14.L_CORE X_NUC_205.L_CORE 0.001989
K_2987 X_NUC_14.L_CORE X_NUC_206.L_CORE 0.001325
K_2988 X_NUC_14.L_CORE X_NUC_207.L_CORE 0.001723
K_2989 X_NUC_14.L_CORE X_NUC_208.L_CORE 0.001572
K_2990 X_NUC_14.L_CORE X_NUC_209.L_CORE 0.001328
K_2991 X_NUC_14.L_CORE X_NUC_210.L_CORE 0.001813
K_2992 X_NUC_14.L_CORE X_NUC_211.L_CORE 0.001332
K_2993 X_NUC_14.L_CORE X_NUC_212.L_CORE 0.001448
K_2994 X_NUC_14.L_CORE X_NUC_213.L_CORE 0.001594
K_2995 X_NUC_14.L_CORE X_NUC_214.L_CORE 0.001262
K_2996 X_NUC_14.L_CORE X_NUC_215.L_CORE 0.001562
K_2997 X_NUC_14.L_CORE X_NUC_216.L_CORE 0.001363
K_2998 X_NUC_14.L_CORE X_NUC_217.L_CORE 0.001303
K_2999 X_NUC_14.L_CORE X_NUC_218.L_CORE 0.001501
K_3000 X_NUC_14.L_CORE X_NUC_219.L_CORE 0.001260
K_3001 X_NUC_14.L_CORE X_NUC_220.L_CORE 0.001366
K_3002 X_NUC_14.L_CORE X_NUC_221.L_CORE 0.001349
K_3003 X_NUC_14.L_CORE X_NUC_222.L_CORE 0.001275
K_3004 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_3005 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.002426
K_3006 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.002418
K_3007 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.002408
K_3008 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.002435
K_3009 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.003129
K_3010 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.003171
K_3011 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.003135
K_3012 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.003157
K_3013 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.004443
K_3014 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.004356
K_3015 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.004370
K_3016 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.004398
K_3017 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.001990
K_3018 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.001995
K_3019 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.001981
K_3020 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.002000
K_3021 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.005148
K_3022 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.005253
K_3023 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.005182
K_3024 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.005135
K_3025 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.002304
K_3026 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.002289
K_3027 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.002283
K_3028 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.002302
K_3029 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.002077
K_3030 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.002092
K_3031 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.002074
K_3032 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.002088
K_3033 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.004722
K_3034 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.004658
K_3035 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.004664
K_3036 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.004618
K_3037 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.001760
K_3038 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.001758
K_3039 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.001749
K_3040 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.001763
K_3041 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.002673
K_3042 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.002704
K_3043 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.002676
K_3044 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.002678
K_3045 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.002460
K_3046 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.002436
K_3047 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.002433
K_3048 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.002443
K_3049 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.001673
K_3050 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.001678
K_3051 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.001667
K_3052 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.001678
K_3053 X_NUC_15.L_CORE X_NUC_65.L_CORE 0.003454
K_3054 X_NUC_15.L_CORE X_NUC_66.L_CORE 0.003466
K_3055 X_NUC_15.L_CORE X_NUC_67.L_CORE 0.003444
K_3056 X_NUC_15.L_CORE X_NUC_68.L_CORE 0.003412
K_3057 X_NUC_15.L_CORE X_NUC_69.L_CORE 0.001728
K_3058 X_NUC_15.L_CORE X_NUC_70.L_CORE 0.001721
K_3059 X_NUC_15.L_CORE X_NUC_71.L_CORE 0.001715
K_3060 X_NUC_15.L_CORE X_NUC_72.L_CORE 0.001726
K_3061 X_NUC_15.L_CORE X_NUC_73.L_CORE 0.001889
K_3062 X_NUC_15.L_CORE X_NUC_74.L_CORE 0.001903
K_3063 X_NUC_15.L_CORE X_NUC_75.L_CORE 0.001886
K_3064 X_NUC_15.L_CORE X_NUC_76.L_CORE 0.001893
K_3065 X_NUC_15.L_CORE X_NUC_77.L_CORE 0.002615
K_3066 X_NUC_15.L_CORE X_NUC_78.L_CORE 0.002593
K_3067 X_NUC_15.L_CORE X_NUC_79.L_CORE 0.002589
K_3068 X_NUC_15.L_CORE X_NUC_80.L_CORE 0.002585
K_3069 X_NUC_15.L_CORE X_NUC_81.L_CORE 0.001508
K_3070 X_NUC_15.L_CORE X_NUC_82.L_CORE 0.001509
K_3071 X_NUC_15.L_CORE X_NUC_83.L_CORE 0.001500
K_3072 X_NUC_15.L_CORE X_NUC_84.L_CORE 0.001510
K_3073 X_NUC_15.L_CORE X_NUC_85.L_CORE 0.002356
K_3074 X_NUC_15.L_CORE X_NUC_86.L_CORE 0.002372
K_3075 X_NUC_15.L_CORE X_NUC_87.L_CORE 0.002353
K_3076 X_NUC_15.L_CORE X_NUC_88.L_CORE 0.002347
K_3077 X_NUC_15.L_CORE X_NUC_89.L_CORE 0.001800
K_3078 X_NUC_15.L_CORE X_NUC_90.L_CORE 0.001790
K_3079 X_NUC_15.L_CORE X_NUC_91.L_CORE 0.001785
K_3080 X_NUC_15.L_CORE X_NUC_92.L_CORE 0.001792
K_3081 X_NUC_15.L_CORE X_NUC_93.L_CORE 0.001546
K_3082 X_NUC_15.L_CORE X_NUC_94.L_CORE 0.001553
K_3083 X_NUC_15.L_CORE X_NUC_95.L_CORE 0.001542
K_3084 X_NUC_15.L_CORE X_NUC_96.L_CORE 0.001549
K_3085 X_NUC_15.L_CORE X_NUC_97.L_CORE 0.002433
K_3086 X_NUC_15.L_CORE X_NUC_98.L_CORE 0.002428
K_3087 X_NUC_15.L_CORE X_NUC_99.L_CORE 0.002417
K_3088 X_NUC_15.L_CORE X_NUC_100.L_CORE 0.002407
K_3089 X_NUC_15.L_CORE X_NUC_101.L_CORE 0.001466
K_3090 X_NUC_15.L_CORE X_NUC_102.L_CORE 0.001464
K_3091 X_NUC_15.L_CORE X_NUC_103.L_CORE 0.001457
K_3092 X_NUC_15.L_CORE X_NUC_104.L_CORE 0.001465
K_3093 X_NUC_15.L_CORE X_NUC_105.L_CORE 0.001777
K_3094 X_NUC_15.L_CORE X_NUC_106.L_CORE 0.001787
K_3095 X_NUC_15.L_CORE X_NUC_107.L_CORE 0.001773
K_3096 X_NUC_15.L_CORE X_NUC_108.L_CORE 0.001776
K_3097 X_NUC_15.L_CORE X_NUC_109.L_CORE 0.001883
K_3098 X_NUC_15.L_CORE X_NUC_110.L_CORE 0.001873
K_3099 X_NUC_15.L_CORE X_NUC_111.L_CORE 0.001867
K_3100 X_NUC_15.L_CORE X_NUC_112.L_CORE 0.001869
K_3101 X_NUC_15.L_CORE X_NUC_113.L_CORE 0.001392
K_3102 X_NUC_15.L_CORE X_NUC_114.L_CORE 0.001395
K_3103 X_NUC_15.L_CORE X_NUC_115.L_CORE 0.001386
K_3104 X_NUC_15.L_CORE X_NUC_116.L_CORE 0.001393
K_3105 X_NUC_15.L_CORE X_NUC_117.L_CORE 0.002004
K_3106 X_NUC_15.L_CORE X_NUC_118.L_CORE 0.002009
K_3107 X_NUC_15.L_CORE X_NUC_119.L_CORE 0.001996
K_3108 X_NUC_15.L_CORE X_NUC_120.L_CORE 0.001991
K_3109 X_NUC_15.L_CORE X_NUC_121.L_CORE 0.001493
K_3110 X_NUC_15.L_CORE X_NUC_122.L_CORE 0.001489
K_3111 X_NUC_15.L_CORE X_NUC_123.L_CORE 0.001483
K_3112 X_NUC_15.L_CORE X_NUC_124.L_CORE 0.001489
K_3113 X_NUC_15.L_CORE X_NUC_125.L_CORE 0.001482
K_3114 X_NUC_15.L_CORE X_NUC_126.L_CORE 0.001488
K_3115 X_NUC_15.L_CORE X_NUC_127.L_CORE 0.001477
K_3116 X_NUC_15.L_CORE X_NUC_128.L_CORE 0.001482
K_3117 X_NUC_15.L_CORE X_NUC_129.L_CORE 0.001842
K_3118 X_NUC_15.L_CORE X_NUC_130.L_CORE 0.001837
K_3119 X_NUC_15.L_CORE X_NUC_131.L_CORE 0.001830
K_3120 X_NUC_15.L_CORE X_NUC_132.L_CORE 0.001828
K_3121 X_NUC_15.L_CORE X_NUC_133.L_CORE 0.001341
K_3122 X_NUC_15.L_CORE X_NUC_134.L_CORE 0.001341
K_3123 X_NUC_15.L_CORE X_NUC_135.L_CORE 0.001334
K_3124 X_NUC_15.L_CORE X_NUC_136.L_CORE 0.001340
K_3125 X_NUC_15.L_CORE X_NUC_137.L_CORE 0.001639
K_3126 X_NUC_15.L_CORE X_NUC_138.L_CORE 0.001645
K_3127 X_NUC_15.L_CORE X_NUC_139.L_CORE 0.001633
K_3128 X_NUC_15.L_CORE X_NUC_140.L_CORE 0.001634
K_3129 X_NUC_15.L_CORE X_NUC_141.L_CORE 0.001527
K_3130 X_NUC_15.L_CORE X_NUC_142.L_CORE 0.001522
K_3131 X_NUC_15.L_CORE X_NUC_143.L_CORE 0.001516
K_3132 X_NUC_15.L_CORE X_NUC_144.L_CORE 0.001519
K_3133 X_NUC_15.L_CORE X_NUC_145.L_CORE 0.001344
K_3134 X_NUC_15.L_CORE X_NUC_146.L_CORE 0.001346
K_3135 X_NUC_15.L_CORE X_NUC_147.L_CORE 0.001338
K_3136 X_NUC_15.L_CORE X_NUC_148.L_CORE 0.001343
K_3137 X_NUC_15.L_CORE X_NUC_149.L_CORE 0.001649
K_3138 X_NUC_15.L_CORE X_NUC_150.L_CORE 0.001650
K_3139 X_NUC_15.L_CORE X_NUC_151.L_CORE 0.001641
K_3140 X_NUC_15.L_CORE X_NUC_152.L_CORE 0.001640
K_3141 X_NUC_15.L_CORE X_NUC_153.L_CORE 0.001348
K_3142 X_NUC_15.L_CORE X_NUC_154.L_CORE 0.001346
K_3143 X_NUC_15.L_CORE X_NUC_155.L_CORE 0.001340
K_3144 X_NUC_15.L_CORE X_NUC_156.L_CORE 0.001344
K_3145 X_NUC_15.L_CORE X_NUC_157.L_CORE 0.001418
K_3146 X_NUC_15.L_CORE X_NUC_158.L_CORE 0.001421
K_3147 X_NUC_15.L_CORE X_NUC_159.L_CORE 0.001412
K_3148 X_NUC_15.L_CORE X_NUC_160.L_CORE 0.001415
K_3149 X_NUC_15.L_CORE X_NUC_161.L_CORE 0.001479
K_3150 X_NUC_15.L_CORE X_NUC_162.L_CORE 0.001478
K_3151 X_NUC_15.L_CORE X_NUC_163.L_CORE 0.001470
K_3152 X_NUC_15.L_CORE X_NUC_164.L_CORE 0.001472
K_3153 X_NUC_15.L_CORE X_NUC_165.L_CORE 0.001316
K_3154 X_NUC_15.L_CORE X_NUC_166.L_CORE 0.001316
K_3155 X_NUC_15.L_CORE X_NUC_167.L_CORE 0.001309
K_3156 X_NUC_15.L_CORE X_NUC_168.L_CORE 0.001313
K_3157 X_NUC_15.L_CORE X_NUC_169.L_CORE 0.001409
K_3158 X_NUC_15.L_CORE X_NUC_170.L_CORE 0.001410
K_3159 X_NUC_15.L_CORE X_NUC_171.L_CORE 0.001402
K_3160 X_NUC_15.L_CORE X_NUC_172.L_CORE 0.001404
K_3161 X_NUC_15.L_CORE X_NUC_173.L_CORE 0.005227
K_3162 X_NUC_15.L_CORE X_NUC_174.L_CORE 0.003991
K_3163 X_NUC_15.L_CORE X_NUC_175.L_CORE 0.002731
K_3164 X_NUC_15.L_CORE X_NUC_176.L_CORE 0.027041
K_3165 X_NUC_15.L_CORE X_NUC_177.L_CORE 0.002408
K_3166 X_NUC_15.L_CORE X_NUC_178.L_CORE 0.003144
K_3167 X_NUC_15.L_CORE X_NUC_179.L_CORE 0.004452
K_3168 X_NUC_15.L_CORE X_NUC_180.L_CORE 0.001989
K_3169 X_NUC_15.L_CORE X_NUC_181.L_CORE 0.005485
K_3170 X_NUC_15.L_CORE X_NUC_182.L_CORE 0.002308
K_3171 X_NUC_15.L_CORE X_NUC_183.L_CORE 0.002093
K_3172 X_NUC_15.L_CORE X_NUC_184.L_CORE 0.005137
K_3173 X_NUC_15.L_CORE X_NUC_185.L_CORE 0.001761
K_3174 X_NUC_15.L_CORE X_NUC_186.L_CORE 0.002766
K_3175 X_NUC_15.L_CORE X_NUC_187.L_CORE 0.002508
K_3176 X_NUC_15.L_CORE X_NUC_188.L_CORE 0.001680
K_3177 X_NUC_15.L_CORE X_NUC_189.L_CORE 0.003806
K_3178 X_NUC_15.L_CORE X_NUC_190.L_CORE 0.001735
K_3179 X_NUC_15.L_CORE X_NUC_191.L_CORE 0.001925
K_3180 X_NUC_15.L_CORE X_NUC_192.L_CORE 0.002770
K_3181 X_NUC_15.L_CORE X_NUC_193.L_CORE 0.001510
K_3182 X_NUC_15.L_CORE X_NUC_194.L_CORE 0.002504
K_3183 X_NUC_15.L_CORE X_NUC_195.L_CORE 0.001830
K_3184 X_NUC_15.L_CORE X_NUC_196.L_CORE 0.001558
K_3185 X_NUC_15.L_CORE X_NUC_197.L_CORE 0.002660
K_3186 X_NUC_15.L_CORE X_NUC_198.L_CORE 0.001468
K_3187 X_NUC_15.L_CORE X_NUC_199.L_CORE 0.001839
K_3188 X_NUC_15.L_CORE X_NUC_200.L_CORE 0.001967
K_3189 X_NUC_15.L_CORE X_NUC_201.L_CORE 0.001391
K_3190 X_NUC_15.L_CORE X_NUC_202.L_CORE 0.002175
K_3191 X_NUC_15.L_CORE X_NUC_203.L_CORE 0.001507
K_3192 X_NUC_15.L_CORE X_NUC_204.L_CORE 0.001503
K_3193 X_NUC_15.L_CORE X_NUC_205.L_CORE 0.001995
K_3194 X_NUC_15.L_CORE X_NUC_206.L_CORE 0.001332
K_3195 X_NUC_15.L_CORE X_NUC_207.L_CORE 0.001735
K_3196 X_NUC_15.L_CORE X_NUC_208.L_CORE 0.001577
K_3197 X_NUC_15.L_CORE X_NUC_209.L_CORE 0.001336
K_3198 X_NUC_15.L_CORE X_NUC_210.L_CORE 0.001822
K_3199 X_NUC_15.L_CORE X_NUC_211.L_CORE 0.001338
K_3200 X_NUC_15.L_CORE X_NUC_212.L_CORE 0.001458
K_3201 X_NUC_15.L_CORE X_NUC_213.L_CORE 0.001600
K_3202 X_NUC_15.L_CORE X_NUC_214.L_CORE 0.001269
K_3203 X_NUC_15.L_CORE X_NUC_215.L_CORE 0.001571
K_3204 X_NUC_15.L_CORE X_NUC_216.L_CORE 0.001368
K_3205 X_NUC_15.L_CORE X_NUC_217.L_CORE 0.001311
K_3206 X_NUC_15.L_CORE X_NUC_218.L_CORE 0.001508
K_3207 X_NUC_15.L_CORE X_NUC_219.L_CORE 0.001266
K_3208 X_NUC_15.L_CORE X_NUC_220.L_CORE 0.001374
K_3209 X_NUC_15.L_CORE X_NUC_221.L_CORE 0.001355
K_3210 X_NUC_15.L_CORE X_NUC_222.L_CORE 0.001282
K_3211 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.002398
K_3212 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.002391
K_3213 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.002381
K_3214 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.002408
K_3215 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.003107
K_3216 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.003147
K_3217 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.003112
K_3218 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.003135
K_3219 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.004413
K_3220 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.004328
K_3221 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.004341
K_3222 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.004370
K_3223 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.001972
K_3224 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.001976
K_3225 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.001963
K_3226 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.001981
K_3227 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.005194
K_3228 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.005302
K_3229 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.005227
K_3230 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.005182
K_3231 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.002285
K_3232 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.002270
K_3233 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.002264
K_3234 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.002283
K_3235 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.002064
K_3236 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.002078
K_3237 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.002060
K_3238 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.002074
K_3239 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.004770
K_3240 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.004704
K_3241 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.004709
K_3242 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.004664
K_3243 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.001745
K_3244 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.001744
K_3245 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.001735
K_3246 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.001749
K_3247 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.002672
K_3248 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.002702
K_3249 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.002675
K_3250 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.002676
K_3251 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.002449
K_3252 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.002426
K_3253 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.002423
K_3254 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.002433
K_3255 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.001661
K_3256 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.001667
K_3257 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.001655
K_3258 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.001667
K_3259 X_NUC_16.L_CORE X_NUC_65.L_CORE 0.003487
K_3260 X_NUC_16.L_CORE X_NUC_66.L_CORE 0.003499
K_3261 X_NUC_16.L_CORE X_NUC_67.L_CORE 0.003476
K_3262 X_NUC_16.L_CORE X_NUC_68.L_CORE 0.003444
K_3263 X_NUC_16.L_CORE X_NUC_69.L_CORE 0.001716
K_3264 X_NUC_16.L_CORE X_NUC_70.L_CORE 0.001710
K_3265 X_NUC_16.L_CORE X_NUC_71.L_CORE 0.001703
K_3266 X_NUC_16.L_CORE X_NUC_72.L_CORE 0.001715
K_3267 X_NUC_16.L_CORE X_NUC_73.L_CORE 0.001882
K_3268 X_NUC_16.L_CORE X_NUC_74.L_CORE 0.001896
K_3269 X_NUC_16.L_CORE X_NUC_75.L_CORE 0.001880
K_3270 X_NUC_16.L_CORE X_NUC_76.L_CORE 0.001886
K_3271 X_NUC_16.L_CORE X_NUC_77.L_CORE 0.002619
K_3272 X_NUC_16.L_CORE X_NUC_78.L_CORE 0.002597
K_3273 X_NUC_16.L_CORE X_NUC_79.L_CORE 0.002593
K_3274 X_NUC_16.L_CORE X_NUC_80.L_CORE 0.002589
K_3275 X_NUC_16.L_CORE X_NUC_81.L_CORE 0.001498
K_3276 X_NUC_16.L_CORE X_NUC_82.L_CORE 0.001499
K_3277 X_NUC_16.L_CORE X_NUC_83.L_CORE 0.001490
K_3278 X_NUC_16.L_CORE X_NUC_84.L_CORE 0.001500
K_3279 X_NUC_16.L_CORE X_NUC_85.L_CORE 0.002362
K_3280 X_NUC_16.L_CORE X_NUC_86.L_CORE 0.002379
K_3281 X_NUC_16.L_CORE X_NUC_87.L_CORE 0.002359
K_3282 X_NUC_16.L_CORE X_NUC_88.L_CORE 0.002353
K_3283 X_NUC_16.L_CORE X_NUC_89.L_CORE 0.001792
K_3284 X_NUC_16.L_CORE X_NUC_90.L_CORE 0.001783
K_3285 X_NUC_16.L_CORE X_NUC_91.L_CORE 0.001777
K_3286 X_NUC_16.L_CORE X_NUC_92.L_CORE 0.001785
K_3287 X_NUC_16.L_CORE X_NUC_93.L_CORE 0.001539
K_3288 X_NUC_16.L_CORE X_NUC_94.L_CORE 0.001545
K_3289 X_NUC_16.L_CORE X_NUC_95.L_CORE 0.001534
K_3290 X_NUC_16.L_CORE X_NUC_96.L_CORE 0.001542
K_3291 X_NUC_16.L_CORE X_NUC_97.L_CORE 0.002444
K_3292 X_NUC_16.L_CORE X_NUC_98.L_CORE 0.002439
K_3293 X_NUC_16.L_CORE X_NUC_99.L_CORE 0.002428
K_3294 X_NUC_16.L_CORE X_NUC_100.L_CORE 0.002417
K_3295 X_NUC_16.L_CORE X_NUC_101.L_CORE 0.001458
K_3296 X_NUC_16.L_CORE X_NUC_102.L_CORE 0.001456
K_3297 X_NUC_16.L_CORE X_NUC_103.L_CORE 0.001449
K_3298 X_NUC_16.L_CORE X_NUC_104.L_CORE 0.001457
K_3299 X_NUC_16.L_CORE X_NUC_105.L_CORE 0.001775
K_3300 X_NUC_16.L_CORE X_NUC_106.L_CORE 0.001785
K_3301 X_NUC_16.L_CORE X_NUC_107.L_CORE 0.001771
K_3302 X_NUC_16.L_CORE X_NUC_108.L_CORE 0.001773
K_3303 X_NUC_16.L_CORE X_NUC_109.L_CORE 0.001880
K_3304 X_NUC_16.L_CORE X_NUC_110.L_CORE 0.001871
K_3305 X_NUC_16.L_CORE X_NUC_111.L_CORE 0.001865
K_3306 X_NUC_16.L_CORE X_NUC_112.L_CORE 0.001867
K_3307 X_NUC_16.L_CORE X_NUC_113.L_CORE 0.001385
K_3308 X_NUC_16.L_CORE X_NUC_114.L_CORE 0.001388
K_3309 X_NUC_16.L_CORE X_NUC_115.L_CORE 0.001379
K_3310 X_NUC_16.L_CORE X_NUC_116.L_CORE 0.001386
K_3311 X_NUC_16.L_CORE X_NUC_117.L_CORE 0.002009
K_3312 X_NUC_16.L_CORE X_NUC_118.L_CORE 0.002014
K_3313 X_NUC_16.L_CORE X_NUC_119.L_CORE 0.002001
K_3314 X_NUC_16.L_CORE X_NUC_120.L_CORE 0.001996
K_3315 X_NUC_16.L_CORE X_NUC_121.L_CORE 0.001487
K_3316 X_NUC_16.L_CORE X_NUC_122.L_CORE 0.001483
K_3317 X_NUC_16.L_CORE X_NUC_123.L_CORE 0.001477
K_3318 X_NUC_16.L_CORE X_NUC_124.L_CORE 0.001483
K_3319 X_NUC_16.L_CORE X_NUC_125.L_CORE 0.001478
K_3320 X_NUC_16.L_CORE X_NUC_126.L_CORE 0.001484
K_3321 X_NUC_16.L_CORE X_NUC_127.L_CORE 0.001473
K_3322 X_NUC_16.L_CORE X_NUC_128.L_CORE 0.001477
K_3323 X_NUC_16.L_CORE X_NUC_129.L_CORE 0.001844
K_3324 X_NUC_16.L_CORE X_NUC_130.L_CORE 0.001839
K_3325 X_NUC_16.L_CORE X_NUC_131.L_CORE 0.001832
K_3326 X_NUC_16.L_CORE X_NUC_132.L_CORE 0.001830
K_3327 X_NUC_16.L_CORE X_NUC_133.L_CORE 0.001335
K_3328 X_NUC_16.L_CORE X_NUC_134.L_CORE 0.001335
K_3329 X_NUC_16.L_CORE X_NUC_135.L_CORE 0.001328
K_3330 X_NUC_16.L_CORE X_NUC_136.L_CORE 0.001334
K_3331 X_NUC_16.L_CORE X_NUC_137.L_CORE 0.001639
K_3332 X_NUC_16.L_CORE X_NUC_138.L_CORE 0.001644
K_3333 X_NUC_16.L_CORE X_NUC_139.L_CORE 0.001633
K_3334 X_NUC_16.L_CORE X_NUC_140.L_CORE 0.001633
K_3335 X_NUC_16.L_CORE X_NUC_141.L_CORE 0.001524
K_3336 X_NUC_16.L_CORE X_NUC_142.L_CORE 0.001519
K_3337 X_NUC_16.L_CORE X_NUC_143.L_CORE 0.001513
K_3338 X_NUC_16.L_CORE X_NUC_144.L_CORE 0.001516
K_3339 X_NUC_16.L_CORE X_NUC_145.L_CORE 0.001339
K_3340 X_NUC_16.L_CORE X_NUC_146.L_CORE 0.001342
K_3341 X_NUC_16.L_CORE X_NUC_147.L_CORE 0.001333
K_3342 X_NUC_16.L_CORE X_NUC_148.L_CORE 0.001338
K_3343 X_NUC_16.L_CORE X_NUC_149.L_CORE 0.001651
K_3344 X_NUC_16.L_CORE X_NUC_150.L_CORE 0.001651
K_3345 X_NUC_16.L_CORE X_NUC_151.L_CORE 0.001642
K_3346 X_NUC_16.L_CORE X_NUC_152.L_CORE 0.001641
K_3347 X_NUC_16.L_CORE X_NUC_153.L_CORE 0.001343
K_3348 X_NUC_16.L_CORE X_NUC_154.L_CORE 0.001342
K_3349 X_NUC_16.L_CORE X_NUC_155.L_CORE 0.001335
K_3350 X_NUC_16.L_CORE X_NUC_156.L_CORE 0.001340
K_3351 X_NUC_16.L_CORE X_NUC_157.L_CORE 0.001416
K_3352 X_NUC_16.L_CORE X_NUC_158.L_CORE 0.001419
K_3353 X_NUC_16.L_CORE X_NUC_159.L_CORE 0.001410
K_3354 X_NUC_16.L_CORE X_NUC_160.L_CORE 0.001412
K_3355 X_NUC_16.L_CORE X_NUC_161.L_CORE 0.001478
K_3356 X_NUC_16.L_CORE X_NUC_162.L_CORE 0.001476
K_3357 X_NUC_16.L_CORE X_NUC_163.L_CORE 0.001469
K_3358 X_NUC_16.L_CORE X_NUC_164.L_CORE 0.001470
K_3359 X_NUC_16.L_CORE X_NUC_165.L_CORE 0.001312
K_3360 X_NUC_16.L_CORE X_NUC_166.L_CORE 0.001313
K_3361 X_NUC_16.L_CORE X_NUC_167.L_CORE 0.001305
K_3362 X_NUC_16.L_CORE X_NUC_168.L_CORE 0.001309
K_3363 X_NUC_16.L_CORE X_NUC_169.L_CORE 0.001407
K_3364 X_NUC_16.L_CORE X_NUC_170.L_CORE 0.001408
K_3365 X_NUC_16.L_CORE X_NUC_171.L_CORE 0.001400
K_3366 X_NUC_16.L_CORE X_NUC_172.L_CORE 0.001402
K_3367 X_NUC_16.L_CORE X_NUC_173.L_CORE 0.005127
K_3368 X_NUC_16.L_CORE X_NUC_174.L_CORE 0.003927
K_3369 X_NUC_16.L_CORE X_NUC_175.L_CORE 0.002700
K_3370 X_NUC_16.L_CORE X_NUC_176.L_CORE 0.027190
K_3371 X_NUC_16.L_CORE X_NUC_177.L_CORE 0.002382
K_3372 X_NUC_16.L_CORE X_NUC_178.L_CORE 0.003121
K_3373 X_NUC_16.L_CORE X_NUC_179.L_CORE 0.004423
K_3374 X_NUC_16.L_CORE X_NUC_180.L_CORE 0.001971
K_3375 X_NUC_16.L_CORE X_NUC_181.L_CORE 0.005545
K_3376 X_NUC_16.L_CORE X_NUC_182.L_CORE 0.002288
K_3377 X_NUC_16.L_CORE X_NUC_183.L_CORE 0.002079
K_3378 X_NUC_16.L_CORE X_NUC_184.L_CORE 0.005204
K_3379 X_NUC_16.L_CORE X_NUC_185.L_CORE 0.001747
K_3380 X_NUC_16.L_CORE X_NUC_186.L_CORE 0.002765
K_3381 X_NUC_16.L_CORE X_NUC_187.L_CORE 0.002498
K_3382 X_NUC_16.L_CORE X_NUC_188.L_CORE 0.001668
K_3383 X_NUC_16.L_CORE X_NUC_189.L_CORE 0.003854
K_3384 X_NUC_16.L_CORE X_NUC_190.L_CORE 0.001724
K_3385 X_NUC_16.L_CORE X_NUC_191.L_CORE 0.001918
K_3386 X_NUC_16.L_CORE X_NUC_192.L_CORE 0.002776
K_3387 X_NUC_16.L_CORE X_NUC_193.L_CORE 0.001500
K_3388 X_NUC_16.L_CORE X_NUC_194.L_CORE 0.002513
K_3389 X_NUC_16.L_CORE X_NUC_195.L_CORE 0.001822
K_3390 X_NUC_16.L_CORE X_NUC_196.L_CORE 0.001551
K_3391 X_NUC_16.L_CORE X_NUC_197.L_CORE 0.002677
K_3392 X_NUC_16.L_CORE X_NUC_198.L_CORE 0.001460
K_3393 X_NUC_16.L_CORE X_NUC_199.L_CORE 0.001837
K_3394 X_NUC_16.L_CORE X_NUC_200.L_CORE 0.001965
K_3395 X_NUC_16.L_CORE X_NUC_201.L_CORE 0.001383
K_3396 X_NUC_16.L_CORE X_NUC_202.L_CORE 0.002184
K_3397 X_NUC_16.L_CORE X_NUC_203.L_CORE 0.001500
K_3398 X_NUC_16.L_CORE X_NUC_204.L_CORE 0.001498
K_3399 X_NUC_16.L_CORE X_NUC_205.L_CORE 0.001999
K_3400 X_NUC_16.L_CORE X_NUC_206.L_CORE 0.001325
K_3401 X_NUC_16.L_CORE X_NUC_207.L_CORE 0.001736
K_3402 X_NUC_16.L_CORE X_NUC_208.L_CORE 0.001574
K_3403 X_NUC_16.L_CORE X_NUC_209.L_CORE 0.001331
K_3404 X_NUC_16.L_CORE X_NUC_210.L_CORE 0.001826
K_3405 X_NUC_16.L_CORE X_NUC_211.L_CORE 0.001332
K_3406 X_NUC_16.L_CORE X_NUC_212.L_CORE 0.001455
K_3407 X_NUC_16.L_CORE X_NUC_213.L_CORE 0.001599
K_3408 X_NUC_16.L_CORE X_NUC_214.L_CORE 0.001264
K_3409 X_NUC_16.L_CORE X_NUC_215.L_CORE 0.001572
K_3410 X_NUC_16.L_CORE X_NUC_216.L_CORE 0.001365
K_3411 X_NUC_16.L_CORE X_NUC_217.L_CORE 0.001308
K_3412 X_NUC_16.L_CORE X_NUC_218.L_CORE 0.001508
K_3413 X_NUC_16.L_CORE X_NUC_219.L_CORE 0.001262
K_3414 X_NUC_16.L_CORE X_NUC_220.L_CORE 0.001372
K_3415 X_NUC_16.L_CORE X_NUC_221.L_CORE 0.001353
K_3416 X_NUC_16.L_CORE X_NUC_222.L_CORE 0.001279
K_3417 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_3418 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_3419 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_3420 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.002180
K_3421 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.002200
K_3422 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.002196
K_3423 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.002183
K_3424 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.002876
K_3425 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.002864
K_3426 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.002885
K_3427 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.002848
K_3428 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.004092
K_3429 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.004167
K_3430 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.004102
K_3431 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.004130
K_3432 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.001839
K_3433 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.001847
K_3434 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.001849
K_3435 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.001835
K_3436 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.005105
K_3437 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.005005
K_3438 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.005036
K_3439 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.004994
K_3440 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.002152
K_3441 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.002174
K_3442 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.002161
K_3443 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.002157
K_3444 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.001961
K_3445 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.001960
K_3446 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.001966
K_3447 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.001948
K_3448 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.004806
K_3449 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.004829
K_3450 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.004727
K_3451 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.004802
K_3452 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.001660
K_3453 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.001669
K_3454 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.001666
K_3455 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.001658
K_3456 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.002611
K_3457 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.002592
K_3458 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.002602
K_3459 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.002580
K_3460 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.002370
K_3461 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.002394
K_3462 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.002370
K_3463 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.002376
K_3464 X_NUC_17.L_CORE X_NUC_65.L_CORE 0.001596
K_3465 X_NUC_17.L_CORE X_NUC_66.L_CORE 0.001599
K_3466 X_NUC_17.L_CORE X_NUC_67.L_CORE 0.001600
K_3467 X_NUC_17.L_CORE X_NUC_68.L_CORE 0.001589
K_3468 X_NUC_17.L_CORE X_NUC_69.L_CORE 0.003574
K_3469 X_NUC_17.L_CORE X_NUC_70.L_CORE 0.003543
K_3470 X_NUC_17.L_CORE X_NUC_71.L_CORE 0.003516
K_3471 X_NUC_17.L_CORE X_NUC_72.L_CORE 0.003530
K_3472 X_NUC_17.L_CORE X_NUC_73.L_CORE 0.001655
K_3473 X_NUC_17.L_CORE X_NUC_74.L_CORE 0.001666
K_3474 X_NUC_17.L_CORE X_NUC_75.L_CORE 0.001658
K_3475 X_NUC_17.L_CORE X_NUC_76.L_CORE 0.001654
K_3476 X_NUC_17.L_CORE X_NUC_77.L_CORE 0.001837
K_3477 X_NUC_17.L_CORE X_NUC_78.L_CORE 0.001832
K_3478 X_NUC_17.L_CORE X_NUC_79.L_CORE 0.001836
K_3479 X_NUC_17.L_CORE X_NUC_80.L_CORE 0.001822
K_3480 X_NUC_17.L_CORE X_NUC_81.L_CORE 0.002615
K_3481 X_NUC_17.L_CORE X_NUC_82.L_CORE 0.002630
K_3482 X_NUC_17.L_CORE X_NUC_83.L_CORE 0.002597
K_3483 X_NUC_17.L_CORE X_NUC_84.L_CORE 0.002613
K_3484 X_NUC_17.L_CORE X_NUC_85.L_CORE 0.001450
K_3485 X_NUC_17.L_CORE X_NUC_86.L_CORE 0.001456
K_3486 X_NUC_17.L_CORE X_NUC_87.L_CORE 0.001454
K_3487 X_NUC_17.L_CORE X_NUC_88.L_CORE 0.001446
K_3488 X_NUC_17.L_CORE X_NUC_89.L_CORE 0.002371
K_3489 X_NUC_17.L_CORE X_NUC_90.L_CORE 0.002355
K_3490 X_NUC_17.L_CORE X_NUC_91.L_CORE 0.002352
K_3491 X_NUC_17.L_CORE X_NUC_92.L_CORE 0.002345
K_3492 X_NUC_17.L_CORE X_NUC_93.L_CORE 0.001754
K_3493 X_NUC_17.L_CORE X_NUC_94.L_CORE 0.001766
K_3494 X_NUC_17.L_CORE X_NUC_95.L_CORE 0.001754
K_3495 X_NUC_17.L_CORE X_NUC_96.L_CORE 0.001754
K_3496 X_NUC_17.L_CORE X_NUC_97.L_CORE 0.001504
K_3497 X_NUC_17.L_CORE X_NUC_98.L_CORE 0.001505
K_3498 X_NUC_17.L_CORE X_NUC_99.L_CORE 0.001505
K_3499 X_NUC_17.L_CORE X_NUC_100.L_CORE 0.001496
K_3500 X_NUC_17.L_CORE X_NUC_101.L_CORE 0.002481
K_3501 X_NUC_17.L_CORE X_NUC_102.L_CORE 0.002478
K_3502 X_NUC_17.L_CORE X_NUC_103.L_CORE 0.002455
K_3503 X_NUC_17.L_CORE X_NUC_104.L_CORE 0.002465
K_3504 X_NUC_17.L_CORE X_NUC_105.L_CORE 0.001424
K_3505 X_NUC_17.L_CORE X_NUC_106.L_CORE 0.001430
K_3506 X_NUC_17.L_CORE X_NUC_107.L_CORE 0.001425
K_3507 X_NUC_17.L_CORE X_NUC_108.L_CORE 0.001421
K_3508 X_NUC_17.L_CORE X_NUC_109.L_CORE 0.001762
K_3509 X_NUC_17.L_CORE X_NUC_110.L_CORE 0.001757
K_3510 X_NUC_17.L_CORE X_NUC_111.L_CORE 0.001756
K_3511 X_NUC_17.L_CORE X_NUC_112.L_CORE 0.001748
K_3512 X_NUC_17.L_CORE X_NUC_113.L_CORE 0.001870
K_3513 X_NUC_17.L_CORE X_NUC_114.L_CORE 0.001879
K_3514 X_NUC_17.L_CORE X_NUC_115.L_CORE 0.001863
K_3515 X_NUC_17.L_CORE X_NUC_116.L_CORE 0.001867
K_3516 X_NUC_17.L_CORE X_NUC_117.L_CORE 0.001359
K_3517 X_NUC_17.L_CORE X_NUC_118.L_CORE 0.001362
K_3518 X_NUC_17.L_CORE X_NUC_119.L_CORE 0.001360
K_3519 X_NUC_17.L_CORE X_NUC_120.L_CORE 0.001353
K_3520 X_NUC_17.L_CORE X_NUC_121.L_CORE 0.002026
K_3521 X_NUC_17.L_CORE X_NUC_122.L_CORE 0.002019
K_3522 X_NUC_17.L_CORE X_NUC_123.L_CORE 0.002010
K_3523 X_NUC_17.L_CORE X_NUC_124.L_CORE 0.002009
K_3524 X_NUC_17.L_CORE X_NUC_125.L_CORE 0.001466
K_3525 X_NUC_17.L_CORE X_NUC_126.L_CORE 0.001473
K_3526 X_NUC_17.L_CORE X_NUC_127.L_CORE 0.001465
K_3527 X_NUC_17.L_CORE X_NUC_128.L_CORE 0.001464
K_3528 X_NUC_17.L_CORE X_NUC_129.L_CORE 0.001464
K_3529 X_NUC_17.L_CORE X_NUC_130.L_CORE 0.001463
K_3530 X_NUC_17.L_CORE X_NUC_131.L_CORE 0.001461
K_3531 X_NUC_17.L_CORE X_NUC_132.L_CORE 0.001454
K_3532 X_NUC_17.L_CORE X_NUC_133.L_CORE 0.001849
K_3533 X_NUC_17.L_CORE X_NUC_134.L_CORE 0.001852
K_3534 X_NUC_17.L_CORE X_NUC_135.L_CORE 0.001837
K_3535 X_NUC_17.L_CORE X_NUC_136.L_CORE 0.001841
K_3536 X_NUC_17.L_CORE X_NUC_137.L_CORE 0.001319
K_3537 X_NUC_17.L_CORE X_NUC_138.L_CORE 0.001323
K_3538 X_NUC_17.L_CORE X_NUC_139.L_CORE 0.001319
K_3539 X_NUC_17.L_CORE X_NUC_140.L_CORE 0.001314
K_3540 X_NUC_17.L_CORE X_NUC_141.L_CORE 0.001638
K_3541 X_NUC_17.L_CORE X_NUC_142.L_CORE 0.001635
K_3542 X_NUC_17.L_CORE X_NUC_143.L_CORE 0.001630
K_3543 X_NUC_17.L_CORE X_NUC_144.L_CORE 0.001626
K_3544 X_NUC_17.L_CORE X_NUC_145.L_CORE 0.001515
K_3545 X_NUC_17.L_CORE X_NUC_146.L_CORE 0.001520
K_3546 X_NUC_17.L_CORE X_NUC_147.L_CORE 0.001511
K_3547 X_NUC_17.L_CORE X_NUC_148.L_CORE 0.001511
K_3548 X_NUC_17.L_CORE X_NUC_149.L_CORE 0.001332
K_3549 X_NUC_17.L_CORE X_NUC_150.L_CORE 0.001333
K_3550 X_NUC_17.L_CORE X_NUC_151.L_CORE 0.001330
K_3551 X_NUC_17.L_CORE X_NUC_152.L_CORE 0.001325
K_3552 X_NUC_17.L_CORE X_NUC_153.L_CORE 0.001646
K_3553 X_NUC_17.L_CORE X_NUC_154.L_CORE 0.001645
K_3554 X_NUC_17.L_CORE X_NUC_155.L_CORE 0.001637
K_3555 X_NUC_17.L_CORE X_NUC_156.L_CORE 0.001636
K_3556 X_NUC_17.L_CORE X_NUC_157.L_CORE 0.001340
K_3557 X_NUC_17.L_CORE X_NUC_158.L_CORE 0.001344
K_3558 X_NUC_17.L_CORE X_NUC_159.L_CORE 0.001338
K_3559 X_NUC_17.L_CORE X_NUC_160.L_CORE 0.001335
K_3560 X_NUC_17.L_CORE X_NUC_161.L_CORE 0.001413
K_3561 X_NUC_17.L_CORE X_NUC_162.L_CORE 0.001413
K_3562 X_NUC_17.L_CORE X_NUC_163.L_CORE 0.001409
K_3563 X_NUC_17.L_CORE X_NUC_164.L_CORE 0.001405
K_3564 X_NUC_17.L_CORE X_NUC_165.L_CORE 0.001463
K_3565 X_NUC_17.L_CORE X_NUC_166.L_CORE 0.001465
K_3566 X_NUC_17.L_CORE X_NUC_167.L_CORE 0.001457
K_3567 X_NUC_17.L_CORE X_NUC_168.L_CORE 0.001457
K_3568 X_NUC_17.L_CORE X_NUC_169.L_CORE 0.001335
K_3569 X_NUC_17.L_CORE X_NUC_170.L_CORE 0.001337
K_3570 X_NUC_17.L_CORE X_NUC_171.L_CORE 0.001332
K_3571 X_NUC_17.L_CORE X_NUC_172.L_CORE 0.001329
K_3572 X_NUC_17.L_CORE X_NUC_173.L_CORE 0.003021
K_3573 X_NUC_17.L_CORE X_NUC_174.L_CORE 0.004881
K_3574 X_NUC_17.L_CORE X_NUC_175.L_CORE 0.003454
K_3575 X_NUC_17.L_CORE X_NUC_176.L_CORE 0.002387
K_3576 X_NUC_17.L_CORE X_NUC_177.L_CORE 0.028665
K_3577 X_NUC_17.L_CORE X_NUC_178.L_CORE 0.002177
K_3578 X_NUC_17.L_CORE X_NUC_179.L_CORE 0.002862
K_3579 X_NUC_17.L_CORE X_NUC_180.L_CORE 0.004174
K_3580 X_NUC_17.L_CORE X_NUC_181.L_CORE 0.001837
K_3581 X_NUC_17.L_CORE X_NUC_182.L_CORE 0.005332
K_3582 X_NUC_17.L_CORE X_NUC_183.L_CORE 0.002169
K_3583 X_NUC_17.L_CORE X_NUC_184.L_CORE 0.001963
K_3584 X_NUC_17.L_CORE X_NUC_185.L_CORE 0.005343
K_3585 X_NUC_17.L_CORE X_NUC_186.L_CORE 0.001662
K_3586 X_NUC_17.L_CORE X_NUC_187.L_CORE 0.002670
K_3587 X_NUC_17.L_CORE X_NUC_188.L_CORE 0.002436
K_3588 X_NUC_17.L_CORE X_NUC_189.L_CORE 0.001597
K_3589 X_NUC_17.L_CORE X_NUC_190.L_CORE 0.003966
K_3590 X_NUC_17.L_CORE X_NUC_191.L_CORE 0.001666
K_3591 X_NUC_17.L_CORE X_NUC_192.L_CORE 0.001857
K_3592 X_NUC_17.L_CORE X_NUC_193.L_CORE 0.002802
K_3593 X_NUC_17.L_CORE X_NUC_194.L_CORE 0.001449
K_3594 X_NUC_17.L_CORE X_NUC_195.L_CORE 0.002508
K_3595 X_NUC_17.L_CORE X_NUC_196.L_CORE 0.001791
K_3596 X_NUC_17.L_CORE X_NUC_197.L_CORE 0.001507
K_3597 X_NUC_17.L_CORE X_NUC_198.L_CORE 0.002746
K_3598 X_NUC_17.L_CORE X_NUC_199.L_CORE 0.001424
K_3599 X_NUC_17.L_CORE X_NUC_200.L_CORE 0.001813
K_3600 X_NUC_17.L_CORE X_NUC_201.L_CORE 0.001967
K_3601 X_NUC_17.L_CORE X_NUC_202.L_CORE 0.001351
K_3602 X_NUC_17.L_CORE X_NUC_203.L_CORE 0.002211
K_3603 X_NUC_17.L_CORE X_NUC_204.L_CORE 0.001480
K_3604 X_NUC_17.L_CORE X_NUC_205.L_CORE 0.001475
K_3605 X_NUC_17.L_CORE X_NUC_206.L_CORE 0.002025
K_3606 X_NUC_17.L_CORE X_NUC_207.L_CORE 0.001303
K_3607 X_NUC_17.L_CORE X_NUC_208.L_CORE 0.001735
K_3608 X_NUC_17.L_CORE X_NUC_209.L_CORE 0.001570
K_3609 X_NUC_17.L_CORE X_NUC_210.L_CORE 0.001313
K_3610 X_NUC_17.L_CORE X_NUC_211.L_CORE 0.001844
K_3611 X_NUC_17.L_CORE X_NUC_212.L_CORE 0.001321
K_3612 X_NUC_17.L_CORE X_NUC_213.L_CORE 0.001447
K_3613 X_NUC_17.L_CORE X_NUC_214.L_CORE 0.001605
K_3614 X_NUC_17.L_CORE X_NUC_215.L_CORE 0.001255
K_3615 X_NUC_17.L_CORE X_NUC_216.L_CORE 0.001573
K_3616 X_NUC_17.L_CORE X_NUC_217.L_CORE 0.001363
K_3617 X_NUC_17.L_CORE X_NUC_218.L_CORE 0.001305
K_3618 X_NUC_17.L_CORE X_NUC_219.L_CORE 0.001504
K_3619 X_NUC_17.L_CORE X_NUC_220.L_CORE 0.001267
K_3620 X_NUC_17.L_CORE X_NUC_221.L_CORE 0.001367
K_3621 X_NUC_17.L_CORE X_NUC_222.L_CORE 0.001345
K_3622 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_3623 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_3624 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.002161
K_3625 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.002180
K_3626 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.002176
K_3627 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.002164
K_3628 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.002887
K_3629 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.002876
K_3630 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.002897
K_3631 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.002860
K_3632 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.004020
K_3633 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.004092
K_3634 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.004030
K_3635 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.004057
K_3636 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.001831
K_3637 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.001839
K_3638 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.001841
K_3639 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.001827
K_3640 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.005209
K_3641 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.005105
K_3642 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.005137
K_3643 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.005092
K_3644 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.002131
K_3645 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.002152
K_3646 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.002140
K_3647 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.002136
K_3648 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.001961
K_3649 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.001961
K_3650 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.001967
K_3651 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.001949
K_3652 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.004781
K_3653 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.004806
K_3654 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.004704
K_3655 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.004778
K_3656 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.001650
K_3657 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.001660
K_3658 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.001656
K_3659 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.001648
K_3660 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.002630
K_3661 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.002611
K_3662 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.002621
K_3663 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.002599
K_3664 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.002348
K_3665 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.002370
K_3666 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.002347
K_3667 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.002353
K_3668 X_NUC_18.L_CORE X_NUC_65.L_CORE 0.001593
K_3669 X_NUC_18.L_CORE X_NUC_66.L_CORE 0.001596
K_3670 X_NUC_18.L_CORE X_NUC_67.L_CORE 0.001597
K_3671 X_NUC_18.L_CORE X_NUC_68.L_CORE 0.001586
K_3672 X_NUC_18.L_CORE X_NUC_69.L_CORE 0.003605
K_3673 X_NUC_18.L_CORE X_NUC_70.L_CORE 0.003574
K_3674 X_NUC_18.L_CORE X_NUC_71.L_CORE 0.003547
K_3675 X_NUC_18.L_CORE X_NUC_72.L_CORE 0.003560
K_3676 X_NUC_18.L_CORE X_NUC_73.L_CORE 0.001643
K_3677 X_NUC_18.L_CORE X_NUC_74.L_CORE 0.001655
K_3678 X_NUC_18.L_CORE X_NUC_75.L_CORE 0.001647
K_3679 X_NUC_18.L_CORE X_NUC_76.L_CORE 0.001643
K_3680 X_NUC_18.L_CORE X_NUC_77.L_CORE 0.001841
K_3681 X_NUC_18.L_CORE X_NUC_78.L_CORE 0.001837
K_3682 X_NUC_18.L_CORE X_NUC_79.L_CORE 0.001840
K_3683 X_NUC_18.L_CORE X_NUC_80.L_CORE 0.001827
K_3684 X_NUC_18.L_CORE X_NUC_81.L_CORE 0.002601
K_3685 X_NUC_18.L_CORE X_NUC_82.L_CORE 0.002615
K_3686 X_NUC_18.L_CORE X_NUC_83.L_CORE 0.002583
K_3687 X_NUC_18.L_CORE X_NUC_84.L_CORE 0.002599
K_3688 X_NUC_18.L_CORE X_NUC_85.L_CORE 0.001445
K_3689 X_NUC_18.L_CORE X_NUC_86.L_CORE 0.001450
K_3690 X_NUC_18.L_CORE X_NUC_87.L_CORE 0.001448
K_3691 X_NUC_18.L_CORE X_NUC_88.L_CORE 0.001441
K_3692 X_NUC_18.L_CORE X_NUC_89.L_CORE 0.002386
K_3693 X_NUC_18.L_CORE X_NUC_90.L_CORE 0.002371
K_3694 X_NUC_18.L_CORE X_NUC_91.L_CORE 0.002368
K_3695 X_NUC_18.L_CORE X_NUC_92.L_CORE 0.002360
K_3696 X_NUC_18.L_CORE X_NUC_93.L_CORE 0.001742
K_3697 X_NUC_18.L_CORE X_NUC_94.L_CORE 0.001754
K_3698 X_NUC_18.L_CORE X_NUC_95.L_CORE 0.001742
K_3699 X_NUC_18.L_CORE X_NUC_96.L_CORE 0.001742
K_3700 X_NUC_18.L_CORE X_NUC_97.L_CORE 0.001503
K_3701 X_NUC_18.L_CORE X_NUC_98.L_CORE 0.001504
K_3702 X_NUC_18.L_CORE X_NUC_99.L_CORE 0.001504
K_3703 X_NUC_18.L_CORE X_NUC_100.L_CORE 0.001495
K_3704 X_NUC_18.L_CORE X_NUC_101.L_CORE 0.002483
K_3705 X_NUC_18.L_CORE X_NUC_102.L_CORE 0.002481
K_3706 X_NUC_18.L_CORE X_NUC_103.L_CORE 0.002457
K_3707 X_NUC_18.L_CORE X_NUC_104.L_CORE 0.002468
K_3708 X_NUC_18.L_CORE X_NUC_105.L_CORE 0.001417
K_3709 X_NUC_18.L_CORE X_NUC_106.L_CORE 0.001424
K_3710 X_NUC_18.L_CORE X_NUC_107.L_CORE 0.001419
K_3711 X_NUC_18.L_CORE X_NUC_108.L_CORE 0.001414
K_3712 X_NUC_18.L_CORE X_NUC_109.L_CORE 0.001768
K_3713 X_NUC_18.L_CORE X_NUC_110.L_CORE 0.001762
K_3714 X_NUC_18.L_CORE X_NUC_111.L_CORE 0.001762
K_3715 X_NUC_18.L_CORE X_NUC_112.L_CORE 0.001753
K_3716 X_NUC_18.L_CORE X_NUC_113.L_CORE 0.001861
K_3717 X_NUC_18.L_CORE X_NUC_114.L_CORE 0.001870
K_3718 X_NUC_18.L_CORE X_NUC_115.L_CORE 0.001854
K_3719 X_NUC_18.L_CORE X_NUC_116.L_CORE 0.001858
K_3720 X_NUC_18.L_CORE X_NUC_117.L_CORE 0.001356
K_3721 X_NUC_18.L_CORE X_NUC_118.L_CORE 0.001359
K_3722 X_NUC_18.L_CORE X_NUC_119.L_CORE 0.001357
K_3723 X_NUC_18.L_CORE X_NUC_120.L_CORE 0.001351
K_3724 X_NUC_18.L_CORE X_NUC_121.L_CORE 0.002032
K_3725 X_NUC_18.L_CORE X_NUC_122.L_CORE 0.002026
K_3726 X_NUC_18.L_CORE X_NUC_123.L_CORE 0.002016
K_3727 X_NUC_18.L_CORE X_NUC_124.L_CORE 0.002015
K_3728 X_NUC_18.L_CORE X_NUC_125.L_CORE 0.001459
K_3729 X_NUC_18.L_CORE X_NUC_126.L_CORE 0.001466
K_3730 X_NUC_18.L_CORE X_NUC_127.L_CORE 0.001458
K_3731 X_NUC_18.L_CORE X_NUC_128.L_CORE 0.001457
K_3732 X_NUC_18.L_CORE X_NUC_129.L_CORE 0.001464
K_3733 X_NUC_18.L_CORE X_NUC_130.L_CORE 0.001464
K_3734 X_NUC_18.L_CORE X_NUC_131.L_CORE 0.001462
K_3735 X_NUC_18.L_CORE X_NUC_132.L_CORE 0.001455
K_3736 X_NUC_18.L_CORE X_NUC_133.L_CORE 0.001846
K_3737 X_NUC_18.L_CORE X_NUC_134.L_CORE 0.001849
K_3738 X_NUC_18.L_CORE X_NUC_135.L_CORE 0.001835
K_3739 X_NUC_18.L_CORE X_NUC_136.L_CORE 0.001838
K_3740 X_NUC_18.L_CORE X_NUC_137.L_CORE 0.001315
K_3741 X_NUC_18.L_CORE X_NUC_138.L_CORE 0.001319
K_3742 X_NUC_18.L_CORE X_NUC_139.L_CORE 0.001315
K_3743 X_NUC_18.L_CORE X_NUC_140.L_CORE 0.001310
K_3744 X_NUC_18.L_CORE X_NUC_141.L_CORE 0.001641
K_3745 X_NUC_18.L_CORE X_NUC_142.L_CORE 0.001638
K_3746 X_NUC_18.L_CORE X_NUC_143.L_CORE 0.001634
K_3747 X_NUC_18.L_CORE X_NUC_144.L_CORE 0.001629
K_3748 X_NUC_18.L_CORE X_NUC_145.L_CORE 0.001509
K_3749 X_NUC_18.L_CORE X_NUC_146.L_CORE 0.001515
K_3750 X_NUC_18.L_CORE X_NUC_147.L_CORE 0.001505
K_3751 X_NUC_18.L_CORE X_NUC_148.L_CORE 0.001505
K_3752 X_NUC_18.L_CORE X_NUC_149.L_CORE 0.001330
K_3753 X_NUC_18.L_CORE X_NUC_150.L_CORE 0.001332
K_3754 X_NUC_18.L_CORE X_NUC_151.L_CORE 0.001329
K_3755 X_NUC_18.L_CORE X_NUC_152.L_CORE 0.001324
K_3756 X_NUC_18.L_CORE X_NUC_153.L_CORE 0.001646
K_3757 X_NUC_18.L_CORE X_NUC_154.L_CORE 0.001646
K_3758 X_NUC_18.L_CORE X_NUC_155.L_CORE 0.001637
K_3759 X_NUC_18.L_CORE X_NUC_156.L_CORE 0.001637
K_3760 X_NUC_18.L_CORE X_NUC_157.L_CORE 0.001336
K_3761 X_NUC_18.L_CORE X_NUC_158.L_CORE 0.001340
K_3762 X_NUC_18.L_CORE X_NUC_159.L_CORE 0.001334
K_3763 X_NUC_18.L_CORE X_NUC_160.L_CORE 0.001331
K_3764 X_NUC_18.L_CORE X_NUC_161.L_CORE 0.001413
K_3765 X_NUC_18.L_CORE X_NUC_162.L_CORE 0.001413
K_3766 X_NUC_18.L_CORE X_NUC_163.L_CORE 0.001409
K_3767 X_NUC_18.L_CORE X_NUC_164.L_CORE 0.001405
K_3768 X_NUC_18.L_CORE X_NUC_165.L_CORE 0.001460
K_3769 X_NUC_18.L_CORE X_NUC_166.L_CORE 0.001463
K_3770 X_NUC_18.L_CORE X_NUC_167.L_CORE 0.001455
K_3771 X_NUC_18.L_CORE X_NUC_168.L_CORE 0.001454
K_3772 X_NUC_18.L_CORE X_NUC_169.L_CORE 0.001333
K_3773 X_NUC_18.L_CORE X_NUC_170.L_CORE 0.001335
K_3774 X_NUC_18.L_CORE X_NUC_171.L_CORE 0.001330
K_3775 X_NUC_18.L_CORE X_NUC_172.L_CORE 0.001327
K_3776 X_NUC_18.L_CORE X_NUC_173.L_CORE 0.002996
K_3777 X_NUC_18.L_CORE X_NUC_174.L_CORE 0.004885
K_3778 X_NUC_18.L_CORE X_NUC_175.L_CORE 0.003402
K_3779 X_NUC_18.L_CORE X_NUC_176.L_CORE 0.002380
K_3780 X_NUC_18.L_CORE X_NUC_177.L_CORE 0.028809
K_3781 X_NUC_18.L_CORE X_NUC_178.L_CORE 0.002158
K_3782 X_NUC_18.L_CORE X_NUC_179.L_CORE 0.002874
K_3783 X_NUC_18.L_CORE X_NUC_180.L_CORE 0.004098
K_3784 X_NUC_18.L_CORE X_NUC_181.L_CORE 0.001829
K_3785 X_NUC_18.L_CORE X_NUC_182.L_CORE 0.005457
K_3786 X_NUC_18.L_CORE X_NUC_183.L_CORE 0.002147
K_3787 X_NUC_18.L_CORE X_NUC_184.L_CORE 0.001964
K_3788 X_NUC_18.L_CORE X_NUC_185.L_CORE 0.005312
K_3789 X_NUC_18.L_CORE X_NUC_186.L_CORE 0.001653
K_3790 X_NUC_18.L_CORE X_NUC_187.L_CORE 0.002692
K_3791 X_NUC_18.L_CORE X_NUC_188.L_CORE 0.002411
K_3792 X_NUC_18.L_CORE X_NUC_189.L_CORE 0.001594
K_3793 X_NUC_18.L_CORE X_NUC_190.L_CORE 0.004014
K_3794 X_NUC_18.L_CORE X_NUC_191.L_CORE 0.001654
K_3795 X_NUC_18.L_CORE X_NUC_192.L_CORE 0.001862
K_3796 X_NUC_18.L_CORE X_NUC_193.L_CORE 0.002784
K_3797 X_NUC_18.L_CORE X_NUC_194.L_CORE 0.001444
K_3798 X_NUC_18.L_CORE X_NUC_195.L_CORE 0.002529
K_3799 X_NUC_18.L_CORE X_NUC_196.L_CORE 0.001777
K_3800 X_NUC_18.L_CORE X_NUC_197.L_CORE 0.001507
K_3801 X_NUC_18.L_CORE X_NUC_198.L_CORE 0.002752
K_3802 X_NUC_18.L_CORE X_NUC_199.L_CORE 0.001417
K_3803 X_NUC_18.L_CORE X_NUC_200.L_CORE 0.001820
K_3804 X_NUC_18.L_CORE X_NUC_201.L_CORE 0.001956
K_3805 X_NUC_18.L_CORE X_NUC_202.L_CORE 0.001348
K_3806 X_NUC_18.L_CORE X_NUC_203.L_CORE 0.002222
K_3807 X_NUC_18.L_CORE X_NUC_204.L_CORE 0.001472
K_3808 X_NUC_18.L_CORE X_NUC_205.L_CORE 0.001476
K_3809 X_NUC_18.L_CORE X_NUC_206.L_CORE 0.002022
K_3810 X_NUC_18.L_CORE X_NUC_207.L_CORE 0.001298
K_3811 X_NUC_18.L_CORE X_NUC_208.L_CORE 0.001741
K_3812 X_NUC_18.L_CORE X_NUC_209.L_CORE 0.001563
K_3813 X_NUC_18.L_CORE X_NUC_210.L_CORE 0.001312
K_3814 X_NUC_18.L_CORE X_NUC_211.L_CORE 0.001847
K_3815 X_NUC_18.L_CORE X_NUC_212.L_CORE 0.001316
K_3816 X_NUC_18.L_CORE X_NUC_213.L_CORE 0.001449
K_3817 X_NUC_18.L_CORE X_NUC_214.L_CORE 0.001601
K_3818 X_NUC_18.L_CORE X_NUC_215.L_CORE 0.001252
K_3819 X_NUC_18.L_CORE X_NUC_216.L_CORE 0.001576
K_3820 X_NUC_18.L_CORE X_NUC_217.L_CORE 0.001359
K_3821 X_NUC_18.L_CORE X_NUC_218.L_CORE 0.001304
K_3822 X_NUC_18.L_CORE X_NUC_219.L_CORE 0.001503
K_3823 X_NUC_18.L_CORE X_NUC_220.L_CORE 0.001265
K_3824 X_NUC_18.L_CORE X_NUC_221.L_CORE 0.001367
K_3825 X_NUC_18.L_CORE X_NUC_222.L_CORE 0.001343
K_3826 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_3827 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.002165
K_3828 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.002184
K_3829 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.002180
K_3830 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.002168
K_3831 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.002865
K_3832 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.002854
K_3833 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.002876
K_3834 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.002838
K_3835 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.004082
K_3836 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.004156
K_3837 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.004092
K_3838 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.004120
K_3839 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.001830
K_3840 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.001838
K_3841 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.001839
K_3842 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.001825
K_3843 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.005174
K_3844 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.005071
K_3845 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.005105
K_3846 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.005059
K_3847 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.002143
K_3848 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.002164
K_3849 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.002152
K_3850 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.002148
K_3851 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.001955
K_3852 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.001954
K_3853 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.001961
K_3854 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.001943
K_3855 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.004888
K_3856 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.004913
K_3857 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.004806
K_3858 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.004884
K_3859 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.001653
K_3860 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.001663
K_3861 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.001660
K_3862 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.001651
K_3863 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.002621
K_3864 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.002601
K_3865 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.002611
K_3866 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.002589
K_3867 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.002371
K_3868 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.002394
K_3869 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.002370
K_3870 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.002377
K_3871 X_NUC_19.L_CORE X_NUC_65.L_CORE 0.001592
K_3872 X_NUC_19.L_CORE X_NUC_66.L_CORE 0.001595
K_3873 X_NUC_19.L_CORE X_NUC_67.L_CORE 0.001596
K_3874 X_NUC_19.L_CORE X_NUC_68.L_CORE 0.001585
K_3875 X_NUC_19.L_CORE X_NUC_69.L_CORE 0.003634
K_3876 X_NUC_19.L_CORE X_NUC_70.L_CORE 0.003601
K_3877 X_NUC_19.L_CORE X_NUC_71.L_CORE 0.003574
K_3878 X_NUC_19.L_CORE X_NUC_72.L_CORE 0.003587
K_3879 X_NUC_19.L_CORE X_NUC_73.L_CORE 0.001651
K_3880 X_NUC_19.L_CORE X_NUC_74.L_CORE 0.001662
K_3881 X_NUC_19.L_CORE X_NUC_75.L_CORE 0.001655
K_3882 X_NUC_19.L_CORE X_NUC_76.L_CORE 0.001650
K_3883 X_NUC_19.L_CORE X_NUC_77.L_CORE 0.001838
K_3884 X_NUC_19.L_CORE X_NUC_78.L_CORE 0.001834
K_3885 X_NUC_19.L_CORE X_NUC_79.L_CORE 0.001837
K_3886 X_NUC_19.L_CORE X_NUC_80.L_CORE 0.001824
K_3887 X_NUC_19.L_CORE X_NUC_81.L_CORE 0.002634
K_3888 X_NUC_19.L_CORE X_NUC_82.L_CORE 0.002649
K_3889 X_NUC_19.L_CORE X_NUC_83.L_CORE 0.002615
K_3890 X_NUC_19.L_CORE X_NUC_84.L_CORE 0.002632
K_3891 X_NUC_19.L_CORE X_NUC_85.L_CORE 0.001447
K_3892 X_NUC_19.L_CORE X_NUC_86.L_CORE 0.001453
K_3893 X_NUC_19.L_CORE X_NUC_87.L_CORE 0.001450
K_3894 X_NUC_19.L_CORE X_NUC_88.L_CORE 0.001443
K_3895 X_NUC_19.L_CORE X_NUC_89.L_CORE 0.002389
K_3896 X_NUC_19.L_CORE X_NUC_90.L_CORE 0.002373
K_3897 X_NUC_19.L_CORE X_NUC_91.L_CORE 0.002371
K_3898 X_NUC_19.L_CORE X_NUC_92.L_CORE 0.002362
K_3899 X_NUC_19.L_CORE X_NUC_93.L_CORE 0.001755
K_3900 X_NUC_19.L_CORE X_NUC_94.L_CORE 0.001767
K_3901 X_NUC_19.L_CORE X_NUC_95.L_CORE 0.001754
K_3902 X_NUC_19.L_CORE X_NUC_96.L_CORE 0.001754
K_3903 X_NUC_19.L_CORE X_NUC_97.L_CORE 0.001503
K_3904 X_NUC_19.L_CORE X_NUC_98.L_CORE 0.001504
K_3905 X_NUC_19.L_CORE X_NUC_99.L_CORE 0.001504
K_3906 X_NUC_19.L_CORE X_NUC_100.L_CORE 0.001495
K_3907 X_NUC_19.L_CORE X_NUC_101.L_CORE 0.002507
K_3908 X_NUC_19.L_CORE X_NUC_102.L_CORE 0.002504
K_3909 X_NUC_19.L_CORE X_NUC_103.L_CORE 0.002481
K_3910 X_NUC_19.L_CORE X_NUC_104.L_CORE 0.002491
K_3911 X_NUC_19.L_CORE X_NUC_105.L_CORE 0.001422
K_3912 X_NUC_19.L_CORE X_NUC_106.L_CORE 0.001429
K_3913 X_NUC_19.L_CORE X_NUC_107.L_CORE 0.001424
K_3914 X_NUC_19.L_CORE X_NUC_108.L_CORE 0.001419
K_3915 X_NUC_19.L_CORE X_NUC_109.L_CORE 0.001768
K_3916 X_NUC_19.L_CORE X_NUC_110.L_CORE 0.001763
K_3917 X_NUC_19.L_CORE X_NUC_111.L_CORE 0.001762
K_3918 X_NUC_19.L_CORE X_NUC_112.L_CORE 0.001754
K_3919 X_NUC_19.L_CORE X_NUC_113.L_CORE 0.001877
K_3920 X_NUC_19.L_CORE X_NUC_114.L_CORE 0.001886
K_3921 X_NUC_19.L_CORE X_NUC_115.L_CORE 0.001870
K_3922 X_NUC_19.L_CORE X_NUC_116.L_CORE 0.001874
K_3923 X_NUC_19.L_CORE X_NUC_117.L_CORE 0.001358
K_3924 X_NUC_19.L_CORE X_NUC_118.L_CORE 0.001361
K_3925 X_NUC_19.L_CORE X_NUC_119.L_CORE 0.001359
K_3926 X_NUC_19.L_CORE X_NUC_120.L_CORE 0.001353
K_3927 X_NUC_19.L_CORE X_NUC_121.L_CORE 0.002042
K_3928 X_NUC_19.L_CORE X_NUC_122.L_CORE 0.002035
K_3929 X_NUC_19.L_CORE X_NUC_123.L_CORE 0.002026
K_3930 X_NUC_19.L_CORE X_NUC_124.L_CORE 0.002025
K_3931 X_NUC_19.L_CORE X_NUC_125.L_CORE 0.001467
K_3932 X_NUC_19.L_CORE X_NUC_126.L_CORE 0.001474
K_3933 X_NUC_19.L_CORE X_NUC_127.L_CORE 0.001466
K_3934 X_NUC_19.L_CORE X_NUC_128.L_CORE 0.001464
K_3935 X_NUC_19.L_CORE X_NUC_129.L_CORE 0.001466
K_3936 X_NUC_19.L_CORE X_NUC_130.L_CORE 0.001465
K_3937 X_NUC_19.L_CORE X_NUC_131.L_CORE 0.001464
K_3938 X_NUC_19.L_CORE X_NUC_132.L_CORE 0.001457
K_3939 X_NUC_19.L_CORE X_NUC_133.L_CORE 0.001861
K_3940 X_NUC_19.L_CORE X_NUC_134.L_CORE 0.001864
K_3941 X_NUC_19.L_CORE X_NUC_135.L_CORE 0.001849
K_3942 X_NUC_19.L_CORE X_NUC_136.L_CORE 0.001853
K_3943 X_NUC_19.L_CORE X_NUC_137.L_CORE 0.001319
K_3944 X_NUC_19.L_CORE X_NUC_138.L_CORE 0.001323
K_3945 X_NUC_19.L_CORE X_NUC_139.L_CORE 0.001319
K_3946 X_NUC_19.L_CORE X_NUC_140.L_CORE 0.001314
K_3947 X_NUC_19.L_CORE X_NUC_141.L_CORE 0.001646
K_3948 X_NUC_19.L_CORE X_NUC_142.L_CORE 0.001642
K_3949 X_NUC_19.L_CORE X_NUC_143.L_CORE 0.001638
K_3950 X_NUC_19.L_CORE X_NUC_144.L_CORE 0.001634
K_3951 X_NUC_19.L_CORE X_NUC_145.L_CORE 0.001519
K_3952 X_NUC_19.L_CORE X_NUC_146.L_CORE 0.001524
K_3953 X_NUC_19.L_CORE X_NUC_147.L_CORE 0.001515
K_3954 X_NUC_19.L_CORE X_NUC_148.L_CORE 0.001515
K_3955 X_NUC_19.L_CORE X_NUC_149.L_CORE 0.001333
K_3956 X_NUC_19.L_CORE X_NUC_150.L_CORE 0.001335
K_3957 X_NUC_19.L_CORE X_NUC_151.L_CORE 0.001332
K_3958 X_NUC_19.L_CORE X_NUC_152.L_CORE 0.001327
K_3959 X_NUC_19.L_CORE X_NUC_153.L_CORE 0.001655
K_3960 X_NUC_19.L_CORE X_NUC_154.L_CORE 0.001655
K_3961 X_NUC_19.L_CORE X_NUC_155.L_CORE 0.001646
K_3962 X_NUC_19.L_CORE X_NUC_156.L_CORE 0.001645
K_3963 X_NUC_19.L_CORE X_NUC_157.L_CORE 0.001341
K_3964 X_NUC_19.L_CORE X_NUC_158.L_CORE 0.001345
K_3965 X_NUC_19.L_CORE X_NUC_159.L_CORE 0.001340
K_3966 X_NUC_19.L_CORE X_NUC_160.L_CORE 0.001337
K_3967 X_NUC_19.L_CORE X_NUC_161.L_CORE 0.001418
K_3968 X_NUC_19.L_CORE X_NUC_162.L_CORE 0.001417
K_3969 X_NUC_19.L_CORE X_NUC_163.L_CORE 0.001413
K_3970 X_NUC_19.L_CORE X_NUC_164.L_CORE 0.001409
K_3971 X_NUC_19.L_CORE X_NUC_165.L_CORE 0.001468
K_3972 X_NUC_19.L_CORE X_NUC_166.L_CORE 0.001471
K_3973 X_NUC_19.L_CORE X_NUC_167.L_CORE 0.001463
K_3974 X_NUC_19.L_CORE X_NUC_168.L_CORE 0.001462
K_3975 X_NUC_19.L_CORE X_NUC_169.L_CORE 0.001338
K_3976 X_NUC_19.L_CORE X_NUC_170.L_CORE 0.001340
K_3977 X_NUC_19.L_CORE X_NUC_171.L_CORE 0.001335
K_3978 X_NUC_19.L_CORE X_NUC_172.L_CORE 0.001332
K_3979 X_NUC_19.L_CORE X_NUC_173.L_CORE 0.002983
K_3980 X_NUC_19.L_CORE X_NUC_174.L_CORE 0.004799
K_3981 X_NUC_19.L_CORE X_NUC_175.L_CORE 0.003411
K_3982 X_NUC_19.L_CORE X_NUC_176.L_CORE 0.002368
K_3983 X_NUC_19.L_CORE X_NUC_177.L_CORE 0.026267
K_3984 X_NUC_19.L_CORE X_NUC_178.L_CORE 0.002161
K_3985 X_NUC_19.L_CORE X_NUC_179.L_CORE 0.002849
K_3986 X_NUC_19.L_CORE X_NUC_180.L_CORE 0.004154
K_3987 X_NUC_19.L_CORE X_NUC_181.L_CORE 0.001827
K_3988 X_NUC_19.L_CORE X_NUC_182.L_CORE 0.005393
K_3989 X_NUC_19.L_CORE X_NUC_183.L_CORE 0.002158
K_3990 X_NUC_19.L_CORE X_NUC_184.L_CORE 0.001957
K_3991 X_NUC_19.L_CORE X_NUC_185.L_CORE 0.005436
K_3992 X_NUC_19.L_CORE X_NUC_186.L_CORE 0.001655
K_3993 X_NUC_19.L_CORE X_NUC_187.L_CORE 0.002678
K_3994 X_NUC_19.L_CORE X_NUC_188.L_CORE 0.002435
K_3995 X_NUC_19.L_CORE X_NUC_189.L_CORE 0.001592
K_3996 X_NUC_19.L_CORE X_NUC_190.L_CORE 0.004041
K_3997 X_NUC_19.L_CORE X_NUC_191.L_CORE 0.001661
K_3998 X_NUC_19.L_CORE X_NUC_192.L_CORE 0.001857
K_3999 X_NUC_19.L_CORE X_NUC_193.L_CORE 0.002821
K_4000 X_NUC_19.L_CORE X_NUC_194.L_CORE 0.001445
K_4001 X_NUC_19.L_CORE X_NUC_195.L_CORE 0.002529
K_4002 X_NUC_19.L_CORE X_NUC_196.L_CORE 0.001790
K_4003 X_NUC_19.L_CORE X_NUC_197.L_CORE 0.001506
K_4004 X_NUC_19.L_CORE X_NUC_198.L_CORE 0.002780
K_4005 X_NUC_19.L_CORE X_NUC_199.L_CORE 0.001422
K_4006 X_NUC_19.L_CORE X_NUC_200.L_CORE 0.001818
K_4007 X_NUC_19.L_CORE X_NUC_201.L_CORE 0.001974
K_4008 X_NUC_19.L_CORE X_NUC_202.L_CORE 0.001350
K_4009 X_NUC_19.L_CORE X_NUC_203.L_CORE 0.002232
K_4010 X_NUC_19.L_CORE X_NUC_204.L_CORE 0.001480
K_4011 X_NUC_19.L_CORE X_NUC_205.L_CORE 0.001476
K_4012 X_NUC_19.L_CORE X_NUC_206.L_CORE 0.002040
K_4013 X_NUC_19.L_CORE X_NUC_207.L_CORE 0.001302
K_4014 X_NUC_19.L_CORE X_NUC_208.L_CORE 0.001744
K_4015 X_NUC_19.L_CORE X_NUC_209.L_CORE 0.001573
K_4016 X_NUC_19.L_CORE X_NUC_210.L_CORE 0.001313
K_4017 X_NUC_19.L_CORE X_NUC_211.L_CORE 0.001858
K_4018 X_NUC_19.L_CORE X_NUC_212.L_CORE 0.001322
K_4019 X_NUC_19.L_CORE X_NUC_213.L_CORE 0.001451
K_4020 X_NUC_19.L_CORE X_NUC_214.L_CORE 0.001612
K_4021 X_NUC_19.L_CORE X_NUC_215.L_CORE 0.001255
K_4022 X_NUC_19.L_CORE X_NUC_216.L_CORE 0.001582
K_4023 X_NUC_19.L_CORE X_NUC_217.L_CORE 0.001366
K_4024 X_NUC_19.L_CORE X_NUC_218.L_CORE 0.001307
K_4025 X_NUC_19.L_CORE X_NUC_219.L_CORE 0.001511
K_4026 X_NUC_19.L_CORE X_NUC_220.L_CORE 0.001269
K_4027 X_NUC_19.L_CORE X_NUC_221.L_CORE 0.001371
K_4028 X_NUC_19.L_CORE X_NUC_222.L_CORE 0.001349
K_4029 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.002178
K_4030 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.002197
K_4031 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.002193
K_4032 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.002180
K_4033 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.002903
K_4034 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.002891
K_4035 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.002914
K_4036 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.002876
K_4037 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.004054
K_4038 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.004127
K_4039 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.004064
K_4040 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.004092
K_4041 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.001844
K_4042 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.001852
K_4043 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.001854
K_4044 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.001839
K_4045 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.005222
K_4046 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.005116
K_4047 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.005149
K_4048 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.005105
K_4049 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.002147
K_4050 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.002168
K_4051 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.002156
K_4052 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.002152
K_4053 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.001973
K_4054 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.001972
K_4055 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.001979
K_4056 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.001961
K_4057 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.004808
K_4058 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.004833
K_4059 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.004730
K_4060 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.004806
K_4061 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.001661
K_4062 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.001671
K_4063 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.001668
K_4064 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.001660
K_4065 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.002643
K_4066 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.002623
K_4067 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.002633
K_4068 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.002611
K_4069 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.002364
K_4070 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.002388
K_4071 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.002364
K_4072 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.002370
K_4073 X_NUC_20.L_CORE X_NUC_65.L_CORE 0.001603
K_4074 X_NUC_20.L_CORE X_NUC_66.L_CORE 0.001606
K_4075 X_NUC_20.L_CORE X_NUC_67.L_CORE 0.001607
K_4076 X_NUC_20.L_CORE X_NUC_68.L_CORE 0.001596
K_4077 X_NUC_20.L_CORE X_NUC_69.L_CORE 0.003619
K_4078 X_NUC_20.L_CORE X_NUC_70.L_CORE 0.003587
K_4079 X_NUC_20.L_CORE X_NUC_71.L_CORE 0.003560
K_4080 X_NUC_20.L_CORE X_NUC_72.L_CORE 0.003574
K_4081 X_NUC_20.L_CORE X_NUC_73.L_CORE 0.001655
K_4082 X_NUC_20.L_CORE X_NUC_74.L_CORE 0.001666
K_4083 X_NUC_20.L_CORE X_NUC_75.L_CORE 0.001659
K_4084 X_NUC_20.L_CORE X_NUC_76.L_CORE 0.001655
K_4085 X_NUC_20.L_CORE X_NUC_77.L_CORE 0.001852
K_4086 X_NUC_20.L_CORE X_NUC_78.L_CORE 0.001847
K_4087 X_NUC_20.L_CORE X_NUC_79.L_CORE 0.001850
K_4088 X_NUC_20.L_CORE X_NUC_80.L_CORE 0.001837
K_4089 X_NUC_20.L_CORE X_NUC_81.L_CORE 0.002617
K_4090 X_NUC_20.L_CORE X_NUC_82.L_CORE 0.002632
K_4091 X_NUC_20.L_CORE X_NUC_83.L_CORE 0.002599
K_4092 X_NUC_20.L_CORE X_NUC_84.L_CORE 0.002615
K_4093 X_NUC_20.L_CORE X_NUC_85.L_CORE 0.001454
K_4094 X_NUC_20.L_CORE X_NUC_86.L_CORE 0.001460
K_4095 X_NUC_20.L_CORE X_NUC_87.L_CORE 0.001458
K_4096 X_NUC_20.L_CORE X_NUC_88.L_CORE 0.001450
K_4097 X_NUC_20.L_CORE X_NUC_89.L_CORE 0.002397
K_4098 X_NUC_20.L_CORE X_NUC_90.L_CORE 0.002381
K_4099 X_NUC_20.L_CORE X_NUC_91.L_CORE 0.002378
K_4100 X_NUC_20.L_CORE X_NUC_92.L_CORE 0.002371
K_4101 X_NUC_20.L_CORE X_NUC_93.L_CORE 0.001754
K_4102 X_NUC_20.L_CORE X_NUC_94.L_CORE 0.001766
K_4103 X_NUC_20.L_CORE X_NUC_95.L_CORE 0.001754
K_4104 X_NUC_20.L_CORE X_NUC_96.L_CORE 0.001754
K_4105 X_NUC_20.L_CORE X_NUC_97.L_CORE 0.001512
K_4106 X_NUC_20.L_CORE X_NUC_98.L_CORE 0.001513
K_4107 X_NUC_20.L_CORE X_NUC_99.L_CORE 0.001513
K_4108 X_NUC_20.L_CORE X_NUC_100.L_CORE 0.001504
K_4109 X_NUC_20.L_CORE X_NUC_101.L_CORE 0.002496
K_4110 X_NUC_20.L_CORE X_NUC_102.L_CORE 0.002493
K_4111 X_NUC_20.L_CORE X_NUC_103.L_CORE 0.002470
K_4112 X_NUC_20.L_CORE X_NUC_104.L_CORE 0.002481
K_4113 X_NUC_20.L_CORE X_NUC_105.L_CORE 0.001426
K_4114 X_NUC_20.L_CORE X_NUC_106.L_CORE 0.001433
K_4115 X_NUC_20.L_CORE X_NUC_107.L_CORE 0.001428
K_4116 X_NUC_20.L_CORE X_NUC_108.L_CORE 0.001424
K_4117 X_NUC_20.L_CORE X_NUC_109.L_CORE 0.001777
K_4118 X_NUC_20.L_CORE X_NUC_110.L_CORE 0.001772
K_4119 X_NUC_20.L_CORE X_NUC_111.L_CORE 0.001771
K_4120 X_NUC_20.L_CORE X_NUC_112.L_CORE 0.001762
K_4121 X_NUC_20.L_CORE X_NUC_113.L_CORE 0.001873
K_4122 X_NUC_20.L_CORE X_NUC_114.L_CORE 0.001882
K_4123 X_NUC_20.L_CORE X_NUC_115.L_CORE 0.001866
K_4124 X_NUC_20.L_CORE X_NUC_116.L_CORE 0.001870
K_4125 X_NUC_20.L_CORE X_NUC_117.L_CORE 0.001365
K_4126 X_NUC_20.L_CORE X_NUC_118.L_CORE 0.001368
K_4127 X_NUC_20.L_CORE X_NUC_119.L_CORE 0.001365
K_4128 X_NUC_20.L_CORE X_NUC_120.L_CORE 0.001359
K_4129 X_NUC_20.L_CORE X_NUC_121.L_CORE 0.002043
K_4130 X_NUC_20.L_CORE X_NUC_122.L_CORE 0.002036
K_4131 X_NUC_20.L_CORE X_NUC_123.L_CORE 0.002026
K_4132 X_NUC_20.L_CORE X_NUC_124.L_CORE 0.002026
K_4133 X_NUC_20.L_CORE X_NUC_125.L_CORE 0.001469
K_4134 X_NUC_20.L_CORE X_NUC_126.L_CORE 0.001476
K_4135 X_NUC_20.L_CORE X_NUC_127.L_CORE 0.001468
K_4136 X_NUC_20.L_CORE X_NUC_128.L_CORE 0.001466
K_4137 X_NUC_20.L_CORE X_NUC_129.L_CORE 0.001473
K_4138 X_NUC_20.L_CORE X_NUC_130.L_CORE 0.001472
K_4139 X_NUC_20.L_CORE X_NUC_131.L_CORE 0.001471
K_4140 X_NUC_20.L_CORE X_NUC_132.L_CORE 0.001464
K_4141 X_NUC_20.L_CORE X_NUC_133.L_CORE 0.001857
K_4142 X_NUC_20.L_CORE X_NUC_134.L_CORE 0.001860
K_4143 X_NUC_20.L_CORE X_NUC_135.L_CORE 0.001845
K_4144 X_NUC_20.L_CORE X_NUC_136.L_CORE 0.001849
K_4145 X_NUC_20.L_CORE X_NUC_137.L_CORE 0.001323
K_4146 X_NUC_20.L_CORE X_NUC_138.L_CORE 0.001327
K_4147 X_NUC_20.L_CORE X_NUC_139.L_CORE 0.001323
K_4148 X_NUC_20.L_CORE X_NUC_140.L_CORE 0.001319
K_4149 X_NUC_20.L_CORE X_NUC_141.L_CORE 0.001650
K_4150 X_NUC_20.L_CORE X_NUC_142.L_CORE 0.001647
K_4151 X_NUC_20.L_CORE X_NUC_143.L_CORE 0.001642
K_4152 X_NUC_20.L_CORE X_NUC_144.L_CORE 0.001638
K_4153 X_NUC_20.L_CORE X_NUC_145.L_CORE 0.001519
K_4154 X_NUC_20.L_CORE X_NUC_146.L_CORE 0.001524
K_4155 X_NUC_20.L_CORE X_NUC_147.L_CORE 0.001515
K_4156 X_NUC_20.L_CORE X_NUC_148.L_CORE 0.001515
K_4157 X_NUC_20.L_CORE X_NUC_149.L_CORE 0.001338
K_4158 X_NUC_20.L_CORE X_NUC_150.L_CORE 0.001340
K_4159 X_NUC_20.L_CORE X_NUC_151.L_CORE 0.001337
K_4160 X_NUC_20.L_CORE X_NUC_152.L_CORE 0.001332
K_4161 X_NUC_20.L_CORE X_NUC_153.L_CORE 0.001655
K_4162 X_NUC_20.L_CORE X_NUC_154.L_CORE 0.001655
K_4163 X_NUC_20.L_CORE X_NUC_155.L_CORE 0.001646
K_4164 X_NUC_20.L_CORE X_NUC_156.L_CORE 0.001646
K_4165 X_NUC_20.L_CORE X_NUC_157.L_CORE 0.001344
K_4166 X_NUC_20.L_CORE X_NUC_158.L_CORE 0.001348
K_4167 X_NUC_20.L_CORE X_NUC_159.L_CORE 0.001342
K_4168 X_NUC_20.L_CORE X_NUC_160.L_CORE 0.001340
K_4169 X_NUC_20.L_CORE X_NUC_161.L_CORE 0.001422
K_4170 X_NUC_20.L_CORE X_NUC_162.L_CORE 0.001421
K_4171 X_NUC_20.L_CORE X_NUC_163.L_CORE 0.001417
K_4172 X_NUC_20.L_CORE X_NUC_164.L_CORE 0.001413
K_4173 X_NUC_20.L_CORE X_NUC_165.L_CORE 0.001469
K_4174 X_NUC_20.L_CORE X_NUC_166.L_CORE 0.001471
K_4175 X_NUC_20.L_CORE X_NUC_167.L_CORE 0.001464
K_4176 X_NUC_20.L_CORE X_NUC_168.L_CORE 0.001463
K_4177 X_NUC_20.L_CORE X_NUC_169.L_CORE 0.001341
K_4178 X_NUC_20.L_CORE X_NUC_170.L_CORE 0.001343
K_4179 X_NUC_20.L_CORE X_NUC_171.L_CORE 0.001338
K_4180 X_NUC_20.L_CORE X_NUC_172.L_CORE 0.001335
K_4181 X_NUC_20.L_CORE X_NUC_173.L_CORE 0.003015
K_4182 X_NUC_20.L_CORE X_NUC_174.L_CORE 0.004901
K_4183 X_NUC_20.L_CORE X_NUC_175.L_CORE 0.003426
K_4184 X_NUC_20.L_CORE X_NUC_176.L_CORE 0.002394
K_4185 X_NUC_20.L_CORE X_NUC_177.L_CORE 0.026110
K_4186 X_NUC_20.L_CORE X_NUC_178.L_CORE 0.002173
K_4187 X_NUC_20.L_CORE X_NUC_179.L_CORE 0.002887
K_4188 X_NUC_20.L_CORE X_NUC_180.L_CORE 0.004123
K_4189 X_NUC_20.L_CORE X_NUC_181.L_CORE 0.001841
K_4190 X_NUC_20.L_CORE X_NUC_182.L_CORE 0.005445
K_4191 X_NUC_20.L_CORE X_NUC_183.L_CORE 0.002162
K_4192 X_NUC_20.L_CORE X_NUC_184.L_CORE 0.001975
K_4193 X_NUC_20.L_CORE X_NUC_185.L_CORE 0.005321
K_4194 X_NUC_20.L_CORE X_NUC_186.L_CORE 0.001664
K_4195 X_NUC_20.L_CORE X_NUC_187.L_CORE 0.002702
K_4196 X_NUC_20.L_CORE X_NUC_188.L_CORE 0.002427
K_4197 X_NUC_20.L_CORE X_NUC_189.L_CORE 0.001603
K_4198 X_NUC_20.L_CORE X_NUC_190.L_CORE 0.004017
K_4199 X_NUC_20.L_CORE X_NUC_191.L_CORE 0.001665
K_4200 X_NUC_20.L_CORE X_NUC_192.L_CORE 0.001872
K_4201 X_NUC_20.L_CORE X_NUC_193.L_CORE 0.002799
K_4202 X_NUC_20.L_CORE X_NUC_194.L_CORE 0.001453
K_4203 X_NUC_20.L_CORE X_NUC_195.L_CORE 0.002538
K_4204 X_NUC_20.L_CORE X_NUC_196.L_CORE 0.001789
K_4205 X_NUC_20.L_CORE X_NUC_197.L_CORE 0.001515
K_4206 X_NUC_20.L_CORE X_NUC_198.L_CORE 0.002762
K_4207 X_NUC_20.L_CORE X_NUC_199.L_CORE 0.001426
K_4208 X_NUC_20.L_CORE X_NUC_200.L_CORE 0.001828
K_4209 X_NUC_20.L_CORE X_NUC_201.L_CORE 0.001968
K_4210 X_NUC_20.L_CORE X_NUC_202.L_CORE 0.001357
K_4211 X_NUC_20.L_CORE X_NUC_203.L_CORE 0.002231
K_4212 X_NUC_20.L_CORE X_NUC_204.L_CORE 0.001481
K_4213 X_NUC_20.L_CORE X_NUC_205.L_CORE 0.001484
K_4214 X_NUC_20.L_CORE X_NUC_206.L_CORE 0.002032
K_4215 X_NUC_20.L_CORE X_NUC_207.L_CORE 0.001307
K_4216 X_NUC_20.L_CORE X_NUC_208.L_CORE 0.001749
K_4217 X_NUC_20.L_CORE X_NUC_209.L_CORE 0.001572
K_4218 X_NUC_20.L_CORE X_NUC_210.L_CORE 0.001319
K_4219 X_NUC_20.L_CORE X_NUC_211.L_CORE 0.001856
K_4220 X_NUC_20.L_CORE X_NUC_212.L_CORE 0.001324
K_4221 X_NUC_20.L_CORE X_NUC_213.L_CORE 0.001457
K_4222 X_NUC_20.L_CORE X_NUC_214.L_CORE 0.001610
K_4223 X_NUC_20.L_CORE X_NUC_215.L_CORE 0.001260
K_4224 X_NUC_20.L_CORE X_NUC_216.L_CORE 0.001584
K_4225 X_NUC_20.L_CORE X_NUC_217.L_CORE 0.001367
K_4226 X_NUC_20.L_CORE X_NUC_218.L_CORE 0.001312
K_4227 X_NUC_20.L_CORE X_NUC_219.L_CORE 0.001511
K_4228 X_NUC_20.L_CORE X_NUC_220.L_CORE 0.001272
K_4229 X_NUC_20.L_CORE X_NUC_221.L_CORE 0.001374
K_4230 X_NUC_20.L_CORE X_NUC_222.L_CORE 0.001350
K_4231 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_4232 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_4233 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_4234 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.002017
K_4235 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.001998
K_4236 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.002008
K_4237 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.002005
K_4238 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.002683
K_4239 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.002667
K_4240 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.002657
K_4241 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.002688
K_4242 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.003870
K_4243 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.003836
K_4244 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.003873
K_4245 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.003813
K_4246 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.001732
K_4247 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.001718
K_4248 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.001722
K_4249 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.001726
K_4250 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.005011
K_4251 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.005046
K_4252 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.004940
K_4253 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.005041
K_4254 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.002049
K_4255 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.002032
K_4256 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.002043
K_4257 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.002033
K_4258 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.001871
K_4259 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.001861
K_4260 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.001857
K_4261 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.001869
K_4262 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.004909
K_4263 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.004936
K_4264 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.004903
K_4265 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.004827
K_4266 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.001590
K_4267 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.001578
K_4268 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.001582
K_4269 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.001582
K_4270 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.002552
K_4271 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.002550
K_4272 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.002527
K_4273 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.002555
K_4274 X_NUC_21.L_CORE X_NUC_65.L_CORE 0.002315
K_4275 X_NUC_21.L_CORE X_NUC_66.L_CORE 0.002302
K_4276 X_NUC_21.L_CORE X_NUC_67.L_CORE 0.002310
K_4277 X_NUC_21.L_CORE X_NUC_68.L_CORE 0.002291
K_4278 X_NUC_21.L_CORE X_NUC_69.L_CORE 0.001540
K_4279 X_NUC_21.L_CORE X_NUC_70.L_CORE 0.001531
K_4280 X_NUC_21.L_CORE X_NUC_71.L_CORE 0.001530
K_4281 X_NUC_21.L_CORE X_NUC_72.L_CORE 0.001535
K_4282 X_NUC_21.L_CORE X_NUC_73.L_CORE 0.003681
K_4283 X_NUC_21.L_CORE X_NUC_74.L_CORE 0.003712
K_4284 X_NUC_21.L_CORE X_NUC_75.L_CORE 0.003651
K_4285 X_NUC_21.L_CORE X_NUC_76.L_CORE 0.003664
K_4286 X_NUC_21.L_CORE X_NUC_77.L_CORE 0.001607
K_4287 X_NUC_21.L_CORE X_NUC_78.L_CORE 0.001596
K_4288 X_NUC_21.L_CORE X_NUC_79.L_CORE 0.001600
K_4289 X_NUC_21.L_CORE X_NUC_80.L_CORE 0.001596
K_4290 X_NUC_21.L_CORE X_NUC_81.L_CORE 0.001796
K_4291 X_NUC_21.L_CORE X_NUC_82.L_CORE 0.001790
K_4292 X_NUC_21.L_CORE X_NUC_83.L_CORE 0.001782
K_4293 X_NUC_21.L_CORE X_NUC_84.L_CORE 0.001794
K_4294 X_NUC_21.L_CORE X_NUC_85.L_CORE 0.002632
K_4295 X_NUC_21.L_CORE X_NUC_86.L_CORE 0.002631
K_4296 X_NUC_21.L_CORE X_NUC_87.L_CORE 0.002625
K_4297 X_NUC_21.L_CORE X_NUC_88.L_CORE 0.002603
K_4298 X_NUC_21.L_CORE X_NUC_89.L_CORE 0.001412
K_4299 X_NUC_21.L_CORE X_NUC_90.L_CORE 0.001403
K_4300 X_NUC_21.L_CORE X_NUC_91.L_CORE 0.001404
K_4301 X_NUC_21.L_CORE X_NUC_92.L_CORE 0.001405
K_4302 X_NUC_21.L_CORE X_NUC_93.L_CORE 0.002381
K_4303 X_NUC_21.L_CORE X_NUC_94.L_CORE 0.002386
K_4304 X_NUC_21.L_CORE X_NUC_95.L_CORE 0.002361
K_4305 X_NUC_21.L_CORE X_NUC_96.L_CORE 0.002377
K_4306 X_NUC_21.L_CORE X_NUC_97.L_CORE 0.001729
K_4307 X_NUC_21.L_CORE X_NUC_98.L_CORE 0.001720
K_4308 X_NUC_21.L_CORE X_NUC_99.L_CORE 0.001722
K_4309 X_NUC_21.L_CORE X_NUC_100.L_CORE 0.001715
K_4310 X_NUC_21.L_CORE X_NUC_101.L_CORE 0.001475
K_4311 X_NUC_21.L_CORE X_NUC_102.L_CORE 0.001468
K_4312 X_NUC_21.L_CORE X_NUC_103.L_CORE 0.001465
K_4313 X_NUC_21.L_CORE X_NUC_104.L_CORE 0.001471
K_4314 X_NUC_21.L_CORE X_NUC_105.L_CORE 0.002531
K_4315 X_NUC_21.L_CORE X_NUC_106.L_CORE 0.002539
K_4316 X_NUC_21.L_CORE X_NUC_107.L_CORE 0.002517
K_4317 X_NUC_21.L_CORE X_NUC_108.L_CORE 0.002511
K_4318 X_NUC_21.L_CORE X_NUC_109.L_CORE 0.001398
K_4319 X_NUC_21.L_CORE X_NUC_110.L_CORE 0.001390
K_4320 X_NUC_21.L_CORE X_NUC_111.L_CORE 0.001391
K_4321 X_NUC_21.L_CORE X_NUC_112.L_CORE 0.001390
K_4322 X_NUC_21.L_CORE X_NUC_113.L_CORE 0.001753
K_4323 X_NUC_21.L_CORE X_NUC_114.L_CORE 0.001750
K_4324 X_NUC_21.L_CORE X_NUC_115.L_CORE 0.001739
K_4325 X_NUC_21.L_CORE X_NUC_116.L_CORE 0.001749
K_4326 X_NUC_21.L_CORE X_NUC_117.L_CORE 0.001871
K_4327 X_NUC_21.L_CORE X_NUC_118.L_CORE 0.001866
K_4328 X_NUC_21.L_CORE X_NUC_119.L_CORE 0.001863
K_4329 X_NUC_21.L_CORE X_NUC_120.L_CORE 0.001855
K_4330 X_NUC_21.L_CORE X_NUC_121.L_CORE 0.001340
K_4331 X_NUC_21.L_CORE X_NUC_122.L_CORE 0.001333
K_4332 X_NUC_21.L_CORE X_NUC_123.L_CORE 0.001331
K_4333 X_NUC_21.L_CORE X_NUC_124.L_CORE 0.001334
K_4334 X_NUC_21.L_CORE X_NUC_125.L_CORE 0.002047
K_4335 X_NUC_21.L_CORE X_NUC_126.L_CORE 0.002050
K_4336 X_NUC_21.L_CORE X_NUC_127.L_CORE 0.002032
K_4337 X_NUC_21.L_CORE X_NUC_128.L_CORE 0.002037
K_4338 X_NUC_21.L_CORE X_NUC_129.L_CORE 0.001455
K_4339 X_NUC_21.L_CORE X_NUC_130.L_CORE 0.001448
K_4340 X_NUC_21.L_CORE X_NUC_131.L_CORE 0.001448
K_4341 X_NUC_21.L_CORE X_NUC_132.L_CORE 0.001445
K_4342 X_NUC_21.L_CORE X_NUC_133.L_CORE 0.001454
K_4343 X_NUC_21.L_CORE X_NUC_134.L_CORE 0.001450
K_4344 X_NUC_21.L_CORE X_NUC_135.L_CORE 0.001444
K_4345 X_NUC_21.L_CORE X_NUC_136.L_CORE 0.001450
K_4346 X_NUC_21.L_CORE X_NUC_137.L_CORE 0.001861
K_4347 X_NUC_21.L_CORE X_NUC_138.L_CORE 0.001860
K_4348 X_NUC_21.L_CORE X_NUC_139.L_CORE 0.001851
K_4349 X_NUC_21.L_CORE X_NUC_140.L_CORE 0.001847
K_4350 X_NUC_21.L_CORE X_NUC_141.L_CORE 0.001310
K_4351 X_NUC_21.L_CORE X_NUC_142.L_CORE 0.001304
K_4352 X_NUC_21.L_CORE X_NUC_143.L_CORE 0.001303
K_4353 X_NUC_21.L_CORE X_NUC_144.L_CORE 0.001304
K_4354 X_NUC_21.L_CORE X_NUC_145.L_CORE 0.001640
K_4355 X_NUC_21.L_CORE X_NUC_146.L_CORE 0.001639
K_4356 X_NUC_21.L_CORE X_NUC_147.L_CORE 0.001629
K_4357 X_NUC_21.L_CORE X_NUC_148.L_CORE 0.001634
K_4358 X_NUC_21.L_CORE X_NUC_149.L_CORE 0.001514
K_4359 X_NUC_21.L_CORE X_NUC_150.L_CORE 0.001510
K_4360 X_NUC_21.L_CORE X_NUC_151.L_CORE 0.001507
K_4361 X_NUC_21.L_CORE X_NUC_152.L_CORE 0.001504
K_4362 X_NUC_21.L_CORE X_NUC_153.L_CORE 0.001332
K_4363 X_NUC_21.L_CORE X_NUC_154.L_CORE 0.001327
K_4364 X_NUC_21.L_CORE X_NUC_155.L_CORE 0.001323
K_4365 X_NUC_21.L_CORE X_NUC_156.L_CORE 0.001326
K_4366 X_NUC_21.L_CORE X_NUC_157.L_CORE 0.001641
K_4367 X_NUC_21.L_CORE X_NUC_158.L_CORE 0.001640
K_4368 X_NUC_21.L_CORE X_NUC_159.L_CORE 0.001631
K_4369 X_NUC_21.L_CORE X_NUC_160.L_CORE 0.001632
K_4370 X_NUC_21.L_CORE X_NUC_161.L_CORE 0.001346
K_4371 X_NUC_21.L_CORE X_NUC_162.L_CORE 0.001342
K_4372 X_NUC_21.L_CORE X_NUC_163.L_CORE 0.001339
K_4373 X_NUC_21.L_CORE X_NUC_164.L_CORE 0.001339
K_4374 X_NUC_21.L_CORE X_NUC_165.L_CORE 0.001416
K_4375 X_NUC_21.L_CORE X_NUC_166.L_CORE 0.001413
K_4376 X_NUC_21.L_CORE X_NUC_167.L_CORE 0.001407
K_4377 X_NUC_21.L_CORE X_NUC_168.L_CORE 0.001410
K_4378 X_NUC_21.L_CORE X_NUC_169.L_CORE 0.001442
K_4379 X_NUC_21.L_CORE X_NUC_170.L_CORE 0.001439
K_4380 X_NUC_21.L_CORE X_NUC_171.L_CORE 0.001434
K_4381 X_NUC_21.L_CORE X_NUC_172.L_CORE 0.001434
K_4382 X_NUC_21.L_CORE X_NUC_173.L_CORE 0.004387
K_4383 X_NUC_21.L_CORE X_NUC_174.L_CORE 0.002428
K_4384 X_NUC_21.L_CORE X_NUC_175.L_CORE 0.004475
K_4385 X_NUC_21.L_CORE X_NUC_176.L_CORE 0.003054
K_4386 X_NUC_21.L_CORE X_NUC_177.L_CORE 0.002149
K_4387 X_NUC_21.L_CORE X_NUC_178.L_CORE 0.027832
K_4388 X_NUC_21.L_CORE X_NUC_179.L_CORE 0.001993
K_4389 X_NUC_21.L_CORE X_NUC_180.L_CORE 0.002663
K_4390 X_NUC_21.L_CORE X_NUC_181.L_CORE 0.003882
K_4391 X_NUC_21.L_CORE X_NUC_182.L_CORE 0.001716
K_4392 X_NUC_21.L_CORE X_NUC_183.L_CORE 0.005302
K_4393 X_NUC_21.L_CORE X_NUC_184.L_CORE 0.002041
K_4394 X_NUC_21.L_CORE X_NUC_185.L_CORE 0.001864
K_4395 X_NUC_21.L_CORE X_NUC_186.L_CORE 0.005504
K_4396 X_NUC_21.L_CORE X_NUC_187.L_CORE 0.001578
K_4397 X_NUC_21.L_CORE X_NUC_188.L_CORE 0.002613
K_4398 X_NUC_21.L_CORE X_NUC_189.L_CORE 0.002354
K_4399 X_NUC_21.L_CORE X_NUC_190.L_CORE 0.001530
K_4400 X_NUC_21.L_CORE X_NUC_191.L_CORE 0.004187
K_4401 X_NUC_21.L_CORE X_NUC_192.L_CORE 0.001601
K_4402 X_NUC_21.L_CORE X_NUC_193.L_CORE 0.001810
K_4403 X_NUC_21.L_CORE X_NUC_194.L_CORE 0.002818
K_4404 X_NUC_21.L_CORE X_NUC_195.L_CORE 0.001399
K_4405 X_NUC_21.L_CORE X_NUC_196.L_CORE 0.002539
K_4406 X_NUC_21.L_CORE X_NUC_197.L_CORE 0.001748
K_4407 X_NUC_21.L_CORE X_NUC_198.L_CORE 0.001469
K_4408 X_NUC_21.L_CORE X_NUC_199.L_CORE 0.002845
K_4409 X_NUC_21.L_CORE X_NUC_200.L_CORE 0.001385
K_4410 X_NUC_21.L_CORE X_NUC_201.L_CORE 0.001802
K_4411 X_NUC_21.L_CORE X_NUC_202.L_CORE 0.001962
K_4412 X_NUC_21.L_CORE X_NUC_203.L_CORE 0.001321
K_4413 X_NUC_21.L_CORE X_NUC_204.L_CORE 0.002263
K_4414 X_NUC_21.L_CORE X_NUC_205.L_CORE 0.001455
K_4415 X_NUC_21.L_CORE X_NUC_206.L_CORE 0.001458
K_4416 X_NUC_21.L_CORE X_NUC_207.L_CORE 0.002056
K_4417 X_NUC_21.L_CORE X_NUC_208.L_CORE 0.001280
K_4418 X_NUC_21.L_CORE X_NUC_209.L_CORE 0.001747
K_4419 X_NUC_21.L_CORE X_NUC_210.L_CORE 0.001562
K_4420 X_NUC_21.L_CORE X_NUC_211.L_CORE 0.001299
K_4421 X_NUC_21.L_CORE X_NUC_212.L_CORE 0.001871
K_4422 X_NUC_21.L_CORE X_NUC_213.L_CORE 0.001309
K_4423 X_NUC_21.L_CORE X_NUC_214.L_CORE 0.001447
K_4424 X_NUC_21.L_CORE X_NUC_215.L_CORE 0.001610
K_4425 X_NUC_21.L_CORE X_NUC_216.L_CORE 0.001248
K_4426 X_NUC_21.L_CORE X_NUC_217.L_CORE 0.001580
K_4427 X_NUC_21.L_CORE X_NUC_218.L_CORE 0.001362
K_4428 X_NUC_21.L_CORE X_NUC_219.L_CORE 0.001308
K_4429 X_NUC_21.L_CORE X_NUC_220.L_CORE 0.001497
K_4430 X_NUC_21.L_CORE X_NUC_221.L_CORE 0.001279
K_4431 X_NUC_21.L_CORE X_NUC_222.L_CORE 0.001360
K_4432 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_4433 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_4434 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.002036
K_4435 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.002017
K_4436 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.002027
K_4437 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.002024
K_4438 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.002698
K_4439 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.002683
K_4440 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.002672
K_4441 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.002703
K_4442 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.003904
K_4443 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.003870
K_4444 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.003908
K_4445 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.003845
K_4446 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.001746
K_4447 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.001732
K_4448 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.001735
K_4449 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.001740
K_4450 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.004974
K_4451 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.005011
K_4452 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.004906
K_4453 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.005004
K_4454 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.002066
K_4455 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.002049
K_4456 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.002060
K_4457 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.002049
K_4458 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.001882
K_4459 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.001871
K_4460 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.001868
K_4461 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.001880
K_4462 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.004879
K_4463 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.004909
K_4464 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.004875
K_4465 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.004801
K_4466 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.001602
K_4467 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.001590
K_4468 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.001593
K_4469 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.001593
K_4470 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.002554
K_4471 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.002552
K_4472 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.002529
K_4473 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.002557
K_4474 X_NUC_22.L_CORE X_NUC_65.L_CORE 0.002328
K_4475 X_NUC_22.L_CORE X_NUC_66.L_CORE 0.002315
K_4476 X_NUC_22.L_CORE X_NUC_67.L_CORE 0.002323
K_4477 X_NUC_22.L_CORE X_NUC_68.L_CORE 0.002304
K_4478 X_NUC_22.L_CORE X_NUC_69.L_CORE 0.001549
K_4479 X_NUC_22.L_CORE X_NUC_70.L_CORE 0.001540
K_4480 X_NUC_22.L_CORE X_NUC_71.L_CORE 0.001539
K_4481 X_NUC_22.L_CORE X_NUC_72.L_CORE 0.001545
K_4482 X_NUC_22.L_CORE X_NUC_73.L_CORE 0.003650
K_4483 X_NUC_22.L_CORE X_NUC_74.L_CORE 0.003681
K_4484 X_NUC_22.L_CORE X_NUC_75.L_CORE 0.003621
K_4485 X_NUC_22.L_CORE X_NUC_76.L_CORE 0.003633
K_4486 X_NUC_22.L_CORE X_NUC_77.L_CORE 0.001617
K_4487 X_NUC_22.L_CORE X_NUC_78.L_CORE 0.001607
K_4488 X_NUC_22.L_CORE X_NUC_79.L_CORE 0.001610
K_4489 X_NUC_22.L_CORE X_NUC_80.L_CORE 0.001606
K_4490 X_NUC_22.L_CORE X_NUC_81.L_CORE 0.001802
K_4491 X_NUC_22.L_CORE X_NUC_82.L_CORE 0.001796
K_4492 X_NUC_22.L_CORE X_NUC_83.L_CORE 0.001788
K_4493 X_NUC_22.L_CORE X_NUC_84.L_CORE 0.001800
K_4494 X_NUC_22.L_CORE X_NUC_85.L_CORE 0.002634
K_4495 X_NUC_22.L_CORE X_NUC_86.L_CORE 0.002632
K_4496 X_NUC_22.L_CORE X_NUC_87.L_CORE 0.002626
K_4497 X_NUC_22.L_CORE X_NUC_88.L_CORE 0.002605
K_4498 X_NUC_22.L_CORE X_NUC_89.L_CORE 0.001420
K_4499 X_NUC_22.L_CORE X_NUC_90.L_CORE 0.001412
K_4500 X_NUC_22.L_CORE X_NUC_91.L_CORE 0.001412
K_4501 X_NUC_22.L_CORE X_NUC_92.L_CORE 0.001414
K_4502 X_NUC_22.L_CORE X_NUC_93.L_CORE 0.002377
K_4503 X_NUC_22.L_CORE X_NUC_94.L_CORE 0.002381
K_4504 X_NUC_22.L_CORE X_NUC_95.L_CORE 0.002356
K_4505 X_NUC_22.L_CORE X_NUC_96.L_CORE 0.002373
K_4506 X_NUC_22.L_CORE X_NUC_97.L_CORE 0.001737
K_4507 X_NUC_22.L_CORE X_NUC_98.L_CORE 0.001729
K_4508 X_NUC_22.L_CORE X_NUC_99.L_CORE 0.001731
K_4509 X_NUC_22.L_CORE X_NUC_100.L_CORE 0.001723
K_4510 X_NUC_22.L_CORE X_NUC_101.L_CORE 0.001481
K_4511 X_NUC_22.L_CORE X_NUC_102.L_CORE 0.001475
K_4512 X_NUC_22.L_CORE X_NUC_103.L_CORE 0.001471
K_4513 X_NUC_22.L_CORE X_NUC_104.L_CORE 0.001477
K_4514 X_NUC_22.L_CORE X_NUC_105.L_CORE 0.002523
K_4515 X_NUC_22.L_CORE X_NUC_106.L_CORE 0.002531
K_4516 X_NUC_22.L_CORE X_NUC_107.L_CORE 0.002509
K_4517 X_NUC_22.L_CORE X_NUC_108.L_CORE 0.002504
K_4518 X_NUC_22.L_CORE X_NUC_109.L_CORE 0.001406
K_4519 X_NUC_22.L_CORE X_NUC_110.L_CORE 0.001398
K_4520 X_NUC_22.L_CORE X_NUC_111.L_CORE 0.001399
K_4521 X_NUC_22.L_CORE X_NUC_112.L_CORE 0.001398
K_4522 X_NUC_22.L_CORE X_NUC_113.L_CORE 0.001755
K_4523 X_NUC_22.L_CORE X_NUC_114.L_CORE 0.001753
K_4524 X_NUC_22.L_CORE X_NUC_115.L_CORE 0.001741
K_4525 X_NUC_22.L_CORE X_NUC_116.L_CORE 0.001751
K_4526 X_NUC_22.L_CORE X_NUC_117.L_CORE 0.001875
K_4527 X_NUC_22.L_CORE X_NUC_118.L_CORE 0.001871
K_4528 X_NUC_22.L_CORE X_NUC_119.L_CORE 0.001868
K_4529 X_NUC_22.L_CORE X_NUC_120.L_CORE 0.001859
K_4530 X_NUC_22.L_CORE X_NUC_121.L_CORE 0.001346
K_4531 X_NUC_22.L_CORE X_NUC_122.L_CORE 0.001340
K_4532 X_NUC_22.L_CORE X_NUC_123.L_CORE 0.001338
K_4533 X_NUC_22.L_CORE X_NUC_124.L_CORE 0.001340
K_4534 X_NUC_22.L_CORE X_NUC_125.L_CORE 0.002043
K_4535 X_NUC_22.L_CORE X_NUC_126.L_CORE 0.002047
K_4536 X_NUC_22.L_CORE X_NUC_127.L_CORE 0.002029
K_4537 X_NUC_22.L_CORE X_NUC_128.L_CORE 0.002034
K_4538 X_NUC_22.L_CORE X_NUC_129.L_CORE 0.001461
K_4539 X_NUC_22.L_CORE X_NUC_130.L_CORE 0.001455
K_4540 X_NUC_22.L_CORE X_NUC_131.L_CORE 0.001454
K_4541 X_NUC_22.L_CORE X_NUC_132.L_CORE 0.001451
K_4542 X_NUC_22.L_CORE X_NUC_133.L_CORE 0.001459
K_4543 X_NUC_22.L_CORE X_NUC_134.L_CORE 0.001454
K_4544 X_NUC_22.L_CORE X_NUC_135.L_CORE 0.001448
K_4545 X_NUC_22.L_CORE X_NUC_136.L_CORE 0.001454
K_4546 X_NUC_22.L_CORE X_NUC_137.L_CORE 0.001861
K_4547 X_NUC_22.L_CORE X_NUC_138.L_CORE 0.001861
K_4548 X_NUC_22.L_CORE X_NUC_139.L_CORE 0.001852
K_4549 X_NUC_22.L_CORE X_NUC_140.L_CORE 0.001848
K_4550 X_NUC_22.L_CORE X_NUC_141.L_CORE 0.001316
K_4551 X_NUC_22.L_CORE X_NUC_142.L_CORE 0.001310
K_4552 X_NUC_22.L_CORE X_NUC_143.L_CORE 0.001309
K_4553 X_NUC_22.L_CORE X_NUC_144.L_CORE 0.001309
K_4554 X_NUC_22.L_CORE X_NUC_145.L_CORE 0.001641
K_4555 X_NUC_22.L_CORE X_NUC_146.L_CORE 0.001640
K_4556 X_NUC_22.L_CORE X_NUC_147.L_CORE 0.001630
K_4557 X_NUC_22.L_CORE X_NUC_148.L_CORE 0.001635
K_4558 X_NUC_22.L_CORE X_NUC_149.L_CORE 0.001519
K_4559 X_NUC_22.L_CORE X_NUC_150.L_CORE 0.001514
K_4560 X_NUC_22.L_CORE X_NUC_151.L_CORE 0.001512
K_4561 X_NUC_22.L_CORE X_NUC_152.L_CORE 0.001508
K_4562 X_NUC_22.L_CORE X_NUC_153.L_CORE 0.001336
K_4563 X_NUC_22.L_CORE X_NUC_154.L_CORE 0.001332
K_4564 X_NUC_22.L_CORE X_NUC_155.L_CORE 0.001328
K_4565 X_NUC_22.L_CORE X_NUC_156.L_CORE 0.001331
K_4566 X_NUC_22.L_CORE X_NUC_157.L_CORE 0.001642
K_4567 X_NUC_22.L_CORE X_NUC_158.L_CORE 0.001641
K_4568 X_NUC_22.L_CORE X_NUC_159.L_CORE 0.001632
K_4569 X_NUC_22.L_CORE X_NUC_160.L_CORE 0.001633
K_4570 X_NUC_22.L_CORE X_NUC_161.L_CORE 0.001351
K_4571 X_NUC_22.L_CORE X_NUC_162.L_CORE 0.001346
K_4572 X_NUC_22.L_CORE X_NUC_163.L_CORE 0.001344
K_4573 X_NUC_22.L_CORE X_NUC_164.L_CORE 0.001343
K_4574 X_NUC_22.L_CORE X_NUC_165.L_CORE 0.001419
K_4575 X_NUC_22.L_CORE X_NUC_166.L_CORE 0.001416
K_4576 X_NUC_22.L_CORE X_NUC_167.L_CORE 0.001410
K_4577 X_NUC_22.L_CORE X_NUC_168.L_CORE 0.001413
K_4578 X_NUC_22.L_CORE X_NUC_169.L_CORE 0.001445
K_4579 X_NUC_22.L_CORE X_NUC_170.L_CORE 0.001442
K_4580 X_NUC_22.L_CORE X_NUC_171.L_CORE 0.001437
K_4581 X_NUC_22.L_CORE X_NUC_172.L_CORE 0.001437
K_4582 X_NUC_22.L_CORE X_NUC_173.L_CORE 0.004468
K_4583 X_NUC_22.L_CORE X_NUC_174.L_CORE 0.002455
K_4584 X_NUC_22.L_CORE X_NUC_175.L_CORE 0.004524
K_4585 X_NUC_22.L_CORE X_NUC_176.L_CORE 0.003093
K_4586 X_NUC_22.L_CORE X_NUC_177.L_CORE 0.002168
K_4587 X_NUC_22.L_CORE X_NUC_178.L_CORE 0.027538
K_4588 X_NUC_22.L_CORE X_NUC_179.L_CORE 0.002012
K_4589 X_NUC_22.L_CORE X_NUC_180.L_CORE 0.002678
K_4590 X_NUC_22.L_CORE X_NUC_181.L_CORE 0.003916
K_4591 X_NUC_22.L_CORE X_NUC_182.L_CORE 0.001730
K_4592 X_NUC_22.L_CORE X_NUC_183.L_CORE 0.005255
K_4593 X_NUC_22.L_CORE X_NUC_184.L_CORE 0.002058
K_4594 X_NUC_22.L_CORE X_NUC_185.L_CORE 0.001875
K_4595 X_NUC_22.L_CORE X_NUC_186.L_CORE 0.005457
K_4596 X_NUC_22.L_CORE X_NUC_187.L_CORE 0.001590
K_4597 X_NUC_22.L_CORE X_NUC_188.L_CORE 0.002614
K_4598 X_NUC_22.L_CORE X_NUC_189.L_CORE 0.002368
K_4599 X_NUC_22.L_CORE X_NUC_190.L_CORE 0.001540
K_4600 X_NUC_22.L_CORE X_NUC_191.L_CORE 0.004135
K_4601 X_NUC_22.L_CORE X_NUC_192.L_CORE 0.001612
K_4602 X_NUC_22.L_CORE X_NUC_193.L_CORE 0.001816
K_4603 X_NUC_22.L_CORE X_NUC_194.L_CORE 0.002818
K_4604 X_NUC_22.L_CORE X_NUC_195.L_CORE 0.001407
K_4605 X_NUC_22.L_CORE X_NUC_196.L_CORE 0.002532
K_4606 X_NUC_22.L_CORE X_NUC_197.L_CORE 0.001758
K_4607 X_NUC_22.L_CORE X_NUC_198.L_CORE 0.001476
K_4608 X_NUC_22.L_CORE X_NUC_199.L_CORE 0.002830
K_4609 X_NUC_22.L_CORE X_NUC_200.L_CORE 0.001394
K_4610 X_NUC_22.L_CORE X_NUC_201.L_CORE 0.001804
K_4611 X_NUC_22.L_CORE X_NUC_202.L_CORE 0.001966
K_4612 X_NUC_22.L_CORE X_NUC_203.L_CORE 0.001327
K_4613 X_NUC_22.L_CORE X_NUC_204.L_CORE 0.002255
K_4614 X_NUC_22.L_CORE X_NUC_205.L_CORE 0.001462
K_4615 X_NUC_22.L_CORE X_NUC_206.L_CORE 0.001462
K_4616 X_NUC_22.L_CORE X_NUC_207.L_CORE 0.002054
K_4617 X_NUC_22.L_CORE X_NUC_208.L_CORE 0.001287
K_4618 X_NUC_22.L_CORE X_NUC_209.L_CORE 0.001746
K_4619 X_NUC_22.L_CORE X_NUC_210.L_CORE 0.001567
K_4620 X_NUC_22.L_CORE X_NUC_211.L_CORE 0.001304
K_4621 X_NUC_22.L_CORE X_NUC_212.L_CORE 0.001869
K_4622 X_NUC_22.L_CORE X_NUC_213.L_CORE 0.001314
K_4623 X_NUC_22.L_CORE X_NUC_214.L_CORE 0.001449
K_4624 X_NUC_22.L_CORE X_NUC_215.L_CORE 0.001612
K_4625 X_NUC_22.L_CORE X_NUC_216.L_CORE 0.001253
K_4626 X_NUC_22.L_CORE X_NUC_217.L_CORE 0.001581
K_4627 X_NUC_22.L_CORE X_NUC_218.L_CORE 0.001366
K_4628 X_NUC_22.L_CORE X_NUC_219.L_CORE 0.001311
K_4629 X_NUC_22.L_CORE X_NUC_220.L_CORE 0.001499
K_4630 X_NUC_22.L_CORE X_NUC_221.L_CORE 0.001283
K_4631 X_NUC_22.L_CORE X_NUC_222.L_CORE 0.001363
K_4632 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_4633 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.002025
K_4634 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.002006
K_4635 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.002017
K_4636 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.002013
K_4637 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.002708
K_4638 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.002693
K_4639 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.002683
K_4640 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.002714
K_4641 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.003866
K_4642 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.003833
K_4643 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.003870
K_4644 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.003809
K_4645 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.001742
K_4646 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.001728
K_4647 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.001732
K_4648 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.001736
K_4649 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.005082
K_4650 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.005121
K_4651 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.005011
K_4652 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.005115
K_4653 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.002056
K_4654 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.002039
K_4655 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.002049
K_4656 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.002039
K_4657 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.001886
K_4658 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.001875
K_4659 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.001871
K_4660 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.001884
K_4661 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.004912
K_4662 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.004940
K_4663 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.004909
K_4664 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.004832
K_4665 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.001598
K_4666 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.001586
K_4667 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.001590
K_4668 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.001590
K_4669 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.002577
K_4670 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.002575
K_4671 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.002552
K_4672 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.002580
K_4673 X_NUC_23.L_CORE X_NUC_65.L_CORE 0.002320
K_4674 X_NUC_23.L_CORE X_NUC_66.L_CORE 0.002307
K_4675 X_NUC_23.L_CORE X_NUC_67.L_CORE 0.002315
K_4676 X_NUC_23.L_CORE X_NUC_68.L_CORE 0.002296
K_4677 X_NUC_23.L_CORE X_NUC_69.L_CORE 0.001550
K_4678 X_NUC_23.L_CORE X_NUC_70.L_CORE 0.001541
K_4679 X_NUC_23.L_CORE X_NUC_71.L_CORE 0.001540
K_4680 X_NUC_23.L_CORE X_NUC_72.L_CORE 0.001546
K_4681 X_NUC_23.L_CORE X_NUC_73.L_CORE 0.003712
K_4682 X_NUC_23.L_CORE X_NUC_74.L_CORE 0.003744
K_4683 X_NUC_23.L_CORE X_NUC_75.L_CORE 0.003681
K_4684 X_NUC_23.L_CORE X_NUC_76.L_CORE 0.003694
K_4685 X_NUC_23.L_CORE X_NUC_77.L_CORE 0.001614
K_4686 X_NUC_23.L_CORE X_NUC_78.L_CORE 0.001603
K_4687 X_NUC_23.L_CORE X_NUC_79.L_CORE 0.001607
K_4688 X_NUC_23.L_CORE X_NUC_80.L_CORE 0.001603
K_4689 X_NUC_23.L_CORE X_NUC_81.L_CORE 0.001810
K_4690 X_NUC_23.L_CORE X_NUC_82.L_CORE 0.001804
K_4691 X_NUC_23.L_CORE X_NUC_83.L_CORE 0.001796
K_4692 X_NUC_23.L_CORE X_NUC_84.L_CORE 0.001808
K_4693 X_NUC_23.L_CORE X_NUC_85.L_CORE 0.002640
K_4694 X_NUC_23.L_CORE X_NUC_86.L_CORE 0.002638
K_4695 X_NUC_23.L_CORE X_NUC_87.L_CORE 0.002632
K_4696 X_NUC_23.L_CORE X_NUC_88.L_CORE 0.002611
K_4697 X_NUC_23.L_CORE X_NUC_89.L_CORE 0.001420
K_4698 X_NUC_23.L_CORE X_NUC_90.L_CORE 0.001411
K_4699 X_NUC_23.L_CORE X_NUC_91.L_CORE 0.001412
K_4700 X_NUC_23.L_CORE X_NUC_92.L_CORE 0.001413
K_4701 X_NUC_23.L_CORE X_NUC_93.L_CORE 0.002402
K_4702 X_NUC_23.L_CORE X_NUC_94.L_CORE 0.002407
K_4703 X_NUC_23.L_CORE X_NUC_95.L_CORE 0.002381
K_4704 X_NUC_23.L_CORE X_NUC_96.L_CORE 0.002398
K_4705 X_NUC_23.L_CORE X_NUC_97.L_CORE 0.001735
K_4706 X_NUC_23.L_CORE X_NUC_98.L_CORE 0.001726
K_4707 X_NUC_23.L_CORE X_NUC_99.L_CORE 0.001729
K_4708 X_NUC_23.L_CORE X_NUC_100.L_CORE 0.001721
K_4709 X_NUC_23.L_CORE X_NUC_101.L_CORE 0.001485
K_4710 X_NUC_23.L_CORE X_NUC_102.L_CORE 0.001478
K_4711 X_NUC_23.L_CORE X_NUC_103.L_CORE 0.001475
K_4712 X_NUC_23.L_CORE X_NUC_104.L_CORE 0.001481
K_4713 X_NUC_23.L_CORE X_NUC_105.L_CORE 0.002545
K_4714 X_NUC_23.L_CORE X_NUC_106.L_CORE 0.002553
K_4715 X_NUC_23.L_CORE X_NUC_107.L_CORE 0.002531
K_4716 X_NUC_23.L_CORE X_NUC_108.L_CORE 0.002525
K_4717 X_NUC_23.L_CORE X_NUC_109.L_CORE 0.001405
K_4718 X_NUC_23.L_CORE X_NUC_110.L_CORE 0.001397
K_4719 X_NUC_23.L_CORE X_NUC_111.L_CORE 0.001398
K_4720 X_NUC_23.L_CORE X_NUC_112.L_CORE 0.001397
K_4721 X_NUC_23.L_CORE X_NUC_113.L_CORE 0.001766
K_4722 X_NUC_23.L_CORE X_NUC_114.L_CORE 0.001764
K_4723 X_NUC_23.L_CORE X_NUC_115.L_CORE 0.001753
K_4724 X_NUC_23.L_CORE X_NUC_116.L_CORE 0.001763
K_4725 X_NUC_23.L_CORE X_NUC_117.L_CORE 0.001878
K_4726 X_NUC_23.L_CORE X_NUC_118.L_CORE 0.001874
K_4727 X_NUC_23.L_CORE X_NUC_119.L_CORE 0.001871
K_4728 X_NUC_23.L_CORE X_NUC_120.L_CORE 0.001862
K_4729 X_NUC_23.L_CORE X_NUC_121.L_CORE 0.001348
K_4730 X_NUC_23.L_CORE X_NUC_122.L_CORE 0.001341
K_4731 X_NUC_23.L_CORE X_NUC_123.L_CORE 0.001340
K_4732 X_NUC_23.L_CORE X_NUC_124.L_CORE 0.001342
K_4733 X_NUC_23.L_CORE X_NUC_125.L_CORE 0.002061
K_4734 X_NUC_23.L_CORE X_NUC_126.L_CORE 0.002065
K_4735 X_NUC_23.L_CORE X_NUC_127.L_CORE 0.002047
K_4736 X_NUC_23.L_CORE X_NUC_128.L_CORE 0.002052
K_4737 X_NUC_23.L_CORE X_NUC_129.L_CORE 0.001461
K_4738 X_NUC_23.L_CORE X_NUC_130.L_CORE 0.001455
K_4739 X_NUC_23.L_CORE X_NUC_131.L_CORE 0.001455
K_4740 X_NUC_23.L_CORE X_NUC_132.L_CORE 0.001451
K_4741 X_NUC_23.L_CORE X_NUC_133.L_CORE 0.001465
K_4742 X_NUC_23.L_CORE X_NUC_134.L_CORE 0.001460
K_4743 X_NUC_23.L_CORE X_NUC_135.L_CORE 0.001454
K_4744 X_NUC_23.L_CORE X_NUC_136.L_CORE 0.001460
K_4745 X_NUC_23.L_CORE X_NUC_137.L_CORE 0.001870
K_4746 X_NUC_23.L_CORE X_NUC_138.L_CORE 0.001870
K_4747 X_NUC_23.L_CORE X_NUC_139.L_CORE 0.001861
K_4748 X_NUC_23.L_CORE X_NUC_140.L_CORE 0.001856
K_4749 X_NUC_23.L_CORE X_NUC_141.L_CORE 0.001318
K_4750 X_NUC_23.L_CORE X_NUC_142.L_CORE 0.001312
K_4751 X_NUC_23.L_CORE X_NUC_143.L_CORE 0.001310
K_4752 X_NUC_23.L_CORE X_NUC_144.L_CORE 0.001311
K_4753 X_NUC_23.L_CORE X_NUC_145.L_CORE 0.001652
K_4754 X_NUC_23.L_CORE X_NUC_146.L_CORE 0.001651
K_4755 X_NUC_23.L_CORE X_NUC_147.L_CORE 0.001640
K_4756 X_NUC_23.L_CORE X_NUC_148.L_CORE 0.001645
K_4757 X_NUC_23.L_CORE X_NUC_149.L_CORE 0.001522
K_4758 X_NUC_23.L_CORE X_NUC_150.L_CORE 0.001517
K_4759 X_NUC_23.L_CORE X_NUC_151.L_CORE 0.001514
K_4760 X_NUC_23.L_CORE X_NUC_152.L_CORE 0.001511
K_4761 X_NUC_23.L_CORE X_NUC_153.L_CORE 0.001340
K_4762 X_NUC_23.L_CORE X_NUC_154.L_CORE 0.001335
K_4763 X_NUC_23.L_CORE X_NUC_155.L_CORE 0.001332
K_4764 X_NUC_23.L_CORE X_NUC_156.L_CORE 0.001334
K_4765 X_NUC_23.L_CORE X_NUC_157.L_CORE 0.001651
K_4766 X_NUC_23.L_CORE X_NUC_158.L_CORE 0.001650
K_4767 X_NUC_23.L_CORE X_NUC_159.L_CORE 0.001641
K_4768 X_NUC_23.L_CORE X_NUC_160.L_CORE 0.001642
K_4769 X_NUC_23.L_CORE X_NUC_161.L_CORE 0.001354
K_4770 X_NUC_23.L_CORE X_NUC_162.L_CORE 0.001349
K_4771 X_NUC_23.L_CORE X_NUC_163.L_CORE 0.001346
K_4772 X_NUC_23.L_CORE X_NUC_164.L_CORE 0.001346
K_4773 X_NUC_23.L_CORE X_NUC_165.L_CORE 0.001425
K_4774 X_NUC_23.L_CORE X_NUC_166.L_CORE 0.001422
K_4775 X_NUC_23.L_CORE X_NUC_167.L_CORE 0.001416
K_4776 X_NUC_23.L_CORE X_NUC_168.L_CORE 0.001419
K_4777 X_NUC_23.L_CORE X_NUC_169.L_CORE 0.001450
K_4778 X_NUC_23.L_CORE X_NUC_170.L_CORE 0.001447
K_4779 X_NUC_23.L_CORE X_NUC_171.L_CORE 0.001442
K_4780 X_NUC_23.L_CORE X_NUC_172.L_CORE 0.001442
K_4781 X_NUC_23.L_CORE X_NUC_173.L_CORE 0.004391
K_4782 X_NUC_23.L_CORE X_NUC_174.L_CORE 0.002439
K_4783 X_NUC_23.L_CORE X_NUC_175.L_CORE 0.004510
K_4784 X_NUC_23.L_CORE X_NUC_176.L_CORE 0.003056
K_4785 X_NUC_23.L_CORE X_NUC_177.L_CORE 0.002163
K_4786 X_NUC_23.L_CORE X_NUC_178.L_CORE 0.025288
K_4787 X_NUC_23.L_CORE X_NUC_179.L_CORE 0.002000
K_4788 X_NUC_23.L_CORE X_NUC_180.L_CORE 0.002686
K_4789 X_NUC_23.L_CORE X_NUC_181.L_CORE 0.003869
K_4790 X_NUC_23.L_CORE X_NUC_182.L_CORE 0.001726
K_4791 X_NUC_23.L_CORE X_NUC_183.L_CORE 0.005364
K_4792 X_NUC_23.L_CORE X_NUC_184.L_CORE 0.002046
K_4793 X_NUC_23.L_CORE X_NUC_185.L_CORE 0.001878
K_4794 X_NUC_23.L_CORE X_NUC_186.L_CORE 0.005477
K_4795 X_NUC_23.L_CORE X_NUC_187.L_CORE 0.001585
K_4796 X_NUC_23.L_CORE X_NUC_188.L_CORE 0.002637
K_4797 X_NUC_23.L_CORE X_NUC_189.L_CORE 0.002357
K_4798 X_NUC_23.L_CORE X_NUC_190.L_CORE 0.001540
K_4799 X_NUC_23.L_CORE X_NUC_191.L_CORE 0.004214
K_4800 X_NUC_23.L_CORE X_NUC_192.L_CORE 0.001607
K_4801 X_NUC_23.L_CORE X_NUC_193.L_CORE 0.001824
K_4802 X_NUC_23.L_CORE X_NUC_194.L_CORE 0.002821
K_4803 X_NUC_23.L_CORE X_NUC_195.L_CORE 0.001406
K_4804 X_NUC_23.L_CORE X_NUC_196.L_CORE 0.002561
K_4805 X_NUC_23.L_CORE X_NUC_197.L_CORE 0.001754
K_4806 X_NUC_23.L_CORE X_NUC_198.L_CORE 0.001479
K_4807 X_NUC_23.L_CORE X_NUC_199.L_CORE 0.002857
K_4808 X_NUC_23.L_CORE X_NUC_200.L_CORE 0.001392
K_4809 X_NUC_23.L_CORE X_NUC_201.L_CORE 0.001816
K_4810 X_NUC_23.L_CORE X_NUC_202.L_CORE 0.001967
K_4811 X_NUC_23.L_CORE X_NUC_203.L_CORE 0.001328
K_4812 X_NUC_23.L_CORE X_NUC_204.L_CORE 0.002279
K_4813 X_NUC_23.L_CORE X_NUC_205.L_CORE 0.001461
K_4814 X_NUC_23.L_CORE X_NUC_206.L_CORE 0.001468
K_4815 X_NUC_23.L_CORE X_NUC_207.L_CORE 0.002064
K_4816 X_NUC_23.L_CORE X_NUC_208.L_CORE 0.001287
K_4817 X_NUC_23.L_CORE X_NUC_209.L_CORE 0.001759
K_4818 X_NUC_23.L_CORE X_NUC_210.L_CORE 0.001568
K_4819 X_NUC_23.L_CORE X_NUC_211.L_CORE 0.001307
K_4820 X_NUC_23.L_CORE X_NUC_212.L_CORE 0.001882
K_4821 X_NUC_23.L_CORE X_NUC_213.L_CORE 0.001315
K_4822 X_NUC_23.L_CORE X_NUC_214.L_CORE 0.001456
K_4823 X_NUC_23.L_CORE X_NUC_215.L_CORE 0.001617
K_4824 X_NUC_23.L_CORE X_NUC_216.L_CORE 0.001255
K_4825 X_NUC_23.L_CORE X_NUC_217.L_CORE 0.001590
K_4826 X_NUC_23.L_CORE X_NUC_218.L_CORE 0.001368
K_4827 X_NUC_23.L_CORE X_NUC_219.L_CORE 0.001316
K_4828 X_NUC_23.L_CORE X_NUC_220.L_CORE 0.001506
K_4829 X_NUC_23.L_CORE X_NUC_221.L_CORE 0.001286
K_4830 X_NUC_23.L_CORE X_NUC_222.L_CORE 0.001368
K_4831 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.002028
K_4832 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.002009
K_4833 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.002020
K_4834 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.002017
K_4835 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.002677
K_4836 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.002662
K_4837 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.002652
K_4838 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.002683
K_4839 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.003929
K_4840 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.003895
K_4841 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.003933
K_4842 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.003870
K_4843 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.001738
K_4844 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.001724
K_4845 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.001727
K_4846 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.001732
K_4847 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.004979
K_4848 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.005015
K_4849 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.004911
K_4850 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.005011
K_4851 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.002066
K_4852 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.002049
K_4853 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.002059
K_4854 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.002049
K_4855 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.001873
K_4856 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.001863
K_4857 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.001859
K_4858 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.001871
K_4859 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.004991
K_4860 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.005021
K_4861 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.004987
K_4862 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.004909
K_4863 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.001598
K_4864 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.001586
K_4865 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.001590
K_4866 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.001590
K_4867 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.002549
K_4868 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.002547
K_4869 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.002525
K_4870 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.002552
K_4871 X_NUC_24.L_CORE X_NUC_65.L_CORE 0.002340
K_4872 X_NUC_24.L_CORE X_NUC_66.L_CORE 0.002326
K_4873 X_NUC_24.L_CORE X_NUC_67.L_CORE 0.002334
K_4874 X_NUC_24.L_CORE X_NUC_68.L_CORE 0.002315
K_4875 X_NUC_24.L_CORE X_NUC_69.L_CORE 0.001545
K_4876 X_NUC_24.L_CORE X_NUC_70.L_CORE 0.001535
K_4877 X_NUC_24.L_CORE X_NUC_71.L_CORE 0.001535
K_4878 X_NUC_24.L_CORE X_NUC_72.L_CORE 0.001540
K_4879 X_NUC_24.L_CORE X_NUC_73.L_CORE 0.003698
K_4880 X_NUC_24.L_CORE X_NUC_74.L_CORE 0.003730
K_4881 X_NUC_24.L_CORE X_NUC_75.L_CORE 0.003668
K_4882 X_NUC_24.L_CORE X_NUC_76.L_CORE 0.003681
K_4883 X_NUC_24.L_CORE X_NUC_77.L_CORE 0.001618
K_4884 X_NUC_24.L_CORE X_NUC_78.L_CORE 0.001607
K_4885 X_NUC_24.L_CORE X_NUC_79.L_CORE 0.001611
K_4886 X_NUC_24.L_CORE X_NUC_80.L_CORE 0.001607
K_4887 X_NUC_24.L_CORE X_NUC_81.L_CORE 0.001798
K_4888 X_NUC_24.L_CORE X_NUC_82.L_CORE 0.001792
K_4889 X_NUC_24.L_CORE X_NUC_83.L_CORE 0.001784
K_4890 X_NUC_24.L_CORE X_NUC_84.L_CORE 0.001796
K_4891 X_NUC_24.L_CORE X_NUC_85.L_CORE 0.002662
K_4892 X_NUC_24.L_CORE X_NUC_86.L_CORE 0.002661
K_4893 X_NUC_24.L_CORE X_NUC_87.L_CORE 0.002654
K_4894 X_NUC_24.L_CORE X_NUC_88.L_CORE 0.002632
K_4895 X_NUC_24.L_CORE X_NUC_89.L_CORE 0.001418
K_4896 X_NUC_24.L_CORE X_NUC_90.L_CORE 0.001409
K_4897 X_NUC_24.L_CORE X_NUC_91.L_CORE 0.001410
K_4898 X_NUC_24.L_CORE X_NUC_92.L_CORE 0.001412
K_4899 X_NUC_24.L_CORE X_NUC_93.L_CORE 0.002385
K_4900 X_NUC_24.L_CORE X_NUC_94.L_CORE 0.002390
K_4901 X_NUC_24.L_CORE X_NUC_95.L_CORE 0.002365
K_4902 X_NUC_24.L_CORE X_NUC_96.L_CORE 0.002381
K_4903 X_NUC_24.L_CORE X_NUC_97.L_CORE 0.001743
K_4904 X_NUC_24.L_CORE X_NUC_98.L_CORE 0.001734
K_4905 X_NUC_24.L_CORE X_NUC_99.L_CORE 0.001736
K_4906 X_NUC_24.L_CORE X_NUC_100.L_CORE 0.001729
K_4907 X_NUC_24.L_CORE X_NUC_101.L_CORE 0.001479
K_4908 X_NUC_24.L_CORE X_NUC_102.L_CORE 0.001472
K_4909 X_NUC_24.L_CORE X_NUC_103.L_CORE 0.001469
K_4910 X_NUC_24.L_CORE X_NUC_104.L_CORE 0.001475
K_4911 X_NUC_24.L_CORE X_NUC_105.L_CORE 0.002551
K_4912 X_NUC_24.L_CORE X_NUC_106.L_CORE 0.002559
K_4913 X_NUC_24.L_CORE X_NUC_107.L_CORE 0.002537
K_4914 X_NUC_24.L_CORE X_NUC_108.L_CORE 0.002531
K_4915 X_NUC_24.L_CORE X_NUC_109.L_CORE 0.001406
K_4916 X_NUC_24.L_CORE X_NUC_110.L_CORE 0.001398
K_4917 X_NUC_24.L_CORE X_NUC_111.L_CORE 0.001399
K_4918 X_NUC_24.L_CORE X_NUC_112.L_CORE 0.001398
K_4919 X_NUC_24.L_CORE X_NUC_113.L_CORE 0.001756
K_4920 X_NUC_24.L_CORE X_NUC_114.L_CORE 0.001754
K_4921 X_NUC_24.L_CORE X_NUC_115.L_CORE 0.001743
K_4922 X_NUC_24.L_CORE X_NUC_116.L_CORE 0.001753
K_4923 X_NUC_24.L_CORE X_NUC_117.L_CORE 0.001887
K_4924 X_NUC_24.L_CORE X_NUC_118.L_CORE 0.001883
K_4925 X_NUC_24.L_CORE X_NUC_119.L_CORE 0.001880
K_4926 X_NUC_24.L_CORE X_NUC_120.L_CORE 0.001871
K_4927 X_NUC_24.L_CORE X_NUC_121.L_CORE 0.001345
K_4928 X_NUC_24.L_CORE X_NUC_122.L_CORE 0.001339
K_4929 X_NUC_24.L_CORE X_NUC_123.L_CORE 0.001337
K_4930 X_NUC_24.L_CORE X_NUC_124.L_CORE 0.001340
K_4931 X_NUC_24.L_CORE X_NUC_125.L_CORE 0.002056
K_4932 X_NUC_24.L_CORE X_NUC_126.L_CORE 0.002059
K_4933 X_NUC_24.L_CORE X_NUC_127.L_CORE 0.002041
K_4934 X_NUC_24.L_CORE X_NUC_128.L_CORE 0.002047
K_4935 X_NUC_24.L_CORE X_NUC_129.L_CORE 0.001465
K_4936 X_NUC_24.L_CORE X_NUC_130.L_CORE 0.001458
K_4937 X_NUC_24.L_CORE X_NUC_131.L_CORE 0.001458
K_4938 X_NUC_24.L_CORE X_NUC_132.L_CORE 0.001455
K_4939 X_NUC_24.L_CORE X_NUC_133.L_CORE 0.001459
K_4940 X_NUC_24.L_CORE X_NUC_134.L_CORE 0.001455
K_4941 X_NUC_24.L_CORE X_NUC_135.L_CORE 0.001449
K_4942 X_NUC_24.L_CORE X_NUC_136.L_CORE 0.001454
K_4943 X_NUC_24.L_CORE X_NUC_137.L_CORE 0.001875
K_4944 X_NUC_24.L_CORE X_NUC_138.L_CORE 0.001874
K_4945 X_NUC_24.L_CORE X_NUC_139.L_CORE 0.001865
K_4946 X_NUC_24.L_CORE X_NUC_140.L_CORE 0.001861
K_4947 X_NUC_24.L_CORE X_NUC_141.L_CORE 0.001317
K_4948 X_NUC_24.L_CORE X_NUC_142.L_CORE 0.001311
K_4949 X_NUC_24.L_CORE X_NUC_143.L_CORE 0.001310
K_4950 X_NUC_24.L_CORE X_NUC_144.L_CORE 0.001310
K_4951 X_NUC_24.L_CORE X_NUC_145.L_CORE 0.001646
K_4952 X_NUC_24.L_CORE X_NUC_146.L_CORE 0.001645
K_4953 X_NUC_24.L_CORE X_NUC_147.L_CORE 0.001635
K_4954 X_NUC_24.L_CORE X_NUC_148.L_CORE 0.001640
K_4955 X_NUC_24.L_CORE X_NUC_149.L_CORE 0.001525
K_4956 X_NUC_24.L_CORE X_NUC_150.L_CORE 0.001521
K_4957 X_NUC_24.L_CORE X_NUC_151.L_CORE 0.001518
K_4958 X_NUC_24.L_CORE X_NUC_152.L_CORE 0.001514
K_4959 X_NUC_24.L_CORE X_NUC_153.L_CORE 0.001337
K_4960 X_NUC_24.L_CORE X_NUC_154.L_CORE 0.001333
K_4961 X_NUC_24.L_CORE X_NUC_155.L_CORE 0.001329
K_4962 X_NUC_24.L_CORE X_NUC_156.L_CORE 0.001332
K_4963 X_NUC_24.L_CORE X_NUC_157.L_CORE 0.001650
K_4964 X_NUC_24.L_CORE X_NUC_158.L_CORE 0.001649
K_4965 X_NUC_24.L_CORE X_NUC_159.L_CORE 0.001640
K_4966 X_NUC_24.L_CORE X_NUC_160.L_CORE 0.001641
K_4967 X_NUC_24.L_CORE X_NUC_161.L_CORE 0.001354
K_4968 X_NUC_24.L_CORE X_NUC_162.L_CORE 0.001350
K_4969 X_NUC_24.L_CORE X_NUC_163.L_CORE 0.001347
K_4970 X_NUC_24.L_CORE X_NUC_164.L_CORE 0.001346
K_4971 X_NUC_24.L_CORE X_NUC_165.L_CORE 0.001422
K_4972 X_NUC_24.L_CORE X_NUC_166.L_CORE 0.001419
K_4973 X_NUC_24.L_CORE X_NUC_167.L_CORE 0.001413
K_4974 X_NUC_24.L_CORE X_NUC_168.L_CORE 0.001416
K_4975 X_NUC_24.L_CORE X_NUC_169.L_CORE 0.001450
K_4976 X_NUC_24.L_CORE X_NUC_170.L_CORE 0.001447
K_4977 X_NUC_24.L_CORE X_NUC_171.L_CORE 0.001442
K_4978 X_NUC_24.L_CORE X_NUC_172.L_CORE 0.001442
K_4979 X_NUC_24.L_CORE X_NUC_173.L_CORE 0.004392
K_4980 X_NUC_24.L_CORE X_NUC_174.L_CORE 0.002434
K_4981 X_NUC_24.L_CORE X_NUC_175.L_CORE 0.004436
K_4982 X_NUC_24.L_CORE X_NUC_176.L_CORE 0.003077
K_4983 X_NUC_24.L_CORE X_NUC_177.L_CORE 0.002150
K_4984 X_NUC_24.L_CORE X_NUC_178.L_CORE 0.025338
K_4985 X_NUC_24.L_CORE X_NUC_179.L_CORE 0.002003
K_4986 X_NUC_24.L_CORE X_NUC_180.L_CORE 0.002655
K_4987 X_NUC_24.L_CORE X_NUC_181.L_CORE 0.003934
K_4988 X_NUC_24.L_CORE X_NUC_182.L_CORE 0.001721
K_4989 X_NUC_24.L_CORE X_NUC_183.L_CORE 0.005241
K_4990 X_NUC_24.L_CORE X_NUC_184.L_CORE 0.002056
K_4991 X_NUC_24.L_CORE X_NUC_185.L_CORE 0.001865
K_4992 X_NUC_24.L_CORE X_NUC_186.L_CORE 0.005594
K_4993 X_NUC_24.L_CORE X_NUC_187.L_CORE 0.001585
K_4994 X_NUC_24.L_CORE X_NUC_188.L_CORE 0.002606
K_4995 X_NUC_24.L_CORE X_NUC_189.L_CORE 0.002378
K_4996 X_NUC_24.L_CORE X_NUC_190.L_CORE 0.001534
K_4997 X_NUC_24.L_CORE X_NUC_191.L_CORE 0.004195
K_4998 X_NUC_24.L_CORE X_NUC_192.L_CORE 0.001612
K_4999 X_NUC_24.L_CORE X_NUC_193.L_CORE 0.001810
K_5000 X_NUC_24.L_CORE X_NUC_194.L_CORE 0.002850
K_5001 X_NUC_24.L_CORE X_NUC_195.L_CORE 0.001404
K_5002 X_NUC_24.L_CORE X_NUC_196.L_CORE 0.002539
K_5003 X_NUC_24.L_CORE X_NUC_197.L_CORE 0.001763
K_5004 X_NUC_24.L_CORE X_NUC_198.L_CORE 0.001472
K_5005 X_NUC_24.L_CORE X_NUC_199.L_CORE 0.002866
K_5006 X_NUC_24.L_CORE X_NUC_200.L_CORE 0.001393
K_5007 X_NUC_24.L_CORE X_NUC_201.L_CORE 0.001804
K_5008 X_NUC_24.L_CORE X_NUC_202.L_CORE 0.001980
K_5009 X_NUC_24.L_CORE X_NUC_203.L_CORE 0.001325
K_5010 X_NUC_24.L_CORE X_NUC_204.L_CORE 0.002271
K_5011 X_NUC_24.L_CORE X_NUC_205.L_CORE 0.001465
K_5012 X_NUC_24.L_CORE X_NUC_206.L_CORE 0.001461
K_5013 X_NUC_24.L_CORE X_NUC_207.L_CORE 0.002072
K_5014 X_NUC_24.L_CORE X_NUC_208.L_CORE 0.001286
K_5015 X_NUC_24.L_CORE X_NUC_209.L_CORE 0.001751
K_5016 X_NUC_24.L_CORE X_NUC_210.L_CORE 0.001574
K_5017 X_NUC_24.L_CORE X_NUC_211.L_CORE 0.001303
K_5018 X_NUC_24.L_CORE X_NUC_212.L_CORE 0.001882
K_5019 X_NUC_24.L_CORE X_NUC_213.L_CORE 0.001316
K_5020 X_NUC_24.L_CORE X_NUC_214.L_CORE 0.001451
K_5021 X_NUC_24.L_CORE X_NUC_215.L_CORE 0.001622
K_5022 X_NUC_24.L_CORE X_NUC_216.L_CORE 0.001254
K_5023 X_NUC_24.L_CORE X_NUC_217.L_CORE 0.001587
K_5024 X_NUC_24.L_CORE X_NUC_218.L_CORE 0.001370
K_5025 X_NUC_24.L_CORE X_NUC_219.L_CORE 0.001313
K_5026 X_NUC_24.L_CORE X_NUC_220.L_CORE 0.001506
K_5027 X_NUC_24.L_CORE X_NUC_221.L_CORE 0.001286
K_5028 X_NUC_24.L_CORE X_NUC_222.L_CORE 0.001367
K_5029 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_5030 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_5031 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_5032 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.001892
K_5033 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.001903
K_5034 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.001891
K_5035 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.001904
K_5036 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.002533
K_5037 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.002562
K_5038 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.002551
K_5039 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.002540
K_5040 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.003691
K_5041 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.003677
K_5042 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.003644
K_5043 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.003706
K_5044 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.001647
K_5045 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.001659
K_5046 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.001650
K_5047 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.001655
K_5048 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.004914
K_5049 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.004960
K_5050 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.004947
K_5051 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.004854
K_5052 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.001966
K_5053 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.001972
K_5054 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.001958
K_5055 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.001975
K_5056 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.001800
K_5057 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.001815
K_5058 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.001805
K_5059 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.001804
K_5060 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.004982
K_5061 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.004912
K_5062 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.004867
K_5063 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.004909
K_5064 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.001534
K_5065 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.001542
K_5066 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.001532
K_5067 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.001540
K_5068 X_NUC_25.L_CORE X_NUC_65.L_CORE 0.002500
K_5069 X_NUC_25.L_CORE X_NUC_66.L_CORE 0.002520
K_5070 X_NUC_25.L_CORE X_NUC_67.L_CORE 0.002509
K_5071 X_NUC_25.L_CORE X_NUC_68.L_CORE 0.002492
K_5072 X_NUC_25.L_CORE X_NUC_69.L_CORE 0.002267
K_5073 X_NUC_25.L_CORE X_NUC_70.L_CORE 0.002265
K_5074 X_NUC_25.L_CORE X_NUC_71.L_CORE 0.002247
K_5075 X_NUC_25.L_CORE X_NUC_72.L_CORE 0.002269
K_5076 X_NUC_25.L_CORE X_NUC_73.L_CORE 0.001495
K_5077 X_NUC_25.L_CORE X_NUC_74.L_CORE 0.001505
K_5078 X_NUC_25.L_CORE X_NUC_75.L_CORE 0.001497
K_5079 X_NUC_25.L_CORE X_NUC_76.L_CORE 0.001499
K_5080 X_NUC_25.L_CORE X_NUC_77.L_CORE 0.003771
K_5081 X_NUC_25.L_CORE X_NUC_78.L_CORE 0.003759
K_5082 X_NUC_25.L_CORE X_NUC_79.L_CORE 0.003738
K_5083 X_NUC_25.L_CORE X_NUC_80.L_CORE 0.003708
K_5084 X_NUC_25.L_CORE X_NUC_81.L_CORE 0.001568
K_5085 X_NUC_25.L_CORE X_NUC_82.L_CORE 0.001573
K_5086 X_NUC_25.L_CORE X_NUC_83.L_CORE 0.001562
K_5087 X_NUC_25.L_CORE X_NUC_84.L_CORE 0.001572
K_5088 X_NUC_25.L_CORE X_NUC_85.L_CORE 0.001762
K_5089 X_NUC_25.L_CORE X_NUC_86.L_CORE 0.001774
K_5090 X_NUC_25.L_CORE X_NUC_87.L_CORE 0.001765
K_5091 X_NUC_25.L_CORE X_NUC_88.L_CORE 0.001761
K_5092 X_NUC_25.L_CORE X_NUC_89.L_CORE 0.002643
K_5093 X_NUC_25.L_CORE X_NUC_90.L_CORE 0.002631
K_5094 X_NUC_25.L_CORE X_NUC_91.L_CORE 0.002610
K_5095 X_NUC_25.L_CORE X_NUC_92.L_CORE 0.002628
K_5096 X_NUC_25.L_CORE X_NUC_93.L_CORE 0.001381
K_5097 X_NUC_25.L_CORE X_NUC_94.L_CORE 0.001388
K_5098 X_NUC_25.L_CORE X_NUC_95.L_CORE 0.001380
K_5099 X_NUC_25.L_CORE X_NUC_96.L_CORE 0.001384
K_5100 X_NUC_25.L_CORE X_NUC_97.L_CORE 0.002388
K_5101 X_NUC_25.L_CORE X_NUC_98.L_CORE 0.002397
K_5102 X_NUC_25.L_CORE X_NUC_99.L_CORE 0.002385
K_5103 X_NUC_25.L_CORE X_NUC_100.L_CORE 0.002370
K_5104 X_NUC_25.L_CORE X_NUC_101.L_CORE 0.001708
K_5105 X_NUC_25.L_CORE X_NUC_102.L_CORE 0.001709
K_5106 X_NUC_25.L_CORE X_NUC_103.L_CORE 0.001697
K_5107 X_NUC_25.L_CORE X_NUC_104.L_CORE 0.001709
K_5108 X_NUC_25.L_CORE X_NUC_105.L_CORE 0.001452
K_5109 X_NUC_25.L_CORE X_NUC_106.L_CORE 0.001460
K_5110 X_NUC_25.L_CORE X_NUC_107.L_CORE 0.001452
K_5111 X_NUC_25.L_CORE X_NUC_108.L_CORE 0.001452
K_5112 X_NUC_25.L_CORE X_NUC_109.L_CORE 0.002571
K_5113 X_NUC_25.L_CORE X_NUC_110.L_CORE 0.002562
K_5114 X_NUC_25.L_CORE X_NUC_111.L_CORE 0.002545
K_5115 X_NUC_25.L_CORE X_NUC_112.L_CORE 0.002545
K_5116 X_NUC_25.L_CORE X_NUC_113.L_CORE 0.001379
K_5117 X_NUC_25.L_CORE X_NUC_114.L_CORE 0.001384
K_5118 X_NUC_25.L_CORE X_NUC_115.L_CORE 0.001375
K_5119 X_NUC_25.L_CORE X_NUC_116.L_CORE 0.001381
K_5120 X_NUC_25.L_CORE X_NUC_117.L_CORE 0.001745
K_5121 X_NUC_25.L_CORE X_NUC_118.L_CORE 0.001754
K_5122 X_NUC_25.L_CORE X_NUC_119.L_CORE 0.001744
K_5123 X_NUC_25.L_CORE X_NUC_120.L_CORE 0.001739
K_5124 X_NUC_25.L_CORE X_NUC_121.L_CORE 0.001871
K_5125 X_NUC_25.L_CORE X_NUC_122.L_CORE 0.001869
K_5126 X_NUC_25.L_CORE X_NUC_123.L_CORE 0.001856
K_5127 X_NUC_25.L_CORE X_NUC_124.L_CORE 0.001865
K_5128 X_NUC_25.L_CORE X_NUC_125.L_CORE 0.001326
K_5129 X_NUC_25.L_CORE X_NUC_126.L_CORE 0.001332
K_5130 X_NUC_25.L_CORE X_NUC_127.L_CORE 0.001324
K_5131 X_NUC_25.L_CORE X_NUC_128.L_CORE 0.001327
K_5132 X_NUC_25.L_CORE X_NUC_129.L_CORE 0.002061
K_5133 X_NUC_25.L_CORE X_NUC_130.L_CORE 0.002063
K_5134 X_NUC_25.L_CORE X_NUC_131.L_CORE 0.002051
K_5135 X_NUC_25.L_CORE X_NUC_132.L_CORE 0.002045
K_5136 X_NUC_25.L_CORE X_NUC_133.L_CORE 0.001447
K_5137 X_NUC_25.L_CORE X_NUC_134.L_CORE 0.001450
K_5138 X_NUC_25.L_CORE X_NUC_135.L_CORE 0.001440
K_5139 X_NUC_25.L_CORE X_NUC_136.L_CORE 0.001447
K_5140 X_NUC_25.L_CORE X_NUC_137.L_CORE 0.001449
K_5141 X_NUC_25.L_CORE X_NUC_138.L_CORE 0.001456
K_5142 X_NUC_25.L_CORE X_NUC_139.L_CORE 0.001448
K_5143 X_NUC_25.L_CORE X_NUC_140.L_CORE 0.001447
K_5144 X_NUC_25.L_CORE X_NUC_141.L_CORE 0.001867
K_5145 X_NUC_25.L_CORE X_NUC_142.L_CORE 0.001865
K_5146 X_NUC_25.L_CORE X_NUC_143.L_CORE 0.001852
K_5147 X_NUC_25.L_CORE X_NUC_144.L_CORE 0.001856
K_5148 X_NUC_25.L_CORE X_NUC_145.L_CORE 0.001308
K_5149 X_NUC_25.L_CORE X_NUC_146.L_CORE 0.001312
K_5150 X_NUC_25.L_CORE X_NUC_147.L_CORE 0.001304
K_5151 X_NUC_25.L_CORE X_NUC_148.L_CORE 0.001308
K_5152 X_NUC_25.L_CORE X_NUC_149.L_CORE 0.001640
K_5153 X_NUC_25.L_CORE X_NUC_150.L_CORE 0.001645
K_5154 X_NUC_25.L_CORE X_NUC_151.L_CORE 0.001635
K_5155 X_NUC_25.L_CORE X_NUC_152.L_CORE 0.001633
K_5156 X_NUC_25.L_CORE X_NUC_153.L_CORE 0.001515
K_5157 X_NUC_25.L_CORE X_NUC_154.L_CORE 0.001516
K_5158 X_NUC_25.L_CORE X_NUC_155.L_CORE 0.001506
K_5159 X_NUC_25.L_CORE X_NUC_156.L_CORE 0.001511
K_5160 X_NUC_25.L_CORE X_NUC_157.L_CORE 0.001338
K_5161 X_NUC_25.L_CORE X_NUC_158.L_CORE 0.001343
K_5162 X_NUC_25.L_CORE X_NUC_159.L_CORE 0.001335
K_5163 X_NUC_25.L_CORE X_NUC_160.L_CORE 0.001336
K_5164 X_NUC_25.L_CORE X_NUC_161.L_CORE 0.001626
K_5165 X_NUC_25.L_CORE X_NUC_162.L_CORE 0.001628
K_5166 X_NUC_25.L_CORE X_NUC_163.L_CORE 0.001618
K_5167 X_NUC_25.L_CORE X_NUC_164.L_CORE 0.001618
K_5168 X_NUC_25.L_CORE X_NUC_165.L_CORE 0.001362
K_5169 X_NUC_25.L_CORE X_NUC_166.L_CORE 0.001365
K_5170 X_NUC_25.L_CORE X_NUC_167.L_CORE 0.001357
K_5171 X_NUC_25.L_CORE X_NUC_168.L_CORE 0.001360
K_5172 X_NUC_25.L_CORE X_NUC_169.L_CORE 0.001420
K_5173 X_NUC_25.L_CORE X_NUC_170.L_CORE 0.001424
K_5174 X_NUC_25.L_CORE X_NUC_171.L_CORE 0.001415
K_5175 X_NUC_25.L_CORE X_NUC_172.L_CORE 0.001416
K_5176 X_NUC_25.L_CORE X_NUC_173.L_CORE 0.002994
K_5177 X_NUC_25.L_CORE X_NUC_174.L_CORE 0.004767
K_5178 X_NUC_25.L_CORE X_NUC_175.L_CORE 0.002156
K_5179 X_NUC_25.L_CORE X_NUC_176.L_CORE 0.004219
K_5180 X_NUC_25.L_CORE X_NUC_177.L_CORE 0.002828
K_5181 X_NUC_25.L_CORE X_NUC_178.L_CORE 0.002005
K_5182 X_NUC_25.L_CORE X_NUC_179.L_CORE 0.026544
K_5183 X_NUC_25.L_CORE X_NUC_180.L_CORE 0.001882
K_5184 X_NUC_25.L_CORE X_NUC_181.L_CORE 0.002532
K_5185 X_NUC_25.L_CORE X_NUC_182.L_CORE 0.003699
K_5186 X_NUC_25.L_CORE X_NUC_183.L_CORE 0.001642
K_5187 X_NUC_25.L_CORE X_NUC_184.L_CORE 0.005186
K_5188 X_NUC_25.L_CORE X_NUC_185.L_CORE 0.001965
K_5189 X_NUC_25.L_CORE X_NUC_186.L_CORE 0.001801
K_5190 X_NUC_25.L_CORE X_NUC_187.L_CORE 0.005542
K_5191 X_NUC_25.L_CORE X_NUC_188.L_CORE 0.001528
K_5192 X_NUC_25.L_CORE X_NUC_189.L_CORE 0.002565
K_5193 X_NUC_25.L_CORE X_NUC_190.L_CORE 0.002304
K_5194 X_NUC_25.L_CORE X_NUC_191.L_CORE 0.001491
K_5195 X_NUC_25.L_CORE X_NUC_192.L_CORE 0.004301
K_5196 X_NUC_25.L_CORE X_NUC_193.L_CORE 0.001566
K_5197 X_NUC_25.L_CORE X_NUC_194.L_CORE 0.001780
K_5198 X_NUC_25.L_CORE X_NUC_195.L_CORE 0.002826
K_5199 X_NUC_25.L_CORE X_NUC_196.L_CORE 0.001372
K_5200 X_NUC_25.L_CORE X_NUC_197.L_CORE 0.002552
K_5201 X_NUC_25.L_CORE X_NUC_198.L_CORE 0.001727
K_5202 X_NUC_25.L_CORE X_NUC_199.L_CORE 0.001448
K_5203 X_NUC_25.L_CORE X_NUC_200.L_CORE 0.002906
K_5204 X_NUC_25.L_CORE X_NUC_201.L_CORE 0.001367
K_5205 X_NUC_25.L_CORE X_NUC_202.L_CORE 0.001797
K_5206 X_NUC_25.L_CORE X_NUC_203.L_CORE 0.001963
K_5207 X_NUC_25.L_CORE X_NUC_204.L_CORE 0.001307
K_5208 X_NUC_25.L_CORE X_NUC_205.L_CORE 0.002296
K_5209 X_NUC_25.L_CORE X_NUC_206.L_CORE 0.001446
K_5210 X_NUC_25.L_CORE X_NUC_207.L_CORE 0.001452
K_5211 X_NUC_25.L_CORE X_NUC_208.L_CORE 0.002078
K_5212 X_NUC_25.L_CORE X_NUC_209.L_CORE 0.001273
K_5213 X_NUC_25.L_CORE X_NUC_210.L_CORE 0.001756
K_5214 X_NUC_25.L_CORE X_NUC_211.L_CORE 0.001565
K_5215 X_NUC_25.L_CORE X_NUC_212.L_CORE 0.001297
K_5216 X_NUC_25.L_CORE X_NUC_213.L_CORE 0.001888
K_5217 X_NUC_25.L_CORE X_NUC_214.L_CORE 0.001310
K_5218 X_NUC_25.L_CORE X_NUC_215.L_CORE 0.001452
K_5219 X_NUC_25.L_CORE X_NUC_216.L_CORE 0.001616
K_5220 X_NUC_25.L_CORE X_NUC_217.L_CORE 0.001255
K_5221 X_NUC_25.L_CORE X_NUC_218.L_CORE 0.001583
K_5222 X_NUC_25.L_CORE X_NUC_219.L_CORE 0.001370
K_5223 X_NUC_25.L_CORE X_NUC_220.L_CORE 0.001322
K_5224 X_NUC_25.L_CORE X_NUC_221.L_CORE 0.001483
K_5225 X_NUC_25.L_CORE X_NUC_222.L_CORE 0.001315
K_5226 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_5227 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_5228 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.001882
K_5229 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.001892
K_5230 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.001880
K_5231 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.001893
K_5232 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.002505
K_5233 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.002533
K_5234 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.002522
K_5235 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.002512
K_5236 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.003704
K_5237 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.003691
K_5238 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.003657
K_5239 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.003719
K_5240 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.001636
K_5241 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.001647
K_5242 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.001638
K_5243 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.001643
K_5244 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.004867
K_5245 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.004914
K_5246 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.004901
K_5247 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.004810
K_5248 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.001961
K_5249 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.001966
K_5250 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.001952
K_5251 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.001969
K_5252 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.001785
K_5253 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.001800
K_5254 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.001790
K_5255 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.001789
K_5256 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.005053
K_5257 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.004982
K_5258 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.004935
K_5259 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.004979
K_5260 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.001526
K_5261 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.001534
K_5262 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.001524
K_5263 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.001531
K_5264 X_NUC_26.L_CORE X_NUC_65.L_CORE 0.002480
K_5265 X_NUC_26.L_CORE X_NUC_66.L_CORE 0.002500
K_5266 X_NUC_26.L_CORE X_NUC_67.L_CORE 0.002489
K_5267 X_NUC_26.L_CORE X_NUC_68.L_CORE 0.002472
K_5268 X_NUC_26.L_CORE X_NUC_69.L_CORE 0.002269
K_5269 X_NUC_26.L_CORE X_NUC_70.L_CORE 0.002267
K_5270 X_NUC_26.L_CORE X_NUC_71.L_CORE 0.002250
K_5271 X_NUC_26.L_CORE X_NUC_72.L_CORE 0.002271
K_5272 X_NUC_26.L_CORE X_NUC_73.L_CORE 0.001485
K_5273 X_NUC_26.L_CORE X_NUC_74.L_CORE 0.001495
K_5274 X_NUC_26.L_CORE X_NUC_75.L_CORE 0.001487
K_5275 X_NUC_26.L_CORE X_NUC_76.L_CORE 0.001489
K_5276 X_NUC_26.L_CORE X_NUC_77.L_CORE 0.003782
K_5277 X_NUC_26.L_CORE X_NUC_78.L_CORE 0.003771
K_5278 X_NUC_26.L_CORE X_NUC_79.L_CORE 0.003749
K_5279 X_NUC_26.L_CORE X_NUC_80.L_CORE 0.003719
K_5280 X_NUC_26.L_CORE X_NUC_81.L_CORE 0.001563
K_5281 X_NUC_26.L_CORE X_NUC_82.L_CORE 0.001568
K_5282 X_NUC_26.L_CORE X_NUC_83.L_CORE 0.001557
K_5283 X_NUC_26.L_CORE X_NUC_84.L_CORE 0.001567
K_5284 X_NUC_26.L_CORE X_NUC_85.L_CORE 0.001750
K_5285 X_NUC_26.L_CORE X_NUC_86.L_CORE 0.001762
K_5286 X_NUC_26.L_CORE X_NUC_87.L_CORE 0.001753
K_5287 X_NUC_26.L_CORE X_NUC_88.L_CORE 0.001749
K_5288 X_NUC_26.L_CORE X_NUC_89.L_CORE 0.002656
K_5289 X_NUC_26.L_CORE X_NUC_90.L_CORE 0.002643
K_5290 X_NUC_26.L_CORE X_NUC_91.L_CORE 0.002622
K_5291 X_NUC_26.L_CORE X_NUC_92.L_CORE 0.002640
K_5292 X_NUC_26.L_CORE X_NUC_93.L_CORE 0.001374
K_5293 X_NUC_26.L_CORE X_NUC_94.L_CORE 0.001381
K_5294 X_NUC_26.L_CORE X_NUC_95.L_CORE 0.001373
K_5295 X_NUC_26.L_CORE X_NUC_96.L_CORE 0.001377
K_5296 X_NUC_26.L_CORE X_NUC_97.L_CORE 0.002379
K_5297 X_NUC_26.L_CORE X_NUC_98.L_CORE 0.002388
K_5298 X_NUC_26.L_CORE X_NUC_99.L_CORE 0.002376
K_5299 X_NUC_26.L_CORE X_NUC_100.L_CORE 0.002361
K_5300 X_NUC_26.L_CORE X_NUC_101.L_CORE 0.001706
K_5301 X_NUC_26.L_CORE X_NUC_102.L_CORE 0.001708
K_5302 X_NUC_26.L_CORE X_NUC_103.L_CORE 0.001696
K_5303 X_NUC_26.L_CORE X_NUC_104.L_CORE 0.001707
K_5304 X_NUC_26.L_CORE X_NUC_105.L_CORE 0.001443
K_5305 X_NUC_26.L_CORE X_NUC_106.L_CORE 0.001452
K_5306 X_NUC_26.L_CORE X_NUC_107.L_CORE 0.001444
K_5307 X_NUC_26.L_CORE X_NUC_108.L_CORE 0.001444
K_5308 X_NUC_26.L_CORE X_NUC_109.L_CORE 0.002579
K_5309 X_NUC_26.L_CORE X_NUC_110.L_CORE 0.002571
K_5310 X_NUC_26.L_CORE X_NUC_111.L_CORE 0.002554
K_5311 X_NUC_26.L_CORE X_NUC_112.L_CORE 0.002553
K_5312 X_NUC_26.L_CORE X_NUC_113.L_CORE 0.001374
K_5313 X_NUC_26.L_CORE X_NUC_114.L_CORE 0.001379
K_5314 X_NUC_26.L_CORE X_NUC_115.L_CORE 0.001370
K_5315 X_NUC_26.L_CORE X_NUC_116.L_CORE 0.001376
K_5316 X_NUC_26.L_CORE X_NUC_117.L_CORE 0.001736
K_5317 X_NUC_26.L_CORE X_NUC_118.L_CORE 0.001745
K_5318 X_NUC_26.L_CORE X_NUC_119.L_CORE 0.001736
K_5319 X_NUC_26.L_CORE X_NUC_120.L_CORE 0.001731
K_5320 X_NUC_26.L_CORE X_NUC_121.L_CORE 0.001873
K_5321 X_NUC_26.L_CORE X_NUC_122.L_CORE 0.001871
K_5322 X_NUC_26.L_CORE X_NUC_123.L_CORE 0.001858
K_5323 X_NUC_26.L_CORE X_NUC_124.L_CORE 0.001867
K_5324 X_NUC_26.L_CORE X_NUC_125.L_CORE 0.001319
K_5325 X_NUC_26.L_CORE X_NUC_126.L_CORE 0.001326
K_5326 X_NUC_26.L_CORE X_NUC_127.L_CORE 0.001318
K_5327 X_NUC_26.L_CORE X_NUC_128.L_CORE 0.001320
K_5328 X_NUC_26.L_CORE X_NUC_129.L_CORE 0.002059
K_5329 X_NUC_26.L_CORE X_NUC_130.L_CORE 0.002061
K_5330 X_NUC_26.L_CORE X_NUC_131.L_CORE 0.002049
K_5331 X_NUC_26.L_CORE X_NUC_132.L_CORE 0.002043
K_5332 X_NUC_26.L_CORE X_NUC_133.L_CORE 0.001444
K_5333 X_NUC_26.L_CORE X_NUC_134.L_CORE 0.001447
K_5334 X_NUC_26.L_CORE X_NUC_135.L_CORE 0.001437
K_5335 X_NUC_26.L_CORE X_NUC_136.L_CORE 0.001444
K_5336 X_NUC_26.L_CORE X_NUC_137.L_CORE 0.001442
K_5337 X_NUC_26.L_CORE X_NUC_138.L_CORE 0.001449
K_5338 X_NUC_26.L_CORE X_NUC_139.L_CORE 0.001441
K_5339 X_NUC_26.L_CORE X_NUC_140.L_CORE 0.001440
K_5340 X_NUC_26.L_CORE X_NUC_141.L_CORE 0.001868
K_5341 X_NUC_26.L_CORE X_NUC_142.L_CORE 0.001867
K_5342 X_NUC_26.L_CORE X_NUC_143.L_CORE 0.001854
K_5343 X_NUC_26.L_CORE X_NUC_144.L_CORE 0.001858
K_5344 X_NUC_26.L_CORE X_NUC_145.L_CORE 0.001303
K_5345 X_NUC_26.L_CORE X_NUC_146.L_CORE 0.001308
K_5346 X_NUC_26.L_CORE X_NUC_147.L_CORE 0.001299
K_5347 X_NUC_26.L_CORE X_NUC_148.L_CORE 0.001303
K_5348 X_NUC_26.L_CORE X_NUC_149.L_CORE 0.001635
K_5349 X_NUC_26.L_CORE X_NUC_150.L_CORE 0.001640
K_5350 X_NUC_26.L_CORE X_NUC_151.L_CORE 0.001631
K_5351 X_NUC_26.L_CORE X_NUC_152.L_CORE 0.001628
K_5352 X_NUC_26.L_CORE X_NUC_153.L_CORE 0.001513
K_5353 X_NUC_26.L_CORE X_NUC_154.L_CORE 0.001515
K_5354 X_NUC_26.L_CORE X_NUC_155.L_CORE 0.001505
K_5355 X_NUC_26.L_CORE X_NUC_156.L_CORE 0.001510
K_5356 X_NUC_26.L_CORE X_NUC_157.L_CORE 0.001333
K_5357 X_NUC_26.L_CORE X_NUC_158.L_CORE 0.001338
K_5358 X_NUC_26.L_CORE X_NUC_159.L_CORE 0.001330
K_5359 X_NUC_26.L_CORE X_NUC_160.L_CORE 0.001331
K_5360 X_NUC_26.L_CORE X_NUC_161.L_CORE 0.001624
K_5361 X_NUC_26.L_CORE X_NUC_162.L_CORE 0.001626
K_5362 X_NUC_26.L_CORE X_NUC_163.L_CORE 0.001616
K_5363 X_NUC_26.L_CORE X_NUC_164.L_CORE 0.001617
K_5364 X_NUC_26.L_CORE X_NUC_165.L_CORE 0.001359
K_5365 X_NUC_26.L_CORE X_NUC_166.L_CORE 0.001362
K_5366 X_NUC_26.L_CORE X_NUC_167.L_CORE 0.001353
K_5367 X_NUC_26.L_CORE X_NUC_168.L_CORE 0.001357
K_5368 X_NUC_26.L_CORE X_NUC_169.L_CORE 0.001416
K_5369 X_NUC_26.L_CORE X_NUC_170.L_CORE 0.001420
K_5370 X_NUC_26.L_CORE X_NUC_171.L_CORE 0.001412
K_5371 X_NUC_26.L_CORE X_NUC_172.L_CORE 0.001413
K_5372 X_NUC_26.L_CORE X_NUC_173.L_CORE 0.002956
K_5373 X_NUC_26.L_CORE X_NUC_174.L_CORE 0.004718
K_5374 X_NUC_26.L_CORE X_NUC_175.L_CORE 0.002138
K_5375 X_NUC_26.L_CORE X_NUC_176.L_CORE 0.004145
K_5376 X_NUC_26.L_CORE X_NUC_177.L_CORE 0.002817
K_5377 X_NUC_26.L_CORE X_NUC_178.L_CORE 0.001986
K_5378 X_NUC_26.L_CORE X_NUC_179.L_CORE 0.026842
K_5379 X_NUC_26.L_CORE X_NUC_180.L_CORE 0.001871
K_5380 X_NUC_26.L_CORE X_NUC_181.L_CORE 0.002504
K_5381 X_NUC_26.L_CORE X_NUC_182.L_CORE 0.003714
K_5382 X_NUC_26.L_CORE X_NUC_183.L_CORE 0.001630
K_5383 X_NUC_26.L_CORE X_NUC_184.L_CORE 0.005135
K_5384 X_NUC_26.L_CORE X_NUC_185.L_CORE 0.001959
K_5385 X_NUC_26.L_CORE X_NUC_186.L_CORE 0.001786
K_5386 X_NUC_26.L_CORE X_NUC_187.L_CORE 0.005654
K_5387 X_NUC_26.L_CORE X_NUC_188.L_CORE 0.001520
K_5388 X_NUC_26.L_CORE X_NUC_189.L_CORE 0.002543
K_5389 X_NUC_26.L_CORE X_NUC_190.L_CORE 0.002307
K_5390 X_NUC_26.L_CORE X_NUC_191.L_CORE 0.001481
K_5391 X_NUC_26.L_CORE X_NUC_192.L_CORE 0.004325
K_5392 X_NUC_26.L_CORE X_NUC_193.L_CORE 0.001561
K_5393 X_NUC_26.L_CORE X_NUC_194.L_CORE 0.001767
K_5394 X_NUC_26.L_CORE X_NUC_195.L_CORE 0.002845
K_5395 X_NUC_26.L_CORE X_NUC_196.L_CORE 0.001364
K_5396 X_NUC_26.L_CORE X_NUC_197.L_CORE 0.002542
K_5397 X_NUC_26.L_CORE X_NUC_198.L_CORE 0.001726
K_5398 X_NUC_26.L_CORE X_NUC_199.L_CORE 0.001439
K_5399 X_NUC_26.L_CORE X_NUC_200.L_CORE 0.002923
K_5400 X_NUC_26.L_CORE X_NUC_201.L_CORE 0.001362
K_5401 X_NUC_26.L_CORE X_NUC_202.L_CORE 0.001787
K_5402 X_NUC_26.L_CORE X_NUC_203.L_CORE 0.001968
K_5403 X_NUC_26.L_CORE X_NUC_204.L_CORE 0.001300
K_5404 X_NUC_26.L_CORE X_NUC_205.L_CORE 0.002295
K_5405 X_NUC_26.L_CORE X_NUC_206.L_CORE 0.001443
K_5406 X_NUC_26.L_CORE X_NUC_207.L_CORE 0.001444
K_5407 X_NUC_26.L_CORE X_NUC_208.L_CORE 0.002084
K_5408 X_NUC_26.L_CORE X_NUC_209.L_CORE 0.001269
K_5409 X_NUC_26.L_CORE X_NUC_210.L_CORE 0.001751
K_5410 X_NUC_26.L_CORE X_NUC_211.L_CORE 0.001564
K_5411 X_NUC_26.L_CORE X_NUC_212.L_CORE 0.001291
K_5412 X_NUC_26.L_CORE X_NUC_213.L_CORE 0.001888
K_5413 X_NUC_26.L_CORE X_NUC_214.L_CORE 0.001307
K_5414 X_NUC_26.L_CORE X_NUC_215.L_CORE 0.001447
K_5415 X_NUC_26.L_CORE X_NUC_216.L_CORE 0.001617
K_5416 X_NUC_26.L_CORE X_NUC_217.L_CORE 0.001251
K_5417 X_NUC_26.L_CORE X_NUC_218.L_CORE 0.001580
K_5418 X_NUC_26.L_CORE X_NUC_219.L_CORE 0.001368
K_5419 X_NUC_26.L_CORE X_NUC_220.L_CORE 0.001317
K_5420 X_NUC_26.L_CORE X_NUC_221.L_CORE 0.001481
K_5421 X_NUC_26.L_CORE X_NUC_222.L_CORE 0.001312
K_5422 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_5423 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.001894
K_5424 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.001905
K_5425 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.001892
K_5426 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.001906
K_5427 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.002515
K_5428 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.002544
K_5429 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.002533
K_5430 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.002522
K_5431 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.003738
K_5432 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.003724
K_5433 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.003691
K_5434 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.003754
K_5435 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.001645
K_5436 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.001657
K_5437 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.001647
K_5438 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.001653
K_5439 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.004879
K_5440 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.004925
K_5441 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.004914
K_5442 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.004822
K_5443 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.001975
K_5444 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.001981
K_5445 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.001966
K_5446 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.001984
K_5447 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.001794
K_5448 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.001809
K_5449 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.001800
K_5450 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.001798
K_5451 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.005103
K_5452 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.005029
K_5453 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.004982
K_5454 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.005026
K_5455 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.001535
K_5456 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.001544
K_5457 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.001534
K_5458 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.001541
K_5459 X_NUC_27.L_CORE X_NUC_65.L_CORE 0.002490
K_5460 X_NUC_27.L_CORE X_NUC_66.L_CORE 0.002511
K_5461 X_NUC_27.L_CORE X_NUC_67.L_CORE 0.002500
K_5462 X_NUC_27.L_CORE X_NUC_68.L_CORE 0.002482
K_5463 X_NUC_27.L_CORE X_NUC_69.L_CORE 0.002287
K_5464 X_NUC_27.L_CORE X_NUC_70.L_CORE 0.002285
K_5465 X_NUC_27.L_CORE X_NUC_71.L_CORE 0.002267
K_5466 X_NUC_27.L_CORE X_NUC_72.L_CORE 0.002289
K_5467 X_NUC_27.L_CORE X_NUC_73.L_CORE 0.001494
K_5468 X_NUC_27.L_CORE X_NUC_74.L_CORE 0.001504
K_5469 X_NUC_27.L_CORE X_NUC_75.L_CORE 0.001495
K_5470 X_NUC_27.L_CORE X_NUC_76.L_CORE 0.001497
K_5471 X_NUC_27.L_CORE X_NUC_77.L_CORE 0.003803
K_5472 X_NUC_27.L_CORE X_NUC_78.L_CORE 0.003792
K_5473 X_NUC_27.L_CORE X_NUC_79.L_CORE 0.003771
K_5474 X_NUC_27.L_CORE X_NUC_80.L_CORE 0.003740
K_5475 X_NUC_27.L_CORE X_NUC_81.L_CORE 0.001573
K_5476 X_NUC_27.L_CORE X_NUC_82.L_CORE 0.001579
K_5477 X_NUC_27.L_CORE X_NUC_83.L_CORE 0.001568
K_5478 X_NUC_27.L_CORE X_NUC_84.L_CORE 0.001578
K_5479 X_NUC_27.L_CORE X_NUC_85.L_CORE 0.001758
K_5480 X_NUC_27.L_CORE X_NUC_86.L_CORE 0.001771
K_5481 X_NUC_27.L_CORE X_NUC_87.L_CORE 0.001762
K_5482 X_NUC_27.L_CORE X_NUC_88.L_CORE 0.001757
K_5483 X_NUC_27.L_CORE X_NUC_89.L_CORE 0.002677
K_5484 X_NUC_27.L_CORE X_NUC_90.L_CORE 0.002664
K_5485 X_NUC_27.L_CORE X_NUC_91.L_CORE 0.002643
K_5486 X_NUC_27.L_CORE X_NUC_92.L_CORE 0.002661
K_5487 X_NUC_27.L_CORE X_NUC_93.L_CORE 0.001382
K_5488 X_NUC_27.L_CORE X_NUC_94.L_CORE 0.001390
K_5489 X_NUC_27.L_CORE X_NUC_95.L_CORE 0.001381
K_5490 X_NUC_27.L_CORE X_NUC_96.L_CORE 0.001385
K_5491 X_NUC_27.L_CORE X_NUC_97.L_CORE 0.002391
K_5492 X_NUC_27.L_CORE X_NUC_98.L_CORE 0.002400
K_5493 X_NUC_27.L_CORE X_NUC_99.L_CORE 0.002388
K_5494 X_NUC_27.L_CORE X_NUC_100.L_CORE 0.002373
K_5495 X_NUC_27.L_CORE X_NUC_101.L_CORE 0.001719
K_5496 X_NUC_27.L_CORE X_NUC_102.L_CORE 0.001720
K_5497 X_NUC_27.L_CORE X_NUC_103.L_CORE 0.001708
K_5498 X_NUC_27.L_CORE X_NUC_104.L_CORE 0.001719
K_5499 X_NUC_27.L_CORE X_NUC_105.L_CORE 0.001451
K_5500 X_NUC_27.L_CORE X_NUC_106.L_CORE 0.001460
K_5501 X_NUC_27.L_CORE X_NUC_107.L_CORE 0.001452
K_5502 X_NUC_27.L_CORE X_NUC_108.L_CORE 0.001452
K_5503 X_NUC_27.L_CORE X_NUC_109.L_CORE 0.002597
K_5504 X_NUC_27.L_CORE X_NUC_110.L_CORE 0.002588
K_5505 X_NUC_27.L_CORE X_NUC_111.L_CORE 0.002571
K_5506 X_NUC_27.L_CORE X_NUC_112.L_CORE 0.002571
K_5507 X_NUC_27.L_CORE X_NUC_113.L_CORE 0.001383
K_5508 X_NUC_27.L_CORE X_NUC_114.L_CORE 0.001388
K_5509 X_NUC_27.L_CORE X_NUC_115.L_CORE 0.001379
K_5510 X_NUC_27.L_CORE X_NUC_116.L_CORE 0.001385
K_5511 X_NUC_27.L_CORE X_NUC_117.L_CORE 0.001745
K_5512 X_NUC_27.L_CORE X_NUC_118.L_CORE 0.001754
K_5513 X_NUC_27.L_CORE X_NUC_119.L_CORE 0.001745
K_5514 X_NUC_27.L_CORE X_NUC_120.L_CORE 0.001740
K_5515 X_NUC_27.L_CORE X_NUC_121.L_CORE 0.001886
K_5516 X_NUC_27.L_CORE X_NUC_122.L_CORE 0.001884
K_5517 X_NUC_27.L_CORE X_NUC_123.L_CORE 0.001871
K_5518 X_NUC_27.L_CORE X_NUC_124.L_CORE 0.001881
K_5519 X_NUC_27.L_CORE X_NUC_125.L_CORE 0.001327
K_5520 X_NUC_27.L_CORE X_NUC_126.L_CORE 0.001334
K_5521 X_NUC_27.L_CORE X_NUC_127.L_CORE 0.001326
K_5522 X_NUC_27.L_CORE X_NUC_128.L_CORE 0.001328
K_5523 X_NUC_27.L_CORE X_NUC_129.L_CORE 0.002071
K_5524 X_NUC_27.L_CORE X_NUC_130.L_CORE 0.002073
K_5525 X_NUC_27.L_CORE X_NUC_131.L_CORE 0.002061
K_5526 X_NUC_27.L_CORE X_NUC_132.L_CORE 0.002055
K_5527 X_NUC_27.L_CORE X_NUC_133.L_CORE 0.001454
K_5528 X_NUC_27.L_CORE X_NUC_134.L_CORE 0.001457
K_5529 X_NUC_27.L_CORE X_NUC_135.L_CORE 0.001447
K_5530 X_NUC_27.L_CORE X_NUC_136.L_CORE 0.001454
K_5531 X_NUC_27.L_CORE X_NUC_137.L_CORE 0.001450
K_5532 X_NUC_27.L_CORE X_NUC_138.L_CORE 0.001457
K_5533 X_NUC_27.L_CORE X_NUC_139.L_CORE 0.001449
K_5534 X_NUC_27.L_CORE X_NUC_140.L_CORE 0.001448
K_5535 X_NUC_27.L_CORE X_NUC_141.L_CORE 0.001881
K_5536 X_NUC_27.L_CORE X_NUC_142.L_CORE 0.001879
K_5537 X_NUC_27.L_CORE X_NUC_143.L_CORE 0.001867
K_5538 X_NUC_27.L_CORE X_NUC_144.L_CORE 0.001871
K_5539 X_NUC_27.L_CORE X_NUC_145.L_CORE 0.001311
K_5540 X_NUC_27.L_CORE X_NUC_146.L_CORE 0.001316
K_5541 X_NUC_27.L_CORE X_NUC_147.L_CORE 0.001308
K_5542 X_NUC_27.L_CORE X_NUC_148.L_CORE 0.001311
K_5543 X_NUC_27.L_CORE X_NUC_149.L_CORE 0.001645
K_5544 X_NUC_27.L_CORE X_NUC_150.L_CORE 0.001650
K_5545 X_NUC_27.L_CORE X_NUC_151.L_CORE 0.001640
K_5546 X_NUC_27.L_CORE X_NUC_152.L_CORE 0.001638
K_5547 X_NUC_27.L_CORE X_NUC_153.L_CORE 0.001524
K_5548 X_NUC_27.L_CORE X_NUC_154.L_CORE 0.001525
K_5549 X_NUC_27.L_CORE X_NUC_155.L_CORE 0.001515
K_5550 X_NUC_27.L_CORE X_NUC_156.L_CORE 0.001520
K_5551 X_NUC_27.L_CORE X_NUC_157.L_CORE 0.001341
K_5552 X_NUC_27.L_CORE X_NUC_158.L_CORE 0.001346
K_5553 X_NUC_27.L_CORE X_NUC_159.L_CORE 0.001338
K_5554 X_NUC_27.L_CORE X_NUC_160.L_CORE 0.001339
K_5555 X_NUC_27.L_CORE X_NUC_161.L_CORE 0.001634
K_5556 X_NUC_27.L_CORE X_NUC_162.L_CORE 0.001636
K_5557 X_NUC_27.L_CORE X_NUC_163.L_CORE 0.001626
K_5558 X_NUC_27.L_CORE X_NUC_164.L_CORE 0.001627
K_5559 X_NUC_27.L_CORE X_NUC_165.L_CORE 0.001367
K_5560 X_NUC_27.L_CORE X_NUC_166.L_CORE 0.001371
K_5561 X_NUC_27.L_CORE X_NUC_167.L_CORE 0.001362
K_5562 X_NUC_27.L_CORE X_NUC_168.L_CORE 0.001365
K_5563 X_NUC_27.L_CORE X_NUC_169.L_CORE 0.001425
K_5564 X_NUC_27.L_CORE X_NUC_170.L_CORE 0.001429
K_5565 X_NUC_27.L_CORE X_NUC_171.L_CORE 0.001420
K_5566 X_NUC_27.L_CORE X_NUC_172.L_CORE 0.001421
K_5567 X_NUC_27.L_CORE X_NUC_173.L_CORE 0.002968
K_5568 X_NUC_27.L_CORE X_NUC_174.L_CORE 0.004735
K_5569 X_NUC_27.L_CORE X_NUC_175.L_CORE 0.002149
K_5570 X_NUC_27.L_CORE X_NUC_176.L_CORE 0.004147
K_5571 X_NUC_27.L_CORE X_NUC_177.L_CORE 0.002835
K_5572 X_NUC_27.L_CORE X_NUC_178.L_CORE 0.001995
K_5573 X_NUC_27.L_CORE X_NUC_179.L_CORE 0.024418
K_5574 X_NUC_27.L_CORE X_NUC_180.L_CORE 0.001883
K_5575 X_NUC_27.L_CORE X_NUC_181.L_CORE 0.002512
K_5576 X_NUC_27.L_CORE X_NUC_182.L_CORE 0.003741
K_5577 X_NUC_27.L_CORE X_NUC_183.L_CORE 0.001639
K_5578 X_NUC_27.L_CORE X_NUC_184.L_CORE 0.005124
K_5579 X_NUC_27.L_CORE X_NUC_185.L_CORE 0.001972
K_5580 X_NUC_27.L_CORE X_NUC_186.L_CORE 0.001794
K_5581 X_NUC_27.L_CORE X_NUC_187.L_CORE 0.005686
K_5582 X_NUC_27.L_CORE X_NUC_188.L_CORE 0.001529
K_5583 X_NUC_27.L_CORE X_NUC_189.L_CORE 0.002551
K_5584 X_NUC_27.L_CORE X_NUC_190.L_CORE 0.002324
K_5585 X_NUC_27.L_CORE X_NUC_191.L_CORE 0.001489
K_5586 X_NUC_27.L_CORE X_NUC_192.L_CORE 0.004335
K_5587 X_NUC_27.L_CORE X_NUC_193.L_CORE 0.001571
K_5588 X_NUC_27.L_CORE X_NUC_194.L_CORE 0.001775
K_5589 X_NUC_27.L_CORE X_NUC_195.L_CORE 0.002865
K_5590 X_NUC_27.L_CORE X_NUC_196.L_CORE 0.001372
K_5591 X_NUC_27.L_CORE X_NUC_197.L_CORE 0.002551
K_5592 X_NUC_27.L_CORE X_NUC_198.L_CORE 0.001738
K_5593 X_NUC_27.L_CORE X_NUC_199.L_CORE 0.001447
K_5594 X_NUC_27.L_CORE X_NUC_200.L_CORE 0.002940
K_5595 X_NUC_27.L_CORE X_NUC_201.L_CORE 0.001371
K_5596 X_NUC_27.L_CORE X_NUC_202.L_CORE 0.001796
K_5597 X_NUC_27.L_CORE X_NUC_203.L_CORE 0.001981
K_5598 X_NUC_27.L_CORE X_NUC_204.L_CORE 0.001308
K_5599 X_NUC_27.L_CORE X_NUC_205.L_CORE 0.002306
K_5600 X_NUC_27.L_CORE X_NUC_206.L_CORE 0.001453
K_5601 X_NUC_27.L_CORE X_NUC_207.L_CORE 0.001452
K_5602 X_NUC_27.L_CORE X_NUC_208.L_CORE 0.002097
K_5603 X_NUC_27.L_CORE X_NUC_209.L_CORE 0.001276
K_5604 X_NUC_27.L_CORE X_NUC_210.L_CORE 0.001759
K_5605 X_NUC_27.L_CORE X_NUC_211.L_CORE 0.001575
K_5606 X_NUC_27.L_CORE X_NUC_212.L_CORE 0.001299
K_5607 X_NUC_27.L_CORE X_NUC_213.L_CORE 0.001899
K_5608 X_NUC_27.L_CORE X_NUC_214.L_CORE 0.001315
K_5609 X_NUC_27.L_CORE X_NUC_215.L_CORE 0.001454
K_5610 X_NUC_27.L_CORE X_NUC_216.L_CORE 0.001627
K_5611 X_NUC_27.L_CORE X_NUC_217.L_CORE 0.001258
K_5612 X_NUC_27.L_CORE X_NUC_218.L_CORE 0.001589
K_5613 X_NUC_27.L_CORE X_NUC_219.L_CORE 0.001377
K_5614 X_NUC_27.L_CORE X_NUC_220.L_CORE 0.001325
K_5615 X_NUC_27.L_CORE X_NUC_221.L_CORE 0.001490
K_5616 X_NUC_27.L_CORE X_NUC_222.L_CORE 0.001320
K_5617 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.001881
K_5618 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.001891
K_5619 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.001879
K_5620 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.001892
K_5621 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.002526
K_5622 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.002555
K_5623 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.002544
K_5624 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.002533
K_5625 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.003675
K_5626 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.003661
K_5627 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.003629
K_5628 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.003691
K_5629 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.001640
K_5630 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.001652
K_5631 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.001642
K_5632 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.001647
K_5633 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.004974
K_5634 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.005022
K_5635 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.005009
K_5636 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.004914
K_5637 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.001958
K_5638 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.001963
K_5639 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.001949
K_5640 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.001966
K_5641 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.001795
K_5642 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.001810
K_5643 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.001801
K_5644 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.001800
K_5645 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.005056
K_5646 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.004983
K_5647 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.004937
K_5648 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.004982
K_5649 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.001528
K_5650 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.001536
K_5651 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.001526
K_5652 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.001534
K_5653 X_NUC_28.L_CORE X_NUC_65.L_CORE 0.002508
K_5654 X_NUC_28.L_CORE X_NUC_66.L_CORE 0.002529
K_5655 X_NUC_28.L_CORE X_NUC_67.L_CORE 0.002518
K_5656 X_NUC_28.L_CORE X_NUC_68.L_CORE 0.002500
K_5657 X_NUC_28.L_CORE X_NUC_69.L_CORE 0.002265
K_5658 X_NUC_28.L_CORE X_NUC_70.L_CORE 0.002263
K_5659 X_NUC_28.L_CORE X_NUC_71.L_CORE 0.002245
K_5660 X_NUC_28.L_CORE X_NUC_72.L_CORE 0.002267
K_5661 X_NUC_28.L_CORE X_NUC_73.L_CORE 0.001492
K_5662 X_NUC_28.L_CORE X_NUC_74.L_CORE 0.001502
K_5663 X_NUC_28.L_CORE X_NUC_75.L_CORE 0.001493
K_5664 X_NUC_28.L_CORE X_NUC_76.L_CORE 0.001495
K_5665 X_NUC_28.L_CORE X_NUC_77.L_CORE 0.003835
K_5666 X_NUC_28.L_CORE X_NUC_78.L_CORE 0.003823
K_5667 X_NUC_28.L_CORE X_NUC_79.L_CORE 0.003802
K_5668 X_NUC_28.L_CORE X_NUC_80.L_CORE 0.003771
K_5669 X_NUC_28.L_CORE X_NUC_81.L_CORE 0.001564
K_5670 X_NUC_28.L_CORE X_NUC_82.L_CORE 0.001569
K_5671 X_NUC_28.L_CORE X_NUC_83.L_CORE 0.001558
K_5672 X_NUC_28.L_CORE X_NUC_84.L_CORE 0.001568
K_5673 X_NUC_28.L_CORE X_NUC_85.L_CORE 0.001763
K_5674 X_NUC_28.L_CORE X_NUC_86.L_CORE 0.001775
K_5675 X_NUC_28.L_CORE X_NUC_87.L_CORE 0.001766
K_5676 X_NUC_28.L_CORE X_NUC_88.L_CORE 0.001762
K_5677 X_NUC_28.L_CORE X_NUC_89.L_CORE 0.002658
K_5678 X_NUC_28.L_CORE X_NUC_90.L_CORE 0.002646
K_5679 X_NUC_28.L_CORE X_NUC_91.L_CORE 0.002625
K_5680 X_NUC_28.L_CORE X_NUC_92.L_CORE 0.002643
K_5681 X_NUC_28.L_CORE X_NUC_93.L_CORE 0.001378
K_5682 X_NUC_28.L_CORE X_NUC_94.L_CORE 0.001385
K_5683 X_NUC_28.L_CORE X_NUC_95.L_CORE 0.001377
K_5684 X_NUC_28.L_CORE X_NUC_96.L_CORE 0.001381
K_5685 X_NUC_28.L_CORE X_NUC_97.L_CORE 0.002406
K_5686 X_NUC_28.L_CORE X_NUC_98.L_CORE 0.002415
K_5687 X_NUC_28.L_CORE X_NUC_99.L_CORE 0.002403
K_5688 X_NUC_28.L_CORE X_NUC_100.L_CORE 0.002388
K_5689 X_NUC_28.L_CORE X_NUC_101.L_CORE 0.001707
K_5690 X_NUC_28.L_CORE X_NUC_102.L_CORE 0.001709
K_5691 X_NUC_28.L_CORE X_NUC_103.L_CORE 0.001697
K_5692 X_NUC_28.L_CORE X_NUC_104.L_CORE 0.001708
K_5693 X_NUC_28.L_CORE X_NUC_105.L_CORE 0.001451
K_5694 X_NUC_28.L_CORE X_NUC_106.L_CORE 0.001460
K_5695 X_NUC_28.L_CORE X_NUC_107.L_CORE 0.001452
K_5696 X_NUC_28.L_CORE X_NUC_108.L_CORE 0.001452
K_5697 X_NUC_28.L_CORE X_NUC_109.L_CORE 0.002597
K_5698 X_NUC_28.L_CORE X_NUC_110.L_CORE 0.002589
K_5699 X_NUC_28.L_CORE X_NUC_111.L_CORE 0.002571
K_5700 X_NUC_28.L_CORE X_NUC_112.L_CORE 0.002571
K_5701 X_NUC_28.L_CORE X_NUC_113.L_CORE 0.001377
K_5702 X_NUC_28.L_CORE X_NUC_114.L_CORE 0.001382
K_5703 X_NUC_28.L_CORE X_NUC_115.L_CORE 0.001373
K_5704 X_NUC_28.L_CORE X_NUC_116.L_CORE 0.001379
K_5705 X_NUC_28.L_CORE X_NUC_117.L_CORE 0.001750
K_5706 X_NUC_28.L_CORE X_NUC_118.L_CORE 0.001759
K_5707 X_NUC_28.L_CORE X_NUC_119.L_CORE 0.001750
K_5708 X_NUC_28.L_CORE X_NUC_120.L_CORE 0.001745
K_5709 X_NUC_28.L_CORE X_NUC_121.L_CORE 0.001876
K_5710 X_NUC_28.L_CORE X_NUC_122.L_CORE 0.001874
K_5711 X_NUC_28.L_CORE X_NUC_123.L_CORE 0.001861
K_5712 X_NUC_28.L_CORE X_NUC_124.L_CORE 0.001871
K_5713 X_NUC_28.L_CORE X_NUC_125.L_CORE 0.001325
K_5714 X_NUC_28.L_CORE X_NUC_126.L_CORE 0.001331
K_5715 X_NUC_28.L_CORE X_NUC_127.L_CORE 0.001323
K_5716 X_NUC_28.L_CORE X_NUC_128.L_CORE 0.001326
K_5717 X_NUC_28.L_CORE X_NUC_129.L_CORE 0.002077
K_5718 X_NUC_28.L_CORE X_NUC_130.L_CORE 0.002079
K_5719 X_NUC_28.L_CORE X_NUC_131.L_CORE 0.002066
K_5720 X_NUC_28.L_CORE X_NUC_132.L_CORE 0.002061
K_5721 X_NUC_28.L_CORE X_NUC_133.L_CORE 0.001447
K_5722 X_NUC_28.L_CORE X_NUC_134.L_CORE 0.001450
K_5723 X_NUC_28.L_CORE X_NUC_135.L_CORE 0.001441
K_5724 X_NUC_28.L_CORE X_NUC_136.L_CORE 0.001447
K_5725 X_NUC_28.L_CORE X_NUC_137.L_CORE 0.001451
K_5726 X_NUC_28.L_CORE X_NUC_138.L_CORE 0.001458
K_5727 X_NUC_28.L_CORE X_NUC_139.L_CORE 0.001450
K_5728 X_NUC_28.L_CORE X_NUC_140.L_CORE 0.001449
K_5729 X_NUC_28.L_CORE X_NUC_141.L_CORE 0.001877
K_5730 X_NUC_28.L_CORE X_NUC_142.L_CORE 0.001875
K_5731 X_NUC_28.L_CORE X_NUC_143.L_CORE 0.001863
K_5732 X_NUC_28.L_CORE X_NUC_144.L_CORE 0.001867
K_5733 X_NUC_28.L_CORE X_NUC_145.L_CORE 0.001307
K_5734 X_NUC_28.L_CORE X_NUC_146.L_CORE 0.001312
K_5735 X_NUC_28.L_CORE X_NUC_147.L_CORE 0.001304
K_5736 X_NUC_28.L_CORE X_NUC_148.L_CORE 0.001308
K_5737 X_NUC_28.L_CORE X_NUC_149.L_CORE 0.001647
K_5738 X_NUC_28.L_CORE X_NUC_150.L_CORE 0.001652
K_5739 X_NUC_28.L_CORE X_NUC_151.L_CORE 0.001643
K_5740 X_NUC_28.L_CORE X_NUC_152.L_CORE 0.001640
K_5741 X_NUC_28.L_CORE X_NUC_153.L_CORE 0.001518
K_5742 X_NUC_28.L_CORE X_NUC_154.L_CORE 0.001520
K_5743 X_NUC_28.L_CORE X_NUC_155.L_CORE 0.001510
K_5744 X_NUC_28.L_CORE X_NUC_156.L_CORE 0.001515
K_5745 X_NUC_28.L_CORE X_NUC_157.L_CORE 0.001340
K_5746 X_NUC_28.L_CORE X_NUC_158.L_CORE 0.001345
K_5747 X_NUC_28.L_CORE X_NUC_159.L_CORE 0.001337
K_5748 X_NUC_28.L_CORE X_NUC_160.L_CORE 0.001338
K_5749 X_NUC_28.L_CORE X_NUC_161.L_CORE 0.001634
K_5750 X_NUC_28.L_CORE X_NUC_162.L_CORE 0.001635
K_5751 X_NUC_28.L_CORE X_NUC_163.L_CORE 0.001625
K_5752 X_NUC_28.L_CORE X_NUC_164.L_CORE 0.001626
K_5753 X_NUC_28.L_CORE X_NUC_165.L_CORE 0.001364
K_5754 X_NUC_28.L_CORE X_NUC_166.L_CORE 0.001367
K_5755 X_NUC_28.L_CORE X_NUC_167.L_CORE 0.001359
K_5756 X_NUC_28.L_CORE X_NUC_168.L_CORE 0.001362
K_5757 X_NUC_28.L_CORE X_NUC_169.L_CORE 0.001424
K_5758 X_NUC_28.L_CORE X_NUC_170.L_CORE 0.001428
K_5759 X_NUC_28.L_CORE X_NUC_171.L_CORE 0.001419
K_5760 X_NUC_28.L_CORE X_NUC_172.L_CORE 0.001420
K_5761 X_NUC_28.L_CORE X_NUC_173.L_CORE 0.002958
K_5762 X_NUC_28.L_CORE X_NUC_174.L_CORE 0.004663
K_5763 X_NUC_28.L_CORE X_NUC_175.L_CORE 0.002137
K_5764 X_NUC_28.L_CORE X_NUC_176.L_CORE 0.004172
K_5765 X_NUC_28.L_CORE X_NUC_177.L_CORE 0.002799
K_5766 X_NUC_28.L_CORE X_NUC_178.L_CORE 0.001992
K_5767 X_NUC_28.L_CORE X_NUC_179.L_CORE 0.024551
K_5768 X_NUC_28.L_CORE X_NUC_180.L_CORE 0.001870
K_5769 X_NUC_28.L_CORE X_NUC_181.L_CORE 0.002523
K_5770 X_NUC_28.L_CORE X_NUC_182.L_CORE 0.003677
K_5771 X_NUC_28.L_CORE X_NUC_183.L_CORE 0.001634
K_5772 X_NUC_28.L_CORE X_NUC_184.L_CORE 0.005239
K_5773 X_NUC_28.L_CORE X_NUC_185.L_CORE 0.001955
K_5774 X_NUC_28.L_CORE X_NUC_186.L_CORE 0.001796
K_5775 X_NUC_28.L_CORE X_NUC_187.L_CORE 0.005623
K_5776 X_NUC_28.L_CORE X_NUC_188.L_CORE 0.001522
K_5777 X_NUC_28.L_CORE X_NUC_189.L_CORE 0.002571
K_5778 X_NUC_28.L_CORE X_NUC_190.L_CORE 0.002300
K_5779 X_NUC_28.L_CORE X_NUC_191.L_CORE 0.001487
K_5780 X_NUC_28.L_CORE X_NUC_192.L_CORE 0.004389
K_5781 X_NUC_28.L_CORE X_NUC_193.L_CORE 0.001561
K_5782 X_NUC_28.L_CORE X_NUC_194.L_CORE 0.001780
K_5783 X_NUC_28.L_CORE X_NUC_195.L_CORE 0.002842
K_5784 X_NUC_28.L_CORE X_NUC_196.L_CORE 0.001368
K_5785 X_NUC_28.L_CORE X_NUC_197.L_CORE 0.002572
K_5786 X_NUC_28.L_CORE X_NUC_198.L_CORE 0.001725
K_5787 X_NUC_28.L_CORE X_NUC_199.L_CORE 0.001447
K_5788 X_NUC_28.L_CORE X_NUC_200.L_CORE 0.002942
K_5789 X_NUC_28.L_CORE X_NUC_201.L_CORE 0.001364
K_5790 X_NUC_28.L_CORE X_NUC_202.L_CORE 0.001803
K_5791 X_NUC_28.L_CORE X_NUC_203.L_CORE 0.001969
K_5792 X_NUC_28.L_CORE X_NUC_204.L_CORE 0.001305
K_5793 X_NUC_28.L_CORE X_NUC_205.L_CORE 0.002317
K_5794 X_NUC_28.L_CORE X_NUC_206.L_CORE 0.001445
K_5795 X_NUC_28.L_CORE X_NUC_207.L_CORE 0.001454
K_5796 X_NUC_28.L_CORE X_NUC_208.L_CORE 0.002092
K_5797 X_NUC_28.L_CORE X_NUC_209.L_CORE 0.001272
K_5798 X_NUC_28.L_CORE X_NUC_210.L_CORE 0.001765
K_5799 X_NUC_28.L_CORE X_NUC_211.L_CORE 0.001567
K_5800 X_NUC_28.L_CORE X_NUC_212.L_CORE 0.001298
K_5801 X_NUC_28.L_CORE X_NUC_213.L_CORE 0.001901
K_5802 X_NUC_28.L_CORE X_NUC_214.L_CORE 0.001310
K_5803 X_NUC_28.L_CORE X_NUC_215.L_CORE 0.001456
K_5804 X_NUC_28.L_CORE X_NUC_216.L_CORE 0.001623
K_5805 X_NUC_28.L_CORE X_NUC_217.L_CORE 0.001256
K_5806 X_NUC_28.L_CORE X_NUC_218.L_CORE 0.001591
K_5807 X_NUC_28.L_CORE X_NUC_219.L_CORE 0.001373
K_5808 X_NUC_28.L_CORE X_NUC_220.L_CORE 0.001324
K_5809 X_NUC_28.L_CORE X_NUC_221.L_CORE 0.001488
K_5810 X_NUC_28.L_CORE X_NUC_222.L_CORE 0.001317
K_5811 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_5812 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_5813 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_5814 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.001795
K_5815 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.001796
K_5816 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.001803
K_5817 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.001788
K_5818 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.002415
K_5819 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.002389
K_5820 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.002405
K_5821 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.002395
K_5822 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.003543
K_5823 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.003591
K_5824 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.003576
K_5825 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.003540
K_5826 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.001580
K_5827 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.001575
K_5828 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.001582
K_5829 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.001571
K_5830 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.004821
K_5831 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.004727
K_5832 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.004725
K_5833 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.004755
K_5834 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.001899
K_5835 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.001905
K_5836 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.001907
K_5837 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.001892
K_5838 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.001741
K_5839 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.001730
K_5840 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.001737
K_5841 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.001729
K_5842 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.005035
K_5843 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.005120
K_5844 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.005010
K_5845 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.005018
K_5846 X_NUC_29.L_CORE X_NUC_65.L_CORE 0.001488
K_5847 X_NUC_29.L_CORE X_NUC_66.L_CORE 0.001487
K_5848 X_NUC_29.L_CORE X_NUC_67.L_CORE 0.001491
K_5849 X_NUC_29.L_CORE X_NUC_68.L_CORE 0.001481
K_5850 X_NUC_29.L_CORE X_NUC_69.L_CORE 0.002454
K_5851 X_NUC_29.L_CORE X_NUC_70.L_CORE 0.002429
K_5852 X_NUC_29.L_CORE X_NUC_71.L_CORE 0.002433
K_5853 X_NUC_29.L_CORE X_NUC_72.L_CORE 0.002432
K_5854 X_NUC_29.L_CORE X_NUC_73.L_CORE 0.002226
K_5855 X_NUC_29.L_CORE X_NUC_74.L_CORE 0.002242
K_5856 X_NUC_29.L_CORE X_NUC_75.L_CORE 0.002234
K_5857 X_NUC_29.L_CORE X_NUC_76.L_CORE 0.002219
K_5858 X_NUC_29.L_CORE X_NUC_77.L_CORE 0.001459
K_5859 X_NUC_29.L_CORE X_NUC_78.L_CORE 0.001453
K_5860 X_NUC_29.L_CORE X_NUC_79.L_CORE 0.001458
K_5861 X_NUC_29.L_CORE X_NUC_80.L_CORE 0.001450
K_5862 X_NUC_29.L_CORE X_NUC_81.L_CORE 0.003845
K_5863 X_NUC_29.L_CORE X_NUC_82.L_CORE 0.003830
K_5864 X_NUC_29.L_CORE X_NUC_83.L_CORE 0.003780
K_5865 X_NUC_29.L_CORE X_NUC_84.L_CORE 0.003807
K_5866 X_NUC_29.L_CORE X_NUC_85.L_CORE 0.001536
K_5867 X_NUC_29.L_CORE X_NUC_86.L_CORE 0.001539
K_5868 X_NUC_29.L_CORE X_NUC_87.L_CORE 0.001540
K_5869 X_NUC_29.L_CORE X_NUC_88.L_CORE 0.001529
K_5870 X_NUC_29.L_CORE X_NUC_89.L_CORE 0.001734
K_5871 X_NUC_29.L_CORE X_NUC_90.L_CORE 0.001722
K_5872 X_NUC_29.L_CORE X_NUC_91.L_CORE 0.001726
K_5873 X_NUC_29.L_CORE X_NUC_92.L_CORE 0.001721
K_5874 X_NUC_29.L_CORE X_NUC_93.L_CORE 0.002650
K_5875 X_NUC_29.L_CORE X_NUC_94.L_CORE 0.002671
K_5876 X_NUC_29.L_CORE X_NUC_95.L_CORE 0.002646
K_5877 X_NUC_29.L_CORE X_NUC_96.L_CORE 0.002639
K_5878 X_NUC_29.L_CORE X_NUC_97.L_CORE 0.001357
K_5879 X_NUC_29.L_CORE X_NUC_98.L_CORE 0.001354
K_5880 X_NUC_29.L_CORE X_NUC_99.L_CORE 0.001357
K_5881 X_NUC_29.L_CORE X_NUC_100.L_CORE 0.001349
K_5882 X_NUC_29.L_CORE X_NUC_101.L_CORE 0.002392
K_5883 X_NUC_29.L_CORE X_NUC_102.L_CORE 0.002375
K_5884 X_NUC_29.L_CORE X_NUC_103.L_CORE 0.002367
K_5885 X_NUC_29.L_CORE X_NUC_104.L_CORE 0.002370
K_5886 X_NUC_29.L_CORE X_NUC_105.L_CORE 0.001691
K_5887 X_NUC_29.L_CORE X_NUC_106.L_CORE 0.001697
K_5888 X_NUC_29.L_CORE X_NUC_107.L_CORE 0.001693
K_5889 X_NUC_29.L_CORE X_NUC_108.L_CORE 0.001684
K_5890 X_NUC_29.L_CORE X_NUC_109.L_CORE 0.001434
K_5891 X_NUC_29.L_CORE X_NUC_110.L_CORE 0.001428
K_5892 X_NUC_29.L_CORE X_NUC_111.L_CORE 0.001430
K_5893 X_NUC_29.L_CORE X_NUC_112.L_CORE 0.001424
K_5894 X_NUC_29.L_CORE X_NUC_113.L_CORE 0.002602
K_5895 X_NUC_29.L_CORE X_NUC_114.L_CORE 0.002607
K_5896 X_NUC_29.L_CORE X_NUC_115.L_CORE 0.002580
K_5897 X_NUC_29.L_CORE X_NUC_116.L_CORE 0.002584
K_5898 X_NUC_29.L_CORE X_NUC_117.L_CORE 0.001365
K_5899 X_NUC_29.L_CORE X_NUC_118.L_CORE 0.001365
K_5900 X_NUC_29.L_CORE X_NUC_119.L_CORE 0.001365
K_5901 X_NUC_29.L_CORE X_NUC_120.L_CORE 0.001358
K_5902 X_NUC_29.L_CORE X_NUC_121.L_CORE 0.001739
K_5903 X_NUC_29.L_CORE X_NUC_122.L_CORE 0.001729
K_5904 X_NUC_29.L_CORE X_NUC_123.L_CORE 0.001728
K_5905 X_NUC_29.L_CORE X_NUC_124.L_CORE 0.001725
K_5906 X_NUC_29.L_CORE X_NUC_125.L_CORE 0.001871
K_5907 X_NUC_29.L_CORE X_NUC_126.L_CORE 0.001878
K_5908 X_NUC_29.L_CORE X_NUC_127.L_CORE 0.001868
K_5909 X_NUC_29.L_CORE X_NUC_128.L_CORE 0.001862
K_5910 X_NUC_29.L_CORE X_NUC_129.L_CORE 0.001317
K_5911 X_NUC_29.L_CORE X_NUC_130.L_CORE 0.001314
K_5912 X_NUC_29.L_CORE X_NUC_131.L_CORE 0.001315
K_5913 X_NUC_29.L_CORE X_NUC_132.L_CORE 0.001309
K_5914 X_NUC_29.L_CORE X_NUC_133.L_CORE 0.002069
K_5915 X_NUC_29.L_CORE X_NUC_134.L_CORE 0.002064
K_5916 X_NUC_29.L_CORE X_NUC_135.L_CORE 0.002052
K_5917 X_NUC_29.L_CORE X_NUC_136.L_CORE 0.002053
K_5918 X_NUC_29.L_CORE X_NUC_137.L_CORE 0.001443
K_5919 X_NUC_29.L_CORE X_NUC_138.L_CORE 0.001446
K_5920 X_NUC_29.L_CORE X_NUC_139.L_CORE 0.001443
K_5921 X_NUC_29.L_CORE X_NUC_140.L_CORE 0.001436
K_5922 X_NUC_29.L_CORE X_NUC_141.L_CORE 0.001447
K_5923 X_NUC_29.L_CORE X_NUC_142.L_CORE 0.001442
K_5924 X_NUC_29.L_CORE X_NUC_143.L_CORE 0.001441
K_5925 X_NUC_29.L_CORE X_NUC_144.L_CORE 0.001437
K_5926 X_NUC_29.L_CORE X_NUC_145.L_CORE 0.001867
K_5927 X_NUC_29.L_CORE X_NUC_146.L_CORE 0.001870
K_5928 X_NUC_29.L_CORE X_NUC_147.L_CORE 0.001858
K_5929 X_NUC_29.L_CORE X_NUC_148.L_CORE 0.001856
K_5930 X_NUC_29.L_CORE X_NUC_149.L_CORE 0.001310
K_5931 X_NUC_29.L_CORE X_NUC_150.L_CORE 0.001309
K_5932 X_NUC_29.L_CORE X_NUC_151.L_CORE 0.001308
K_5933 X_NUC_29.L_CORE X_NUC_152.L_CORE 0.001303
K_5934 X_NUC_29.L_CORE X_NUC_153.L_CORE 0.001638
K_5935 X_NUC_29.L_CORE X_NUC_154.L_CORE 0.001633
K_5936 X_NUC_29.L_CORE X_NUC_155.L_CORE 0.001628
K_5937 X_NUC_29.L_CORE X_NUC_156.L_CORE 0.001626
K_5938 X_NUC_29.L_CORE X_NUC_157.L_CORE 0.001516
K_5939 X_NUC_29.L_CORE X_NUC_158.L_CORE 0.001518
K_5940 X_NUC_29.L_CORE X_NUC_159.L_CORE 0.001513
K_5941 X_NUC_29.L_CORE X_NUC_160.L_CORE 0.001508
K_5942 X_NUC_29.L_CORE X_NUC_161.L_CORE 0.001351
K_5943 X_NUC_29.L_CORE X_NUC_162.L_CORE 0.001349
K_5944 X_NUC_29.L_CORE X_NUC_163.L_CORE 0.001347
K_5945 X_NUC_29.L_CORE X_NUC_164.L_CORE 0.001343
K_5946 X_NUC_29.L_CORE X_NUC_165.L_CORE 0.001598
K_5947 X_NUC_29.L_CORE X_NUC_166.L_CORE 0.001597
K_5948 X_NUC_29.L_CORE X_NUC_167.L_CORE 0.001590
K_5949 X_NUC_29.L_CORE X_NUC_168.L_CORE 0.001587
K_5950 X_NUC_29.L_CORE X_NUC_169.L_CORE 0.001393
K_5951 X_NUC_29.L_CORE X_NUC_170.L_CORE 0.001393
K_5952 X_NUC_29.L_CORE X_NUC_171.L_CORE 0.001389
K_5953 X_NUC_29.L_CORE X_NUC_172.L_CORE 0.001385
K_5954 X_NUC_29.L_CORE X_NUC_173.L_CORE 0.002692
K_5955 X_NUC_29.L_CORE X_NUC_174.L_CORE 0.002613
K_5956 X_NUC_29.L_CORE X_NUC_175.L_CORE 0.004810
K_5957 X_NUC_29.L_CORE X_NUC_176.L_CORE 0.001951
K_5958 X_NUC_29.L_CORE X_NUC_177.L_CORE 0.003894
K_5959 X_NUC_29.L_CORE X_NUC_178.L_CORE 0.002641
K_5960 X_NUC_29.L_CORE X_NUC_179.L_CORE 0.001866
K_5961 X_NUC_29.L_CORE X_NUC_180.L_CORE 0.025811
K_5962 X_NUC_29.L_CORE X_NUC_181.L_CORE 0.001779
K_5963 X_NUC_29.L_CORE X_NUC_182.L_CORE 0.002383
K_5964 X_NUC_29.L_CORE X_NUC_183.L_CORE 0.003574
K_5965 X_NUC_29.L_CORE X_NUC_184.L_CORE 0.001564
K_5966 X_NUC_29.L_CORE X_NUC_185.L_CORE 0.004992
K_5967 X_NUC_29.L_CORE X_NUC_186.L_CORE 0.001894
K_5968 X_NUC_29.L_CORE X_NUC_187.L_CORE 0.001725
K_5969 X_NUC_29.L_CORE X_NUC_188.L_CORE 0.005752
K_5970 X_NUC_29.L_CORE X_NUC_189.L_CORE 0.001475
K_5971 X_NUC_29.L_CORE X_NUC_190.L_CORE 0.002487
K_5972 X_NUC_29.L_CORE X_NUC_191.L_CORE 0.002267
K_5973 X_NUC_29.L_CORE X_NUC_192.L_CORE 0.001443
K_5974 X_NUC_29.L_CORE X_NUC_193.L_CORE 0.004440
K_5975 X_NUC_29.L_CORE X_NUC_194.L_CORE 0.001529
K_5976 X_NUC_29.L_CORE X_NUC_195.L_CORE 0.001734
K_5977 X_NUC_29.L_CORE X_NUC_196.L_CORE 0.002863
K_5978 X_NUC_29.L_CORE X_NUC_197.L_CORE 0.001338
K_5979 X_NUC_29.L_CORE X_NUC_198.L_CORE 0.002544
K_5980 X_NUC_29.L_CORE X_NUC_199.L_CORE 0.001709
K_5981 X_NUC_29.L_CORE X_NUC_200.L_CORE 0.001418
K_5982 X_NUC_29.L_CORE X_NUC_201.L_CORE 0.002990
K_5983 X_NUC_29.L_CORE X_NUC_202.L_CORE 0.001345
K_5984 X_NUC_29.L_CORE X_NUC_203.L_CORE 0.001777
K_5985 X_NUC_29.L_CORE X_NUC_204.L_CORE 0.001972
K_5986 X_NUC_29.L_CORE X_NUC_205.L_CORE 0.001287
K_5987 X_NUC_29.L_CORE X_NUC_206.L_CORE 0.002321
K_5988 X_NUC_29.L_CORE X_NUC_207.L_CORE 0.001436
K_5989 X_NUC_29.L_CORE X_NUC_208.L_CORE 0.001437
K_5990 X_NUC_29.L_CORE X_NUC_209.L_CORE 0.002106
K_5991 X_NUC_29.L_CORE X_NUC_210.L_CORE 0.001262
K_5992 X_NUC_29.L_CORE X_NUC_211.L_CORE 0.001756
K_5993 X_NUC_29.L_CORE X_NUC_212.L_CORE 0.001568
K_5994 X_NUC_29.L_CORE X_NUC_213.L_CORE 0.001290
K_5995 X_NUC_29.L_CORE X_NUC_214.L_CORE 0.001899
K_5996 X_NUC_29.L_CORE X_NUC_215.L_CORE 0.001309
K_5997 X_NUC_29.L_CORE X_NUC_216.L_CORE 0.001450
K_5998 X_NUC_29.L_CORE X_NUC_217.L_CORE 0.001621
K_5999 X_NUC_29.L_CORE X_NUC_218.L_CORE 0.001260
K_6000 X_NUC_29.L_CORE X_NUC_219.L_CORE 0.001577
K_6001 X_NUC_29.L_CORE X_NUC_220.L_CORE 0.001378
K_6002 X_NUC_29.L_CORE X_NUC_221.L_CORE 0.001335
K_6003 X_NUC_29.L_CORE X_NUC_222.L_CORE 0.001445
K_6004 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_6005 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_6006 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.001794
K_6007 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.001795
K_6008 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.001802
K_6009 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.001787
K_6010 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.002441
K_6011 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.002415
K_6012 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.002431
K_6013 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.002420
K_6014 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.003496
K_6015 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.003543
K_6016 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.003528
K_6017 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.003494
K_6018 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.001584
K_6019 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.001580
K_6020 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.001586
K_6021 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.001575
K_6022 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.004918
K_6023 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.004821
K_6024 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.004818
K_6025 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.004850
K_6026 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.001892
K_6027 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.001899
K_6028 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.001900
K_6029 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.001885
K_6030 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.001752
K_6031 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.001741
K_6032 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.001749
K_6033 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.001740
K_6034 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.004952
K_6035 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.005035
K_6036 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.004929
K_6037 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.004937
K_6038 X_NUC_30.L_CORE X_NUC_65.L_CORE 0.001489
K_6039 X_NUC_30.L_CORE X_NUC_66.L_CORE 0.001488
K_6040 X_NUC_30.L_CORE X_NUC_67.L_CORE 0.001492
K_6041 X_NUC_30.L_CORE X_NUC_68.L_CORE 0.001482
K_6042 X_NUC_30.L_CORE X_NUC_69.L_CORE 0.002481
K_6043 X_NUC_30.L_CORE X_NUC_70.L_CORE 0.002454
K_6044 X_NUC_30.L_CORE X_NUC_71.L_CORE 0.002459
K_6045 X_NUC_30.L_CORE X_NUC_72.L_CORE 0.002457
K_6046 X_NUC_30.L_CORE X_NUC_73.L_CORE 0.002211
K_6047 X_NUC_30.L_CORE X_NUC_74.L_CORE 0.002226
K_6048 X_NUC_30.L_CORE X_NUC_75.L_CORE 0.002218
K_6049 X_NUC_30.L_CORE X_NUC_76.L_CORE 0.002204
K_6050 X_NUC_30.L_CORE X_NUC_77.L_CORE 0.001464
K_6051 X_NUC_30.L_CORE X_NUC_78.L_CORE 0.001459
K_6052 X_NUC_30.L_CORE X_NUC_79.L_CORE 0.001463
K_6053 X_NUC_30.L_CORE X_NUC_80.L_CORE 0.001455
K_6054 X_NUC_30.L_CORE X_NUC_81.L_CORE 0.003859
K_6055 X_NUC_30.L_CORE X_NUC_82.L_CORE 0.003845
K_6056 X_NUC_30.L_CORE X_NUC_83.L_CORE 0.003794
K_6057 X_NUC_30.L_CORE X_NUC_84.L_CORE 0.003822
K_6058 X_NUC_30.L_CORE X_NUC_85.L_CORE 0.001534
K_6059 X_NUC_30.L_CORE X_NUC_86.L_CORE 0.001536
K_6060 X_NUC_30.L_CORE X_NUC_87.L_CORE 0.001537
K_6061 X_NUC_30.L_CORE X_NUC_88.L_CORE 0.001527
K_6062 X_NUC_30.L_CORE X_NUC_89.L_CORE 0.001746
K_6063 X_NUC_30.L_CORE X_NUC_90.L_CORE 0.001734
K_6064 X_NUC_30.L_CORE X_NUC_91.L_CORE 0.001738
K_6065 X_NUC_30.L_CORE X_NUC_92.L_CORE 0.001732
K_6066 X_NUC_30.L_CORE X_NUC_93.L_CORE 0.002629
K_6067 X_NUC_30.L_CORE X_NUC_94.L_CORE 0.002650
K_6068 X_NUC_30.L_CORE X_NUC_95.L_CORE 0.002625
K_6069 X_NUC_30.L_CORE X_NUC_96.L_CORE 0.002618
K_6070 X_NUC_30.L_CORE X_NUC_97.L_CORE 0.001359
K_6071 X_NUC_30.L_CORE X_NUC_98.L_CORE 0.001357
K_6072 X_NUC_30.L_CORE X_NUC_99.L_CORE 0.001359
K_6073 X_NUC_30.L_CORE X_NUC_100.L_CORE 0.001351
K_6074 X_NUC_30.L_CORE X_NUC_101.L_CORE 0.002409
K_6075 X_NUC_30.L_CORE X_NUC_102.L_CORE 0.002392
K_6076 X_NUC_30.L_CORE X_NUC_103.L_CORE 0.002384
K_6077 X_NUC_30.L_CORE X_NUC_104.L_CORE 0.002387
K_6078 X_NUC_30.L_CORE X_NUC_105.L_CORE 0.001685
K_6079 X_NUC_30.L_CORE X_NUC_106.L_CORE 0.001691
K_6080 X_NUC_30.L_CORE X_NUC_107.L_CORE 0.001687
K_6081 X_NUC_30.L_CORE X_NUC_108.L_CORE 0.001678
K_6082 X_NUC_30.L_CORE X_NUC_109.L_CORE 0.001440
K_6083 X_NUC_30.L_CORE X_NUC_110.L_CORE 0.001434
K_6084 X_NUC_30.L_CORE X_NUC_111.L_CORE 0.001436
K_6085 X_NUC_30.L_CORE X_NUC_112.L_CORE 0.001430
K_6086 X_NUC_30.L_CORE X_NUC_113.L_CORE 0.002596
K_6087 X_NUC_30.L_CORE X_NUC_114.L_CORE 0.002602
K_6088 X_NUC_30.L_CORE X_NUC_115.L_CORE 0.002575
K_6089 X_NUC_30.L_CORE X_NUC_116.L_CORE 0.002579
K_6090 X_NUC_30.L_CORE X_NUC_117.L_CORE 0.001364
K_6091 X_NUC_30.L_CORE X_NUC_118.L_CORE 0.001365
K_6092 X_NUC_30.L_CORE X_NUC_119.L_CORE 0.001365
K_6093 X_NUC_30.L_CORE X_NUC_120.L_CORE 0.001357
K_6094 X_NUC_30.L_CORE X_NUC_121.L_CORE 0.001749
K_6095 X_NUC_30.L_CORE X_NUC_122.L_CORE 0.001739
K_6096 X_NUC_30.L_CORE X_NUC_123.L_CORE 0.001738
K_6097 X_NUC_30.L_CORE X_NUC_124.L_CORE 0.001735
K_6098 X_NUC_30.L_CORE X_NUC_125.L_CORE 0.001863
K_6099 X_NUC_30.L_CORE X_NUC_126.L_CORE 0.001871
K_6100 X_NUC_30.L_CORE X_NUC_127.L_CORE 0.001861
K_6101 X_NUC_30.L_CORE X_NUC_128.L_CORE 0.001854
K_6102 X_NUC_30.L_CORE X_NUC_129.L_CORE 0.001320
K_6103 X_NUC_30.L_CORE X_NUC_130.L_CORE 0.001317
K_6104 X_NUC_30.L_CORE X_NUC_131.L_CORE 0.001318
K_6105 X_NUC_30.L_CORE X_NUC_132.L_CORE 0.001312
K_6106 X_NUC_30.L_CORE X_NUC_133.L_CORE 0.002075
K_6107 X_NUC_30.L_CORE X_NUC_134.L_CORE 0.002069
K_6108 X_NUC_30.L_CORE X_NUC_135.L_CORE 0.002057
K_6109 X_NUC_30.L_CORE X_NUC_136.L_CORE 0.002059
K_6110 X_NUC_30.L_CORE X_NUC_137.L_CORE 0.001441
K_6111 X_NUC_30.L_CORE X_NUC_138.L_CORE 0.001443
K_6112 X_NUC_30.L_CORE X_NUC_139.L_CORE 0.001441
K_6113 X_NUC_30.L_CORE X_NUC_140.L_CORE 0.001434
K_6114 X_NUC_30.L_CORE X_NUC_141.L_CORE 0.001453
K_6115 X_NUC_30.L_CORE X_NUC_142.L_CORE 0.001447
K_6116 X_NUC_30.L_CORE X_NUC_143.L_CORE 0.001447
K_6117 X_NUC_30.L_CORE X_NUC_144.L_CORE 0.001443
K_6118 X_NUC_30.L_CORE X_NUC_145.L_CORE 0.001863
K_6119 X_NUC_30.L_CORE X_NUC_146.L_CORE 0.001867
K_6120 X_NUC_30.L_CORE X_NUC_147.L_CORE 0.001855
K_6121 X_NUC_30.L_CORE X_NUC_148.L_CORE 0.001852
K_6122 X_NUC_30.L_CORE X_NUC_149.L_CORE 0.001311
K_6123 X_NUC_30.L_CORE X_NUC_150.L_CORE 0.001310
K_6124 X_NUC_30.L_CORE X_NUC_151.L_CORE 0.001310
K_6125 X_NUC_30.L_CORE X_NUC_152.L_CORE 0.001304
K_6126 X_NUC_30.L_CORE X_NUC_153.L_CORE 0.001643
K_6127 X_NUC_30.L_CORE X_NUC_154.L_CORE 0.001638
K_6128 X_NUC_30.L_CORE X_NUC_155.L_CORE 0.001633
K_6129 X_NUC_30.L_CORE X_NUC_156.L_CORE 0.001631
K_6130 X_NUC_30.L_CORE X_NUC_157.L_CORE 0.001514
K_6131 X_NUC_30.L_CORE X_NUC_158.L_CORE 0.001516
K_6132 X_NUC_30.L_CORE X_NUC_159.L_CORE 0.001511
K_6133 X_NUC_30.L_CORE X_NUC_160.L_CORE 0.001506
K_6134 X_NUC_30.L_CORE X_NUC_161.L_CORE 0.001354
K_6135 X_NUC_30.L_CORE X_NUC_162.L_CORE 0.001351
K_6136 X_NUC_30.L_CORE X_NUC_163.L_CORE 0.001350
K_6137 X_NUC_30.L_CORE X_NUC_164.L_CORE 0.001346
K_6138 X_NUC_30.L_CORE X_NUC_165.L_CORE 0.001599
K_6139 X_NUC_30.L_CORE X_NUC_166.L_CORE 0.001598
K_6140 X_NUC_30.L_CORE X_NUC_167.L_CORE 0.001591
K_6141 X_NUC_30.L_CORE X_NUC_168.L_CORE 0.001588
K_6142 X_NUC_30.L_CORE X_NUC_169.L_CORE 0.001394
K_6143 X_NUC_30.L_CORE X_NUC_170.L_CORE 0.001393
K_6144 X_NUC_30.L_CORE X_NUC_171.L_CORE 0.001390
K_6145 X_NUC_30.L_CORE X_NUC_172.L_CORE 0.001386
K_6146 X_NUC_30.L_CORE X_NUC_173.L_CORE 0.002695
K_6147 X_NUC_30.L_CORE X_NUC_174.L_CORE 0.002632
K_6148 X_NUC_30.L_CORE X_NUC_175.L_CORE 0.004783
K_6149 X_NUC_30.L_CORE X_NUC_176.L_CORE 0.001955
K_6150 X_NUC_30.L_CORE X_NUC_177.L_CORE 0.003959
K_6151 X_NUC_30.L_CORE X_NUC_178.L_CORE 0.002626
K_6152 X_NUC_30.L_CORE X_NUC_179.L_CORE 0.001876
K_6153 X_NUC_30.L_CORE X_NUC_180.L_CORE 0.025696
K_6154 X_NUC_30.L_CORE X_NUC_181.L_CORE 0.001777
K_6155 X_NUC_30.L_CORE X_NUC_182.L_CORE 0.002409
K_6156 X_NUC_30.L_CORE X_NUC_183.L_CORE 0.003525
K_6157 X_NUC_30.L_CORE X_NUC_184.L_CORE 0.001568
K_6158 X_NUC_30.L_CORE X_NUC_185.L_CORE 0.005104
K_6159 X_NUC_30.L_CORE X_NUC_186.L_CORE 0.001886
K_6160 X_NUC_30.L_CORE X_NUC_187.L_CORE 0.001737
K_6161 X_NUC_30.L_CORE X_NUC_188.L_CORE 0.005623
K_6162 X_NUC_30.L_CORE X_NUC_189.L_CORE 0.001476
K_6163 X_NUC_30.L_CORE X_NUC_190.L_CORE 0.002515
K_6164 X_NUC_30.L_CORE X_NUC_191.L_CORE 0.002249
K_6165 X_NUC_30.L_CORE X_NUC_192.L_CORE 0.001449
K_6166 X_NUC_30.L_CORE X_NUC_193.L_CORE 0.004462
K_6167 X_NUC_30.L_CORE X_NUC_194.L_CORE 0.001526
K_6168 X_NUC_30.L_CORE X_NUC_195.L_CORE 0.001746
K_6169 X_NUC_30.L_CORE X_NUC_196.L_CORE 0.002834
K_6170 X_NUC_30.L_CORE X_NUC_197.L_CORE 0.001340
K_6171 X_NUC_30.L_CORE X_NUC_198.L_CORE 0.002567
K_6172 X_NUC_30.L_CORE X_NUC_199.L_CORE 0.001702
K_6173 X_NUC_30.L_CORE X_NUC_200.L_CORE 0.001424
K_6174 X_NUC_30.L_CORE X_NUC_201.L_CORE 0.002978
K_6175 X_NUC_30.L_CORE X_NUC_202.L_CORE 0.001345
K_6176 X_NUC_30.L_CORE X_NUC_203.L_CORE 0.001789
K_6177 X_NUC_30.L_CORE X_NUC_204.L_CORE 0.001961
K_6178 X_NUC_30.L_CORE X_NUC_205.L_CORE 0.001290
K_6179 X_NUC_30.L_CORE X_NUC_206.L_CORE 0.002330
K_6180 X_NUC_30.L_CORE X_NUC_207.L_CORE 0.001433
K_6181 X_NUC_30.L_CORE X_NUC_208.L_CORE 0.001443
K_6182 X_NUC_30.L_CORE X_NUC_209.L_CORE 0.002098
K_6183 X_NUC_30.L_CORE X_NUC_210.L_CORE 0.001263
K_6184 X_NUC_30.L_CORE X_NUC_211.L_CORE 0.001764
K_6185 X_NUC_30.L_CORE X_NUC_212.L_CORE 0.001563
K_6186 X_NUC_30.L_CORE X_NUC_213.L_CORE 0.001293
K_6187 X_NUC_30.L_CORE X_NUC_214.L_CORE 0.001900
K_6188 X_NUC_30.L_CORE X_NUC_215.L_CORE 0.001309
K_6189 X_NUC_30.L_CORE X_NUC_216.L_CORE 0.001455
K_6190 X_NUC_30.L_CORE X_NUC_217.L_CORE 0.001618
K_6191 X_NUC_30.L_CORE X_NUC_218.L_CORE 0.001262
K_6192 X_NUC_30.L_CORE X_NUC_219.L_CORE 0.001580
K_6193 X_NUC_30.L_CORE X_NUC_220.L_CORE 0.001377
K_6194 X_NUC_30.L_CORE X_NUC_221.L_CORE 0.001337
K_6195 X_NUC_30.L_CORE X_NUC_222.L_CORE 0.001446
K_6196 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_6197 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.001787
K_6198 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.001788
K_6199 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.001795
K_6200 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.001780
K_6201 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.002424
K_6202 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.002398
K_6203 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.002415
K_6204 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.002404
K_6205 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.003510
K_6206 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.003557
K_6207 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.003543
K_6208 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.003508
K_6209 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.001577
K_6210 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.001573
K_6211 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.001580
K_6212 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.001569
K_6213 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.004921
K_6214 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.004822
K_6215 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.004821
K_6216 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.004852
K_6217 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.001890
K_6218 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.001897
K_6219 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.001899
K_6220 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.001883
K_6221 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.001744
K_6222 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.001733
K_6223 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.001741
K_6224 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.001732
K_6225 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.005058
K_6226 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.005146
K_6227 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.005035
K_6228 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.005043
K_6229 X_NUC_31.L_CORE X_NUC_65.L_CORE 0.001485
K_6230 X_NUC_31.L_CORE X_NUC_66.L_CORE 0.001484
K_6231 X_NUC_31.L_CORE X_NUC_67.L_CORE 0.001488
K_6232 X_NUC_31.L_CORE X_NUC_68.L_CORE 0.001478
K_6233 X_NUC_31.L_CORE X_NUC_69.L_CORE 0.002476
K_6234 X_NUC_31.L_CORE X_NUC_70.L_CORE 0.002449
K_6235 X_NUC_31.L_CORE X_NUC_71.L_CORE 0.002454
K_6236 X_NUC_31.L_CORE X_NUC_72.L_CORE 0.002453
K_6237 X_NUC_31.L_CORE X_NUC_73.L_CORE 0.002218
K_6238 X_NUC_31.L_CORE X_NUC_74.L_CORE 0.002234
K_6239 X_NUC_31.L_CORE X_NUC_75.L_CORE 0.002226
K_6240 X_NUC_31.L_CORE X_NUC_76.L_CORE 0.002211
K_6241 X_NUC_31.L_CORE X_NUC_77.L_CORE 0.001460
K_6242 X_NUC_31.L_CORE X_NUC_78.L_CORE 0.001454
K_6243 X_NUC_31.L_CORE X_NUC_79.L_CORE 0.001459
K_6244 X_NUC_31.L_CORE X_NUC_80.L_CORE 0.001451
K_6245 X_NUC_31.L_CORE X_NUC_81.L_CORE 0.003913
K_6246 X_NUC_31.L_CORE X_NUC_82.L_CORE 0.003898
K_6247 X_NUC_31.L_CORE X_NUC_83.L_CORE 0.003845
K_6248 X_NUC_31.L_CORE X_NUC_84.L_CORE 0.003873
K_6249 X_NUC_31.L_CORE X_NUC_85.L_CORE 0.001533
K_6250 X_NUC_31.L_CORE X_NUC_86.L_CORE 0.001535
K_6251 X_NUC_31.L_CORE X_NUC_87.L_CORE 0.001536
K_6252 X_NUC_31.L_CORE X_NUC_88.L_CORE 0.001526
K_6253 X_NUC_31.L_CORE X_NUC_89.L_CORE 0.001742
K_6254 X_NUC_31.L_CORE X_NUC_90.L_CORE 0.001730
K_6255 X_NUC_31.L_CORE X_NUC_91.L_CORE 0.001734
K_6256 X_NUC_31.L_CORE X_NUC_92.L_CORE 0.001729
K_6257 X_NUC_31.L_CORE X_NUC_93.L_CORE 0.002654
K_6258 X_NUC_31.L_CORE X_NUC_94.L_CORE 0.002675
K_6259 X_NUC_31.L_CORE X_NUC_95.L_CORE 0.002650
K_6260 X_NUC_31.L_CORE X_NUC_96.L_CORE 0.002643
K_6261 X_NUC_31.L_CORE X_NUC_97.L_CORE 0.001357
K_6262 X_NUC_31.L_CORE X_NUC_98.L_CORE 0.001354
K_6263 X_NUC_31.L_CORE X_NUC_99.L_CORE 0.001357
K_6264 X_NUC_31.L_CORE X_NUC_100.L_CORE 0.001349
K_6265 X_NUC_31.L_CORE X_NUC_101.L_CORE 0.002418
K_6266 X_NUC_31.L_CORE X_NUC_102.L_CORE 0.002400
K_6267 X_NUC_31.L_CORE X_NUC_103.L_CORE 0.002392
K_6268 X_NUC_31.L_CORE X_NUC_104.L_CORE 0.002396
K_6269 X_NUC_31.L_CORE X_NUC_105.L_CORE 0.001689
K_6270 X_NUC_31.L_CORE X_NUC_106.L_CORE 0.001695
K_6271 X_NUC_31.L_CORE X_NUC_107.L_CORE 0.001691
K_6272 X_NUC_31.L_CORE X_NUC_108.L_CORE 0.001682
K_6273 X_NUC_31.L_CORE X_NUC_109.L_CORE 0.001438
K_6274 X_NUC_31.L_CORE X_NUC_110.L_CORE 0.001432
K_6275 X_NUC_31.L_CORE X_NUC_111.L_CORE 0.001434
K_6276 X_NUC_31.L_CORE X_NUC_112.L_CORE 0.001428
K_6277 X_NUC_31.L_CORE X_NUC_113.L_CORE 0.002624
K_6278 X_NUC_31.L_CORE X_NUC_114.L_CORE 0.002629
K_6279 X_NUC_31.L_CORE X_NUC_115.L_CORE 0.002602
K_6280 X_NUC_31.L_CORE X_NUC_116.L_CORE 0.002606
K_6281 X_NUC_31.L_CORE X_NUC_117.L_CORE 0.001364
K_6282 X_NUC_31.L_CORE X_NUC_118.L_CORE 0.001364
K_6283 X_NUC_31.L_CORE X_NUC_119.L_CORE 0.001365
K_6284 X_NUC_31.L_CORE X_NUC_120.L_CORE 0.001357
K_6285 X_NUC_31.L_CORE X_NUC_121.L_CORE 0.001750
K_6286 X_NUC_31.L_CORE X_NUC_122.L_CORE 0.001740
K_6287 X_NUC_31.L_CORE X_NUC_123.L_CORE 0.001739
K_6288 X_NUC_31.L_CORE X_NUC_124.L_CORE 0.001736
K_6289 X_NUC_31.L_CORE X_NUC_125.L_CORE 0.001873
K_6290 X_NUC_31.L_CORE X_NUC_126.L_CORE 0.001881
K_6291 X_NUC_31.L_CORE X_NUC_127.L_CORE 0.001871
K_6292 X_NUC_31.L_CORE X_NUC_128.L_CORE 0.001864
K_6293 X_NUC_31.L_CORE X_NUC_129.L_CORE 0.001319
K_6294 X_NUC_31.L_CORE X_NUC_130.L_CORE 0.001316
K_6295 X_NUC_31.L_CORE X_NUC_131.L_CORE 0.001317
K_6296 X_NUC_31.L_CORE X_NUC_132.L_CORE 0.001311
K_6297 X_NUC_31.L_CORE X_NUC_133.L_CORE 0.002087
K_6298 X_NUC_31.L_CORE X_NUC_134.L_CORE 0.002081
K_6299 X_NUC_31.L_CORE X_NUC_135.L_CORE 0.002069
K_6300 X_NUC_31.L_CORE X_NUC_136.L_CORE 0.002071
K_6301 X_NUC_31.L_CORE X_NUC_137.L_CORE 0.001444
K_6302 X_NUC_31.L_CORE X_NUC_138.L_CORE 0.001446
K_6303 X_NUC_31.L_CORE X_NUC_139.L_CORE 0.001443
K_6304 X_NUC_31.L_CORE X_NUC_140.L_CORE 0.001437
K_6305 X_NUC_31.L_CORE X_NUC_141.L_CORE 0.001453
K_6306 X_NUC_31.L_CORE X_NUC_142.L_CORE 0.001447
K_6307 X_NUC_31.L_CORE X_NUC_143.L_CORE 0.001447
K_6308 X_NUC_31.L_CORE X_NUC_144.L_CORE 0.001443
K_6309 X_NUC_31.L_CORE X_NUC_145.L_CORE 0.001875
K_6310 X_NUC_31.L_CORE X_NUC_146.L_CORE 0.001878
K_6311 X_NUC_31.L_CORE X_NUC_147.L_CORE 0.001867
K_6312 X_NUC_31.L_CORE X_NUC_148.L_CORE 0.001864
K_6313 X_NUC_31.L_CORE X_NUC_149.L_CORE 0.001312
K_6314 X_NUC_31.L_CORE X_NUC_150.L_CORE 0.001311
K_6315 X_NUC_31.L_CORE X_NUC_151.L_CORE 0.001310
K_6316 X_NUC_31.L_CORE X_NUC_152.L_CORE 0.001305
K_6317 X_NUC_31.L_CORE X_NUC_153.L_CORE 0.001648
K_6318 X_NUC_31.L_CORE X_NUC_154.L_CORE 0.001643
K_6319 X_NUC_31.L_CORE X_NUC_155.L_CORE 0.001638
K_6320 X_NUC_31.L_CORE X_NUC_156.L_CORE 0.001636
K_6321 X_NUC_31.L_CORE X_NUC_157.L_CORE 0.001519
K_6322 X_NUC_31.L_CORE X_NUC_158.L_CORE 0.001521
K_6323 X_NUC_31.L_CORE X_NUC_159.L_CORE 0.001516
K_6324 X_NUC_31.L_CORE X_NUC_160.L_CORE 0.001511
K_6325 X_NUC_31.L_CORE X_NUC_161.L_CORE 0.001356
K_6326 X_NUC_31.L_CORE X_NUC_162.L_CORE 0.001353
K_6327 X_NUC_31.L_CORE X_NUC_163.L_CORE 0.001351
K_6328 X_NUC_31.L_CORE X_NUC_164.L_CORE 0.001347
K_6329 X_NUC_31.L_CORE X_NUC_165.L_CORE 0.001605
K_6330 X_NUC_31.L_CORE X_NUC_166.L_CORE 0.001604
K_6331 X_NUC_31.L_CORE X_NUC_167.L_CORE 0.001598
K_6332 X_NUC_31.L_CORE X_NUC_168.L_CORE 0.001595
K_6333 X_NUC_31.L_CORE X_NUC_169.L_CORE 0.001397
K_6334 X_NUC_31.L_CORE X_NUC_170.L_CORE 0.001396
K_6335 X_NUC_31.L_CORE X_NUC_171.L_CORE 0.001393
K_6336 X_NUC_31.L_CORE X_NUC_172.L_CORE 0.001389
K_6337 X_NUC_31.L_CORE X_NUC_173.L_CORE 0.002668
K_6338 X_NUC_31.L_CORE X_NUC_174.L_CORE 0.002602
K_6339 X_NUC_31.L_CORE X_NUC_175.L_CORE 0.004710
K_6340 X_NUC_31.L_CORE X_NUC_176.L_CORE 0.001942
K_6341 X_NUC_31.L_CORE X_NUC_177.L_CORE 0.003895
K_6342 X_NUC_31.L_CORE X_NUC_178.L_CORE 0.002615
K_6343 X_NUC_31.L_CORE X_NUC_179.L_CORE 0.001863
K_6344 X_NUC_31.L_CORE X_NUC_180.L_CORE 0.023839
K_6345 X_NUC_31.L_CORE X_NUC_181.L_CORE 0.001770
K_6346 X_NUC_31.L_CORE X_NUC_182.L_CORE 0.002390
K_6347 X_NUC_31.L_CORE X_NUC_183.L_CORE 0.003534
K_6348 X_NUC_31.L_CORE X_NUC_184.L_CORE 0.001561
K_6349 X_NUC_31.L_CORE X_NUC_185.L_CORE 0.005088
K_6350 X_NUC_31.L_CORE X_NUC_186.L_CORE 0.001884
K_6351 X_NUC_31.L_CORE X_NUC_187.L_CORE 0.001728
K_6352 X_NUC_31.L_CORE X_NUC_188.L_CORE 0.005757
K_6353 X_NUC_31.L_CORE X_NUC_189.L_CORE 0.001471
K_6354 X_NUC_31.L_CORE X_NUC_190.L_CORE 0.002507
K_6355 X_NUC_31.L_CORE X_NUC_191.L_CORE 0.002256
K_6356 X_NUC_31.L_CORE X_NUC_192.L_CORE 0.001444
K_6357 X_NUC_31.L_CORE X_NUC_193.L_CORE 0.004533
K_6358 X_NUC_31.L_CORE X_NUC_194.L_CORE 0.001525
K_6359 X_NUC_31.L_CORE X_NUC_195.L_CORE 0.001741
K_6360 X_NUC_31.L_CORE X_NUC_196.L_CORE 0.002863
K_6361 X_NUC_31.L_CORE X_NUC_197.L_CORE 0.001337
K_6362 X_NUC_31.L_CORE X_NUC_198.L_CORE 0.002574
K_6363 X_NUC_31.L_CORE X_NUC_199.L_CORE 0.001705
K_6364 X_NUC_31.L_CORE X_NUC_200.L_CORE 0.001421
K_6365 X_NUC_31.L_CORE X_NUC_201.L_CORE 0.003018
K_6366 X_NUC_31.L_CORE X_NUC_202.L_CORE 0.001344
K_6367 X_NUC_31.L_CORE X_NUC_203.L_CORE 0.001789
K_6368 X_NUC_31.L_CORE X_NUC_204.L_CORE 0.001973
K_6369 X_NUC_31.L_CORE X_NUC_205.L_CORE 0.001288
K_6370 X_NUC_31.L_CORE X_NUC_206.L_CORE 0.002346
K_6371 X_NUC_31.L_CORE X_NUC_207.L_CORE 0.001435
K_6372 X_NUC_31.L_CORE X_NUC_208.L_CORE 0.001442
K_6373 X_NUC_31.L_CORE X_NUC_209.L_CORE 0.002116
K_6374 X_NUC_31.L_CORE X_NUC_210.L_CORE 0.001263
K_6375 X_NUC_31.L_CORE X_NUC_211.L_CORE 0.001768
K_6376 X_NUC_31.L_CORE X_NUC_212.L_CORE 0.001569
K_6377 X_NUC_31.L_CORE X_NUC_213.L_CORE 0.001293
K_6378 X_NUC_31.L_CORE X_NUC_214.L_CORE 0.001912
K_6379 X_NUC_31.L_CORE X_NUC_215.L_CORE 0.001310
K_6380 X_NUC_31.L_CORE X_NUC_216.L_CORE 0.001457
K_6381 X_NUC_31.L_CORE X_NUC_217.L_CORE 0.001626
K_6382 X_NUC_31.L_CORE X_NUC_218.L_CORE 0.001262
K_6383 X_NUC_31.L_CORE X_NUC_219.L_CORE 0.001585
K_6384 X_NUC_31.L_CORE X_NUC_220.L_CORE 0.001381
K_6385 X_NUC_31.L_CORE X_NUC_221.L_CORE 0.001339
K_6386 X_NUC_31.L_CORE X_NUC_222.L_CORE 0.001451
K_6387 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.001803
K_6388 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.001804
K_6389 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.001811
K_6390 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.001795
K_6391 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.002435
K_6392 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.002408
K_6393 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.002425
K_6394 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.002415
K_6395 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.003544
K_6396 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.003593
K_6397 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.003578
K_6398 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.003543
K_6399 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.001588
K_6400 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.001584
K_6401 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.001591
K_6402 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.001580
K_6403 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.004887
K_6404 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.004790
K_6405 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.004788
K_6406 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.004821
K_6407 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.001905
K_6408 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.001912
K_6409 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.001914
K_6410 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.001899
K_6411 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.001753
K_6412 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.001742
K_6413 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.001749
K_6414 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.001741
K_6415 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.005049
K_6416 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.005137
K_6417 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.005025
K_6418 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.005035
K_6419 X_NUC_32.L_CORE X_NUC_65.L_CORE 0.001496
K_6420 X_NUC_32.L_CORE X_NUC_66.L_CORE 0.001495
K_6421 X_NUC_32.L_CORE X_NUC_67.L_CORE 0.001499
K_6422 X_NUC_32.L_CORE X_NUC_68.L_CORE 0.001488
K_6423 X_NUC_32.L_CORE X_NUC_69.L_CORE 0.002477
K_6424 X_NUC_32.L_CORE X_NUC_70.L_CORE 0.002451
K_6425 X_NUC_32.L_CORE X_NUC_71.L_CORE 0.002456
K_6426 X_NUC_32.L_CORE X_NUC_72.L_CORE 0.002454
K_6427 X_NUC_32.L_CORE X_NUC_73.L_CORE 0.002233
K_6428 X_NUC_32.L_CORE X_NUC_74.L_CORE 0.002249
K_6429 X_NUC_32.L_CORE X_NUC_75.L_CORE 0.002241
K_6430 X_NUC_32.L_CORE X_NUC_76.L_CORE 0.002226
K_6431 X_NUC_32.L_CORE X_NUC_77.L_CORE 0.001468
K_6432 X_NUC_32.L_CORE X_NUC_78.L_CORE 0.001462
K_6433 X_NUC_32.L_CORE X_NUC_79.L_CORE 0.001467
K_6434 X_NUC_32.L_CORE X_NUC_80.L_CORE 0.001459
K_6435 X_NUC_32.L_CORE X_NUC_81.L_CORE 0.003883
K_6436 X_NUC_32.L_CORE X_NUC_82.L_CORE 0.003868
K_6437 X_NUC_32.L_CORE X_NUC_83.L_CORE 0.003817
K_6438 X_NUC_32.L_CORE X_NUC_84.L_CORE 0.003845
K_6439 X_NUC_32.L_CORE X_NUC_85.L_CORE 0.001543
K_6440 X_NUC_32.L_CORE X_NUC_86.L_CORE 0.001546
K_6441 X_NUC_32.L_CORE X_NUC_87.L_CORE 0.001547
K_6442 X_NUC_32.L_CORE X_NUC_88.L_CORE 0.001536
K_6443 X_NUC_32.L_CORE X_NUC_89.L_CORE 0.001747
K_6444 X_NUC_32.L_CORE X_NUC_90.L_CORE 0.001735
K_6445 X_NUC_32.L_CORE X_NUC_91.L_CORE 0.001739
K_6446 X_NUC_32.L_CORE X_NUC_92.L_CORE 0.001734
K_6447 X_NUC_32.L_CORE X_NUC_93.L_CORE 0.002661
K_6448 X_NUC_32.L_CORE X_NUC_94.L_CORE 0.002682
K_6449 X_NUC_32.L_CORE X_NUC_95.L_CORE 0.002656
K_6450 X_NUC_32.L_CORE X_NUC_96.L_CORE 0.002650
K_6451 X_NUC_32.L_CORE X_NUC_97.L_CORE 0.001364
K_6452 X_NUC_32.L_CORE X_NUC_98.L_CORE 0.001362
K_6453 X_NUC_32.L_CORE X_NUC_99.L_CORE 0.001365
K_6454 X_NUC_32.L_CORE X_NUC_100.L_CORE 0.001357
K_6455 X_NUC_32.L_CORE X_NUC_101.L_CORE 0.002414
K_6456 X_NUC_32.L_CORE X_NUC_102.L_CORE 0.002396
K_6457 X_NUC_32.L_CORE X_NUC_103.L_CORE 0.002388
K_6458 X_NUC_32.L_CORE X_NUC_104.L_CORE 0.002392
K_6459 X_NUC_32.L_CORE X_NUC_105.L_CORE 0.001698
K_6460 X_NUC_32.L_CORE X_NUC_106.L_CORE 0.001705
K_6461 X_NUC_32.L_CORE X_NUC_107.L_CORE 0.001701
K_6462 X_NUC_32.L_CORE X_NUC_108.L_CORE 0.001691
K_6463 X_NUC_32.L_CORE X_NUC_109.L_CORE 0.001444
K_6464 X_NUC_32.L_CORE X_NUC_110.L_CORE 0.001437
K_6465 X_NUC_32.L_CORE X_NUC_111.L_CORE 0.001440
K_6466 X_NUC_32.L_CORE X_NUC_112.L_CORE 0.001434
K_6467 X_NUC_32.L_CORE X_NUC_113.L_CORE 0.002619
K_6468 X_NUC_32.L_CORE X_NUC_114.L_CORE 0.002625
K_6469 X_NUC_32.L_CORE X_NUC_115.L_CORE 0.002597
K_6470 X_NUC_32.L_CORE X_NUC_116.L_CORE 0.002602
K_6471 X_NUC_32.L_CORE X_NUC_117.L_CORE 0.001372
K_6472 X_NUC_32.L_CORE X_NUC_118.L_CORE 0.001372
K_6473 X_NUC_32.L_CORE X_NUC_119.L_CORE 0.001372
K_6474 X_NUC_32.L_CORE X_NUC_120.L_CORE 0.001365
K_6475 X_NUC_32.L_CORE X_NUC_121.L_CORE 0.001752
K_6476 X_NUC_32.L_CORE X_NUC_122.L_CORE 0.001743
K_6477 X_NUC_32.L_CORE X_NUC_123.L_CORE 0.001741
K_6478 X_NUC_32.L_CORE X_NUC_124.L_CORE 0.001739
K_6479 X_NUC_32.L_CORE X_NUC_125.L_CORE 0.001880
K_6480 X_NUC_32.L_CORE X_NUC_126.L_CORE 0.001887
K_6481 X_NUC_32.L_CORE X_NUC_127.L_CORE 0.001877
K_6482 X_NUC_32.L_CORE X_NUC_128.L_CORE 0.001871
K_6483 X_NUC_32.L_CORE X_NUC_129.L_CORE 0.001325
K_6484 X_NUC_32.L_CORE X_NUC_130.L_CORE 0.001322
K_6485 X_NUC_32.L_CORE X_NUC_131.L_CORE 0.001323
K_6486 X_NUC_32.L_CORE X_NUC_132.L_CORE 0.001317
K_6487 X_NUC_32.L_CORE X_NUC_133.L_CORE 0.002085
K_6488 X_NUC_32.L_CORE X_NUC_134.L_CORE 0.002080
K_6489 X_NUC_32.L_CORE X_NUC_135.L_CORE 0.002068
K_6490 X_NUC_32.L_CORE X_NUC_136.L_CORE 0.002069
K_6491 X_NUC_32.L_CORE X_NUC_137.L_CORE 0.001451
K_6492 X_NUC_32.L_CORE X_NUC_138.L_CORE 0.001453
K_6493 X_NUC_32.L_CORE X_NUC_139.L_CORE 0.001450
K_6494 X_NUC_32.L_CORE X_NUC_140.L_CORE 0.001443
K_6495 X_NUC_32.L_CORE X_NUC_141.L_CORE 0.001457
K_6496 X_NUC_32.L_CORE X_NUC_142.L_CORE 0.001452
K_6497 X_NUC_32.L_CORE X_NUC_143.L_CORE 0.001451
K_6498 X_NUC_32.L_CORE X_NUC_144.L_CORE 0.001447
K_6499 X_NUC_32.L_CORE X_NUC_145.L_CORE 0.001878
K_6500 X_NUC_32.L_CORE X_NUC_146.L_CORE 0.001881
K_6501 X_NUC_32.L_CORE X_NUC_147.L_CORE 0.001869
K_6502 X_NUC_32.L_CORE X_NUC_148.L_CORE 0.001867
K_6503 X_NUC_32.L_CORE X_NUC_149.L_CORE 0.001318
K_6504 X_NUC_32.L_CORE X_NUC_150.L_CORE 0.001317
K_6505 X_NUC_32.L_CORE X_NUC_151.L_CORE 0.001316
K_6506 X_NUC_32.L_CORE X_NUC_152.L_CORE 0.001310
K_6507 X_NUC_32.L_CORE X_NUC_153.L_CORE 0.001650
K_6508 X_NUC_32.L_CORE X_NUC_154.L_CORE 0.001645
K_6509 X_NUC_32.L_CORE X_NUC_155.L_CORE 0.001640
K_6510 X_NUC_32.L_CORE X_NUC_156.L_CORE 0.001638
K_6511 X_NUC_32.L_CORE X_NUC_157.L_CORE 0.001525
K_6512 X_NUC_32.L_CORE X_NUC_158.L_CORE 0.001527
K_6513 X_NUC_32.L_CORE X_NUC_159.L_CORE 0.001521
K_6514 X_NUC_32.L_CORE X_NUC_160.L_CORE 0.001516
K_6515 X_NUC_32.L_CORE X_NUC_161.L_CORE 0.001360
K_6516 X_NUC_32.L_CORE X_NUC_162.L_CORE 0.001357
K_6517 X_NUC_32.L_CORE X_NUC_163.L_CORE 0.001356
K_6518 X_NUC_32.L_CORE X_NUC_164.L_CORE 0.001351
K_6519 X_NUC_32.L_CORE X_NUC_165.L_CORE 0.001608
K_6520 X_NUC_32.L_CORE X_NUC_166.L_CORE 0.001607
K_6521 X_NUC_32.L_CORE X_NUC_167.L_CORE 0.001600
K_6522 X_NUC_32.L_CORE X_NUC_168.L_CORE 0.001598
K_6523 X_NUC_32.L_CORE X_NUC_169.L_CORE 0.001402
K_6524 X_NUC_32.L_CORE X_NUC_170.L_CORE 0.001401
K_6525 X_NUC_32.L_CORE X_NUC_171.L_CORE 0.001398
K_6526 X_NUC_32.L_CORE X_NUC_172.L_CORE 0.001393
K_6527 X_NUC_32.L_CORE X_NUC_173.L_CORE 0.002699
K_6528 X_NUC_32.L_CORE X_NUC_174.L_CORE 0.002626
K_6529 X_NUC_32.L_CORE X_NUC_175.L_CORE 0.004793
K_6530 X_NUC_32.L_CORE X_NUC_176.L_CORE 0.001959
K_6531 X_NUC_32.L_CORE X_NUC_177.L_CORE 0.003919
K_6532 X_NUC_32.L_CORE X_NUC_178.L_CORE 0.002644
K_6533 X_NUC_32.L_CORE X_NUC_179.L_CORE 0.001876
K_6534 X_NUC_32.L_CORE X_NUC_180.L_CORE 0.023556
K_6535 X_NUC_32.L_CORE X_NUC_181.L_CORE 0.001785
K_6536 X_NUC_32.L_CORE X_NUC_182.L_CORE 0.002400
K_6537 X_NUC_32.L_CORE X_NUC_183.L_CORE 0.003569
K_6538 X_NUC_32.L_CORE X_NUC_184.L_CORE 0.001572
K_6539 X_NUC_32.L_CORE X_NUC_185.L_CORE 0.005044
K_6540 X_NUC_32.L_CORE X_NUC_186.L_CORE 0.001899
K_6541 X_NUC_32.L_CORE X_NUC_187.L_CORE 0.001737
K_6542 X_NUC_32.L_CORE X_NUC_188.L_CORE 0.005734
K_6543 X_NUC_32.L_CORE X_NUC_189.L_CORE 0.001482
K_6544 X_NUC_32.L_CORE X_NUC_190.L_CORE 0.002508
K_6545 X_NUC_32.L_CORE X_NUC_191.L_CORE 0.002271
K_6546 X_NUC_32.L_CORE X_NUC_192.L_CORE 0.001452
K_6547 X_NUC_32.L_CORE X_NUC_193.L_CORE 0.004477
K_6548 X_NUC_32.L_CORE X_NUC_194.L_CORE 0.001535
K_6549 X_NUC_32.L_CORE X_NUC_195.L_CORE 0.001746
K_6550 X_NUC_32.L_CORE X_NUC_196.L_CORE 0.002869
K_6551 X_NUC_32.L_CORE X_NUC_197.L_CORE 0.001345
K_6552 X_NUC_32.L_CORE X_NUC_198.L_CORE 0.002566
K_6553 X_NUC_32.L_CORE X_NUC_199.L_CORE 0.001715
K_6554 X_NUC_32.L_CORE X_NUC_200.L_CORE 0.001427
K_6555 X_NUC_32.L_CORE X_NUC_201.L_CORE 0.003006
K_6556 X_NUC_32.L_CORE X_NUC_202.L_CORE 0.001351
K_6557 X_NUC_32.L_CORE X_NUC_203.L_CORE 0.001791
K_6558 X_NUC_32.L_CORE X_NUC_204.L_CORE 0.001980
K_6559 X_NUC_32.L_CORE X_NUC_205.L_CORE 0.001294
K_6560 X_NUC_32.L_CORE X_NUC_206.L_CORE 0.002339
K_6561 X_NUC_32.L_CORE X_NUC_207.L_CORE 0.001442
K_6562 X_NUC_32.L_CORE X_NUC_208.L_CORE 0.001447
K_6563 X_NUC_32.L_CORE X_NUC_209.L_CORE 0.002116
K_6564 X_NUC_32.L_CORE X_NUC_210.L_CORE 0.001269
K_6565 X_NUC_32.L_CORE X_NUC_211.L_CORE 0.001769
K_6566 X_NUC_32.L_CORE X_NUC_212.L_CORE 0.001575
K_6567 X_NUC_32.L_CORE X_NUC_213.L_CORE 0.001298
K_6568 X_NUC_32.L_CORE X_NUC_214.L_CORE 0.001912
K_6569 X_NUC_32.L_CORE X_NUC_215.L_CORE 0.001316
K_6570 X_NUC_32.L_CORE X_NUC_216.L_CORE 0.001460
K_6571 X_NUC_32.L_CORE X_NUC_217.L_CORE 0.001629
K_6572 X_NUC_32.L_CORE X_NUC_218.L_CORE 0.001267
K_6573 X_NUC_32.L_CORE X_NUC_219.L_CORE 0.001587
K_6574 X_NUC_32.L_CORE X_NUC_220.L_CORE 0.001385
K_6575 X_NUC_32.L_CORE X_NUC_221.L_CORE 0.001343
K_6576 X_NUC_32.L_CORE X_NUC_222.L_CORE 0.001454
K_6577 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_6578 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_6579 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_6580 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.001717
K_6581 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.001707
K_6582 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.001707
K_6583 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.001716
K_6584 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.002318
K_6585 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.002329
K_6586 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.002310
K_6587 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.002334
K_6588 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.003421
K_6589 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.003366
K_6590 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.003388
K_6591 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.003384
K_6592 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.001524
K_6593 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.001521
K_6594 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.001516
K_6595 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.001527
K_6596 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.004735
K_6597 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.004823
K_6598 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.004723
K_6599 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.004767
K_6600 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.001843
K_6601 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.001828
K_6602 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.001830
K_6603 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.001836
K_6604 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.001692
K_6605 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.001695
K_6606 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.001685
K_6607 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.001698
K_6608 X_NUC_33.L_CORE X_NUC_65.L_CORE 0.005073
K_6609 X_NUC_33.L_CORE X_NUC_66.L_CORE 0.005012
K_6610 X_NUC_33.L_CORE X_NUC_67.L_CORE 0.005009
K_6611 X_NUC_33.L_CORE X_NUC_68.L_CORE 0.004952
K_6612 X_NUC_33.L_CORE X_NUC_69.L_CORE 0.001451
K_6613 X_NUC_33.L_CORE X_NUC_70.L_CORE 0.001445
K_6614 X_NUC_33.L_CORE X_NUC_71.L_CORE 0.001442
K_6615 X_NUC_33.L_CORE X_NUC_72.L_CORE 0.001450
K_6616 X_NUC_33.L_CORE X_NUC_73.L_CORE 0.002415
K_6617 X_NUC_33.L_CORE X_NUC_74.L_CORE 0.002432
K_6618 X_NUC_33.L_CORE X_NUC_75.L_CORE 0.002405
K_6619 X_NUC_33.L_CORE X_NUC_76.L_CORE 0.002424
K_6620 X_NUC_33.L_CORE X_NUC_77.L_CORE 0.002191
K_6621 X_NUC_33.L_CORE X_NUC_78.L_CORE 0.002170
K_6622 X_NUC_33.L_CORE X_NUC_79.L_CORE 0.002173
K_6623 X_NUC_33.L_CORE X_NUC_80.L_CORE 0.002174
K_6624 X_NUC_33.L_CORE X_NUC_81.L_CORE 0.001429
K_6625 X_NUC_33.L_CORE X_NUC_82.L_CORE 0.001428
K_6626 X_NUC_33.L_CORE X_NUC_83.L_CORE 0.001422
K_6627 X_NUC_33.L_CORE X_NUC_84.L_CORE 0.001431
K_6628 X_NUC_33.L_CORE X_NUC_85.L_CORE 0.003907
K_6629 X_NUC_33.L_CORE X_NUC_86.L_CORE 0.003937
K_6630 X_NUC_33.L_CORE X_NUC_87.L_CORE 0.003879
K_6631 X_NUC_33.L_CORE X_NUC_88.L_CORE 0.003871
K_6632 X_NUC_33.L_CORE X_NUC_89.L_CORE 0.001511
K_6633 X_NUC_33.L_CORE X_NUC_90.L_CORE 0.001502
K_6634 X_NUC_33.L_CORE X_NUC_91.L_CORE 0.001501
K_6635 X_NUC_33.L_CORE X_NUC_92.L_CORE 0.001506
K_6636 X_NUC_33.L_CORE X_NUC_93.L_CORE 0.001711
K_6637 X_NUC_33.L_CORE X_NUC_94.L_CORE 0.001716
K_6638 X_NUC_33.L_CORE X_NUC_95.L_CORE 0.001703
K_6639 X_NUC_33.L_CORE X_NUC_96.L_CORE 0.001714
K_6640 X_NUC_33.L_CORE X_NUC_97.L_CORE 0.002654
K_6641 X_NUC_33.L_CORE X_NUC_98.L_CORE 0.002634
K_6642 X_NUC_33.L_CORE X_NUC_99.L_CORE 0.002630
K_6643 X_NUC_33.L_CORE X_NUC_100.L_CORE 0.002622
K_6644 X_NUC_33.L_CORE X_NUC_101.L_CORE 0.001338
K_6645 X_NUC_33.L_CORE X_NUC_102.L_CORE 0.001334
K_6646 X_NUC_33.L_CORE X_NUC_103.L_CORE 0.001330
K_6647 X_NUC_33.L_CORE X_NUC_104.L_CORE 0.001337
K_6648 X_NUC_33.L_CORE X_NUC_105.L_CORE 0.002394
K_6649 X_NUC_33.L_CORE X_NUC_106.L_CORE 0.002409
K_6650 X_NUC_33.L_CORE X_NUC_107.L_CORE 0.002381
K_6651 X_NUC_33.L_CORE X_NUC_108.L_CORE 0.002391
K_6652 X_NUC_33.L_CORE X_NUC_109.L_CORE 0.001678
K_6653 X_NUC_33.L_CORE X_NUC_110.L_CORE 0.001667
K_6654 X_NUC_33.L_CORE X_NUC_111.L_CORE 0.001666
K_6655 X_NUC_33.L_CORE X_NUC_112.L_CORE 0.001669
K_6656 X_NUC_33.L_CORE X_NUC_113.L_CORE 0.001421
K_6657 X_NUC_33.L_CORE X_NUC_114.L_CORE 0.001421
K_6658 X_NUC_33.L_CORE X_NUC_115.L_CORE 0.001413
K_6659 X_NUC_33.L_CORE X_NUC_116.L_CORE 0.001422
K_6660 X_NUC_33.L_CORE X_NUC_117.L_CORE 0.002624
K_6661 X_NUC_33.L_CORE X_NUC_118.L_CORE 0.002622
K_6662 X_NUC_33.L_CORE X_NUC_119.L_CORE 0.002603
K_6663 X_NUC_33.L_CORE X_NUC_120.L_CORE 0.002598
K_6664 X_NUC_33.L_CORE X_NUC_121.L_CORE 0.001355
K_6665 X_NUC_33.L_CORE X_NUC_122.L_CORE 0.001350
K_6666 X_NUC_33.L_CORE X_NUC_123.L_CORE 0.001346
K_6667 X_NUC_33.L_CORE X_NUC_124.L_CORE 0.001352
K_6668 X_NUC_33.L_CORE X_NUC_125.L_CORE 0.001735
K_6669 X_NUC_33.L_CORE X_NUC_126.L_CORE 0.001740
K_6670 X_NUC_33.L_CORE X_NUC_127.L_CORE 0.001726
K_6671 X_NUC_33.L_CORE X_NUC_128.L_CORE 0.001734
K_6672 X_NUC_33.L_CORE X_NUC_129.L_CORE 0.001870
K_6673 X_NUC_33.L_CORE X_NUC_130.L_CORE 0.001860
K_6674 X_NUC_33.L_CORE X_NUC_131.L_CORE 0.001856
K_6675 X_NUC_33.L_CORE X_NUC_132.L_CORE 0.001856
K_6676 X_NUC_33.L_CORE X_NUC_133.L_CORE 0.001313
K_6677 X_NUC_33.L_CORE X_NUC_134.L_CORE 0.001311
K_6678 X_NUC_33.L_CORE X_NUC_135.L_CORE 0.001305
K_6679 X_NUC_33.L_CORE X_NUC_136.L_CORE 0.001312
K_6680 X_NUC_33.L_CORE X_NUC_137.L_CORE 0.002072
K_6681 X_NUC_33.L_CORE X_NUC_138.L_CORE 0.002076
K_6682 X_NUC_33.L_CORE X_NUC_139.L_CORE 0.002059
K_6683 X_NUC_33.L_CORE X_NUC_140.L_CORE 0.002062
K_6684 X_NUC_33.L_CORE X_NUC_141.L_CORE 0.001443
K_6685 X_NUC_33.L_CORE X_NUC_142.L_CORE 0.001437
K_6686 X_NUC_33.L_CORE X_NUC_143.L_CORE 0.001434
K_6687 X_NUC_33.L_CORE X_NUC_144.L_CORE 0.001437
K_6688 X_NUC_33.L_CORE X_NUC_145.L_CORE 0.001449
K_6689 X_NUC_33.L_CORE X_NUC_146.L_CORE 0.001450
K_6690 X_NUC_33.L_CORE X_NUC_147.L_CORE 0.001441
K_6691 X_NUC_33.L_CORE X_NUC_148.L_CORE 0.001448
K_6692 X_NUC_33.L_CORE X_NUC_149.L_CORE 0.001861
K_6693 X_NUC_33.L_CORE X_NUC_150.L_CORE 0.001856
K_6694 X_NUC_33.L_CORE X_NUC_151.L_CORE 0.001847
K_6695 X_NUC_33.L_CORE X_NUC_152.L_CORE 0.001848
K_6696 X_NUC_33.L_CORE X_NUC_153.L_CORE 0.001319
K_6697 X_NUC_33.L_CORE X_NUC_154.L_CORE 0.001316
K_6698 X_NUC_33.L_CORE X_NUC_155.L_CORE 0.001311
K_6699 X_NUC_33.L_CORE X_NUC_156.L_CORE 0.001315
K_6700 X_NUC_33.L_CORE X_NUC_157.L_CORE 0.001633
K_6701 X_NUC_33.L_CORE X_NUC_158.L_CORE 0.001635
K_6702 X_NUC_33.L_CORE X_NUC_159.L_CORE 0.001624
K_6703 X_NUC_33.L_CORE X_NUC_160.L_CORE 0.001629
K_6704 X_NUC_33.L_CORE X_NUC_161.L_CORE 0.001518
K_6705 X_NUC_33.L_CORE X_NUC_162.L_CORE 0.001513
K_6706 X_NUC_33.L_CORE X_NUC_163.L_CORE 0.001508
K_6707 X_NUC_33.L_CORE X_NUC_164.L_CORE 0.001510
K_6708 X_NUC_33.L_CORE X_NUC_165.L_CORE 0.001375
K_6709 X_NUC_33.L_CORE X_NUC_166.L_CORE 0.001374
K_6710 X_NUC_33.L_CORE X_NUC_167.L_CORE 0.001367
K_6711 X_NUC_33.L_CORE X_NUC_168.L_CORE 0.001372
K_6712 X_NUC_33.L_CORE X_NUC_169.L_CORE 0.001545
K_6713 X_NUC_33.L_CORE X_NUC_170.L_CORE 0.001543
K_6714 X_NUC_33.L_CORE X_NUC_171.L_CORE 0.001535
K_6715 X_NUC_33.L_CORE X_NUC_172.L_CORE 0.001538
K_6716 X_NUC_33.L_CORE X_NUC_173.L_CORE 0.003470
K_6717 X_NUC_33.L_CORE X_NUC_174.L_CORE 0.002363
K_6718 X_NUC_33.L_CORE X_NUC_175.L_CORE 0.002395
K_6719 X_NUC_33.L_CORE X_NUC_176.L_CORE 0.004718
K_6720 X_NUC_33.L_CORE X_NUC_177.L_CORE 0.001810
K_6721 X_NUC_33.L_CORE X_NUC_178.L_CORE 0.003734
K_6722 X_NUC_33.L_CORE X_NUC_179.L_CORE 0.002473
K_6723 X_NUC_33.L_CORE X_NUC_180.L_CORE 0.001773
K_6724 X_NUC_33.L_CORE X_NUC_181.L_CORE 0.024952
K_6725 X_NUC_33.L_CORE X_NUC_182.L_CORE 0.001693
K_6726 X_NUC_33.L_CORE X_NUC_183.L_CORE 0.002302
K_6727 X_NUC_33.L_CORE X_NUC_184.L_CORE 0.003391
K_6728 X_NUC_33.L_CORE X_NUC_185.L_CORE 0.001507
K_6729 X_NUC_33.L_CORE X_NUC_186.L_CORE 0.004996
K_6730 X_NUC_33.L_CORE X_NUC_187.L_CORE 0.001823
K_6731 X_NUC_33.L_CORE X_NUC_188.L_CORE 0.001680
K_6732 X_NUC_33.L_CORE X_NUC_189.L_CORE 0.005713
K_6733 X_NUC_33.L_CORE X_NUC_190.L_CORE 0.001432
K_6734 X_NUC_33.L_CORE X_NUC_191.L_CORE 0.002464
K_6735 X_NUC_33.L_CORE X_NUC_192.L_CORE 0.002206
K_6736 X_NUC_33.L_CORE X_NUC_193.L_CORE 0.001412
K_6737 X_NUC_33.L_CORE X_NUC_194.L_CORE 0.004604
K_6738 X_NUC_33.L_CORE X_NUC_195.L_CORE 0.001493
K_6739 X_NUC_33.L_CORE X_NUC_196.L_CORE 0.001715
K_6740 X_NUC_33.L_CORE X_NUC_197.L_CORE 0.002845
K_6741 X_NUC_33.L_CORE X_NUC_198.L_CORE 0.001314
K_6742 X_NUC_33.L_CORE X_NUC_199.L_CORE 0.002572
K_6743 X_NUC_33.L_CORE X_NUC_200.L_CORE 0.001681
K_6744 X_NUC_33.L_CORE X_NUC_201.L_CORE 0.001403
K_6745 X_NUC_33.L_CORE X_NUC_202.L_CORE 0.003045
K_6746 X_NUC_33.L_CORE X_NUC_203.L_CORE 0.001327
K_6747 X_NUC_33.L_CORE X_NUC_204.L_CORE 0.001780
K_6748 X_NUC_33.L_CORE X_NUC_205.L_CORE 0.001962
K_6749 X_NUC_33.L_CORE X_NUC_206.L_CORE 0.001276
K_6750 X_NUC_33.L_CORE X_NUC_207.L_CORE 0.002356
K_6751 X_NUC_33.L_CORE X_NUC_208.L_CORE 0.001424
K_6752 X_NUC_33.L_CORE X_NUC_209.L_CORE 0.001436
K_6753 X_NUC_33.L_CORE X_NUC_210.L_CORE 0.002116
K_6754 X_NUC_33.L_CORE X_NUC_211.L_CORE 0.001257
K_6755 X_NUC_33.L_CORE X_NUC_212.L_CORE 0.001768
K_6756 X_NUC_33.L_CORE X_NUC_213.L_CORE 0.001564
K_6757 X_NUC_33.L_CORE X_NUC_214.L_CORE 0.001292
K_6758 X_NUC_33.L_CORE X_NUC_215.L_CORE 0.001906
K_6759 X_NUC_33.L_CORE X_NUC_216.L_CORE 0.001311
K_6760 X_NUC_33.L_CORE X_NUC_217.L_CORE 0.001458
K_6761 X_NUC_33.L_CORE X_NUC_218.L_CORE 0.001616
K_6762 X_NUC_33.L_CORE X_NUC_219.L_CORE 0.001273
K_6763 X_NUC_33.L_CORE X_NUC_220.L_CORE 0.001568
K_6764 X_NUC_33.L_CORE X_NUC_221.L_CORE 0.001388
K_6765 X_NUC_33.L_CORE X_NUC_222.L_CORE 0.001364
K_6766 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_6767 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_6768 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.001727
K_6769 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.001717
K_6770 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.001717
K_6771 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.001727
K_6772 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.002307
K_6773 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.002318
K_6774 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.002300
K_6775 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.002323
K_6776 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.003477
K_6777 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.003421
K_6778 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.003443
K_6779 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.003438
K_6780 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.001528
K_6781 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.001524
K_6782 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.001520
K_6783 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.001531
K_6784 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.004649
K_6785 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.004735
K_6786 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.004639
K_6787 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.004680
K_6788 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.001857
K_6789 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.001843
K_6790 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.001844
K_6791 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.001851
K_6792 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.001690
K_6793 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.001692
K_6794 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.001683
K_6795 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.001696
K_6796 X_NUC_34.L_CORE X_NUC_65.L_CORE 0.005134
K_6797 X_NUC_34.L_CORE X_NUC_66.L_CORE 0.005073
K_6798 X_NUC_34.L_CORE X_NUC_67.L_CORE 0.005068
K_6799 X_NUC_34.L_CORE X_NUC_68.L_CORE 0.005010
K_6800 X_NUC_34.L_CORE X_NUC_69.L_CORE 0.001457
K_6801 X_NUC_34.L_CORE X_NUC_70.L_CORE 0.001451
K_6802 X_NUC_34.L_CORE X_NUC_71.L_CORE 0.001448
K_6803 X_NUC_34.L_CORE X_NUC_72.L_CORE 0.001456
K_6804 X_NUC_34.L_CORE X_NUC_73.L_CORE 0.002398
K_6805 X_NUC_34.L_CORE X_NUC_74.L_CORE 0.002415
K_6806 X_NUC_34.L_CORE X_NUC_75.L_CORE 0.002389
K_6807 X_NUC_34.L_CORE X_NUC_76.L_CORE 0.002407
K_6808 X_NUC_34.L_CORE X_NUC_77.L_CORE 0.002212
K_6809 X_NUC_34.L_CORE X_NUC_78.L_CORE 0.002191
K_6810 X_NUC_34.L_CORE X_NUC_79.L_CORE 0.002194
K_6811 X_NUC_34.L_CORE X_NUC_80.L_CORE 0.002195
K_6812 X_NUC_34.L_CORE X_NUC_81.L_CORE 0.001430
K_6813 X_NUC_34.L_CORE X_NUC_82.L_CORE 0.001429
K_6814 X_NUC_34.L_CORE X_NUC_83.L_CORE 0.001423
K_6815 X_NUC_34.L_CORE X_NUC_84.L_CORE 0.001432
K_6816 X_NUC_34.L_CORE X_NUC_85.L_CORE 0.003877
K_6817 X_NUC_34.L_CORE X_NUC_86.L_CORE 0.003907
K_6818 X_NUC_34.L_CORE X_NUC_87.L_CORE 0.003850
K_6819 X_NUC_34.L_CORE X_NUC_88.L_CORE 0.003842
K_6820 X_NUC_34.L_CORE X_NUC_89.L_CORE 0.001519
K_6821 X_NUC_34.L_CORE X_NUC_90.L_CORE 0.001511
K_6822 X_NUC_34.L_CORE X_NUC_91.L_CORE 0.001509
K_6823 X_NUC_34.L_CORE X_NUC_92.L_CORE 0.001515
K_6824 X_NUC_34.L_CORE X_NUC_93.L_CORE 0.001706
K_6825 X_NUC_34.L_CORE X_NUC_94.L_CORE 0.001711
K_6826 X_NUC_34.L_CORE X_NUC_95.L_CORE 0.001698
K_6827 X_NUC_34.L_CORE X_NUC_96.L_CORE 0.001710
K_6828 X_NUC_34.L_CORE X_NUC_97.L_CORE 0.002675
K_6829 X_NUC_34.L_CORE X_NUC_98.L_CORE 0.002654
K_6830 X_NUC_34.L_CORE X_NUC_99.L_CORE 0.002650
K_6831 X_NUC_34.L_CORE X_NUC_100.L_CORE 0.002642
K_6832 X_NUC_34.L_CORE X_NUC_101.L_CORE 0.001341
K_6833 X_NUC_34.L_CORE X_NUC_102.L_CORE 0.001338
K_6834 X_NUC_34.L_CORE X_NUC_103.L_CORE 0.001334
K_6835 X_NUC_34.L_CORE X_NUC_104.L_CORE 0.001341
K_6836 X_NUC_34.L_CORE X_NUC_105.L_CORE 0.002379
K_6837 X_NUC_34.L_CORE X_NUC_106.L_CORE 0.002394
K_6838 X_NUC_34.L_CORE X_NUC_107.L_CORE 0.002367
K_6839 X_NUC_34.L_CORE X_NUC_108.L_CORE 0.002377
K_6840 X_NUC_34.L_CORE X_NUC_109.L_CORE 0.001689
K_6841 X_NUC_34.L_CORE X_NUC_110.L_CORE 0.001678
K_6842 X_NUC_34.L_CORE X_NUC_111.L_CORE 0.001676
K_6843 X_NUC_34.L_CORE X_NUC_112.L_CORE 0.001679
K_6844 X_NUC_34.L_CORE X_NUC_113.L_CORE 0.001420
K_6845 X_NUC_34.L_CORE X_NUC_114.L_CORE 0.001421
K_6846 X_NUC_34.L_CORE X_NUC_115.L_CORE 0.001413
K_6847 X_NUC_34.L_CORE X_NUC_116.L_CORE 0.001421
K_6848 X_NUC_34.L_CORE X_NUC_117.L_CORE 0.002626
K_6849 X_NUC_34.L_CORE X_NUC_118.L_CORE 0.002624
K_6850 X_NUC_34.L_CORE X_NUC_119.L_CORE 0.002605
K_6851 X_NUC_34.L_CORE X_NUC_120.L_CORE 0.002600
K_6852 X_NUC_34.L_CORE X_NUC_121.L_CORE 0.001360
K_6853 X_NUC_34.L_CORE X_NUC_122.L_CORE 0.001355
K_6854 X_NUC_34.L_CORE X_NUC_123.L_CORE 0.001351
K_6855 X_NUC_34.L_CORE X_NUC_124.L_CORE 0.001357
K_6856 X_NUC_34.L_CORE X_NUC_125.L_CORE 0.001730
K_6857 X_NUC_34.L_CORE X_NUC_126.L_CORE 0.001735
K_6858 X_NUC_34.L_CORE X_NUC_127.L_CORE 0.001721
K_6859 X_NUC_34.L_CORE X_NUC_128.L_CORE 0.001729
K_6860 X_NUC_34.L_CORE X_NUC_129.L_CORE 0.001880
K_6861 X_NUC_34.L_CORE X_NUC_130.L_CORE 0.001870
K_6862 X_NUC_34.L_CORE X_NUC_131.L_CORE 0.001866
K_6863 X_NUC_34.L_CORE X_NUC_132.L_CORE 0.001866
K_6864 X_NUC_34.L_CORE X_NUC_133.L_CORE 0.001315
K_6865 X_NUC_34.L_CORE X_NUC_134.L_CORE 0.001313
K_6866 X_NUC_34.L_CORE X_NUC_135.L_CORE 0.001307
K_6867 X_NUC_34.L_CORE X_NUC_136.L_CORE 0.001314
K_6868 X_NUC_34.L_CORE X_NUC_137.L_CORE 0.002067
K_6869 X_NUC_34.L_CORE X_NUC_138.L_CORE 0.002072
K_6870 X_NUC_34.L_CORE X_NUC_139.L_CORE 0.002054
K_6871 X_NUC_34.L_CORE X_NUC_140.L_CORE 0.002057
K_6872 X_NUC_34.L_CORE X_NUC_141.L_CORE 0.001450
K_6873 X_NUC_34.L_CORE X_NUC_142.L_CORE 0.001443
K_6874 X_NUC_34.L_CORE X_NUC_143.L_CORE 0.001440
K_6875 X_NUC_34.L_CORE X_NUC_144.L_CORE 0.001443
K_6876 X_NUC_34.L_CORE X_NUC_145.L_CORE 0.001448
K_6877 X_NUC_34.L_CORE X_NUC_146.L_CORE 0.001449
K_6878 X_NUC_34.L_CORE X_NUC_147.L_CORE 0.001440
K_6879 X_NUC_34.L_CORE X_NUC_148.L_CORE 0.001447
K_6880 X_NUC_34.L_CORE X_NUC_149.L_CORE 0.001865
K_6881 X_NUC_34.L_CORE X_NUC_150.L_CORE 0.001861
K_6882 X_NUC_34.L_CORE X_NUC_151.L_CORE 0.001851
K_6883 X_NUC_34.L_CORE X_NUC_152.L_CORE 0.001852
K_6884 X_NUC_34.L_CORE X_NUC_153.L_CORE 0.001322
K_6885 X_NUC_34.L_CORE X_NUC_154.L_CORE 0.001319
K_6886 X_NUC_34.L_CORE X_NUC_155.L_CORE 0.001314
K_6887 X_NUC_34.L_CORE X_NUC_156.L_CORE 0.001319
K_6888 X_NUC_34.L_CORE X_NUC_157.L_CORE 0.001632
K_6889 X_NUC_34.L_CORE X_NUC_158.L_CORE 0.001633
K_6890 X_NUC_34.L_CORE X_NUC_159.L_CORE 0.001622
K_6891 X_NUC_34.L_CORE X_NUC_160.L_CORE 0.001627
K_6892 X_NUC_34.L_CORE X_NUC_161.L_CORE 0.001523
K_6893 X_NUC_34.L_CORE X_NUC_162.L_CORE 0.001518
K_6894 X_NUC_34.L_CORE X_NUC_163.L_CORE 0.001512
K_6895 X_NUC_34.L_CORE X_NUC_164.L_CORE 0.001515
K_6896 X_NUC_34.L_CORE X_NUC_165.L_CORE 0.001376
K_6897 X_NUC_34.L_CORE X_NUC_166.L_CORE 0.001375
K_6898 X_NUC_34.L_CORE X_NUC_167.L_CORE 0.001368
K_6899 X_NUC_34.L_CORE X_NUC_168.L_CORE 0.001373
K_6900 X_NUC_34.L_CORE X_NUC_169.L_CORE 0.001546
K_6901 X_NUC_34.L_CORE X_NUC_170.L_CORE 0.001545
K_6902 X_NUC_34.L_CORE X_NUC_171.L_CORE 0.001536
K_6903 X_NUC_34.L_CORE X_NUC_172.L_CORE 0.001540
K_6904 X_NUC_34.L_CORE X_NUC_173.L_CORE 0.003485
K_6905 X_NUC_34.L_CORE X_NUC_174.L_CORE 0.002381
K_6906 X_NUC_34.L_CORE X_NUC_175.L_CORE 0.002395
K_6907 X_NUC_34.L_CORE X_NUC_176.L_CORE 0.004799
K_6908 X_NUC_34.L_CORE X_NUC_177.L_CORE 0.001817
K_6909 X_NUC_34.L_CORE X_NUC_178.L_CORE 0.003703
K_6910 X_NUC_34.L_CORE X_NUC_179.L_CORE 0.002500
K_6911 X_NUC_34.L_CORE X_NUC_180.L_CORE 0.001774
K_6912 X_NUC_34.L_CORE X_NUC_181.L_CORE 0.024777
K_6913 X_NUC_34.L_CORE X_NUC_182.L_CORE 0.001703
K_6914 X_NUC_34.L_CORE X_NUC_183.L_CORE 0.002291
K_6915 X_NUC_34.L_CORE X_NUC_184.L_CORE 0.003447
K_6916 X_NUC_34.L_CORE X_NUC_185.L_CORE 0.001510
K_6917 X_NUC_34.L_CORE X_NUC_186.L_CORE 0.004891
K_6918 X_NUC_34.L_CORE X_NUC_187.L_CORE 0.001838
K_6919 X_NUC_34.L_CORE X_NUC_188.L_CORE 0.001678
K_6920 X_NUC_34.L_CORE X_NUC_189.L_CORE 0.005801
K_6921 X_NUC_34.L_CORE X_NUC_190.L_CORE 0.001438
K_6922 X_NUC_34.L_CORE X_NUC_191.L_CORE 0.002445
K_6923 X_NUC_34.L_CORE X_NUC_192.L_CORE 0.002228
K_6924 X_NUC_34.L_CORE X_NUC_193.L_CORE 0.001413
K_6925 X_NUC_34.L_CORE X_NUC_194.L_CORE 0.004549
K_6926 X_NUC_34.L_CORE X_NUC_195.L_CORE 0.001502
K_6927 X_NUC_34.L_CORE X_NUC_196.L_CORE 0.001710
K_6928 X_NUC_34.L_CORE X_NUC_197.L_CORE 0.002872
K_6929 X_NUC_34.L_CORE X_NUC_198.L_CORE 0.001318
K_6930 X_NUC_34.L_CORE X_NUC_199.L_CORE 0.002551
K_6931 X_NUC_34.L_CORE X_NUC_200.L_CORE 0.001693
K_6932 X_NUC_34.L_CORE X_NUC_201.L_CORE 0.001402
K_6933 X_NUC_34.L_CORE X_NUC_202.L_CORE 0.003046
K_6934 X_NUC_34.L_CORE X_NUC_203.L_CORE 0.001332
K_6935 X_NUC_34.L_CORE X_NUC_204.L_CORE 0.001773
K_6936 X_NUC_34.L_CORE X_NUC_205.L_CORE 0.001975
K_6937 X_NUC_34.L_CORE X_NUC_206.L_CORE 0.001278
K_6938 X_NUC_34.L_CORE X_NUC_207.L_CORE 0.002346
K_6939 X_NUC_34.L_CORE X_NUC_208.L_CORE 0.001431
K_6940 X_NUC_34.L_CORE X_NUC_209.L_CORE 0.001434
K_6941 X_NUC_34.L_CORE X_NUC_210.L_CORE 0.002122
K_6942 X_NUC_34.L_CORE X_NUC_211.L_CORE 0.001260
K_6943 X_NUC_34.L_CORE X_NUC_212.L_CORE 0.001762
K_6944 X_NUC_34.L_CORE X_NUC_213.L_CORE 0.001572
K_6945 X_NUC_34.L_CORE X_NUC_214.L_CORE 0.001293
K_6946 X_NUC_34.L_CORE X_NUC_215.L_CORE 0.001905
K_6947 X_NUC_34.L_CORE X_NUC_216.L_CORE 0.001316
K_6948 X_NUC_34.L_CORE X_NUC_217.L_CORE 0.001457
K_6949 X_NUC_34.L_CORE X_NUC_218.L_CORE 0.001621
K_6950 X_NUC_34.L_CORE X_NUC_219.L_CORE 0.001275
K_6951 X_NUC_34.L_CORE X_NUC_220.L_CORE 0.001568
K_6952 X_NUC_34.L_CORE X_NUC_221.L_CORE 0.001391
K_6953 X_NUC_34.L_CORE X_NUC_222.L_CORE 0.001365
K_6954 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_6955 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.001727
K_6956 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.001717
K_6957 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.001717
K_6958 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.001727
K_6959 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.002326
K_6960 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.002337
K_6961 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.002318
K_6962 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.002342
K_6963 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.003453
K_6964 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.003398
K_6965 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.003421
K_6966 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.003416
K_6967 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.001532
K_6968 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.001528
K_6969 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.001524
K_6970 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.001535
K_6971 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.004744
K_6972 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.004834
K_6973 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.004735
K_6974 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.004778
K_6975 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.001855
K_6976 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.001841
K_6977 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.001843
K_6978 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.001849
K_6979 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.001700
K_6980 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.001702
K_6981 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.001692
K_6982 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.001706
K_6983 X_NUC_35.L_CORE X_NUC_65.L_CORE 0.005137
K_6984 X_NUC_35.L_CORE X_NUC_66.L_CORE 0.005075
K_6985 X_NUC_35.L_CORE X_NUC_67.L_CORE 0.005073
K_6986 X_NUC_35.L_CORE X_NUC_68.L_CORE 0.005013
K_6987 X_NUC_35.L_CORE X_NUC_69.L_CORE 0.001459
K_6988 X_NUC_35.L_CORE X_NUC_70.L_CORE 0.001453
K_6989 X_NUC_35.L_CORE X_NUC_71.L_CORE 0.001451
K_6990 X_NUC_35.L_CORE X_NUC_72.L_CORE 0.001459
K_6991 X_NUC_35.L_CORE X_NUC_73.L_CORE 0.002424
K_6992 X_NUC_35.L_CORE X_NUC_74.L_CORE 0.002442
K_6993 X_NUC_35.L_CORE X_NUC_75.L_CORE 0.002415
K_6994 X_NUC_35.L_CORE X_NUC_76.L_CORE 0.002434
K_6995 X_NUC_35.L_CORE X_NUC_77.L_CORE 0.002209
K_6996 X_NUC_35.L_CORE X_NUC_78.L_CORE 0.002188
K_6997 X_NUC_35.L_CORE X_NUC_79.L_CORE 0.002191
K_6998 X_NUC_35.L_CORE X_NUC_80.L_CORE 0.002192
K_6999 X_NUC_35.L_CORE X_NUC_81.L_CORE 0.001436
K_7000 X_NUC_35.L_CORE X_NUC_82.L_CORE 0.001435
K_7001 X_NUC_35.L_CORE X_NUC_83.L_CORE 0.001429
K_7002 X_NUC_35.L_CORE X_NUC_84.L_CORE 0.001438
K_7003 X_NUC_35.L_CORE X_NUC_85.L_CORE 0.003935
K_7004 X_NUC_35.L_CORE X_NUC_86.L_CORE 0.003966
K_7005 X_NUC_35.L_CORE X_NUC_87.L_CORE 0.003907
K_7006 X_NUC_35.L_CORE X_NUC_88.L_CORE 0.003898
K_7007 X_NUC_35.L_CORE X_NUC_89.L_CORE 0.001521
K_7008 X_NUC_35.L_CORE X_NUC_90.L_CORE 0.001512
K_7009 X_NUC_35.L_CORE X_NUC_91.L_CORE 0.001511
K_7010 X_NUC_35.L_CORE X_NUC_92.L_CORE 0.001516
K_7011 X_NUC_35.L_CORE X_NUC_93.L_CORE 0.001719
K_7012 X_NUC_35.L_CORE X_NUC_94.L_CORE 0.001724
K_7013 X_NUC_35.L_CORE X_NUC_95.L_CORE 0.001711
K_7014 X_NUC_35.L_CORE X_NUC_96.L_CORE 0.001723
K_7015 X_NUC_35.L_CORE X_NUC_97.L_CORE 0.002679
K_7016 X_NUC_35.L_CORE X_NUC_98.L_CORE 0.002658
K_7017 X_NUC_35.L_CORE X_NUC_99.L_CORE 0.002654
K_7018 X_NUC_35.L_CORE X_NUC_100.L_CORE 0.002646
K_7019 X_NUC_35.L_CORE X_NUC_101.L_CORE 0.001346
K_7020 X_NUC_35.L_CORE X_NUC_102.L_CORE 0.001342
K_7021 X_NUC_35.L_CORE X_NUC_103.L_CORE 0.001338
K_7022 X_NUC_35.L_CORE X_NUC_104.L_CORE 0.001345
K_7023 X_NUC_35.L_CORE X_NUC_105.L_CORE 0.002407
K_7024 X_NUC_35.L_CORE X_NUC_106.L_CORE 0.002422
K_7025 X_NUC_35.L_CORE X_NUC_107.L_CORE 0.002394
K_7026 X_NUC_35.L_CORE X_NUC_108.L_CORE 0.002404
K_7027 X_NUC_35.L_CORE X_NUC_109.L_CORE 0.001690
K_7028 X_NUC_35.L_CORE X_NUC_110.L_CORE 0.001680
K_7029 X_NUC_35.L_CORE X_NUC_111.L_CORE 0.001678
K_7030 X_NUC_35.L_CORE X_NUC_112.L_CORE 0.001681
K_7031 X_NUC_35.L_CORE X_NUC_113.L_CORE 0.001428
K_7032 X_NUC_35.L_CORE X_NUC_114.L_CORE 0.001429
K_7033 X_NUC_35.L_CORE X_NUC_115.L_CORE 0.001421
K_7034 X_NUC_35.L_CORE X_NUC_116.L_CORE 0.001429
K_7035 X_NUC_35.L_CORE X_NUC_117.L_CORE 0.002646
K_7036 X_NUC_35.L_CORE X_NUC_118.L_CORE 0.002644
K_7037 X_NUC_35.L_CORE X_NUC_119.L_CORE 0.002624
K_7038 X_NUC_35.L_CORE X_NUC_120.L_CORE 0.002619
K_7039 X_NUC_35.L_CORE X_NUC_121.L_CORE 0.001364
K_7040 X_NUC_35.L_CORE X_NUC_122.L_CORE 0.001358
K_7041 X_NUC_35.L_CORE X_NUC_123.L_CORE 0.001355
K_7042 X_NUC_35.L_CORE X_NUC_124.L_CORE 0.001360
K_7043 X_NUC_35.L_CORE X_NUC_125.L_CORE 0.001744
K_7044 X_NUC_35.L_CORE X_NUC_126.L_CORE 0.001749
K_7045 X_NUC_35.L_CORE X_NUC_127.L_CORE 0.001735
K_7046 X_NUC_35.L_CORE X_NUC_128.L_CORE 0.001744
K_7047 X_NUC_35.L_CORE X_NUC_129.L_CORE 0.001885
K_7048 X_NUC_35.L_CORE X_NUC_130.L_CORE 0.001875
K_7049 X_NUC_35.L_CORE X_NUC_131.L_CORE 0.001870
K_7050 X_NUC_35.L_CORE X_NUC_132.L_CORE 0.001871
K_7051 X_NUC_35.L_CORE X_NUC_133.L_CORE 0.001320
K_7052 X_NUC_35.L_CORE X_NUC_134.L_CORE 0.001319
K_7053 X_NUC_35.L_CORE X_NUC_135.L_CORE 0.001313
K_7054 X_NUC_35.L_CORE X_NUC_136.L_CORE 0.001319
K_7055 X_NUC_35.L_CORE X_NUC_137.L_CORE 0.002086
K_7056 X_NUC_35.L_CORE X_NUC_138.L_CORE 0.002090
K_7057 X_NUC_35.L_CORE X_NUC_139.L_CORE 0.002072
K_7058 X_NUC_35.L_CORE X_NUC_140.L_CORE 0.002075
K_7059 X_NUC_35.L_CORE X_NUC_141.L_CORE 0.001453
K_7060 X_NUC_35.L_CORE X_NUC_142.L_CORE 0.001447
K_7061 X_NUC_35.L_CORE X_NUC_143.L_CORE 0.001443
K_7062 X_NUC_35.L_CORE X_NUC_144.L_CORE 0.001447
K_7063 X_NUC_35.L_CORE X_NUC_145.L_CORE 0.001457
K_7064 X_NUC_35.L_CORE X_NUC_146.L_CORE 0.001458
K_7065 X_NUC_35.L_CORE X_NUC_147.L_CORE 0.001449
K_7066 X_NUC_35.L_CORE X_NUC_148.L_CORE 0.001456
K_7067 X_NUC_35.L_CORE X_NUC_149.L_CORE 0.001875
K_7068 X_NUC_35.L_CORE X_NUC_150.L_CORE 0.001870
K_7069 X_NUC_35.L_CORE X_NUC_151.L_CORE 0.001861
K_7070 X_NUC_35.L_CORE X_NUC_152.L_CORE 0.001861
K_7071 X_NUC_35.L_CORE X_NUC_153.L_CORE 0.001327
K_7072 X_NUC_35.L_CORE X_NUC_154.L_CORE 0.001324
K_7073 X_NUC_35.L_CORE X_NUC_155.L_CORE 0.001319
K_7074 X_NUC_35.L_CORE X_NUC_156.L_CORE 0.001324
K_7075 X_NUC_35.L_CORE X_NUC_157.L_CORE 0.001643
K_7076 X_NUC_35.L_CORE X_NUC_158.L_CORE 0.001645
K_7077 X_NUC_35.L_CORE X_NUC_159.L_CORE 0.001633
K_7078 X_NUC_35.L_CORE X_NUC_160.L_CORE 0.001639
K_7079 X_NUC_35.L_CORE X_NUC_161.L_CORE 0.001529
K_7080 X_NUC_35.L_CORE X_NUC_162.L_CORE 0.001524
K_7081 X_NUC_35.L_CORE X_NUC_163.L_CORE 0.001518
K_7082 X_NUC_35.L_CORE X_NUC_164.L_CORE 0.001521
K_7083 X_NUC_35.L_CORE X_NUC_165.L_CORE 0.001383
K_7084 X_NUC_35.L_CORE X_NUC_166.L_CORE 0.001382
K_7085 X_NUC_35.L_CORE X_NUC_167.L_CORE 0.001375
K_7086 X_NUC_35.L_CORE X_NUC_168.L_CORE 0.001380
K_7087 X_NUC_35.L_CORE X_NUC_169.L_CORE 0.001555
K_7088 X_NUC_35.L_CORE X_NUC_170.L_CORE 0.001554
K_7089 X_NUC_35.L_CORE X_NUC_171.L_CORE 0.001545
K_7090 X_NUC_35.L_CORE X_NUC_172.L_CORE 0.001549
K_7091 X_NUC_35.L_CORE X_NUC_173.L_CORE 0.003475
K_7092 X_NUC_35.L_CORE X_NUC_174.L_CORE 0.002374
K_7093 X_NUC_35.L_CORE X_NUC_175.L_CORE 0.002402
K_7094 X_NUC_35.L_CORE X_NUC_176.L_CORE 0.004730
K_7095 X_NUC_35.L_CORE X_NUC_177.L_CORE 0.001818
K_7096 X_NUC_35.L_CORE X_NUC_178.L_CORE 0.003730
K_7097 X_NUC_35.L_CORE X_NUC_179.L_CORE 0.002488
K_7098 X_NUC_35.L_CORE X_NUC_180.L_CORE 0.001780
K_7099 X_NUC_35.L_CORE X_NUC_181.L_CORE 0.022798
K_7100 X_NUC_35.L_CORE X_NUC_182.L_CORE 0.001703
K_7101 X_NUC_35.L_CORE X_NUC_183.L_CORE 0.002308
K_7102 X_NUC_35.L_CORE X_NUC_184.L_CORE 0.003417
K_7103 X_NUC_35.L_CORE X_NUC_185.L_CORE 0.001514
K_7104 X_NUC_35.L_CORE X_NUC_186.L_CORE 0.004983
K_7105 X_NUC_35.L_CORE X_NUC_187.L_CORE 0.001835
K_7106 X_NUC_35.L_CORE X_NUC_188.L_CORE 0.001687
K_7107 X_NUC_35.L_CORE X_NUC_189.L_CORE 0.005764
K_7108 X_NUC_35.L_CORE X_NUC_190.L_CORE 0.001440
K_7109 X_NUC_35.L_CORE X_NUC_191.L_CORE 0.002471
K_7110 X_NUC_35.L_CORE X_NUC_192.L_CORE 0.002222
K_7111 X_NUC_35.L_CORE X_NUC_193.L_CORE 0.001419
K_7112 X_NUC_35.L_CORE X_NUC_194.L_CORE 0.004623
K_7113 X_NUC_35.L_CORE X_NUC_195.L_CORE 0.001502
K_7114 X_NUC_35.L_CORE X_NUC_196.L_CORE 0.001722
K_7115 X_NUC_35.L_CORE X_NUC_197.L_CORE 0.002869
K_7116 X_NUC_35.L_CORE X_NUC_198.L_CORE 0.001321
K_7117 X_NUC_35.L_CORE X_NUC_199.L_CORE 0.002582
K_7118 X_NUC_35.L_CORE X_NUC_200.L_CORE 0.001693
K_7119 X_NUC_35.L_CORE X_NUC_201.L_CORE 0.001410
K_7120 X_NUC_35.L_CORE X_NUC_202.L_CORE 0.003067
K_7121 X_NUC_35.L_CORE X_NUC_203.L_CORE 0.001335
K_7122 X_NUC_35.L_CORE X_NUC_204.L_CORE 0.001788
K_7123 X_NUC_35.L_CORE X_NUC_205.L_CORE 0.001977
K_7124 X_NUC_35.L_CORE X_NUC_206.L_CORE 0.001283
K_7125 X_NUC_35.L_CORE X_NUC_207.L_CORE 0.002369
K_7126 X_NUC_35.L_CORE X_NUC_208.L_CORE 0.001434
K_7127 X_NUC_35.L_CORE X_NUC_209.L_CORE 0.001443
K_7128 X_NUC_35.L_CORE X_NUC_210.L_CORE 0.002131
K_7129 X_NUC_35.L_CORE X_NUC_211.L_CORE 0.001264
K_7130 X_NUC_35.L_CORE X_NUC_212.L_CORE 0.001777
K_7131 X_NUC_35.L_CORE X_NUC_213.L_CORE 0.001575
K_7132 X_NUC_35.L_CORE X_NUC_214.L_CORE 0.001299
K_7133 X_NUC_35.L_CORE X_NUC_215.L_CORE 0.001918
K_7134 X_NUC_35.L_CORE X_NUC_216.L_CORE 0.001320
K_7135 X_NUC_35.L_CORE X_NUC_217.L_CORE 0.001466
K_7136 X_NUC_35.L_CORE X_NUC_218.L_CORE 0.001628
K_7137 X_NUC_35.L_CORE X_NUC_219.L_CORE 0.001281
K_7138 X_NUC_35.L_CORE X_NUC_220.L_CORE 0.001578
K_7139 X_NUC_35.L_CORE X_NUC_221.L_CORE 0.001397
K_7140 X_NUC_35.L_CORE X_NUC_222.L_CORE 0.001372
K_7141 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.001718
K_7142 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.001707
K_7143 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.001707
K_7144 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.001717
K_7145 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.002303
K_7146 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.002313
K_7147 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.002295
K_7148 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.002318
K_7149 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.003458
K_7150 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.003402
K_7151 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.003425
K_7152 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.003421
K_7153 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.001522
K_7154 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.001518
K_7155 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.001514
K_7156 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.001524
K_7157 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.004701
K_7158 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.004789
K_7159 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.004691
K_7160 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.004735
K_7161 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.001849
K_7162 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.001834
K_7163 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.001836
K_7164 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.001843
K_7165 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.001687
K_7166 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.001689
K_7167 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.001679
K_7168 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.001692
K_7169 X_NUC_36.L_CORE X_NUC_65.L_CORE 0.005200
K_7170 X_NUC_36.L_CORE X_NUC_66.L_CORE 0.005135
K_7171 X_NUC_36.L_CORE X_NUC_67.L_CORE 0.005132
K_7172 X_NUC_36.L_CORE X_NUC_68.L_CORE 0.005073
K_7173 X_NUC_36.L_CORE X_NUC_69.L_CORE 0.001451
K_7174 X_NUC_36.L_CORE X_NUC_70.L_CORE 0.001445
K_7175 X_NUC_36.L_CORE X_NUC_71.L_CORE 0.001443
K_7176 X_NUC_36.L_CORE X_NUC_72.L_CORE 0.001451
K_7177 X_NUC_36.L_CORE X_NUC_73.L_CORE 0.002406
K_7178 X_NUC_36.L_CORE X_NUC_74.L_CORE 0.002422
K_7179 X_NUC_36.L_CORE X_NUC_75.L_CORE 0.002396
K_7180 X_NUC_36.L_CORE X_NUC_76.L_CORE 0.002415
K_7181 X_NUC_36.L_CORE X_NUC_77.L_CORE 0.002208
K_7182 X_NUC_36.L_CORE X_NUC_78.L_CORE 0.002187
K_7183 X_NUC_36.L_CORE X_NUC_79.L_CORE 0.002190
K_7184 X_NUC_36.L_CORE X_NUC_80.L_CORE 0.002191
K_7185 X_NUC_36.L_CORE X_NUC_81.L_CORE 0.001427
K_7186 X_NUC_36.L_CORE X_NUC_82.L_CORE 0.001426
K_7187 X_NUC_36.L_CORE X_NUC_83.L_CORE 0.001420
K_7188 X_NUC_36.L_CORE X_NUC_84.L_CORE 0.001429
K_7189 X_NUC_36.L_CORE X_NUC_85.L_CORE 0.003943
K_7190 X_NUC_36.L_CORE X_NUC_86.L_CORE 0.003974
K_7191 X_NUC_36.L_CORE X_NUC_87.L_CORE 0.003914
K_7192 X_NUC_36.L_CORE X_NUC_88.L_CORE 0.003907
K_7193 X_NUC_36.L_CORE X_NUC_89.L_CORE 0.001515
K_7194 X_NUC_36.L_CORE X_NUC_90.L_CORE 0.001506
K_7195 X_NUC_36.L_CORE X_NUC_91.L_CORE 0.001505
K_7196 X_NUC_36.L_CORE X_NUC_92.L_CORE 0.001511
K_7197 X_NUC_36.L_CORE X_NUC_93.L_CORE 0.001707
K_7198 X_NUC_36.L_CORE X_NUC_94.L_CORE 0.001712
K_7199 X_NUC_36.L_CORE X_NUC_95.L_CORE 0.001699
K_7200 X_NUC_36.L_CORE X_NUC_96.L_CORE 0.001711
K_7201 X_NUC_36.L_CORE X_NUC_97.L_CORE 0.002687
K_7202 X_NUC_36.L_CORE X_NUC_98.L_CORE 0.002666
K_7203 X_NUC_36.L_CORE X_NUC_99.L_CORE 0.002662
K_7204 X_NUC_36.L_CORE X_NUC_100.L_CORE 0.002654
K_7205 X_NUC_36.L_CORE X_NUC_101.L_CORE 0.001338
K_7206 X_NUC_36.L_CORE X_NUC_102.L_CORE 0.001335
K_7207 X_NUC_36.L_CORE X_NUC_103.L_CORE 0.001331
K_7208 X_NUC_36.L_CORE X_NUC_104.L_CORE 0.001338
K_7209 X_NUC_36.L_CORE X_NUC_105.L_CORE 0.002397
K_7210 X_NUC_36.L_CORE X_NUC_106.L_CORE 0.002412
K_7211 X_NUC_36.L_CORE X_NUC_107.L_CORE 0.002384
K_7212 X_NUC_36.L_CORE X_NUC_108.L_CORE 0.002394
K_7213 X_NUC_36.L_CORE X_NUC_109.L_CORE 0.001687
K_7214 X_NUC_36.L_CORE X_NUC_110.L_CORE 0.001677
K_7215 X_NUC_36.L_CORE X_NUC_111.L_CORE 0.001675
K_7216 X_NUC_36.L_CORE X_NUC_112.L_CORE 0.001678
K_7217 X_NUC_36.L_CORE X_NUC_113.L_CORE 0.001420
K_7218 X_NUC_36.L_CORE X_NUC_114.L_CORE 0.001420
K_7219 X_NUC_36.L_CORE X_NUC_115.L_CORE 0.001413
K_7220 X_NUC_36.L_CORE X_NUC_116.L_CORE 0.001421
K_7221 X_NUC_36.L_CORE X_NUC_117.L_CORE 0.002651
K_7222 X_NUC_36.L_CORE X_NUC_118.L_CORE 0.002649
K_7223 X_NUC_36.L_CORE X_NUC_119.L_CORE 0.002630
K_7224 X_NUC_36.L_CORE X_NUC_120.L_CORE 0.002624
K_7225 X_NUC_36.L_CORE X_NUC_121.L_CORE 0.001358
K_7226 X_NUC_36.L_CORE X_NUC_122.L_CORE 0.001353
K_7227 X_NUC_36.L_CORE X_NUC_123.L_CORE 0.001349
K_7228 X_NUC_36.L_CORE X_NUC_124.L_CORE 0.001355
K_7229 X_NUC_36.L_CORE X_NUC_125.L_CORE 0.001735
K_7230 X_NUC_36.L_CORE X_NUC_126.L_CORE 0.001740
K_7231 X_NUC_36.L_CORE X_NUC_127.L_CORE 0.001726
K_7232 X_NUC_36.L_CORE X_NUC_128.L_CORE 0.001735
K_7233 X_NUC_36.L_CORE X_NUC_129.L_CORE 0.001885
K_7234 X_NUC_36.L_CORE X_NUC_130.L_CORE 0.001875
K_7235 X_NUC_36.L_CORE X_NUC_131.L_CORE 0.001870
K_7236 X_NUC_36.L_CORE X_NUC_132.L_CORE 0.001870
K_7237 X_NUC_36.L_CORE X_NUC_133.L_CORE 0.001314
K_7238 X_NUC_36.L_CORE X_NUC_134.L_CORE 0.001312
K_7239 X_NUC_36.L_CORE X_NUC_135.L_CORE 0.001306
K_7240 X_NUC_36.L_CORE X_NUC_136.L_CORE 0.001313
K_7241 X_NUC_36.L_CORE X_NUC_137.L_CORE 0.002082
K_7242 X_NUC_36.L_CORE X_NUC_138.L_CORE 0.002087
K_7243 X_NUC_36.L_CORE X_NUC_139.L_CORE 0.002068
K_7244 X_NUC_36.L_CORE X_NUC_140.L_CORE 0.002072
K_7245 X_NUC_36.L_CORE X_NUC_141.L_CORE 0.001450
K_7246 X_NUC_36.L_CORE X_NUC_142.L_CORE 0.001443
K_7247 X_NUC_36.L_CORE X_NUC_143.L_CORE 0.001440
K_7248 X_NUC_36.L_CORE X_NUC_144.L_CORE 0.001443
K_7249 X_NUC_36.L_CORE X_NUC_145.L_CORE 0.001450
K_7250 X_NUC_36.L_CORE X_NUC_146.L_CORE 0.001451
K_7251 X_NUC_36.L_CORE X_NUC_147.L_CORE 0.001442
K_7252 X_NUC_36.L_CORE X_NUC_148.L_CORE 0.001449
K_7253 X_NUC_36.L_CORE X_NUC_149.L_CORE 0.001874
K_7254 X_NUC_36.L_CORE X_NUC_150.L_CORE 0.001870
K_7255 X_NUC_36.L_CORE X_NUC_151.L_CORE 0.001860
K_7256 X_NUC_36.L_CORE X_NUC_152.L_CORE 0.001861
K_7257 X_NUC_36.L_CORE X_NUC_153.L_CORE 0.001322
K_7258 X_NUC_36.L_CORE X_NUC_154.L_CORE 0.001319
K_7259 X_NUC_36.L_CORE X_NUC_155.L_CORE 0.001314
K_7260 X_NUC_36.L_CORE X_NUC_156.L_CORE 0.001319
K_7261 X_NUC_36.L_CORE X_NUC_157.L_CORE 0.001638
K_7262 X_NUC_36.L_CORE X_NUC_158.L_CORE 0.001640
K_7263 X_NUC_36.L_CORE X_NUC_159.L_CORE 0.001628
K_7264 X_NUC_36.L_CORE X_NUC_160.L_CORE 0.001633
K_7265 X_NUC_36.L_CORE X_NUC_161.L_CORE 0.001526
K_7266 X_NUC_36.L_CORE X_NUC_162.L_CORE 0.001521
K_7267 X_NUC_36.L_CORE X_NUC_163.L_CORE 0.001515
K_7268 X_NUC_36.L_CORE X_NUC_164.L_CORE 0.001518
K_7269 X_NUC_36.L_CORE X_NUC_165.L_CORE 0.001378
K_7270 X_NUC_36.L_CORE X_NUC_166.L_CORE 0.001377
K_7271 X_NUC_36.L_CORE X_NUC_167.L_CORE 0.001370
K_7272 X_NUC_36.L_CORE X_NUC_168.L_CORE 0.001375
K_7273 X_NUC_36.L_CORE X_NUC_169.L_CORE 0.001552
K_7274 X_NUC_36.L_CORE X_NUC_170.L_CORE 0.001550
K_7275 X_NUC_36.L_CORE X_NUC_171.L_CORE 0.001541
K_7276 X_NUC_36.L_CORE X_NUC_172.L_CORE 0.001545
K_7277 X_NUC_36.L_CORE X_NUC_173.L_CORE 0.003431
K_7278 X_NUC_36.L_CORE X_NUC_174.L_CORE 0.002356
K_7279 X_NUC_36.L_CORE X_NUC_175.L_CORE 0.002376
K_7280 X_NUC_36.L_CORE X_NUC_176.L_CORE 0.004696
K_7281 X_NUC_36.L_CORE X_NUC_177.L_CORE 0.001804
K_7282 X_NUC_36.L_CORE X_NUC_178.L_CORE 0.003676
K_7283 X_NUC_36.L_CORE X_NUC_179.L_CORE 0.002478
K_7284 X_NUC_36.L_CORE X_NUC_180.L_CORE 0.001765
K_7285 X_NUC_36.L_CORE X_NUC_181.L_CORE 0.023094
K_7286 X_NUC_36.L_CORE X_NUC_182.L_CORE 0.001693
K_7287 X_NUC_36.L_CORE X_NUC_183.L_CORE 0.002285
K_7288 X_NUC_36.L_CORE X_NUC_184.L_CORE 0.003423
K_7289 X_NUC_36.L_CORE X_NUC_185.L_CORE 0.001504
K_7290 X_NUC_36.L_CORE X_NUC_186.L_CORE 0.004936
K_7291 X_NUC_36.L_CORE X_NUC_187.L_CORE 0.001828
K_7292 X_NUC_36.L_CORE X_NUC_188.L_CORE 0.001674
K_7293 X_NUC_36.L_CORE X_NUC_189.L_CORE 0.005870
K_7294 X_NUC_36.L_CORE X_NUC_190.L_CORE 0.001432
K_7295 X_NUC_36.L_CORE X_NUC_191.L_CORE 0.002451
K_7296 X_NUC_36.L_CORE X_NUC_192.L_CORE 0.002222
K_7297 X_NUC_36.L_CORE X_NUC_193.L_CORE 0.001409
K_7298 X_NUC_36.L_CORE X_NUC_194.L_CORE 0.004646
K_7299 X_NUC_36.L_CORE X_NUC_195.L_CORE 0.001497
K_7300 X_NUC_36.L_CORE X_NUC_196.L_CORE 0.001710
K_7301 X_NUC_36.L_CORE X_NUC_197.L_CORE 0.002883
K_7302 X_NUC_36.L_CORE X_NUC_198.L_CORE 0.001314
K_7303 X_NUC_36.L_CORE X_NUC_199.L_CORE 0.002571
K_7304 X_NUC_36.L_CORE X_NUC_200.L_CORE 0.001690
K_7305 X_NUC_36.L_CORE X_NUC_201.L_CORE 0.001401
K_7306 X_NUC_36.L_CORE X_NUC_202.L_CORE 0.003083
K_7307 X_NUC_36.L_CORE X_NUC_203.L_CORE 0.001329
K_7308 X_NUC_36.L_CORE X_NUC_204.L_CORE 0.001778
K_7309 X_NUC_36.L_CORE X_NUC_205.L_CORE 0.001979
K_7310 X_NUC_36.L_CORE X_NUC_206.L_CORE 0.001276
K_7311 X_NUC_36.L_CORE X_NUC_207.L_CORE 0.002368
K_7312 X_NUC_36.L_CORE X_NUC_208.L_CORE 0.001430
K_7313 X_NUC_36.L_CORE X_NUC_209.L_CORE 0.001435
K_7314 X_NUC_36.L_CORE X_NUC_210.L_CORE 0.002135
K_7315 X_NUC_36.L_CORE X_NUC_211.L_CORE 0.001259
K_7316 X_NUC_36.L_CORE X_NUC_212.L_CORE 0.001771
K_7317 X_NUC_36.L_CORE X_NUC_213.L_CORE 0.001574
K_7318 X_NUC_36.L_CORE X_NUC_214.L_CORE 0.001293
K_7319 X_NUC_36.L_CORE X_NUC_215.L_CORE 0.001917
K_7320 X_NUC_36.L_CORE X_NUC_216.L_CORE 0.001316
K_7321 X_NUC_36.L_CORE X_NUC_217.L_CORE 0.001461
K_7322 X_NUC_36.L_CORE X_NUC_218.L_CORE 0.001626
K_7323 X_NUC_36.L_CORE X_NUC_219.L_CORE 0.001276
K_7324 X_NUC_36.L_CORE X_NUC_220.L_CORE 0.001574
K_7325 X_NUC_36.L_CORE X_NUC_221.L_CORE 0.001394
K_7326 X_NUC_36.L_CORE X_NUC_222.L_CORE 0.001368
K_7327 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_7328 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_7329 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_7330 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.001653
K_7331 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.001667
K_7332 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.001660
K_7333 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.001660
K_7334 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.002239
K_7335 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.002246
K_7336 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.002253
K_7337 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.002230
K_7338 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.003318
K_7339 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.003355
K_7340 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.003311
K_7341 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.003349
K_7342 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.001479
K_7343 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.001488
K_7344 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.001485
K_7345 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.001480
K_7346 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.004657
K_7347 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.004625
K_7348 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.004655
K_7349 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.004568
K_7350 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.001796
K_7351 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.001811
K_7352 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.001799
K_7353 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.001803
K_7354 X_NUC_37.L_CORE X_NUC_65.L_CORE 0.001652
K_7355 X_NUC_37.L_CORE X_NUC_66.L_CORE 0.001659
K_7356 X_NUC_37.L_CORE X_NUC_67.L_CORE 0.001659
K_7357 X_NUC_37.L_CORE X_NUC_68.L_CORE 0.001648
K_7358 X_NUC_37.L_CORE X_NUC_69.L_CORE 0.005100
K_7359 X_NUC_37.L_CORE X_NUC_70.L_CORE 0.005109
K_7360 X_NUC_37.L_CORE X_NUC_71.L_CORE 0.004999
K_7361 X_NUC_37.L_CORE X_NUC_72.L_CORE 0.005081
K_7362 X_NUC_37.L_CORE X_NUC_73.L_CORE 0.001420
K_7363 X_NUC_37.L_CORE X_NUC_74.L_CORE 0.001429
K_7364 X_NUC_37.L_CORE X_NUC_75.L_CORE 0.001424
K_7365 X_NUC_37.L_CORE X_NUC_76.L_CORE 0.001422
K_7366 X_NUC_37.L_CORE X_NUC_77.L_CORE 0.002381
K_7367 X_NUC_37.L_CORE X_NUC_78.L_CORE 0.002382
K_7368 X_NUC_37.L_CORE X_NUC_79.L_CORE 0.002386
K_7369 X_NUC_37.L_CORE X_NUC_80.L_CORE 0.002361
K_7370 X_NUC_37.L_CORE X_NUC_81.L_CORE 0.002161
K_7371 X_NUC_37.L_CORE X_NUC_82.L_CORE 0.002177
K_7372 X_NUC_37.L_CORE X_NUC_83.L_CORE 0.002156
K_7373 X_NUC_37.L_CORE X_NUC_84.L_CORE 0.002168
K_7374 X_NUC_37.L_CORE X_NUC_85.L_CORE 0.001405
K_7375 X_NUC_37.L_CORE X_NUC_86.L_CORE 0.001412
K_7376 X_NUC_37.L_CORE X_NUC_87.L_CORE 0.001409
K_7377 X_NUC_37.L_CORE X_NUC_88.L_CORE 0.001403
K_7378 X_NUC_37.L_CORE X_NUC_89.L_CORE 0.003958
K_7379 X_NUC_37.L_CORE X_NUC_90.L_CORE 0.003932
K_7380 X_NUC_37.L_CORE X_NUC_91.L_CORE 0.003905
K_7381 X_NUC_37.L_CORE X_NUC_92.L_CORE 0.003889
K_7382 X_NUC_37.L_CORE X_NUC_93.L_CORE 0.001490
K_7383 X_NUC_37.L_CORE X_NUC_94.L_CORE 0.001500
K_7384 X_NUC_37.L_CORE X_NUC_95.L_CORE 0.001491
K_7385 X_NUC_37.L_CORE X_NUC_96.L_CORE 0.001493
K_7386 X_NUC_37.L_CORE X_NUC_97.L_CORE 0.001693
K_7387 X_NUC_37.L_CORE X_NUC_98.L_CORE 0.001697
K_7388 X_NUC_37.L_CORE X_NUC_99.L_CORE 0.001696
K_7389 X_NUC_37.L_CORE X_NUC_100.L_CORE 0.001685
K_7390 X_NUC_37.L_CORE X_NUC_101.L_CORE 0.002656
K_7391 X_NUC_37.L_CORE X_NUC_102.L_CORE 0.002667
K_7392 X_NUC_37.L_CORE X_NUC_103.L_CORE 0.002634
K_7393 X_NUC_37.L_CORE X_NUC_104.L_CORE 0.002653
K_7394 X_NUC_37.L_CORE X_NUC_105.L_CORE 0.001323
K_7395 X_NUC_37.L_CORE X_NUC_106.L_CORE 0.001331
K_7396 X_NUC_37.L_CORE X_NUC_107.L_CORE 0.001326
K_7397 X_NUC_37.L_CORE X_NUC_108.L_CORE 0.001323
K_7398 X_NUC_37.L_CORE X_NUC_109.L_CORE 0.002395
K_7399 X_NUC_37.L_CORE X_NUC_110.L_CORE 0.002392
K_7400 X_NUC_37.L_CORE X_NUC_111.L_CORE 0.002387
K_7401 X_NUC_37.L_CORE X_NUC_112.L_CORE 0.002370
K_7402 X_NUC_37.L_CORE X_NUC_113.L_CORE 0.001668
K_7403 X_NUC_37.L_CORE X_NUC_114.L_CORE 0.001678
K_7404 X_NUC_37.L_CORE X_NUC_115.L_CORE 0.001666
K_7405 X_NUC_37.L_CORE X_NUC_116.L_CORE 0.001670
K_7406 X_NUC_37.L_CORE X_NUC_117.L_CORE 0.001412
K_7407 X_NUC_37.L_CORE X_NUC_118.L_CORE 0.001417
K_7408 X_NUC_37.L_CORE X_NUC_119.L_CORE 0.001414
K_7409 X_NUC_37.L_CORE X_NUC_120.L_CORE 0.001408
K_7410 X_NUC_37.L_CORE X_NUC_121.L_CORE 0.002639
K_7411 X_NUC_37.L_CORE X_NUC_122.L_CORE 0.002638
K_7412 X_NUC_37.L_CORE X_NUC_123.L_CORE 0.002613
K_7413 X_NUC_37.L_CORE X_NUC_124.L_CORE 0.002618
K_7414 X_NUC_37.L_CORE X_NUC_125.L_CORE 0.001349
K_7415 X_NUC_37.L_CORE X_NUC_126.L_CORE 0.001357
K_7416 X_NUC_37.L_CORE X_NUC_127.L_CORE 0.001350
K_7417 X_NUC_37.L_CORE X_NUC_128.L_CORE 0.001349
K_7418 X_NUC_37.L_CORE X_NUC_129.L_CORE 0.001733
K_7419 X_NUC_37.L_CORE X_NUC_130.L_CORE 0.001735
K_7420 X_NUC_37.L_CORE X_NUC_131.L_CORE 0.001732
K_7421 X_NUC_37.L_CORE X_NUC_132.L_CORE 0.001722
K_7422 X_NUC_37.L_CORE X_NUC_133.L_CORE 0.001870
K_7423 X_NUC_37.L_CORE X_NUC_134.L_CORE 0.001878
K_7424 X_NUC_37.L_CORE X_NUC_135.L_CORE 0.001862
K_7425 X_NUC_37.L_CORE X_NUC_136.L_CORE 0.001868
K_7426 X_NUC_37.L_CORE X_NUC_137.L_CORE 0.001313
K_7427 X_NUC_37.L_CORE X_NUC_138.L_CORE 0.001319
K_7428 X_NUC_37.L_CORE X_NUC_139.L_CORE 0.001314
K_7429 X_NUC_37.L_CORE X_NUC_140.L_CORE 0.001310
K_7430 X_NUC_37.L_CORE X_NUC_141.L_CORE 0.002069
K_7431 X_NUC_37.L_CORE X_NUC_142.L_CORE 0.002069
K_7432 X_NUC_37.L_CORE X_NUC_143.L_CORE 0.002058
K_7433 X_NUC_37.L_CORE X_NUC_144.L_CORE 0.002053
K_7434 X_NUC_37.L_CORE X_NUC_145.L_CORE 0.001447
K_7435 X_NUC_37.L_CORE X_NUC_146.L_CORE 0.001454
K_7436 X_NUC_37.L_CORE X_NUC_147.L_CORE 0.001445
K_7437 X_NUC_37.L_CORE X_NUC_148.L_CORE 0.001446
K_7438 X_NUC_37.L_CORE X_NUC_149.L_CORE 0.001454
K_7439 X_NUC_37.L_CORE X_NUC_150.L_CORE 0.001458
K_7440 X_NUC_37.L_CORE X_NUC_151.L_CORE 0.001454
K_7441 X_NUC_37.L_CORE X_NUC_152.L_CORE 0.001448
K_7442 X_NUC_37.L_CORE X_NUC_153.L_CORE 0.001849
K_7443 X_NUC_37.L_CORE X_NUC_154.L_CORE 0.001853
K_7444 X_NUC_37.L_CORE X_NUC_155.L_CORE 0.001839
K_7445 X_NUC_37.L_CORE X_NUC_156.L_CORE 0.001841
K_7446 X_NUC_37.L_CORE X_NUC_157.L_CORE 0.001334
K_7447 X_NUC_37.L_CORE X_NUC_158.L_CORE 0.001339
K_7448 X_NUC_37.L_CORE X_NUC_159.L_CORE 0.001333
K_7449 X_NUC_37.L_CORE X_NUC_160.L_CORE 0.001331
K_7450 X_NUC_37.L_CORE X_NUC_161.L_CORE 0.001625
K_7451 X_NUC_37.L_CORE X_NUC_162.L_CORE 0.001628
K_7452 X_NUC_37.L_CORE X_NUC_163.L_CORE 0.001621
K_7453 X_NUC_37.L_CORE X_NUC_164.L_CORE 0.001617
K_7454 X_NUC_37.L_CORE X_NUC_165.L_CORE 0.001520
K_7455 X_NUC_37.L_CORE X_NUC_166.L_CORE 0.001525
K_7456 X_NUC_37.L_CORE X_NUC_167.L_CORE 0.001516
K_7457 X_NUC_37.L_CORE X_NUC_168.L_CORE 0.001516
K_7458 X_NUC_37.L_CORE X_NUC_169.L_CORE 0.001418
K_7459 X_NUC_37.L_CORE X_NUC_170.L_CORE 0.001423
K_7460 X_NUC_37.L_CORE X_NUC_171.L_CORE 0.001416
K_7461 X_NUC_37.L_CORE X_NUC_172.L_CORE 0.001413
K_7462 X_NUC_37.L_CORE X_NUC_173.L_CORE 0.002285
K_7463 X_NUC_37.L_CORE X_NUC_174.L_CORE 0.003883
K_7464 X_NUC_37.L_CORE X_NUC_175.L_CORE 0.002183
K_7465 X_NUC_37.L_CORE X_NUC_176.L_CORE 0.002237
K_7466 X_NUC_37.L_CORE X_NUC_177.L_CORE 0.004722
K_7467 X_NUC_37.L_CORE X_NUC_178.L_CORE 0.001713
K_7468 X_NUC_37.L_CORE X_NUC_179.L_CORE 0.003554
K_7469 X_NUC_37.L_CORE X_NUC_180.L_CORE 0.002381
K_7470 X_NUC_37.L_CORE X_NUC_181.L_CORE 0.001699
K_7471 X_NUC_37.L_CORE X_NUC_182.L_CORE 0.023815
K_7472 X_NUC_37.L_CORE X_NUC_183.L_CORE 0.001640
K_7473 X_NUC_37.L_CORE X_NUC_184.L_CORE 0.002218
K_7474 X_NUC_37.L_CORE X_NUC_185.L_CORE 0.003327
K_7475 X_NUC_37.L_CORE X_NUC_186.L_CORE 0.001465
K_7476 X_NUC_37.L_CORE X_NUC_187.L_CORE 0.004827
K_7477 X_NUC_37.L_CORE X_NUC_188.L_CORE 0.001788
K_7478 X_NUC_37.L_CORE X_NUC_189.L_CORE 0.001639
K_7479 X_NUC_37.L_CORE X_NUC_190.L_CORE 0.005813
K_7480 X_NUC_37.L_CORE X_NUC_191.L_CORE 0.001406
K_7481 X_NUC_37.L_CORE X_NUC_192.L_CORE 0.002415
K_7482 X_NUC_37.L_CORE X_NUC_193.L_CORE 0.002190
K_7483 X_NUC_37.L_CORE X_NUC_194.L_CORE 0.001388
K_7484 X_NUC_37.L_CORE X_NUC_195.L_CORE 0.004664
K_7485 X_NUC_37.L_CORE X_NUC_196.L_CORE 0.001478
K_7486 X_NUC_37.L_CORE X_NUC_197.L_CORE 0.001691
K_7487 X_NUC_37.L_CORE X_NUC_198.L_CORE 0.002872
K_7488 X_NUC_37.L_CORE X_NUC_199.L_CORE 0.001301
K_7489 X_NUC_37.L_CORE X_NUC_200.L_CORE 0.002564
K_7490 X_NUC_37.L_CORE X_NUC_201.L_CORE 0.001678
K_7491 X_NUC_37.L_CORE X_NUC_202.L_CORE 0.001391
K_7492 X_NUC_37.L_CORE X_NUC_203.L_CORE 0.003096
K_7493 X_NUC_37.L_CORE X_NUC_204.L_CORE 0.001321
K_7494 X_NUC_37.L_CORE X_NUC_205.L_CORE 0.001773
K_7495 X_NUC_37.L_CORE X_NUC_206.L_CORE 0.001975
K_7496 X_NUC_37.L_CORE X_NUC_207.L_CORE 0.001272
K_7497 X_NUC_37.L_CORE X_NUC_208.L_CORE 0.002370
K_7498 X_NUC_37.L_CORE X_NUC_209.L_CORE 0.001428
K_7499 X_NUC_37.L_CORE X_NUC_210.L_CORE 0.001435
K_7500 X_NUC_37.L_CORE X_NUC_211.L_CORE 0.002134
K_7501 X_NUC_37.L_CORE X_NUC_212.L_CORE 0.001261
K_7502 X_NUC_37.L_CORE X_NUC_213.L_CORE 0.001771
K_7503 X_NUC_37.L_CORE X_NUC_214.L_CORE 0.001575
K_7504 X_NUC_37.L_CORE X_NUC_215.L_CORE 0.001299
K_7505 X_NUC_37.L_CORE X_NUC_216.L_CORE 0.001905
K_7506 X_NUC_37.L_CORE X_NUC_217.L_CORE 0.001325
K_7507 X_NUC_37.L_CORE X_NUC_218.L_CORE 0.001466
K_7508 X_NUC_37.L_CORE X_NUC_219.L_CORE 0.001617
K_7509 X_NUC_37.L_CORE X_NUC_220.L_CORE 0.001298
K_7510 X_NUC_37.L_CORE X_NUC_221.L_CORE 0.001550
K_7511 X_NUC_37.L_CORE X_NUC_222.L_CORE 0.001409
K_7512 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_7513 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_7514 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.001640
K_7515 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.001653
K_7516 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.001647
K_7517 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.001646
K_7518 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.002232
K_7519 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.002239
K_7520 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.002245
K_7521 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.002223
K_7522 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.003283
K_7523 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.003318
K_7524 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.003275
K_7525 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.003312
K_7526 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.001469
K_7527 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.001479
K_7528 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.001476
K_7529 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.001471
K_7530 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.004687
K_7531 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.004657
K_7532 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.004686
K_7533 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.004597
K_7534 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.001782
K_7535 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.001796
K_7536 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.001784
K_7537 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.001789
K_7538 X_NUC_38.L_CORE X_NUC_65.L_CORE 0.001645
K_7539 X_NUC_38.L_CORE X_NUC_66.L_CORE 0.001652
K_7540 X_NUC_38.L_CORE X_NUC_67.L_CORE 0.001652
K_7541 X_NUC_38.L_CORE X_NUC_68.L_CORE 0.001641
K_7542 X_NUC_38.L_CORE X_NUC_69.L_CORE 0.005087
K_7543 X_NUC_38.L_CORE X_NUC_70.L_CORE 0.005100
K_7544 X_NUC_38.L_CORE X_NUC_71.L_CORE 0.004989
K_7545 X_NUC_38.L_CORE X_NUC_72.L_CORE 0.005071
K_7546 X_NUC_38.L_CORE X_NUC_73.L_CORE 0.001411
K_7547 X_NUC_38.L_CORE X_NUC_74.L_CORE 0.001420
K_7548 X_NUC_38.L_CORE X_NUC_75.L_CORE 0.001415
K_7549 X_NUC_38.L_CORE X_NUC_76.L_CORE 0.001413
K_7550 X_NUC_38.L_CORE X_NUC_77.L_CORE 0.002380
K_7551 X_NUC_38.L_CORE X_NUC_78.L_CORE 0.002381
K_7552 X_NUC_38.L_CORE X_NUC_79.L_CORE 0.002385
K_7553 X_NUC_38.L_CORE X_NUC_80.L_CORE 0.002360
K_7554 X_NUC_38.L_CORE X_NUC_81.L_CORE 0.002145
K_7555 X_NUC_38.L_CORE X_NUC_82.L_CORE 0.002161
K_7556 X_NUC_38.L_CORE X_NUC_83.L_CORE 0.002140
K_7557 X_NUC_38.L_CORE X_NUC_84.L_CORE 0.002153
K_7558 X_NUC_38.L_CORE X_NUC_85.L_CORE 0.001398
K_7559 X_NUC_38.L_CORE X_NUC_86.L_CORE 0.001405
K_7560 X_NUC_38.L_CORE X_NUC_87.L_CORE 0.001402
K_7561 X_NUC_38.L_CORE X_NUC_88.L_CORE 0.001396
K_7562 X_NUC_38.L_CORE X_NUC_89.L_CORE 0.003982
K_7563 X_NUC_38.L_CORE X_NUC_90.L_CORE 0.003958
K_7564 X_NUC_38.L_CORE X_NUC_91.L_CORE 0.003929
K_7565 X_NUC_38.L_CORE X_NUC_92.L_CORE 0.003913
K_7566 X_NUC_38.L_CORE X_NUC_93.L_CORE 0.001480
K_7567 X_NUC_38.L_CORE X_NUC_94.L_CORE 0.001490
K_7568 X_NUC_38.L_CORE X_NUC_95.L_CORE 0.001482
K_7569 X_NUC_38.L_CORE X_NUC_96.L_CORE 0.001483
K_7570 X_NUC_38.L_CORE X_NUC_97.L_CORE 0.001688
K_7571 X_NUC_38.L_CORE X_NUC_98.L_CORE 0.001693
K_7572 X_NUC_38.L_CORE X_NUC_99.L_CORE 0.001692
K_7573 X_NUC_38.L_CORE X_NUC_100.L_CORE 0.001680
K_7574 X_NUC_38.L_CORE X_NUC_101.L_CORE 0.002645
K_7575 X_NUC_38.L_CORE X_NUC_102.L_CORE 0.002656
K_7576 X_NUC_38.L_CORE X_NUC_103.L_CORE 0.002624
K_7577 X_NUC_38.L_CORE X_NUC_104.L_CORE 0.002642
K_7578 X_NUC_38.L_CORE X_NUC_105.L_CORE 0.001316
K_7579 X_NUC_38.L_CORE X_NUC_106.L_CORE 0.001323
K_7580 X_NUC_38.L_CORE X_NUC_107.L_CORE 0.001319
K_7581 X_NUC_38.L_CORE X_NUC_108.L_CORE 0.001316
K_7582 X_NUC_38.L_CORE X_NUC_109.L_CORE 0.002398
K_7583 X_NUC_38.L_CORE X_NUC_110.L_CORE 0.002395
K_7584 X_NUC_38.L_CORE X_NUC_111.L_CORE 0.002390
K_7585 X_NUC_38.L_CORE X_NUC_112.L_CORE 0.002373
K_7586 X_NUC_38.L_CORE X_NUC_113.L_CORE 0.001658
K_7587 X_NUC_38.L_CORE X_NUC_114.L_CORE 0.001668
K_7588 X_NUC_38.L_CORE X_NUC_115.L_CORE 0.001656
K_7589 X_NUC_38.L_CORE X_NUC_116.L_CORE 0.001660
K_7590 X_NUC_38.L_CORE X_NUC_117.L_CORE 0.001406
K_7591 X_NUC_38.L_CORE X_NUC_118.L_CORE 0.001412
K_7592 X_NUC_38.L_CORE X_NUC_119.L_CORE 0.001409
K_7593 X_NUC_38.L_CORE X_NUC_120.L_CORE 0.001403
K_7594 X_NUC_38.L_CORE X_NUC_121.L_CORE 0.002639
K_7595 X_NUC_38.L_CORE X_NUC_122.L_CORE 0.002639
K_7596 X_NUC_38.L_CORE X_NUC_123.L_CORE 0.002614
K_7597 X_NUC_38.L_CORE X_NUC_124.L_CORE 0.002618
K_7598 X_NUC_38.L_CORE X_NUC_125.L_CORE 0.001342
K_7599 X_NUC_38.L_CORE X_NUC_126.L_CORE 0.001349
K_7600 X_NUC_38.L_CORE X_NUC_127.L_CORE 0.001343
K_7601 X_NUC_38.L_CORE X_NUC_128.L_CORE 0.001342
K_7602 X_NUC_38.L_CORE X_NUC_129.L_CORE 0.001730
K_7603 X_NUC_38.L_CORE X_NUC_130.L_CORE 0.001733
K_7604 X_NUC_38.L_CORE X_NUC_131.L_CORE 0.001729
K_7605 X_NUC_38.L_CORE X_NUC_132.L_CORE 0.001719
K_7606 X_NUC_38.L_CORE X_NUC_133.L_CORE 0.001862
K_7607 X_NUC_38.L_CORE X_NUC_134.L_CORE 0.001870
K_7608 X_NUC_38.L_CORE X_NUC_135.L_CORE 0.001854
K_7609 X_NUC_38.L_CORE X_NUC_136.L_CORE 0.001860
K_7610 X_NUC_38.L_CORE X_NUC_137.L_CORE 0.001307
K_7611 X_NUC_38.L_CORE X_NUC_138.L_CORE 0.001313
K_7612 X_NUC_38.L_CORE X_NUC_139.L_CORE 0.001308
K_7613 X_NUC_38.L_CORE X_NUC_140.L_CORE 0.001305
K_7614 X_NUC_38.L_CORE X_NUC_141.L_CORE 0.002069
K_7615 X_NUC_38.L_CORE X_NUC_142.L_CORE 0.002069
K_7616 X_NUC_38.L_CORE X_NUC_143.L_CORE 0.002058
K_7617 X_NUC_38.L_CORE X_NUC_144.L_CORE 0.002052
K_7618 X_NUC_38.L_CORE X_NUC_145.L_CORE 0.001440
K_7619 X_NUC_38.L_CORE X_NUC_146.L_CORE 0.001447
K_7620 X_NUC_38.L_CORE X_NUC_147.L_CORE 0.001438
K_7621 X_NUC_38.L_CORE X_NUC_148.L_CORE 0.001439
K_7622 X_NUC_38.L_CORE X_NUC_149.L_CORE 0.001450
K_7623 X_NUC_38.L_CORE X_NUC_150.L_CORE 0.001454
K_7624 X_NUC_38.L_CORE X_NUC_151.L_CORE 0.001450
K_7625 X_NUC_38.L_CORE X_NUC_152.L_CORE 0.001444
K_7626 X_NUC_38.L_CORE X_NUC_153.L_CORE 0.001845
K_7627 X_NUC_38.L_CORE X_NUC_154.L_CORE 0.001849
K_7628 X_NUC_38.L_CORE X_NUC_155.L_CORE 0.001835
K_7629 X_NUC_38.L_CORE X_NUC_156.L_CORE 0.001837
K_7630 X_NUC_38.L_CORE X_NUC_157.L_CORE 0.001328
K_7631 X_NUC_38.L_CORE X_NUC_158.L_CORE 0.001334
K_7632 X_NUC_38.L_CORE X_NUC_159.L_CORE 0.001327
K_7633 X_NUC_38.L_CORE X_NUC_160.L_CORE 0.001326
K_7634 X_NUC_38.L_CORE X_NUC_161.L_CORE 0.001622
K_7635 X_NUC_38.L_CORE X_NUC_162.L_CORE 0.001625
K_7636 X_NUC_38.L_CORE X_NUC_163.L_CORE 0.001618
K_7637 X_NUC_38.L_CORE X_NUC_164.L_CORE 0.001614
K_7638 X_NUC_38.L_CORE X_NUC_165.L_CORE 0.001514
K_7639 X_NUC_38.L_CORE X_NUC_166.L_CORE 0.001520
K_7640 X_NUC_38.L_CORE X_NUC_167.L_CORE 0.001510
K_7641 X_NUC_38.L_CORE X_NUC_168.L_CORE 0.001510
K_7642 X_NUC_38.L_CORE X_NUC_169.L_CORE 0.001414
K_7643 X_NUC_38.L_CORE X_NUC_170.L_CORE 0.001418
K_7644 X_NUC_38.L_CORE X_NUC_171.L_CORE 0.001411
K_7645 X_NUC_38.L_CORE X_NUC_172.L_CORE 0.001409
K_7646 X_NUC_38.L_CORE X_NUC_173.L_CORE 0.002265
K_7647 X_NUC_38.L_CORE X_NUC_174.L_CORE 0.003841
K_7648 X_NUC_38.L_CORE X_NUC_175.L_CORE 0.002161
K_7649 X_NUC_38.L_CORE X_NUC_176.L_CORE 0.002223
K_7650 X_NUC_38.L_CORE X_NUC_177.L_CORE 0.004644
K_7651 X_NUC_38.L_CORE X_NUC_178.L_CORE 0.001700
K_7652 X_NUC_38.L_CORE X_NUC_179.L_CORE 0.003543
K_7653 X_NUC_38.L_CORE X_NUC_180.L_CORE 0.002357
K_7654 X_NUC_38.L_CORE X_NUC_181.L_CORE 0.001690
K_7655 X_NUC_38.L_CORE X_NUC_182.L_CORE 0.024225
K_7656 X_NUC_38.L_CORE X_NUC_183.L_CORE 0.001627
K_7657 X_NUC_38.L_CORE X_NUC_184.L_CORE 0.002211
K_7658 X_NUC_38.L_CORE X_NUC_185.L_CORE 0.003292
K_7659 X_NUC_38.L_CORE X_NUC_186.L_CORE 0.001456
K_7660 X_NUC_38.L_CORE X_NUC_187.L_CORE 0.004869
K_7661 X_NUC_38.L_CORE X_NUC_188.L_CORE 0.001773
K_7662 X_NUC_38.L_CORE X_NUC_189.L_CORE 0.001632
K_7663 X_NUC_38.L_CORE X_NUC_190.L_CORE 0.005810
K_7664 X_NUC_38.L_CORE X_NUC_191.L_CORE 0.001397
K_7665 X_NUC_38.L_CORE X_NUC_192.L_CORE 0.002415
K_7666 X_NUC_38.L_CORE X_NUC_193.L_CORE 0.002173
K_7667 X_NUC_38.L_CORE X_NUC_194.L_CORE 0.001381
K_7668 X_NUC_38.L_CORE X_NUC_195.L_CORE 0.004719
K_7669 X_NUC_38.L_CORE X_NUC_196.L_CORE 0.001468
K_7670 X_NUC_38.L_CORE X_NUC_197.L_CORE 0.001687
K_7671 X_NUC_38.L_CORE X_NUC_198.L_CORE 0.002861
K_7672 X_NUC_38.L_CORE X_NUC_199.L_CORE 0.001293
K_7673 X_NUC_38.L_CORE X_NUC_200.L_CORE 0.002571
K_7674 X_NUC_38.L_CORE X_NUC_201.L_CORE 0.001668
K_7675 X_NUC_38.L_CORE X_NUC_202.L_CORE 0.001386
K_7676 X_NUC_38.L_CORE X_NUC_203.L_CORE 0.003104
K_7677 X_NUC_38.L_CORE X_NUC_204.L_CORE 0.001314
K_7678 X_NUC_38.L_CORE X_NUC_205.L_CORE 0.001771
K_7679 X_NUC_38.L_CORE X_NUC_206.L_CORE 0.001966
K_7680 X_NUC_38.L_CORE X_NUC_207.L_CORE 0.001266
K_7681 X_NUC_38.L_CORE X_NUC_208.L_CORE 0.002375
K_7682 X_NUC_38.L_CORE X_NUC_209.L_CORE 0.001420
K_7683 X_NUC_38.L_CORE X_NUC_210.L_CORE 0.001431
K_7684 X_NUC_38.L_CORE X_NUC_211.L_CORE 0.002130
K_7685 X_NUC_38.L_CORE X_NUC_212.L_CORE 0.001255
K_7686 X_NUC_38.L_CORE X_NUC_213.L_CORE 0.001770
K_7687 X_NUC_38.L_CORE X_NUC_214.L_CORE 0.001568
K_7688 X_NUC_38.L_CORE X_NUC_215.L_CORE 0.001294
K_7689 X_NUC_38.L_CORE X_NUC_216.L_CORE 0.001904
K_7690 X_NUC_38.L_CORE X_NUC_217.L_CORE 0.001319
K_7691 X_NUC_38.L_CORE X_NUC_218.L_CORE 0.001463
K_7692 X_NUC_38.L_CORE X_NUC_219.L_CORE 0.001612
K_7693 X_NUC_38.L_CORE X_NUC_220.L_CORE 0.001293
K_7694 X_NUC_38.L_CORE X_NUC_221.L_CORE 0.001548
K_7695 X_NUC_38.L_CORE X_NUC_222.L_CORE 0.001405
K_7696 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_7697 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.001647
K_7698 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.001660
K_7699 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.001653
K_7700 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.001653
K_7701 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.002225
K_7702 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.002233
K_7703 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.002239
K_7704 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.002217
K_7705 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.003326
K_7706 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.003362
K_7707 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.003318
K_7708 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.003356
K_7709 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.001472
K_7710 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.001482
K_7711 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.001479
K_7712 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.001474
K_7713 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.004657
K_7714 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.004627
K_7715 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.004657
K_7716 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.004569
K_7717 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.001793
K_7718 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.001808
K_7719 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.001796
K_7720 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.001801
K_7721 X_NUC_39.L_CORE X_NUC_65.L_CORE 0.001645
K_7722 X_NUC_39.L_CORE X_NUC_66.L_CORE 0.001652
K_7723 X_NUC_39.L_CORE X_NUC_67.L_CORE 0.001652
K_7724 X_NUC_39.L_CORE X_NUC_68.L_CORE 0.001641
K_7725 X_NUC_39.L_CORE X_NUC_69.L_CORE 0.005203
K_7726 X_NUC_39.L_CORE X_NUC_70.L_CORE 0.005214
K_7727 X_NUC_39.L_CORE X_NUC_71.L_CORE 0.005100
K_7728 X_NUC_39.L_CORE X_NUC_72.L_CORE 0.005185
K_7729 X_NUC_39.L_CORE X_NUC_73.L_CORE 0.001416
K_7730 X_NUC_39.L_CORE X_NUC_74.L_CORE 0.001425
K_7731 X_NUC_39.L_CORE X_NUC_75.L_CORE 0.001420
K_7732 X_NUC_39.L_CORE X_NUC_76.L_CORE 0.001418
K_7733 X_NUC_39.L_CORE X_NUC_77.L_CORE 0.002377
K_7734 X_NUC_39.L_CORE X_NUC_78.L_CORE 0.002377
K_7735 X_NUC_39.L_CORE X_NUC_79.L_CORE 0.002381
K_7736 X_NUC_39.L_CORE X_NUC_80.L_CORE 0.002357
K_7737 X_NUC_39.L_CORE X_NUC_81.L_CORE 0.002166
K_7738 X_NUC_39.L_CORE X_NUC_82.L_CORE 0.002182
K_7739 X_NUC_39.L_CORE X_NUC_83.L_CORE 0.002161
K_7740 X_NUC_39.L_CORE X_NUC_84.L_CORE 0.002174
K_7741 X_NUC_39.L_CORE X_NUC_85.L_CORE 0.001400
K_7742 X_NUC_39.L_CORE X_NUC_86.L_CORE 0.001407
K_7743 X_NUC_39.L_CORE X_NUC_87.L_CORE 0.001405
K_7744 X_NUC_39.L_CORE X_NUC_88.L_CORE 0.001399
K_7745 X_NUC_39.L_CORE X_NUC_89.L_CORE 0.004011
K_7746 X_NUC_39.L_CORE X_NUC_90.L_CORE 0.003986
K_7747 X_NUC_39.L_CORE X_NUC_91.L_CORE 0.003958
K_7748 X_NUC_39.L_CORE X_NUC_92.L_CORE 0.003941
K_7749 X_NUC_39.L_CORE X_NUC_93.L_CORE 0.001489
K_7750 X_NUC_39.L_CORE X_NUC_94.L_CORE 0.001498
K_7751 X_NUC_39.L_CORE X_NUC_95.L_CORE 0.001490
K_7752 X_NUC_39.L_CORE X_NUC_96.L_CORE 0.001491
K_7753 X_NUC_39.L_CORE X_NUC_97.L_CORE 0.001689
K_7754 X_NUC_39.L_CORE X_NUC_98.L_CORE 0.001693
K_7755 X_NUC_39.L_CORE X_NUC_99.L_CORE 0.001693
K_7756 X_NUC_39.L_CORE X_NUC_100.L_CORE 0.001681
K_7757 X_NUC_39.L_CORE X_NUC_101.L_CORE 0.002679
K_7758 X_NUC_39.L_CORE X_NUC_102.L_CORE 0.002690
K_7759 X_NUC_39.L_CORE X_NUC_103.L_CORE 0.002656
K_7760 X_NUC_39.L_CORE X_NUC_104.L_CORE 0.002676
K_7761 X_NUC_39.L_CORE X_NUC_105.L_CORE 0.001321
K_7762 X_NUC_39.L_CORE X_NUC_106.L_CORE 0.001328
K_7763 X_NUC_39.L_CORE X_NUC_107.L_CORE 0.001323
K_7764 X_NUC_39.L_CORE X_NUC_108.L_CORE 0.001320
K_7765 X_NUC_39.L_CORE X_NUC_109.L_CORE 0.002403
K_7766 X_NUC_39.L_CORE X_NUC_110.L_CORE 0.002400
K_7767 X_NUC_39.L_CORE X_NUC_111.L_CORE 0.002395
K_7768 X_NUC_39.L_CORE X_NUC_112.L_CORE 0.002378
K_7769 X_NUC_39.L_CORE X_NUC_113.L_CORE 0.001671
K_7770 X_NUC_39.L_CORE X_NUC_114.L_CORE 0.001681
K_7771 X_NUC_39.L_CORE X_NUC_115.L_CORE 0.001668
K_7772 X_NUC_39.L_CORE X_NUC_116.L_CORE 0.001673
K_7773 X_NUC_39.L_CORE X_NUC_117.L_CORE 0.001409
K_7774 X_NUC_39.L_CORE X_NUC_118.L_CORE 0.001415
K_7775 X_NUC_39.L_CORE X_NUC_119.L_CORE 0.001412
K_7776 X_NUC_39.L_CORE X_NUC_120.L_CORE 0.001405
K_7777 X_NUC_39.L_CORE X_NUC_121.L_CORE 0.002665
K_7778 X_NUC_39.L_CORE X_NUC_122.L_CORE 0.002665
K_7779 X_NUC_39.L_CORE X_NUC_123.L_CORE 0.002639
K_7780 X_NUC_39.L_CORE X_NUC_124.L_CORE 0.002643
K_7781 X_NUC_39.L_CORE X_NUC_125.L_CORE 0.001348
K_7782 X_NUC_39.L_CORE X_NUC_126.L_CORE 0.001356
K_7783 X_NUC_39.L_CORE X_NUC_127.L_CORE 0.001349
K_7784 X_NUC_39.L_CORE X_NUC_128.L_CORE 0.001349
K_7785 X_NUC_39.L_CORE X_NUC_129.L_CORE 0.001734
K_7786 X_NUC_39.L_CORE X_NUC_130.L_CORE 0.001736
K_7787 X_NUC_39.L_CORE X_NUC_131.L_CORE 0.001733
K_7788 X_NUC_39.L_CORE X_NUC_132.L_CORE 0.001723
K_7789 X_NUC_39.L_CORE X_NUC_133.L_CORE 0.001879
K_7790 X_NUC_39.L_CORE X_NUC_134.L_CORE 0.001887
K_7791 X_NUC_39.L_CORE X_NUC_135.L_CORE 0.001870
K_7792 X_NUC_39.L_CORE X_NUC_136.L_CORE 0.001876
K_7793 X_NUC_39.L_CORE X_NUC_137.L_CORE 0.001312
K_7794 X_NUC_39.L_CORE X_NUC_138.L_CORE 0.001317
K_7795 X_NUC_39.L_CORE X_NUC_139.L_CORE 0.001313
K_7796 X_NUC_39.L_CORE X_NUC_140.L_CORE 0.001309
K_7797 X_NUC_39.L_CORE X_NUC_141.L_CORE 0.002080
K_7798 X_NUC_39.L_CORE X_NUC_142.L_CORE 0.002080
K_7799 X_NUC_39.L_CORE X_NUC_143.L_CORE 0.002069
K_7800 X_NUC_39.L_CORE X_NUC_144.L_CORE 0.002064
K_7801 X_NUC_39.L_CORE X_NUC_145.L_CORE 0.001449
K_7802 X_NUC_39.L_CORE X_NUC_146.L_CORE 0.001456
K_7803 X_NUC_39.L_CORE X_NUC_147.L_CORE 0.001447
K_7804 X_NUC_39.L_CORE X_NUC_148.L_CORE 0.001448
K_7805 X_NUC_39.L_CORE X_NUC_149.L_CORE 0.001455
K_7806 X_NUC_39.L_CORE X_NUC_150.L_CORE 0.001459
K_7807 X_NUC_39.L_CORE X_NUC_151.L_CORE 0.001454
K_7808 X_NUC_39.L_CORE X_NUC_152.L_CORE 0.001449
K_7809 X_NUC_39.L_CORE X_NUC_153.L_CORE 0.001859
K_7810 X_NUC_39.L_CORE X_NUC_154.L_CORE 0.001863
K_7811 X_NUC_39.L_CORE X_NUC_155.L_CORE 0.001849
K_7812 X_NUC_39.L_CORE X_NUC_156.L_CORE 0.001851
K_7813 X_NUC_39.L_CORE X_NUC_157.L_CORE 0.001334
K_7814 X_NUC_39.L_CORE X_NUC_158.L_CORE 0.001340
K_7815 X_NUC_39.L_CORE X_NUC_159.L_CORE 0.001334
K_7816 X_NUC_39.L_CORE X_NUC_160.L_CORE 0.001332
K_7817 X_NUC_39.L_CORE X_NUC_161.L_CORE 0.001630
K_7818 X_NUC_39.L_CORE X_NUC_162.L_CORE 0.001633
K_7819 X_NUC_39.L_CORE X_NUC_163.L_CORE 0.001625
K_7820 X_NUC_39.L_CORE X_NUC_164.L_CORE 0.001621
K_7821 X_NUC_39.L_CORE X_NUC_165.L_CORE 0.001524
K_7822 X_NUC_39.L_CORE X_NUC_166.L_CORE 0.001530
K_7823 X_NUC_39.L_CORE X_NUC_167.L_CORE 0.001520
K_7824 X_NUC_39.L_CORE X_NUC_168.L_CORE 0.001520
K_7825 X_NUC_39.L_CORE X_NUC_169.L_CORE 0.001420
K_7826 X_NUC_39.L_CORE X_NUC_170.L_CORE 0.001425
K_7827 X_NUC_39.L_CORE X_NUC_171.L_CORE 0.001418
K_7828 X_NUC_39.L_CORE X_NUC_172.L_CORE 0.001415
K_7829 X_NUC_39.L_CORE X_NUC_173.L_CORE 0.002263
K_7830 X_NUC_39.L_CORE X_NUC_174.L_CORE 0.003813
K_7831 X_NUC_39.L_CORE X_NUC_175.L_CORE 0.002166
K_7832 X_NUC_39.L_CORE X_NUC_176.L_CORE 0.002216
K_7833 X_NUC_39.L_CORE X_NUC_177.L_CORE 0.004656
K_7834 X_NUC_39.L_CORE X_NUC_178.L_CORE 0.001703
K_7835 X_NUC_39.L_CORE X_NUC_179.L_CORE 0.003507
K_7836 X_NUC_39.L_CORE X_NUC_180.L_CORE 0.002370
K_7837 X_NUC_39.L_CORE X_NUC_181.L_CORE 0.001689
K_7838 X_NUC_39.L_CORE X_NUC_182.L_CORE 0.022295
K_7839 X_NUC_39.L_CORE X_NUC_183.L_CORE 0.001633
K_7840 X_NUC_39.L_CORE X_NUC_184.L_CORE 0.002203
K_7841 X_NUC_39.L_CORE X_NUC_185.L_CORE 0.003330
K_7842 X_NUC_39.L_CORE X_NUC_186.L_CORE 0.001458
K_7843 X_NUC_39.L_CORE X_NUC_187.L_CORE 0.004813
K_7844 X_NUC_39.L_CORE X_NUC_188.L_CORE 0.001784
K_7845 X_NUC_39.L_CORE X_NUC_189.L_CORE 0.001631
K_7846 X_NUC_39.L_CORE X_NUC_190.L_CORE 0.005944
K_7847 X_NUC_39.L_CORE X_NUC_191.L_CORE 0.001401
K_7848 X_NUC_39.L_CORE X_NUC_192.L_CORE 0.002408
K_7849 X_NUC_39.L_CORE X_NUC_193.L_CORE 0.002194
K_7850 X_NUC_39.L_CORE X_NUC_194.L_CORE 0.001383
K_7851 X_NUC_39.L_CORE X_NUC_195.L_CORE 0.004741
K_7852 X_NUC_39.L_CORE X_NUC_196.L_CORE 0.001476
K_7853 X_NUC_39.L_CORE X_NUC_197.L_CORE 0.001686
K_7854 X_NUC_39.L_CORE X_NUC_198.L_CORE 0.002899
K_7855 X_NUC_39.L_CORE X_NUC_199.L_CORE 0.001297
K_7856 X_NUC_39.L_CORE X_NUC_200.L_CORE 0.002571
K_7857 X_NUC_39.L_CORE X_NUC_201.L_CORE 0.001680
K_7858 X_NUC_39.L_CORE X_NUC_202.L_CORE 0.001388
K_7859 X_NUC_39.L_CORE X_NUC_203.L_CORE 0.003137
K_7860 X_NUC_39.L_CORE X_NUC_204.L_CORE 0.001320
K_7861 X_NUC_39.L_CORE X_NUC_205.L_CORE 0.001772
K_7862 X_NUC_39.L_CORE X_NUC_206.L_CORE 0.001985
K_7863 X_NUC_39.L_CORE X_NUC_207.L_CORE 0.001270
K_7864 X_NUC_39.L_CORE X_NUC_208.L_CORE 0.002386
K_7865 X_NUC_39.L_CORE X_NUC_209.L_CORE 0.001429
K_7866 X_NUC_39.L_CORE X_NUC_210.L_CORE 0.001434
K_7867 X_NUC_39.L_CORE X_NUC_211.L_CORE 0.002150
K_7868 X_NUC_39.L_CORE X_NUC_212.L_CORE 0.001260
K_7869 X_NUC_39.L_CORE X_NUC_213.L_CORE 0.001775
K_7870 X_NUC_39.L_CORE X_NUC_214.L_CORE 0.001580
K_7871 X_NUC_39.L_CORE X_NUC_215.L_CORE 0.001298
K_7872 X_NUC_39.L_CORE X_NUC_216.L_CORE 0.001917
K_7873 X_NUC_39.L_CORE X_NUC_217.L_CORE 0.001326
K_7874 X_NUC_39.L_CORE X_NUC_218.L_CORE 0.001468
K_7875 X_NUC_39.L_CORE X_NUC_219.L_CORE 0.001624
K_7876 X_NUC_39.L_CORE X_NUC_220.L_CORE 0.001299
K_7877 X_NUC_39.L_CORE X_NUC_221.L_CORE 0.001555
K_7878 X_NUC_39.L_CORE X_NUC_222.L_CORE 0.001413
K_7879 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.001647
K_7880 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.001660
K_7881 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.001654
K_7882 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.001653
K_7883 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.002248
K_7884 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.002256
K_7885 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.002262
K_7886 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.002239
K_7887 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.003288
K_7888 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.003324
K_7889 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.003281
K_7890 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.003318
K_7891 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.001477
K_7892 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.001486
K_7893 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.001483
K_7894 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.001479
K_7895 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.004749
K_7896 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.004717
K_7897 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.004748
K_7898 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.004657
K_7899 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.001788
K_7900 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.001803
K_7901 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.001791
K_7902 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.001796
K_7903 X_NUC_40.L_CORE X_NUC_65.L_CORE 0.001656
K_7904 X_NUC_40.L_CORE X_NUC_66.L_CORE 0.001663
K_7905 X_NUC_40.L_CORE X_NUC_67.L_CORE 0.001663
K_7906 X_NUC_40.L_CORE X_NUC_68.L_CORE 0.001652
K_7907 X_NUC_40.L_CORE X_NUC_69.L_CORE 0.005115
K_7908 X_NUC_40.L_CORE X_NUC_70.L_CORE 0.005125
K_7909 X_NUC_40.L_CORE X_NUC_71.L_CORE 0.005015
K_7910 X_NUC_40.L_CORE X_NUC_72.L_CORE 0.005100
K_7911 X_NUC_40.L_CORE X_NUC_73.L_CORE 0.001418
K_7912 X_NUC_40.L_CORE X_NUC_74.L_CORE 0.001427
K_7913 X_NUC_40.L_CORE X_NUC_75.L_CORE 0.001422
K_7914 X_NUC_40.L_CORE X_NUC_76.L_CORE 0.001420
K_7915 X_NUC_40.L_CORE X_NUC_77.L_CORE 0.002401
K_7916 X_NUC_40.L_CORE X_NUC_78.L_CORE 0.002402
K_7917 X_NUC_40.L_CORE X_NUC_79.L_CORE 0.002406
K_7918 X_NUC_40.L_CORE X_NUC_80.L_CORE 0.002381
K_7919 X_NUC_40.L_CORE X_NUC_81.L_CORE 0.002153
K_7920 X_NUC_40.L_CORE X_NUC_82.L_CORE 0.002169
K_7921 X_NUC_40.L_CORE X_NUC_83.L_CORE 0.002148
K_7922 X_NUC_40.L_CORE X_NUC_84.L_CORE 0.002161
K_7923 X_NUC_40.L_CORE X_NUC_85.L_CORE 0.001406
K_7924 X_NUC_40.L_CORE X_NUC_86.L_CORE 0.001413
K_7925 X_NUC_40.L_CORE X_NUC_87.L_CORE 0.001411
K_7926 X_NUC_40.L_CORE X_NUC_88.L_CORE 0.001405
K_7927 X_NUC_40.L_CORE X_NUC_89.L_CORE 0.004028
K_7928 X_NUC_40.L_CORE X_NUC_90.L_CORE 0.004002
K_7929 X_NUC_40.L_CORE X_NUC_91.L_CORE 0.003973
K_7930 X_NUC_40.L_CORE X_NUC_92.L_CORE 0.003958
K_7931 X_NUC_40.L_CORE X_NUC_93.L_CORE 0.001487
K_7932 X_NUC_40.L_CORE X_NUC_94.L_CORE 0.001497
K_7933 X_NUC_40.L_CORE X_NUC_95.L_CORE 0.001489
K_7934 X_NUC_40.L_CORE X_NUC_96.L_CORE 0.001490
K_7935 X_NUC_40.L_CORE X_NUC_97.L_CORE 0.001700
K_7936 X_NUC_40.L_CORE X_NUC_98.L_CORE 0.001705
K_7937 X_NUC_40.L_CORE X_NUC_99.L_CORE 0.001704
K_7938 X_NUC_40.L_CORE X_NUC_100.L_CORE 0.001693
K_7939 X_NUC_40.L_CORE X_NUC_101.L_CORE 0.002659
K_7940 X_NUC_40.L_CORE X_NUC_102.L_CORE 0.002670
K_7941 X_NUC_40.L_CORE X_NUC_103.L_CORE 0.002637
K_7942 X_NUC_40.L_CORE X_NUC_104.L_CORE 0.002656
K_7943 X_NUC_40.L_CORE X_NUC_105.L_CORE 0.001323
K_7944 X_NUC_40.L_CORE X_NUC_106.L_CORE 0.001331
K_7945 X_NUC_40.L_CORE X_NUC_107.L_CORE 0.001326
K_7946 X_NUC_40.L_CORE X_NUC_108.L_CORE 0.001323
K_7947 X_NUC_40.L_CORE X_NUC_109.L_CORE 0.002421
K_7948 X_NUC_40.L_CORE X_NUC_110.L_CORE 0.002417
K_7949 X_NUC_40.L_CORE X_NUC_111.L_CORE 0.002413
K_7950 X_NUC_40.L_CORE X_NUC_112.L_CORE 0.002395
K_7951 X_NUC_40.L_CORE X_NUC_113.L_CORE 0.001666
K_7952 X_NUC_40.L_CORE X_NUC_114.L_CORE 0.001676
K_7953 X_NUC_40.L_CORE X_NUC_115.L_CORE 0.001664
K_7954 X_NUC_40.L_CORE X_NUC_116.L_CORE 0.001668
K_7955 X_NUC_40.L_CORE X_NUC_117.L_CORE 0.001416
K_7956 X_NUC_40.L_CORE X_NUC_118.L_CORE 0.001421
K_7957 X_NUC_40.L_CORE X_NUC_119.L_CORE 0.001418
K_7958 X_NUC_40.L_CORE X_NUC_120.L_CORE 0.001412
K_7959 X_NUC_40.L_CORE X_NUC_121.L_CORE 0.002660
K_7960 X_NUC_40.L_CORE X_NUC_122.L_CORE 0.002660
K_7961 X_NUC_40.L_CORE X_NUC_123.L_CORE 0.002634
K_7962 X_NUC_40.L_CORE X_NUC_124.L_CORE 0.002639
K_7963 X_NUC_40.L_CORE X_NUC_125.L_CORE 0.001349
K_7964 X_NUC_40.L_CORE X_NUC_126.L_CORE 0.001356
K_7965 X_NUC_40.L_CORE X_NUC_127.L_CORE 0.001350
K_7966 X_NUC_40.L_CORE X_NUC_128.L_CORE 0.001349
K_7967 X_NUC_40.L_CORE X_NUC_129.L_CORE 0.001744
K_7968 X_NUC_40.L_CORE X_NUC_130.L_CORE 0.001746
K_7969 X_NUC_40.L_CORE X_NUC_131.L_CORE 0.001743
K_7970 X_NUC_40.L_CORE X_NUC_132.L_CORE 0.001733
K_7971 X_NUC_40.L_CORE X_NUC_133.L_CORE 0.001873
K_7972 X_NUC_40.L_CORE X_NUC_134.L_CORE 0.001881
K_7973 X_NUC_40.L_CORE X_NUC_135.L_CORE 0.001864
K_7974 X_NUC_40.L_CORE X_NUC_136.L_CORE 0.001870
K_7975 X_NUC_40.L_CORE X_NUC_137.L_CORE 0.001315
K_7976 X_NUC_40.L_CORE X_NUC_138.L_CORE 0.001321
K_7977 X_NUC_40.L_CORE X_NUC_139.L_CORE 0.001316
K_7978 X_NUC_40.L_CORE X_NUC_140.L_CORE 0.001313
K_7979 X_NUC_40.L_CORE X_NUC_141.L_CORE 0.002086
K_7980 X_NUC_40.L_CORE X_NUC_142.L_CORE 0.002086
K_7981 X_NUC_40.L_CORE X_NUC_143.L_CORE 0.002075
K_7982 X_NUC_40.L_CORE X_NUC_144.L_CORE 0.002069
K_7983 X_NUC_40.L_CORE X_NUC_145.L_CORE 0.001448
K_7984 X_NUC_40.L_CORE X_NUC_146.L_CORE 0.001455
K_7985 X_NUC_40.L_CORE X_NUC_147.L_CORE 0.001446
K_7986 X_NUC_40.L_CORE X_NUC_148.L_CORE 0.001447
K_7987 X_NUC_40.L_CORE X_NUC_149.L_CORE 0.001460
K_7988 X_NUC_40.L_CORE X_NUC_150.L_CORE 0.001465
K_7989 X_NUC_40.L_CORE X_NUC_151.L_CORE 0.001460
K_7990 X_NUC_40.L_CORE X_NUC_152.L_CORE 0.001454
K_7991 X_NUC_40.L_CORE X_NUC_153.L_CORE 0.001857
K_7992 X_NUC_40.L_CORE X_NUC_154.L_CORE 0.001861
K_7993 X_NUC_40.L_CORE X_NUC_155.L_CORE 0.001847
K_7994 X_NUC_40.L_CORE X_NUC_156.L_CORE 0.001849
K_7995 X_NUC_40.L_CORE X_NUC_157.L_CORE 0.001336
K_7996 X_NUC_40.L_CORE X_NUC_158.L_CORE 0.001342
K_7997 X_NUC_40.L_CORE X_NUC_159.L_CORE 0.001335
K_7998 X_NUC_40.L_CORE X_NUC_160.L_CORE 0.001334
K_7999 X_NUC_40.L_CORE X_NUC_161.L_CORE 0.001634
K_8000 X_NUC_40.L_CORE X_NUC_162.L_CORE 0.001637
K_8001 X_NUC_40.L_CORE X_NUC_163.L_CORE 0.001630
K_8002 X_NUC_40.L_CORE X_NUC_164.L_CORE 0.001625
K_8003 X_NUC_40.L_CORE X_NUC_165.L_CORE 0.001524
K_8004 X_NUC_40.L_CORE X_NUC_166.L_CORE 0.001529
K_8005 X_NUC_40.L_CORE X_NUC_167.L_CORE 0.001520
K_8006 X_NUC_40.L_CORE X_NUC_168.L_CORE 0.001520
K_8007 X_NUC_40.L_CORE X_NUC_169.L_CORE 0.001423
K_8008 X_NUC_40.L_CORE X_NUC_170.L_CORE 0.001428
K_8009 X_NUC_40.L_CORE X_NUC_171.L_CORE 0.001421
K_8010 X_NUC_40.L_CORE X_NUC_172.L_CORE 0.001418
K_8011 X_NUC_40.L_CORE X_NUC_173.L_CORE 0.002273
K_8012 X_NUC_40.L_CORE X_NUC_174.L_CORE 0.003844
K_8013 X_NUC_40.L_CORE X_NUC_175.L_CORE 0.002167
K_8014 X_NUC_40.L_CORE X_NUC_176.L_CORE 0.002234
K_8015 X_NUC_40.L_CORE X_NUC_177.L_CORE 0.004622
K_8016 X_NUC_40.L_CORE X_NUC_178.L_CORE 0.001707
K_8017 X_NUC_40.L_CORE X_NUC_179.L_CORE 0.003563
K_8018 X_NUC_40.L_CORE X_NUC_180.L_CORE 0.002360
K_8019 X_NUC_40.L_CORE X_NUC_181.L_CORE 0.001698
K_8020 X_NUC_40.L_CORE X_NUC_182.L_CORE 0.022160
K_8021 X_NUC_40.L_CORE X_NUC_183.L_CORE 0.001633
K_8022 X_NUC_40.L_CORE X_NUC_184.L_CORE 0.002225
K_8023 X_NUC_40.L_CORE X_NUC_185.L_CORE 0.003291
K_8024 X_NUC_40.L_CORE X_NUC_186.L_CORE 0.001463
K_8025 X_NUC_40.L_CORE X_NUC_187.L_CORE 0.004916
K_8026 X_NUC_40.L_CORE X_NUC_188.L_CORE 0.001779
K_8027 X_NUC_40.L_CORE X_NUC_189.L_CORE 0.001642
K_8028 X_NUC_40.L_CORE X_NUC_190.L_CORE 0.005802
K_8029 X_NUC_40.L_CORE X_NUC_191.L_CORE 0.001403
K_8030 X_NUC_40.L_CORE X_NUC_192.L_CORE 0.002434
K_8031 X_NUC_40.L_CORE X_NUC_193.L_CORE 0.002180
K_8032 X_NUC_40.L_CORE X_NUC_194.L_CORE 0.001389
K_8033 X_NUC_40.L_CORE X_NUC_195.L_CORE 0.004766
K_8034 X_NUC_40.L_CORE X_NUC_196.L_CORE 0.001474
K_8035 X_NUC_40.L_CORE X_NUC_197.L_CORE 0.001699
K_8036 X_NUC_40.L_CORE X_NUC_198.L_CORE 0.002870
K_8037 X_NUC_40.L_CORE X_NUC_199.L_CORE 0.001300
K_8038 X_NUC_40.L_CORE X_NUC_200.L_CORE 0.002594
K_8039 X_NUC_40.L_CORE X_NUC_201.L_CORE 0.001674
K_8040 X_NUC_40.L_CORE X_NUC_202.L_CORE 0.001394
K_8041 X_NUC_40.L_CORE X_NUC_203.L_CORE 0.003125
K_8042 X_NUC_40.L_CORE X_NUC_204.L_CORE 0.001320
K_8043 X_NUC_40.L_CORE X_NUC_205.L_CORE 0.001784
K_8044 X_NUC_40.L_CORE X_NUC_206.L_CORE 0.001975
K_8045 X_NUC_40.L_CORE X_NUC_207.L_CORE 0.001273
K_8046 X_NUC_40.L_CORE X_NUC_208.L_CORE 0.002395
K_8047 X_NUC_40.L_CORE X_NUC_209.L_CORE 0.001427
K_8048 X_NUC_40.L_CORE X_NUC_210.L_CORE 0.001440
K_8049 X_NUC_40.L_CORE X_NUC_211.L_CORE 0.002143
K_8050 X_NUC_40.L_CORE X_NUC_212.L_CORE 0.001262
K_8051 X_NUC_40.L_CORE X_NUC_213.L_CORE 0.001783
K_8052 X_NUC_40.L_CORE X_NUC_214.L_CORE 0.001577
K_8053 X_NUC_40.L_CORE X_NUC_215.L_CORE 0.001302
K_8054 X_NUC_40.L_CORE X_NUC_216.L_CORE 0.001918
K_8055 X_NUC_40.L_CORE X_NUC_217.L_CORE 0.001326
K_8056 X_NUC_40.L_CORE X_NUC_218.L_CORE 0.001473
K_8057 X_NUC_40.L_CORE X_NUC_219.L_CORE 0.001622
K_8058 X_NUC_40.L_CORE X_NUC_220.L_CORE 0.001301
K_8059 X_NUC_40.L_CORE X_NUC_221.L_CORE 0.001558
K_8060 X_NUC_40.L_CORE X_NUC_222.L_CORE 0.001413
K_8061 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_8062 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_8063 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_8064 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.001601
K_8065 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.001592
K_8066 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.001600
K_8067 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.001592
K_8068 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.002174
K_8069 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.002154
K_8070 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.002157
K_8071 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.002168
K_8072 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.003233
K_8073 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.003231
K_8074 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.003250
K_8075 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.003201
K_8076 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.001441
K_8077 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.001431
K_8078 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.001436
K_8079 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.001434
K_8080 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.004588
K_8081 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.004548
K_8082 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.004499
K_8083 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.004580
K_8084 X_NUC_41.L_CORE X_NUC_65.L_CORE 0.001757
K_8085 X_NUC_41.L_CORE X_NUC_66.L_CORE 0.001750
K_8086 X_NUC_41.L_CORE X_NUC_67.L_CORE 0.001758
K_8087 X_NUC_41.L_CORE X_NUC_68.L_CORE 0.001745
K_8088 X_NUC_41.L_CORE X_NUC_69.L_CORE 0.001619
K_8089 X_NUC_41.L_CORE X_NUC_70.L_CORE 0.001607
K_8090 X_NUC_41.L_CORE X_NUC_71.L_CORE 0.001609
K_8091 X_NUC_41.L_CORE X_NUC_72.L_CORE 0.001612
K_8092 X_NUC_41.L_CORE X_NUC_73.L_CORE 0.005118
K_8093 X_NUC_41.L_CORE X_NUC_74.L_CORE 0.005162
K_8094 X_NUC_41.L_CORE X_NUC_75.L_CORE 0.005110
K_8095 X_NUC_41.L_CORE X_NUC_76.L_CORE 0.005039
K_8096 X_NUC_41.L_CORE X_NUC_77.L_CORE 0.001395
K_8097 X_NUC_41.L_CORE X_NUC_78.L_CORE 0.001387
K_8098 X_NUC_41.L_CORE X_NUC_79.L_CORE 0.001392
K_8099 X_NUC_41.L_CORE X_NUC_80.L_CORE 0.001387
K_8100 X_NUC_41.L_CORE X_NUC_81.L_CORE 0.002353
K_8101 X_NUC_41.L_CORE X_NUC_82.L_CORE 0.002336
K_8102 X_NUC_41.L_CORE X_NUC_83.L_CORE 0.002328
K_8103 X_NUC_41.L_CORE X_NUC_84.L_CORE 0.002345
K_8104 X_NUC_41.L_CORE X_NUC_85.L_CORE 0.002136
K_8105 X_NUC_41.L_CORE X_NUC_86.L_CORE 0.002133
K_8106 X_NUC_41.L_CORE X_NUC_87.L_CORE 0.002138
K_8107 X_NUC_41.L_CORE X_NUC_88.L_CORE 0.002118
K_8108 X_NUC_41.L_CORE X_NUC_89.L_CORE 0.001385
K_8109 X_NUC_41.L_CORE X_NUC_90.L_CORE 0.001377
K_8110 X_NUC_41.L_CORE X_NUC_91.L_CORE 0.001379
K_8111 X_NUC_41.L_CORE X_NUC_92.L_CORE 0.001379
K_8112 X_NUC_41.L_CORE X_NUC_93.L_CORE 0.003998
K_8113 X_NUC_41.L_CORE X_NUC_94.L_CORE 0.004002
K_8114 X_NUC_41.L_CORE X_NUC_95.L_CORE 0.003936
K_8115 X_NUC_41.L_CORE X_NUC_96.L_CORE 0.003964
K_8116 X_NUC_41.L_CORE X_NUC_97.L_CORE 0.001474
K_8117 X_NUC_41.L_CORE X_NUC_98.L_CORE 0.001468
K_8118 X_NUC_41.L_CORE X_NUC_99.L_CORE 0.001472
K_8119 X_NUC_41.L_CORE X_NUC_100.L_CORE 0.001464
K_8120 X_NUC_41.L_CORE X_NUC_101.L_CORE 0.001678
K_8121 X_NUC_41.L_CORE X_NUC_102.L_CORE 0.001667
K_8122 X_NUC_41.L_CORE X_NUC_103.L_CORE 0.001666
K_8123 X_NUC_41.L_CORE X_NUC_104.L_CORE 0.001671
K_8124 X_NUC_41.L_CORE X_NUC_105.L_CORE 0.002658
K_8125 X_NUC_41.L_CORE X_NUC_106.L_CORE 0.002661
K_8126 X_NUC_41.L_CORE X_NUC_107.L_CORE 0.002652
K_8127 X_NUC_41.L_CORE X_NUC_108.L_CORE 0.002631
K_8128 X_NUC_41.L_CORE X_NUC_109.L_CORE 0.001313
K_8129 X_NUC_41.L_CORE X_NUC_110.L_CORE 0.001306
K_8130 X_NUC_41.L_CORE X_NUC_111.L_CORE 0.001308
K_8131 X_NUC_41.L_CORE X_NUC_112.L_CORE 0.001306
K_8132 X_NUC_41.L_CORE X_NUC_113.L_CORE 0.002396
K_8133 X_NUC_41.L_CORE X_NUC_114.L_CORE 0.002385
K_8134 X_NUC_41.L_CORE X_NUC_115.L_CORE 0.002369
K_8135 X_NUC_41.L_CORE X_NUC_116.L_CORE 0.002383
K_8136 X_NUC_41.L_CORE X_NUC_117.L_CORE 0.001662
K_8137 X_NUC_41.L_CORE X_NUC_118.L_CORE 0.001658
K_8138 X_NUC_41.L_CORE X_NUC_119.L_CORE 0.001660
K_8139 X_NUC_41.L_CORE X_NUC_120.L_CORE 0.001650
K_8140 X_NUC_41.L_CORE X_NUC_121.L_CORE 0.001406
K_8141 X_NUC_41.L_CORE X_NUC_122.L_CORE 0.001398
K_8142 X_NUC_41.L_CORE X_NUC_123.L_CORE 0.001399
K_8143 X_NUC_41.L_CORE X_NUC_124.L_CORE 0.001399
K_8144 X_NUC_41.L_CORE X_NUC_125.L_CORE 0.002646
K_8145 X_NUC_41.L_CORE X_NUC_126.L_CORE 0.002648
K_8146 X_NUC_41.L_CORE X_NUC_127.L_CORE 0.002625
K_8147 X_NUC_41.L_CORE X_NUC_128.L_CORE 0.002622
K_8148 X_NUC_41.L_CORE X_NUC_129.L_CORE 0.001347
K_8149 X_NUC_41.L_CORE X_NUC_130.L_CORE 0.001341
K_8150 X_NUC_41.L_CORE X_NUC_131.L_CORE 0.001343
K_8151 X_NUC_41.L_CORE X_NUC_132.L_CORE 0.001339
K_8152 X_NUC_41.L_CORE X_NUC_133.L_CORE 0.001733
K_8153 X_NUC_41.L_CORE X_NUC_134.L_CORE 0.001724
K_8154 X_NUC_41.L_CORE X_NUC_135.L_CORE 0.001719
K_8155 X_NUC_41.L_CORE X_NUC_136.L_CORE 0.001724
K_8156 X_NUC_41.L_CORE X_NUC_137.L_CORE 0.001870
K_8157 X_NUC_41.L_CORE X_NUC_138.L_CORE 0.001868
K_8158 X_NUC_41.L_CORE X_NUC_139.L_CORE 0.001864
K_8159 X_NUC_41.L_CORE X_NUC_140.L_CORE 0.001855
K_8160 X_NUC_41.L_CORE X_NUC_141.L_CORE 0.001317
K_8161 X_NUC_41.L_CORE X_NUC_142.L_CORE 0.001311
K_8162 X_NUC_41.L_CORE X_NUC_143.L_CORE 0.001311
K_8163 X_NUC_41.L_CORE X_NUC_144.L_CORE 0.001310
K_8164 X_NUC_41.L_CORE X_NUC_145.L_CORE 0.002061
K_8165 X_NUC_41.L_CORE X_NUC_146.L_CORE 0.002056
K_8166 X_NUC_41.L_CORE X_NUC_147.L_CORE 0.002043
K_8167 X_NUC_41.L_CORE X_NUC_148.L_CORE 0.002047
K_8168 X_NUC_41.L_CORE X_NUC_149.L_CORE 0.001455
K_8169 X_NUC_41.L_CORE X_NUC_150.L_CORE 0.001450
K_8170 X_NUC_41.L_CORE X_NUC_151.L_CORE 0.001450
K_8171 X_NUC_41.L_CORE X_NUC_152.L_CORE 0.001445
K_8172 X_NUC_41.L_CORE X_NUC_153.L_CORE 0.001464
K_8173 X_NUC_41.L_CORE X_NUC_154.L_CORE 0.001457
K_8174 X_NUC_41.L_CORE X_NUC_155.L_CORE 0.001454
K_8175 X_NUC_41.L_CORE X_NUC_156.L_CORE 0.001455
K_8176 X_NUC_41.L_CORE X_NUC_157.L_CORE 0.001830
K_8177 X_NUC_41.L_CORE X_NUC_158.L_CORE 0.001827
K_8178 X_NUC_41.L_CORE X_NUC_159.L_CORE 0.001820
K_8179 X_NUC_41.L_CORE X_NUC_160.L_CORE 0.001816
K_8180 X_NUC_41.L_CORE X_NUC_161.L_CORE 0.001357
K_8181 X_NUC_41.L_CORE X_NUC_162.L_CORE 0.001352
K_8182 X_NUC_41.L_CORE X_NUC_163.L_CORE 0.001351
K_8183 X_NUC_41.L_CORE X_NUC_164.L_CORE 0.001349
K_8184 X_NUC_41.L_CORE X_NUC_165.L_CORE 0.001612
K_8185 X_NUC_41.L_CORE X_NUC_166.L_CORE 0.001606
K_8186 X_NUC_41.L_CORE X_NUC_167.L_CORE 0.001601
K_8187 X_NUC_41.L_CORE X_NUC_168.L_CORE 0.001601
K_8188 X_NUC_41.L_CORE X_NUC_169.L_CORE 0.001519
K_8189 X_NUC_41.L_CORE X_NUC_170.L_CORE 0.001515
K_8190 X_NUC_41.L_CORE X_NUC_171.L_CORE 0.001512
K_8191 X_NUC_41.L_CORE X_NUC_172.L_CORE 0.001509
K_8192 X_NUC_41.L_CORE X_NUC_173.L_CORE 0.002700
K_8193 X_NUC_41.L_CORE X_NUC_174.L_CORE 0.001984
K_8194 X_NUC_41.L_CORE X_NUC_175.L_CORE 0.004050
K_8195 X_NUC_41.L_CORE X_NUC_176.L_CORE 0.002021
K_8196 X_NUC_41.L_CORE X_NUC_177.L_CORE 0.002094
K_8197 X_NUC_41.L_CORE X_NUC_178.L_CORE 0.004579
K_8198 X_NUC_41.L_CORE X_NUC_179.L_CORE 0.001617
K_8199 X_NUC_41.L_CORE X_NUC_180.L_CORE 0.003386
K_8200 X_NUC_41.L_CORE X_NUC_181.L_CORE 0.002267
K_8201 X_NUC_41.L_CORE X_NUC_182.L_CORE 0.001623
K_8202 X_NUC_41.L_CORE X_NUC_183.L_CORE 0.023433
K_8203 X_NUC_41.L_CORE X_NUC_184.L_CORE 0.001574
K_8204 X_NUC_41.L_CORE X_NUC_185.L_CORE 0.002136
K_8205 X_NUC_41.L_CORE X_NUC_186.L_CORE 0.003217
K_8206 X_NUC_41.L_CORE X_NUC_187.L_CORE 0.001416
K_8207 X_NUC_41.L_CORE X_NUC_188.L_CORE 0.004744
K_8208 X_NUC_41.L_CORE X_NUC_189.L_CORE 0.001735
K_8209 X_NUC_41.L_CORE X_NUC_190.L_CORE 0.001593
K_8210 X_NUC_41.L_CORE X_NUC_191.L_CORE 0.005900
K_8211 X_NUC_41.L_CORE X_NUC_192.L_CORE 0.001369
K_8212 X_NUC_41.L_CORE X_NUC_193.L_CORE 0.002372
K_8213 X_NUC_41.L_CORE X_NUC_194.L_CORE 0.002150
K_8214 X_NUC_41.L_CORE X_NUC_195.L_CORE 0.001358
K_8215 X_NUC_41.L_CORE X_NUC_196.L_CORE 0.004808
K_8216 X_NUC_41.L_CORE X_NUC_197.L_CORE 0.001449
K_8217 X_NUC_41.L_CORE X_NUC_198.L_CORE 0.001665
K_8218 X_NUC_41.L_CORE X_NUC_199.L_CORE 0.002878
K_8219 X_NUC_41.L_CORE X_NUC_200.L_CORE 0.001278
K_8220 X_NUC_41.L_CORE X_NUC_201.L_CORE 0.002568
K_8221 X_NUC_41.L_CORE X_NUC_202.L_CORE 0.001660
K_8222 X_NUC_41.L_CORE X_NUC_203.L_CORE 0.001373
K_8223 X_NUC_41.L_CORE X_NUC_204.L_CORE 0.003153
K_8224 X_NUC_41.L_CORE X_NUC_205.L_CORE 0.001306
K_8225 X_NUC_41.L_CORE X_NUC_206.L_CORE 0.001764
K_8226 X_NUC_41.L_CORE X_NUC_207.L_CORE 0.001973
K_8227 X_NUC_41.L_CORE X_NUC_208.L_CORE 0.001261
K_8228 X_NUC_41.L_CORE X_NUC_209.L_CORE 0.002388
K_8229 X_NUC_41.L_CORE X_NUC_210.L_CORE 0.001421
K_8230 X_NUC_41.L_CORE X_NUC_211.L_CORE 0.001430
K_8231 X_NUC_41.L_CORE X_NUC_212.L_CORE 0.002142
K_8232 X_NUC_41.L_CORE X_NUC_213.L_CORE 0.001258
K_8233 X_NUC_41.L_CORE X_NUC_214.L_CORE 0.001772
K_8234 X_NUC_41.L_CORE X_NUC_215.L_CORE 0.001576
K_8235 X_NUC_41.L_CORE X_NUC_216.L_CORE 0.001302
K_8236 X_NUC_41.L_CORE X_NUC_217.L_CORE 0.001897
K_8237 X_NUC_41.L_CORE X_NUC_218.L_CORE 0.001333
K_8238 X_NUC_41.L_CORE X_NUC_219.L_CORE 0.001470
K_8239 X_NUC_41.L_CORE X_NUC_220.L_CORE 0.001604
K_8240 X_NUC_41.L_CORE X_NUC_221.L_CORE 0.001325
K_8241 X_NUC_41.L_CORE X_NUC_222.L_CORE 0.001509
K_8242 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_8243 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_8244 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.001610
K_8245 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.001601
K_8246 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.001609
K_8247 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.001601
K_8248 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.002193
K_8249 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.002174
K_8250 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.002177
K_8251 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.002188
K_8252 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.003234
K_8253 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.003233
K_8254 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.003252
K_8255 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.003203
K_8256 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.001450
K_8257 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.001441
K_8258 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.001446
K_8259 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.001443
K_8260 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.004627
K_8261 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.004588
K_8262 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.004536
K_8263 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.004619
K_8264 X_NUC_42.L_CORE X_NUC_65.L_CORE 0.001764
K_8265 X_NUC_42.L_CORE X_NUC_66.L_CORE 0.001757
K_8266 X_NUC_42.L_CORE X_NUC_67.L_CORE 0.001765
K_8267 X_NUC_42.L_CORE X_NUC_68.L_CORE 0.001753
K_8268 X_NUC_42.L_CORE X_NUC_69.L_CORE 0.001631
K_8269 X_NUC_42.L_CORE X_NUC_70.L_CORE 0.001619
K_8270 X_NUC_42.L_CORE X_NUC_71.L_CORE 0.001621
K_8271 X_NUC_42.L_CORE X_NUC_72.L_CORE 0.001624
K_8272 X_NUC_42.L_CORE X_NUC_73.L_CORE 0.005072
K_8273 X_NUC_42.L_CORE X_NUC_74.L_CORE 0.005118
K_8274 X_NUC_42.L_CORE X_NUC_75.L_CORE 0.005066
K_8275 X_NUC_42.L_CORE X_NUC_76.L_CORE 0.004997
K_8276 X_NUC_42.L_CORE X_NUC_77.L_CORE 0.001402
K_8277 X_NUC_42.L_CORE X_NUC_78.L_CORE 0.001395
K_8278 X_NUC_42.L_CORE X_NUC_79.L_CORE 0.001399
K_8279 X_NUC_42.L_CORE X_NUC_80.L_CORE 0.001395
K_8280 X_NUC_42.L_CORE X_NUC_81.L_CORE 0.002370
K_8281 X_NUC_42.L_CORE X_NUC_82.L_CORE 0.002353
K_8282 X_NUC_42.L_CORE X_NUC_83.L_CORE 0.002345
K_8283 X_NUC_42.L_CORE X_NUC_84.L_CORE 0.002362
K_8284 X_NUC_42.L_CORE X_NUC_85.L_CORE 0.002140
K_8285 X_NUC_42.L_CORE X_NUC_86.L_CORE 0.002136
K_8286 X_NUC_42.L_CORE X_NUC_87.L_CORE 0.002141
K_8287 X_NUC_42.L_CORE X_NUC_88.L_CORE 0.002122
K_8288 X_NUC_42.L_CORE X_NUC_89.L_CORE 0.001394
K_8289 X_NUC_42.L_CORE X_NUC_90.L_CORE 0.001385
K_8290 X_NUC_42.L_CORE X_NUC_91.L_CORE 0.001388
K_8291 X_NUC_42.L_CORE X_NUC_92.L_CORE 0.001388
K_8292 X_NUC_42.L_CORE X_NUC_93.L_CORE 0.003994
K_8293 X_NUC_42.L_CORE X_NUC_94.L_CORE 0.003998
K_8294 X_NUC_42.L_CORE X_NUC_95.L_CORE 0.003933
K_8295 X_NUC_42.L_CORE X_NUC_96.L_CORE 0.003960
K_8296 X_NUC_42.L_CORE X_NUC_97.L_CORE 0.001480
K_8297 X_NUC_42.L_CORE X_NUC_98.L_CORE 0.001474
K_8298 X_NUC_42.L_CORE X_NUC_99.L_CORE 0.001478
K_8299 X_NUC_42.L_CORE X_NUC_100.L_CORE 0.001471
K_8300 X_NUC_42.L_CORE X_NUC_101.L_CORE 0.001689
K_8301 X_NUC_42.L_CORE X_NUC_102.L_CORE 0.001678
K_8302 X_NUC_42.L_CORE X_NUC_103.L_CORE 0.001677
K_8303 X_NUC_42.L_CORE X_NUC_104.L_CORE 0.001682
K_8304 X_NUC_42.L_CORE X_NUC_105.L_CORE 0.002654
K_8305 X_NUC_42.L_CORE X_NUC_106.L_CORE 0.002658
K_8306 X_NUC_42.L_CORE X_NUC_107.L_CORE 0.002648
K_8307 X_NUC_42.L_CORE X_NUC_108.L_CORE 0.002627
K_8308 X_NUC_42.L_CORE X_NUC_109.L_CORE 0.001320
K_8309 X_NUC_42.L_CORE X_NUC_110.L_CORE 0.001313
K_8310 X_NUC_42.L_CORE X_NUC_111.L_CORE 0.001315
K_8311 X_NUC_42.L_CORE X_NUC_112.L_CORE 0.001313
K_8312 X_NUC_42.L_CORE X_NUC_113.L_CORE 0.002406
K_8313 X_NUC_42.L_CORE X_NUC_114.L_CORE 0.002396
K_8314 X_NUC_42.L_CORE X_NUC_115.L_CORE 0.002379
K_8315 X_NUC_42.L_CORE X_NUC_116.L_CORE 0.002393
K_8316 X_NUC_42.L_CORE X_NUC_117.L_CORE 0.001667
K_8317 X_NUC_42.L_CORE X_NUC_118.L_CORE 0.001662
K_8318 X_NUC_42.L_CORE X_NUC_119.L_CORE 0.001664
K_8319 X_NUC_42.L_CORE X_NUC_120.L_CORE 0.001654
K_8320 X_NUC_42.L_CORE X_NUC_121.L_CORE 0.001415
K_8321 X_NUC_42.L_CORE X_NUC_122.L_CORE 0.001406
K_8322 X_NUC_42.L_CORE X_NUC_123.L_CORE 0.001407
K_8323 X_NUC_42.L_CORE X_NUC_124.L_CORE 0.001407
K_8324 X_NUC_42.L_CORE X_NUC_125.L_CORE 0.002644
K_8325 X_NUC_42.L_CORE X_NUC_126.L_CORE 0.002646
K_8326 X_NUC_42.L_CORE X_NUC_127.L_CORE 0.002624
K_8327 X_NUC_42.L_CORE X_NUC_128.L_CORE 0.002620
K_8328 X_NUC_42.L_CORE X_NUC_129.L_CORE 0.001353
K_8329 X_NUC_42.L_CORE X_NUC_130.L_CORE 0.001347
K_8330 X_NUC_42.L_CORE X_NUC_131.L_CORE 0.001349
K_8331 X_NUC_42.L_CORE X_NUC_132.L_CORE 0.001345
K_8332 X_NUC_42.L_CORE X_NUC_133.L_CORE 0.001742
K_8333 X_NUC_42.L_CORE X_NUC_134.L_CORE 0.001733
K_8334 X_NUC_42.L_CORE X_NUC_135.L_CORE 0.001727
K_8335 X_NUC_42.L_CORE X_NUC_136.L_CORE 0.001732
K_8336 X_NUC_42.L_CORE X_NUC_137.L_CORE 0.001873
K_8337 X_NUC_42.L_CORE X_NUC_138.L_CORE 0.001870
K_8338 X_NUC_42.L_CORE X_NUC_139.L_CORE 0.001867
K_8339 X_NUC_42.L_CORE X_NUC_140.L_CORE 0.001857
K_8340 X_NUC_42.L_CORE X_NUC_141.L_CORE 0.001324
K_8341 X_NUC_42.L_CORE X_NUC_142.L_CORE 0.001317
K_8342 X_NUC_42.L_CORE X_NUC_143.L_CORE 0.001318
K_8343 X_NUC_42.L_CORE X_NUC_144.L_CORE 0.001316
K_8344 X_NUC_42.L_CORE X_NUC_145.L_CORE 0.002066
K_8345 X_NUC_42.L_CORE X_NUC_146.L_CORE 0.002061
K_8346 X_NUC_42.L_CORE X_NUC_147.L_CORE 0.002048
K_8347 X_NUC_42.L_CORE X_NUC_148.L_CORE 0.002051
K_8348 X_NUC_42.L_CORE X_NUC_149.L_CORE 0.001459
K_8349 X_NUC_42.L_CORE X_NUC_150.L_CORE 0.001455
K_8350 X_NUC_42.L_CORE X_NUC_151.L_CORE 0.001455
K_8351 X_NUC_42.L_CORE X_NUC_152.L_CORE 0.001449
K_8352 X_NUC_42.L_CORE X_NUC_153.L_CORE 0.001471
K_8353 X_NUC_42.L_CORE X_NUC_154.L_CORE 0.001464
K_8354 X_NUC_42.L_CORE X_NUC_155.L_CORE 0.001461
K_8355 X_NUC_42.L_CORE X_NUC_156.L_CORE 0.001462
K_8356 X_NUC_42.L_CORE X_NUC_157.L_CORE 0.001833
K_8357 X_NUC_42.L_CORE X_NUC_158.L_CORE 0.001830
K_8358 X_NUC_42.L_CORE X_NUC_159.L_CORE 0.001823
K_8359 X_NUC_42.L_CORE X_NUC_160.L_CORE 0.001819
K_8360 X_NUC_42.L_CORE X_NUC_161.L_CORE 0.001363
K_8361 X_NUC_42.L_CORE X_NUC_162.L_CORE 0.001357
K_8362 X_NUC_42.L_CORE X_NUC_163.L_CORE 0.001357
K_8363 X_NUC_42.L_CORE X_NUC_164.L_CORE 0.001354
K_8364 X_NUC_42.L_CORE X_NUC_165.L_CORE 0.001617
K_8365 X_NUC_42.L_CORE X_NUC_166.L_CORE 0.001612
K_8366 X_NUC_42.L_CORE X_NUC_167.L_CORE 0.001606
K_8367 X_NUC_42.L_CORE X_NUC_168.L_CORE 0.001607
K_8368 X_NUC_42.L_CORE X_NUC_169.L_CORE 0.001524
K_8369 X_NUC_42.L_CORE X_NUC_170.L_CORE 0.001519
K_8370 X_NUC_42.L_CORE X_NUC_171.L_CORE 0.001516
K_8371 X_NUC_42.L_CORE X_NUC_172.L_CORE 0.001513
K_8372 X_NUC_42.L_CORE X_NUC_173.L_CORE 0.002724
K_8373 X_NUC_42.L_CORE X_NUC_174.L_CORE 0.002001
K_8374 X_NUC_42.L_CORE X_NUC_175.L_CORE 0.004106
K_8375 X_NUC_42.L_CORE X_NUC_176.L_CORE 0.002035
K_8376 X_NUC_42.L_CORE X_NUC_177.L_CORE 0.002114
K_8377 X_NUC_42.L_CORE X_NUC_178.L_CORE 0.004606
K_8378 X_NUC_42.L_CORE X_NUC_179.L_CORE 0.001629
K_8379 X_NUC_42.L_CORE X_NUC_180.L_CORE 0.003428
K_8380 X_NUC_42.L_CORE X_NUC_181.L_CORE 0.002278
K_8381 X_NUC_42.L_CORE X_NUC_182.L_CORE 0.001636
K_8382 X_NUC_42.L_CORE X_NUC_183.L_CORE 0.022992
K_8383 X_NUC_42.L_CORE X_NUC_184.L_CORE 0.001583
K_8384 X_NUC_42.L_CORE X_NUC_185.L_CORE 0.002155
K_8385 X_NUC_42.L_CORE X_NUC_186.L_CORE 0.003217
K_8386 X_NUC_42.L_CORE X_NUC_187.L_CORE 0.001425
K_8387 X_NUC_42.L_CORE X_NUC_188.L_CORE 0.004783
K_8388 X_NUC_42.L_CORE X_NUC_189.L_CORE 0.001742
K_8389 X_NUC_42.L_CORE X_NUC_190.L_CORE 0.001605
K_8390 X_NUC_42.L_CORE X_NUC_191.L_CORE 0.005813
K_8391 X_NUC_42.L_CORE X_NUC_192.L_CORE 0.001377
K_8392 X_NUC_42.L_CORE X_NUC_193.L_CORE 0.002390
K_8393 X_NUC_42.L_CORE X_NUC_194.L_CORE 0.002153
K_8394 X_NUC_42.L_CORE X_NUC_195.L_CORE 0.001366
K_8395 X_NUC_42.L_CORE X_NUC_196.L_CORE 0.004787
K_8396 X_NUC_42.L_CORE X_NUC_197.L_CORE 0.001455
K_8397 X_NUC_42.L_CORE X_NUC_198.L_CORE 0.001676
K_8398 X_NUC_42.L_CORE X_NUC_199.L_CORE 0.002869
K_8399 X_NUC_42.L_CORE X_NUC_200.L_CORE 0.001285
K_8400 X_NUC_42.L_CORE X_NUC_201.L_CORE 0.002579
K_8401 X_NUC_42.L_CORE X_NUC_202.L_CORE 0.001664
K_8402 X_NUC_42.L_CORE X_NUC_203.L_CORE 0.001381
K_8403 X_NUC_42.L_CORE X_NUC_204.L_CORE 0.003141
K_8404 X_NUC_42.L_CORE X_NUC_205.L_CORE 0.001312
K_8405 X_NUC_42.L_CORE X_NUC_206.L_CORE 0.001774
K_8406 X_NUC_42.L_CORE X_NUC_207.L_CORE 0.001974
K_8407 X_NUC_42.L_CORE X_NUC_208.L_CORE 0.001268
K_8408 X_NUC_42.L_CORE X_NUC_209.L_CORE 0.002391
K_8409 X_NUC_42.L_CORE X_NUC_210.L_CORE 0.001425
K_8410 X_NUC_42.L_CORE X_NUC_211.L_CORE 0.001437
K_8411 X_NUC_42.L_CORE X_NUC_212.L_CORE 0.002141
K_8412 X_NUC_42.L_CORE X_NUC_213.L_CORE 0.001263
K_8413 X_NUC_42.L_CORE X_NUC_214.L_CORE 0.001778
K_8414 X_NUC_42.L_CORE X_NUC_215.L_CORE 0.001579
K_8415 X_NUC_42.L_CORE X_NUC_216.L_CORE 0.001308
K_8416 X_NUC_42.L_CORE X_NUC_217.L_CORE 0.001899
K_8417 X_NUC_42.L_CORE X_NUC_218.L_CORE 0.001337
K_8418 X_NUC_42.L_CORE X_NUC_219.L_CORE 0.001476
K_8419 X_NUC_42.L_CORE X_NUC_220.L_CORE 0.001607
K_8420 X_NUC_42.L_CORE X_NUC_221.L_CORE 0.001330
K_8421 X_NUC_42.L_CORE X_NUC_222.L_CORE 0.001514
K_8422 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_8423 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.001602
K_8424 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.001592
K_8425 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.001601
K_8426 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.001593
K_8427 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.002190
K_8428 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.002170
K_8429 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.002174
K_8430 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.002185
K_8431 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.003215
K_8432 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.003213
K_8433 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.003233
K_8434 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.003184
K_8435 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.001445
K_8436 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.001435
K_8437 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.001441
K_8438 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.001438
K_8439 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.004680
K_8440 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.004639
K_8441 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.004588
K_8442 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.004673
K_8443 X_NUC_43.L_CORE X_NUC_65.L_CORE 0.001756
K_8444 X_NUC_43.L_CORE X_NUC_66.L_CORE 0.001749
K_8445 X_NUC_43.L_CORE X_NUC_67.L_CORE 0.001757
K_8446 X_NUC_43.L_CORE X_NUC_68.L_CORE 0.001745
K_8447 X_NUC_43.L_CORE X_NUC_69.L_CORE 0.001628
K_8448 X_NUC_43.L_CORE X_NUC_70.L_CORE 0.001616
K_8449 X_NUC_43.L_CORE X_NUC_71.L_CORE 0.001619
K_8450 X_NUC_43.L_CORE X_NUC_72.L_CORE 0.001622
K_8451 X_NUC_43.L_CORE X_NUC_73.L_CORE 0.005122
K_8452 X_NUC_43.L_CORE X_NUC_74.L_CORE 0.005168
K_8453 X_NUC_43.L_CORE X_NUC_75.L_CORE 0.005118
K_8454 X_NUC_43.L_CORE X_NUC_76.L_CORE 0.005045
K_8455 X_NUC_43.L_CORE X_NUC_77.L_CORE 0.001398
K_8456 X_NUC_43.L_CORE X_NUC_78.L_CORE 0.001390
K_8457 X_NUC_43.L_CORE X_NUC_79.L_CORE 0.001395
K_8458 X_NUC_43.L_CORE X_NUC_80.L_CORE 0.001390
K_8459 X_NUC_43.L_CORE X_NUC_81.L_CORE 0.002378
K_8460 X_NUC_43.L_CORE X_NUC_82.L_CORE 0.002360
K_8461 X_NUC_43.L_CORE X_NUC_83.L_CORE 0.002353
K_8462 X_NUC_43.L_CORE X_NUC_84.L_CORE 0.002370
K_8463 X_NUC_43.L_CORE X_NUC_85.L_CORE 0.002135
K_8464 X_NUC_43.L_CORE X_NUC_86.L_CORE 0.002131
K_8465 X_NUC_43.L_CORE X_NUC_87.L_CORE 0.002136
K_8466 X_NUC_43.L_CORE X_NUC_88.L_CORE 0.002117
K_8467 X_NUC_43.L_CORE X_NUC_89.L_CORE 0.001391
K_8468 X_NUC_43.L_CORE X_NUC_90.L_CORE 0.001383
K_8469 X_NUC_43.L_CORE X_NUC_91.L_CORE 0.001385
K_8470 X_NUC_43.L_CORE X_NUC_92.L_CORE 0.001385
K_8471 X_NUC_43.L_CORE X_NUC_93.L_CORE 0.004062
K_8472 X_NUC_43.L_CORE X_NUC_94.L_CORE 0.004066
K_8473 X_NUC_43.L_CORE X_NUC_95.L_CORE 0.003998
K_8474 X_NUC_43.L_CORE X_NUC_96.L_CORE 0.004026
K_8475 X_NUC_43.L_CORE X_NUC_97.L_CORE 0.001476
K_8476 X_NUC_43.L_CORE X_NUC_98.L_CORE 0.001470
K_8477 X_NUC_43.L_CORE X_NUC_99.L_CORE 0.001474
K_8478 X_NUC_43.L_CORE X_NUC_100.L_CORE 0.001467
K_8479 X_NUC_43.L_CORE X_NUC_101.L_CORE 0.001691
K_8480 X_NUC_43.L_CORE X_NUC_102.L_CORE 0.001680
K_8481 X_NUC_43.L_CORE X_NUC_103.L_CORE 0.001678
K_8482 X_NUC_43.L_CORE X_NUC_104.L_CORE 0.001683
K_8483 X_NUC_43.L_CORE X_NUC_105.L_CORE 0.002663
K_8484 X_NUC_43.L_CORE X_NUC_106.L_CORE 0.002667
K_8485 X_NUC_43.L_CORE X_NUC_107.L_CORE 0.002658
K_8486 X_NUC_43.L_CORE X_NUC_108.L_CORE 0.002636
K_8487 X_NUC_43.L_CORE X_NUC_109.L_CORE 0.001317
K_8488 X_NUC_43.L_CORE X_NUC_110.L_CORE 0.001310
K_8489 X_NUC_43.L_CORE X_NUC_111.L_CORE 0.001313
K_8490 X_NUC_43.L_CORE X_NUC_112.L_CORE 0.001310
K_8491 X_NUC_43.L_CORE X_NUC_113.L_CORE 0.002423
K_8492 X_NUC_43.L_CORE X_NUC_114.L_CORE 0.002413
K_8493 X_NUC_43.L_CORE X_NUC_115.L_CORE 0.002396
K_8494 X_NUC_43.L_CORE X_NUC_116.L_CORE 0.002410
K_8495 X_NUC_43.L_CORE X_NUC_117.L_CORE 0.001665
K_8496 X_NUC_43.L_CORE X_NUC_118.L_CORE 0.001660
K_8497 X_NUC_43.L_CORE X_NUC_119.L_CORE 0.001662
K_8498 X_NUC_43.L_CORE X_NUC_120.L_CORE 0.001652
K_8499 X_NUC_43.L_CORE X_NUC_121.L_CORE 0.001414
K_8500 X_NUC_43.L_CORE X_NUC_122.L_CORE 0.001406
K_8501 X_NUC_43.L_CORE X_NUC_123.L_CORE 0.001406
K_8502 X_NUC_43.L_CORE X_NUC_124.L_CORE 0.001407
K_8503 X_NUC_43.L_CORE X_NUC_125.L_CORE 0.002667
K_8504 X_NUC_43.L_CORE X_NUC_126.L_CORE 0.002669
K_8505 X_NUC_43.L_CORE X_NUC_127.L_CORE 0.002646
K_8506 X_NUC_43.L_CORE X_NUC_128.L_CORE 0.002642
K_8507 X_NUC_43.L_CORE X_NUC_129.L_CORE 0.001351
K_8508 X_NUC_43.L_CORE X_NUC_130.L_CORE 0.001345
K_8509 X_NUC_43.L_CORE X_NUC_131.L_CORE 0.001347
K_8510 X_NUC_43.L_CORE X_NUC_132.L_CORE 0.001343
K_8511 X_NUC_43.L_CORE X_NUC_133.L_CORE 0.001747
K_8512 X_NUC_43.L_CORE X_NUC_134.L_CORE 0.001738
K_8513 X_NUC_43.L_CORE X_NUC_135.L_CORE 0.001733
K_8514 X_NUC_43.L_CORE X_NUC_136.L_CORE 0.001738
K_8515 X_NUC_43.L_CORE X_NUC_137.L_CORE 0.001876
K_8516 X_NUC_43.L_CORE X_NUC_138.L_CORE 0.001874
K_8517 X_NUC_43.L_CORE X_NUC_139.L_CORE 0.001870
K_8518 X_NUC_43.L_CORE X_NUC_140.L_CORE 0.001861
K_8519 X_NUC_43.L_CORE X_NUC_141.L_CORE 0.001323
K_8520 X_NUC_43.L_CORE X_NUC_142.L_CORE 0.001317
K_8521 X_NUC_43.L_CORE X_NUC_143.L_CORE 0.001317
K_8522 X_NUC_43.L_CORE X_NUC_144.L_CORE 0.001316
K_8523 X_NUC_43.L_CORE X_NUC_145.L_CORE 0.002079
K_8524 X_NUC_43.L_CORE X_NUC_146.L_CORE 0.002074
K_8525 X_NUC_43.L_CORE X_NUC_147.L_CORE 0.002061
K_8526 X_NUC_43.L_CORE X_NUC_148.L_CORE 0.002064
K_8527 X_NUC_43.L_CORE X_NUC_149.L_CORE 0.001459
K_8528 X_NUC_43.L_CORE X_NUC_150.L_CORE 0.001455
K_8529 X_NUC_43.L_CORE X_NUC_151.L_CORE 0.001455
K_8530 X_NUC_43.L_CORE X_NUC_152.L_CORE 0.001449
K_8531 X_NUC_43.L_CORE X_NUC_153.L_CORE 0.001473
K_8532 X_NUC_43.L_CORE X_NUC_154.L_CORE 0.001466
K_8533 X_NUC_43.L_CORE X_NUC_155.L_CORE 0.001464
K_8534 X_NUC_43.L_CORE X_NUC_156.L_CORE 0.001465
K_8535 X_NUC_43.L_CORE X_NUC_157.L_CORE 0.001840
K_8536 X_NUC_43.L_CORE X_NUC_158.L_CORE 0.001837
K_8537 X_NUC_43.L_CORE X_NUC_159.L_CORE 0.001830
K_8538 X_NUC_43.L_CORE X_NUC_160.L_CORE 0.001826
K_8539 X_NUC_43.L_CORE X_NUC_161.L_CORE 0.001363
K_8540 X_NUC_43.L_CORE X_NUC_162.L_CORE 0.001358
K_8541 X_NUC_43.L_CORE X_NUC_163.L_CORE 0.001357
K_8542 X_NUC_43.L_CORE X_NUC_164.L_CORE 0.001354
K_8543 X_NUC_43.L_CORE X_NUC_165.L_CORE 0.001623
K_8544 X_NUC_43.L_CORE X_NUC_166.L_CORE 0.001617
K_8545 X_NUC_43.L_CORE X_NUC_167.L_CORE 0.001612
K_8546 X_NUC_43.L_CORE X_NUC_168.L_CORE 0.001612
K_8547 X_NUC_43.L_CORE X_NUC_169.L_CORE 0.001527
K_8548 X_NUC_43.L_CORE X_NUC_170.L_CORE 0.001522
K_8549 X_NUC_43.L_CORE X_NUC_171.L_CORE 0.001519
K_8550 X_NUC_43.L_CORE X_NUC_172.L_CORE 0.001516
K_8551 X_NUC_43.L_CORE X_NUC_173.L_CORE 0.002690
K_8552 X_NUC_43.L_CORE X_NUC_174.L_CORE 0.001985
K_8553 X_NUC_43.L_CORE X_NUC_175.L_CORE 0.004038
K_8554 X_NUC_43.L_CORE X_NUC_176.L_CORE 0.002017
K_8555 X_NUC_43.L_CORE X_NUC_177.L_CORE 0.002101
K_8556 X_NUC_43.L_CORE X_NUC_178.L_CORE 0.004514
K_8557 X_NUC_43.L_CORE X_NUC_179.L_CORE 0.001619
K_8558 X_NUC_43.L_CORE X_NUC_180.L_CORE 0.003411
K_8559 X_NUC_43.L_CORE X_NUC_181.L_CORE 0.002258
K_8560 X_NUC_43.L_CORE X_NUC_182.L_CORE 0.001629
K_8561 X_NUC_43.L_CORE X_NUC_183.L_CORE 0.021603
K_8562 X_NUC_43.L_CORE X_NUC_184.L_CORE 0.001575
K_8563 X_NUC_43.L_CORE X_NUC_185.L_CORE 0.002151
K_8564 X_NUC_43.L_CORE X_NUC_186.L_CORE 0.003193
K_8565 X_NUC_43.L_CORE X_NUC_187.L_CORE 0.001420
K_8566 X_NUC_43.L_CORE X_NUC_188.L_CORE 0.004829
K_8567 X_NUC_43.L_CORE X_NUC_189.L_CORE 0.001733
K_8568 X_NUC_43.L_CORE X_NUC_190.L_CORE 0.001602
K_8569 X_NUC_43.L_CORE X_NUC_191.L_CORE 0.005862
K_8570 X_NUC_43.L_CORE X_NUC_192.L_CORE 0.001371
K_8571 X_NUC_43.L_CORE X_NUC_193.L_CORE 0.002396
K_8572 X_NUC_43.L_CORE X_NUC_194.L_CORE 0.002146
K_8573 X_NUC_43.L_CORE X_NUC_195.L_CORE 0.001363
K_8574 X_NUC_43.L_CORE X_NUC_196.L_CORE 0.004893
K_8575 X_NUC_43.L_CORE X_NUC_197.L_CORE 0.001450
K_8576 X_NUC_43.L_CORE X_NUC_198.L_CORE 0.001676
K_8577 X_NUC_43.L_CORE X_NUC_199.L_CORE 0.002877
K_8578 X_NUC_43.L_CORE X_NUC_200.L_CORE 0.001282
K_8579 X_NUC_43.L_CORE X_NUC_201.L_CORE 0.002599
K_8580 X_NUC_43.L_CORE X_NUC_202.L_CORE 0.001661
K_8581 X_NUC_43.L_CORE X_NUC_203.L_CORE 0.001380
K_8582 X_NUC_43.L_CORE X_NUC_204.L_CORE 0.003178
K_8583 X_NUC_43.L_CORE X_NUC_205.L_CORE 0.001309
K_8584 X_NUC_43.L_CORE X_NUC_206.L_CORE 0.001779
K_8585 X_NUC_43.L_CORE X_NUC_207.L_CORE 0.001976
K_8586 X_NUC_43.L_CORE X_NUC_208.L_CORE 0.001266
K_8587 X_NUC_43.L_CORE X_NUC_209.L_CORE 0.002413
K_8588 X_NUC_43.L_CORE X_NUC_210.L_CORE 0.001424
K_8589 X_NUC_43.L_CORE X_NUC_211.L_CORE 0.001439
K_8590 X_NUC_43.L_CORE X_NUC_212.L_CORE 0.002152
K_8591 X_NUC_43.L_CORE X_NUC_213.L_CORE 0.001262
K_8592 X_NUC_43.L_CORE X_NUC_214.L_CORE 0.001787
K_8593 X_NUC_43.L_CORE X_NUC_215.L_CORE 0.001580
K_8594 X_NUC_43.L_CORE X_NUC_216.L_CORE 0.001309
K_8595 X_NUC_43.L_CORE X_NUC_217.L_CORE 0.001910
K_8596 X_NUC_43.L_CORE X_NUC_218.L_CORE 0.001337
K_8597 X_NUC_43.L_CORE X_NUC_219.L_CORE 0.001480
K_8598 X_NUC_43.L_CORE X_NUC_220.L_CORE 0.001612
K_8599 X_NUC_43.L_CORE X_NUC_221.L_CORE 0.001331
K_8600 X_NUC_43.L_CORE X_NUC_222.L_CORE 0.001518
K_8601 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.001610
K_8602 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.001601
K_8603 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.001609
K_8604 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.001601
K_8605 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.002179
K_8606 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.002159
K_8607 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.002162
K_8608 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.002174
K_8609 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.003265
K_8610 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.003263
K_8611 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.003283
K_8612 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.003233
K_8613 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.001447
K_8614 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.001438
K_8615 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.001443
K_8616 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.001441
K_8617 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.004594
K_8618 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.004555
K_8619 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.004506
K_8620 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.004588
K_8621 X_NUC_44.L_CORE X_NUC_65.L_CORE 0.001769
K_8622 X_NUC_44.L_CORE X_NUC_66.L_CORE 0.001762
K_8623 X_NUC_44.L_CORE X_NUC_67.L_CORE 0.001770
K_8624 X_NUC_44.L_CORE X_NUC_68.L_CORE 0.001757
K_8625 X_NUC_44.L_CORE X_NUC_69.L_CORE 0.001625
K_8626 X_NUC_44.L_CORE X_NUC_70.L_CORE 0.001613
K_8627 X_NUC_44.L_CORE X_NUC_71.L_CORE 0.001616
K_8628 X_NUC_44.L_CORE X_NUC_72.L_CORE 0.001619
K_8629 X_NUC_44.L_CORE X_NUC_73.L_CORE 0.005197
K_8630 X_NUC_44.L_CORE X_NUC_74.L_CORE 0.005245
K_8631 X_NUC_44.L_CORE X_NUC_75.L_CORE 0.005191
K_8632 X_NUC_44.L_CORE X_NUC_76.L_CORE 0.005118
K_8633 X_NUC_44.L_CORE X_NUC_77.L_CORE 0.001402
K_8634 X_NUC_44.L_CORE X_NUC_78.L_CORE 0.001395
K_8635 X_NUC_44.L_CORE X_NUC_79.L_CORE 0.001399
K_8636 X_NUC_44.L_CORE X_NUC_80.L_CORE 0.001395
K_8637 X_NUC_44.L_CORE X_NUC_81.L_CORE 0.002361
K_8638 X_NUC_44.L_CORE X_NUC_82.L_CORE 0.002344
K_8639 X_NUC_44.L_CORE X_NUC_83.L_CORE 0.002336
K_8640 X_NUC_44.L_CORE X_NUC_84.L_CORE 0.002353
K_8641 X_NUC_44.L_CORE X_NUC_85.L_CORE 0.002155
K_8642 X_NUC_44.L_CORE X_NUC_86.L_CORE 0.002151
K_8643 X_NUC_44.L_CORE X_NUC_87.L_CORE 0.002156
K_8644 X_NUC_44.L_CORE X_NUC_88.L_CORE 0.002136
K_8645 X_NUC_44.L_CORE X_NUC_89.L_CORE 0.001392
K_8646 X_NUC_44.L_CORE X_NUC_90.L_CORE 0.001383
K_8647 X_NUC_44.L_CORE X_NUC_91.L_CORE 0.001386
K_8648 X_NUC_44.L_CORE X_NUC_92.L_CORE 0.001385
K_8649 X_NUC_44.L_CORE X_NUC_93.L_CORE 0.004032
K_8650 X_NUC_44.L_CORE X_NUC_94.L_CORE 0.004036
K_8651 X_NUC_44.L_CORE X_NUC_95.L_CORE 0.003970
K_8652 X_NUC_44.L_CORE X_NUC_96.L_CORE 0.003998
K_8653 X_NUC_44.L_CORE X_NUC_97.L_CORE 0.001483
K_8654 X_NUC_44.L_CORE X_NUC_98.L_CORE 0.001477
K_8655 X_NUC_44.L_CORE X_NUC_99.L_CORE 0.001481
K_8656 X_NUC_44.L_CORE X_NUC_100.L_CORE 0.001474
K_8657 X_NUC_44.L_CORE X_NUC_101.L_CORE 0.001686
K_8658 X_NUC_44.L_CORE X_NUC_102.L_CORE 0.001675
K_8659 X_NUC_44.L_CORE X_NUC_103.L_CORE 0.001673
K_8660 X_NUC_44.L_CORE X_NUC_104.L_CORE 0.001678
K_8661 X_NUC_44.L_CORE X_NUC_105.L_CORE 0.002685
K_8662 X_NUC_44.L_CORE X_NUC_106.L_CORE 0.002689
K_8663 X_NUC_44.L_CORE X_NUC_107.L_CORE 0.002679
K_8664 X_NUC_44.L_CORE X_NUC_108.L_CORE 0.002658
K_8665 X_NUC_44.L_CORE X_NUC_109.L_CORE 0.001320
K_8666 X_NUC_44.L_CORE X_NUC_110.L_CORE 0.001313
K_8667 X_NUC_44.L_CORE X_NUC_111.L_CORE 0.001316
K_8668 X_NUC_44.L_CORE X_NUC_112.L_CORE 0.001313
K_8669 X_NUC_44.L_CORE X_NUC_113.L_CORE 0.002409
K_8670 X_NUC_44.L_CORE X_NUC_114.L_CORE 0.002398
K_8671 X_NUC_44.L_CORE X_NUC_115.L_CORE 0.002381
K_8672 X_NUC_44.L_CORE X_NUC_116.L_CORE 0.002396
K_8673 X_NUC_44.L_CORE X_NUC_117.L_CORE 0.001675
K_8674 X_NUC_44.L_CORE X_NUC_118.L_CORE 0.001670
K_8675 X_NUC_44.L_CORE X_NUC_119.L_CORE 0.001672
K_8676 X_NUC_44.L_CORE X_NUC_120.L_CORE 0.001662
K_8677 X_NUC_44.L_CORE X_NUC_121.L_CORE 0.001413
K_8678 X_NUC_44.L_CORE X_NUC_122.L_CORE 0.001405
K_8679 X_NUC_44.L_CORE X_NUC_123.L_CORE 0.001405
K_8680 X_NUC_44.L_CORE X_NUC_124.L_CORE 0.001406
K_8681 X_NUC_44.L_CORE X_NUC_125.L_CORE 0.002671
K_8682 X_NUC_44.L_CORE X_NUC_126.L_CORE 0.002673
K_8683 X_NUC_44.L_CORE X_NUC_127.L_CORE 0.002650
K_8684 X_NUC_44.L_CORE X_NUC_128.L_CORE 0.002646
K_8685 X_NUC_44.L_CORE X_NUC_129.L_CORE 0.001356
K_8686 X_NUC_44.L_CORE X_NUC_130.L_CORE 0.001350
K_8687 X_NUC_44.L_CORE X_NUC_131.L_CORE 0.001352
K_8688 X_NUC_44.L_CORE X_NUC_132.L_CORE 0.001347
K_8689 X_NUC_44.L_CORE X_NUC_133.L_CORE 0.001742
K_8690 X_NUC_44.L_CORE X_NUC_134.L_CORE 0.001733
K_8691 X_NUC_44.L_CORE X_NUC_135.L_CORE 0.001728
K_8692 X_NUC_44.L_CORE X_NUC_136.L_CORE 0.001733
K_8693 X_NUC_44.L_CORE X_NUC_137.L_CORE 0.001886
K_8694 X_NUC_44.L_CORE X_NUC_138.L_CORE 0.001884
K_8695 X_NUC_44.L_CORE X_NUC_139.L_CORE 0.001880
K_8696 X_NUC_44.L_CORE X_NUC_140.L_CORE 0.001870
K_8697 X_NUC_44.L_CORE X_NUC_141.L_CORE 0.001325
K_8698 X_NUC_44.L_CORE X_NUC_142.L_CORE 0.001318
K_8699 X_NUC_44.L_CORE X_NUC_143.L_CORE 0.001318
K_8700 X_NUC_44.L_CORE X_NUC_144.L_CORE 0.001317
K_8701 X_NUC_44.L_CORE X_NUC_145.L_CORE 0.002076
K_8702 X_NUC_44.L_CORE X_NUC_146.L_CORE 0.002071
K_8703 X_NUC_44.L_CORE X_NUC_147.L_CORE 0.002057
K_8704 X_NUC_44.L_CORE X_NUC_148.L_CORE 0.002061
K_8705 X_NUC_44.L_CORE X_NUC_149.L_CORE 0.001465
K_8706 X_NUC_44.L_CORE X_NUC_150.L_CORE 0.001460
K_8707 X_NUC_44.L_CORE X_NUC_151.L_CORE 0.001460
K_8708 X_NUC_44.L_CORE X_NUC_152.L_CORE 0.001455
K_8709 X_NUC_44.L_CORE X_NUC_153.L_CORE 0.001472
K_8710 X_NUC_44.L_CORE X_NUC_154.L_CORE 0.001465
K_8711 X_NUC_44.L_CORE X_NUC_155.L_CORE 0.001463
K_8712 X_NUC_44.L_CORE X_NUC_156.L_CORE 0.001464
K_8713 X_NUC_44.L_CORE X_NUC_157.L_CORE 0.001844
K_8714 X_NUC_44.L_CORE X_NUC_158.L_CORE 0.001841
K_8715 X_NUC_44.L_CORE X_NUC_159.L_CORE 0.001834
K_8716 X_NUC_44.L_CORE X_NUC_160.L_CORE 0.001830
K_8717 X_NUC_44.L_CORE X_NUC_161.L_CORE 0.001366
K_8718 X_NUC_44.L_CORE X_NUC_162.L_CORE 0.001360
K_8719 X_NUC_44.L_CORE X_NUC_163.L_CORE 0.001360
K_8720 X_NUC_44.L_CORE X_NUC_164.L_CORE 0.001357
K_8721 X_NUC_44.L_CORE X_NUC_165.L_CORE 0.001622
K_8722 X_NUC_44.L_CORE X_NUC_166.L_CORE 0.001616
K_8723 X_NUC_44.L_CORE X_NUC_167.L_CORE 0.001611
K_8724 X_NUC_44.L_CORE X_NUC_168.L_CORE 0.001612
K_8725 X_NUC_44.L_CORE X_NUC_169.L_CORE 0.001530
K_8726 X_NUC_44.L_CORE X_NUC_170.L_CORE 0.001526
K_8727 X_NUC_44.L_CORE X_NUC_171.L_CORE 0.001522
K_8728 X_NUC_44.L_CORE X_NUC_172.L_CORE 0.001519
K_8729 X_NUC_44.L_CORE X_NUC_173.L_CORE 0.002706
K_8730 X_NUC_44.L_CORE X_NUC_174.L_CORE 0.001989
K_8731 X_NUC_44.L_CORE X_NUC_175.L_CORE 0.004037
K_8732 X_NUC_44.L_CORE X_NUC_176.L_CORE 0.002030
K_8733 X_NUC_44.L_CORE X_NUC_177.L_CORE 0.002097
K_8734 X_NUC_44.L_CORE X_NUC_178.L_CORE 0.004590
K_8735 X_NUC_44.L_CORE X_NUC_179.L_CORE 0.001624
K_8736 X_NUC_44.L_CORE X_NUC_180.L_CORE 0.003379
K_8737 X_NUC_44.L_CORE X_NUC_181.L_CORE 0.002281
K_8738 X_NUC_44.L_CORE X_NUC_182.L_CORE 0.001629
K_8739 X_NUC_44.L_CORE X_NUC_183.L_CORE 0.021475
K_8740 X_NUC_44.L_CORE X_NUC_184.L_CORE 0.001583
K_8741 X_NUC_44.L_CORE X_NUC_185.L_CORE 0.002140
K_8742 X_NUC_44.L_CORE X_NUC_186.L_CORE 0.003242
K_8743 X_NUC_44.L_CORE X_NUC_187.L_CORE 0.001422
K_8744 X_NUC_44.L_CORE X_NUC_188.L_CORE 0.004728
K_8745 X_NUC_44.L_CORE X_NUC_189.L_CORE 0.001746
K_8746 X_NUC_44.L_CORE X_NUC_190.L_CORE 0.001599
K_8747 X_NUC_44.L_CORE X_NUC_191.L_CORE 0.005975
K_8748 X_NUC_44.L_CORE X_NUC_192.L_CORE 0.001376
K_8749 X_NUC_44.L_CORE X_NUC_193.L_CORE 0.002377
K_8750 X_NUC_44.L_CORE X_NUC_194.L_CORE 0.002167
K_8751 X_NUC_44.L_CORE X_NUC_195.L_CORE 0.001363
K_8752 X_NUC_44.L_CORE X_NUC_196.L_CORE 0.004833
K_8753 X_NUC_44.L_CORE X_NUC_197.L_CORE 0.001458
K_8754 X_NUC_44.L_CORE X_NUC_198.L_CORE 0.001670
K_8755 X_NUC_44.L_CORE X_NUC_199.L_CORE 0.002907
K_8756 X_NUC_44.L_CORE X_NUC_200.L_CORE 0.001285
K_8757 X_NUC_44.L_CORE X_NUC_201.L_CORE 0.002577
K_8758 X_NUC_44.L_CORE X_NUC_202.L_CORE 0.001672
K_8759 X_NUC_44.L_CORE X_NUC_203.L_CORE 0.001379
K_8760 X_NUC_44.L_CORE X_NUC_204.L_CORE 0.003182
K_8761 X_NUC_44.L_CORE X_NUC_205.L_CORE 0.001314
K_8762 X_NUC_44.L_CORE X_NUC_206.L_CORE 0.001772
K_8763 X_NUC_44.L_CORE X_NUC_207.L_CORE 0.001990
K_8764 X_NUC_44.L_CORE X_NUC_208.L_CORE 0.001267
K_8765 X_NUC_44.L_CORE X_NUC_209.L_CORE 0.002403
K_8766 X_NUC_44.L_CORE X_NUC_210.L_CORE 0.001430
K_8767 X_NUC_44.L_CORE X_NUC_211.L_CORE 0.001436
K_8768 X_NUC_44.L_CORE X_NUC_212.L_CORE 0.002160
K_8769 X_NUC_44.L_CORE X_NUC_213.L_CORE 0.001265
K_8770 X_NUC_44.L_CORE X_NUC_214.L_CORE 0.001781
K_8771 X_NUC_44.L_CORE X_NUC_215.L_CORE 0.001587
K_8772 X_NUC_44.L_CORE X_NUC_216.L_CORE 0.001309
K_8773 X_NUC_44.L_CORE X_NUC_217.L_CORE 0.001910
K_8774 X_NUC_44.L_CORE X_NUC_218.L_CORE 0.001341
K_8775 X_NUC_44.L_CORE X_NUC_219.L_CORE 0.001479
K_8776 X_NUC_44.L_CORE X_NUC_220.L_CORE 0.001616
K_8777 X_NUC_44.L_CORE X_NUC_221.L_CORE 0.001333
K_8778 X_NUC_44.L_CORE X_NUC_222.L_CORE 0.001519
K_8779 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_8780 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_8781 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_8782 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.001557
K_8783 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.001558
K_8784 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.001552
K_8785 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.001563
K_8786 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.002119
K_8787 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.002140
K_8788 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.002126
K_8789 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.002131
K_8790 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.003161
K_8791 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.003131
K_8792 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.003122
K_8793 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.003158
K_8794 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.001409
K_8795 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.001414
K_8796 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.001407
K_8797 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.001415
K_8798 X_NUC_45.L_CORE X_NUC_65.L_CORE 0.004528
K_8799 X_NUC_45.L_CORE X_NUC_66.L_CORE 0.004613
K_8800 X_NUC_45.L_CORE X_NUC_67.L_CORE 0.004557
K_8801 X_NUC_45.L_CORE X_NUC_68.L_CORE 0.004525
K_8802 X_NUC_45.L_CORE X_NUC_69.L_CORE 0.001725
K_8803 X_NUC_45.L_CORE X_NUC_70.L_CORE 0.001722
K_8804 X_NUC_45.L_CORE X_NUC_71.L_CORE 0.001715
K_8805 X_NUC_45.L_CORE X_NUC_72.L_CORE 0.001729
K_8806 X_NUC_45.L_CORE X_NUC_73.L_CORE 0.001591
K_8807 X_NUC_45.L_CORE X_NUC_74.L_CORE 0.001602
K_8808 X_NUC_45.L_CORE X_NUC_75.L_CORE 0.001592
K_8809 X_NUC_45.L_CORE X_NUC_76.L_CORE 0.001598
K_8810 X_NUC_45.L_CORE X_NUC_77.L_CORE 0.005130
K_8811 X_NUC_45.L_CORE X_NUC_78.L_CORE 0.005050
K_8812 X_NUC_45.L_CORE X_NUC_79.L_CORE 0.005013
K_8813 X_NUC_45.L_CORE X_NUC_80.L_CORE 0.005039
K_8814 X_NUC_45.L_CORE X_NUC_81.L_CORE 0.001374
K_8815 X_NUC_45.L_CORE X_NUC_82.L_CORE 0.001376
K_8816 X_NUC_45.L_CORE X_NUC_83.L_CORE 0.001370
K_8817 X_NUC_45.L_CORE X_NUC_84.L_CORE 0.001378
K_8818 X_NUC_45.L_CORE X_NUC_85.L_CORE 0.002329
K_8819 X_NUC_45.L_CORE X_NUC_86.L_CORE 0.002353
K_8820 X_NUC_45.L_CORE X_NUC_87.L_CORE 0.002334
K_8821 X_NUC_45.L_CORE X_NUC_88.L_CORE 0.002333
K_8822 X_NUC_45.L_CORE X_NUC_89.L_CORE 0.002116
K_8823 X_NUC_45.L_CORE X_NUC_90.L_CORE 0.002106
K_8824 X_NUC_45.L_CORE X_NUC_91.L_CORE 0.002097
K_8825 X_NUC_45.L_CORE X_NUC_92.L_CORE 0.002113
K_8826 X_NUC_45.L_CORE X_NUC_93.L_CORE 0.001370
K_8827 X_NUC_45.L_CORE X_NUC_94.L_CORE 0.001376
K_8828 X_NUC_45.L_CORE X_NUC_95.L_CORE 0.001368
K_8829 X_NUC_45.L_CORE X_NUC_96.L_CORE 0.001374
K_8830 X_NUC_45.L_CORE X_NUC_97.L_CORE 0.004030
K_8831 X_NUC_45.L_CORE X_NUC_98.L_CORE 0.004048
K_8832 X_NUC_45.L_CORE X_NUC_99.L_CORE 0.003997
K_8833 X_NUC_45.L_CORE X_NUC_100.L_CORE 0.003977
K_8834 X_NUC_45.L_CORE X_NUC_101.L_CORE 0.001462
K_8835 X_NUC_45.L_CORE X_NUC_102.L_CORE 0.001461
K_8836 X_NUC_45.L_CORE X_NUC_103.L_CORE 0.001454
K_8837 X_NUC_45.L_CORE X_NUC_104.L_CORE 0.001464
K_8838 X_NUC_45.L_CORE X_NUC_105.L_CORE 0.001668
K_8839 X_NUC_45.L_CORE X_NUC_106.L_CORE 0.001679
K_8840 X_NUC_45.L_CORE X_NUC_107.L_CORE 0.001667
K_8841 X_NUC_45.L_CORE X_NUC_108.L_CORE 0.001671
K_8842 X_NUC_45.L_CORE X_NUC_109.L_CORE 0.002658
K_8843 X_NUC_45.L_CORE X_NUC_110.L_CORE 0.002642
K_8844 X_NUC_45.L_CORE X_NUC_111.L_CORE 0.002625
K_8845 X_NUC_45.L_CORE X_NUC_112.L_CORE 0.002639
K_8846 X_NUC_45.L_CORE X_NUC_113.L_CORE 0.001306
K_8847 X_NUC_45.L_CORE X_NUC_114.L_CORE 0.001309
K_8848 X_NUC_45.L_CORE X_NUC_115.L_CORE 0.001302
K_8849 X_NUC_45.L_CORE X_NUC_116.L_CORE 0.001309
K_8850 X_NUC_45.L_CORE X_NUC_117.L_CORE 0.002396
K_8851 X_NUC_45.L_CORE X_NUC_118.L_CORE 0.002413
K_8852 X_NUC_45.L_CORE X_NUC_119.L_CORE 0.002391
K_8853 X_NUC_45.L_CORE X_NUC_120.L_CORE 0.002388
K_8854 X_NUC_45.L_CORE X_NUC_121.L_CORE 0.001659
K_8855 X_NUC_45.L_CORE X_NUC_122.L_CORE 0.001656
K_8856 X_NUC_45.L_CORE X_NUC_123.L_CORE 0.001647
K_8857 X_NUC_45.L_CORE X_NUC_124.L_CORE 0.001657
K_8858 X_NUC_45.L_CORE X_NUC_125.L_CORE 0.001405
K_8859 X_NUC_45.L_CORE X_NUC_126.L_CORE 0.001411
K_8860 X_NUC_45.L_CORE X_NUC_127.L_CORE 0.001402
K_8861 X_NUC_45.L_CORE X_NUC_128.L_CORE 0.001407
K_8862 X_NUC_45.L_CORE X_NUC_129.L_CORE 0.002646
K_8863 X_NUC_45.L_CORE X_NUC_130.L_CORE 0.002643
K_8864 X_NUC_45.L_CORE X_NUC_131.L_CORE 0.002620
K_8865 X_NUC_45.L_CORE X_NUC_132.L_CORE 0.002623
K_8866 X_NUC_45.L_CORE X_NUC_133.L_CORE 0.001349
K_8867 X_NUC_45.L_CORE X_NUC_134.L_CORE 0.001351
K_8868 X_NUC_45.L_CORE X_NUC_135.L_CORE 0.001343
K_8869 X_NUC_45.L_CORE X_NUC_136.L_CORE 0.001350
K_8870 X_NUC_45.L_CORE X_NUC_137.L_CORE 0.001735
K_8871 X_NUC_45.L_CORE X_NUC_138.L_CORE 0.001745
K_8872 X_NUC_45.L_CORE X_NUC_139.L_CORE 0.001731
K_8873 X_NUC_45.L_CORE X_NUC_140.L_CORE 0.001734
K_8874 X_NUC_45.L_CORE X_NUC_141.L_CORE 0.001871
K_8875 X_NUC_45.L_CORE X_NUC_142.L_CORE 0.001866
K_8876 X_NUC_45.L_CORE X_NUC_143.L_CORE 0.001855
K_8877 X_NUC_45.L_CORE X_NUC_144.L_CORE 0.001864
K_8878 X_NUC_45.L_CORE X_NUC_145.L_CORE 0.001326
K_8879 X_NUC_45.L_CORE X_NUC_146.L_CORE 0.001330
K_8880 X_NUC_45.L_CORE X_NUC_147.L_CORE 0.001321
K_8881 X_NUC_45.L_CORE X_NUC_148.L_CORE 0.001327
K_8882 X_NUC_45.L_CORE X_NUC_149.L_CORE 0.002047
K_8883 X_NUC_45.L_CORE X_NUC_150.L_CORE 0.002053
K_8884 X_NUC_45.L_CORE X_NUC_151.L_CORE 0.002035
K_8885 X_NUC_45.L_CORE X_NUC_152.L_CORE 0.002037
K_8886 X_NUC_45.L_CORE X_NUC_153.L_CORE 0.001466
K_8887 X_NUC_45.L_CORE X_NUC_154.L_CORE 0.001466
K_8888 X_NUC_45.L_CORE X_NUC_155.L_CORE 0.001458
K_8889 X_NUC_45.L_CORE X_NUC_156.L_CORE 0.001465
K_8890 X_NUC_45.L_CORE X_NUC_157.L_CORE 0.001477
K_8891 X_NUC_45.L_CORE X_NUC_158.L_CORE 0.001483
K_8892 X_NUC_45.L_CORE X_NUC_159.L_CORE 0.001473
K_8893 X_NUC_45.L_CORE X_NUC_160.L_CORE 0.001477
K_8894 X_NUC_45.L_CORE X_NUC_161.L_CORE 0.001802
K_8895 X_NUC_45.L_CORE X_NUC_162.L_CORE 0.001802
K_8896 X_NUC_45.L_CORE X_NUC_163.L_CORE 0.001789
K_8897 X_NUC_45.L_CORE X_NUC_164.L_CORE 0.001794
K_8898 X_NUC_45.L_CORE X_NUC_165.L_CORE 0.001393
K_8899 X_NUC_45.L_CORE X_NUC_166.L_CORE 0.001396
K_8900 X_NUC_45.L_CORE X_NUC_167.L_CORE 0.001387
K_8901 X_NUC_45.L_CORE X_NUC_168.L_CORE 0.001392
K_8902 X_NUC_45.L_CORE X_NUC_169.L_CORE 0.001584
K_8903 X_NUC_45.L_CORE X_NUC_170.L_CORE 0.001588
K_8904 X_NUC_45.L_CORE X_NUC_171.L_CORE 0.001576
K_8905 X_NUC_45.L_CORE X_NUC_172.L_CORE 0.001580
K_8906 X_NUC_45.L_CORE X_NUC_173.L_CORE 0.002535
K_8907 X_NUC_45.L_CORE X_NUC_174.L_CORE 0.002686
K_8908 X_NUC_45.L_CORE X_NUC_175.L_CORE 0.001833
K_8909 X_NUC_45.L_CORE X_NUC_176.L_CORE 0.004239
K_8910 X_NUC_45.L_CORE X_NUC_177.L_CORE 0.001919
K_8911 X_NUC_45.L_CORE X_NUC_178.L_CORE 0.002011
K_8912 X_NUC_45.L_CORE X_NUC_179.L_CORE 0.004482
K_8913 X_NUC_45.L_CORE X_NUC_180.L_CORE 0.001557
K_8914 X_NUC_45.L_CORE X_NUC_181.L_CORE 0.003314
K_8915 X_NUC_45.L_CORE X_NUC_182.L_CORE 0.002189
K_8916 X_NUC_45.L_CORE X_NUC_183.L_CORE 0.001580
K_8917 X_NUC_45.L_CORE X_NUC_184.L_CORE 0.022324
K_8918 X_NUC_45.L_CORE X_NUC_185.L_CORE 0.001534
K_8919 X_NUC_45.L_CORE X_NUC_186.L_CORE 0.002098
K_8920 X_NUC_45.L_CORE X_NUC_187.L_CORE 0.003122
K_8921 X_NUC_45.L_CORE X_NUC_188.L_CORE 0.001389
K_8922 X_NUC_45.L_CORE X_NUC_189.L_CORE 0.004737
K_8923 X_NUC_45.L_CORE X_NUC_190.L_CORE 0.001701
K_8924 X_NUC_45.L_CORE X_NUC_191.L_CORE 0.001573
K_8925 X_NUC_45.L_CORE X_NUC_192.L_CORE 0.005825
K_8926 X_NUC_45.L_CORE X_NUC_193.L_CORE 0.001350
K_8927 X_NUC_45.L_CORE X_NUC_194.L_CORE 0.002365
K_8928 X_NUC_45.L_CORE X_NUC_195.L_CORE 0.002121
K_8929 X_NUC_45.L_CORE X_NUC_196.L_CORE 0.001346
K_8930 X_NUC_45.L_CORE X_NUC_197.L_CORE 0.004909
K_8931 X_NUC_45.L_CORE X_NUC_198.L_CORE 0.001436
K_8932 X_NUC_45.L_CORE X_NUC_199.L_CORE 0.001661
K_8933 X_NUC_45.L_CORE X_NUC_200.L_CORE 0.002868
K_8934 X_NUC_45.L_CORE X_NUC_201.L_CORE 0.001272
K_8935 X_NUC_45.L_CORE X_NUC_202.L_CORE 0.002590
K_8936 X_NUC_45.L_CORE X_NUC_203.L_CORE 0.001652
K_8937 X_NUC_45.L_CORE X_NUC_204.L_CORE 0.001373
K_8938 X_NUC_45.L_CORE X_NUC_205.L_CORE 0.003183
K_8939 X_NUC_45.L_CORE X_NUC_206.L_CORE 0.001304
K_8940 X_NUC_45.L_CORE X_NUC_207.L_CORE 0.001775
K_8941 X_NUC_45.L_CORE X_NUC_208.L_CORE 0.001974
K_8942 X_NUC_45.L_CORE X_NUC_209.L_CORE 0.001265
K_8943 X_NUC_45.L_CORE X_NUC_210.L_CORE 0.002408
K_8944 X_NUC_45.L_CORE X_NUC_211.L_CORE 0.001425
K_8945 X_NUC_45.L_CORE X_NUC_212.L_CORE 0.001440
K_8946 X_NUC_45.L_CORE X_NUC_213.L_CORE 0.002144
K_8947 X_NUC_45.L_CORE X_NUC_214.L_CORE 0.001268
K_8948 X_NUC_45.L_CORE X_NUC_215.L_CORE 0.001784
K_8949 X_NUC_45.L_CORE X_NUC_216.L_CORE 0.001583
K_8950 X_NUC_45.L_CORE X_NUC_217.L_CORE 0.001320
K_8951 X_NUC_45.L_CORE X_NUC_218.L_CORE 0.001885
K_8952 X_NUC_45.L_CORE X_NUC_219.L_CORE 0.001353
K_8953 X_NUC_45.L_CORE X_NUC_220.L_CORE 0.001487
K_8954 X_NUC_45.L_CORE X_NUC_221.L_CORE 0.001589
K_8955 X_NUC_45.L_CORE X_NUC_222.L_CORE 0.001385
K_8956 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_8957 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_8958 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.001556
K_8959 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.001557
K_8960 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.001551
K_8961 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.001562
K_8962 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.002098
K_8963 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.002119
K_8964 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.002105
K_8965 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.002110
K_8966 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.003192
K_8967 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.003161
K_8968 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.003152
K_8969 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.003189
K_8970 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.001404
K_8971 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.001409
K_8972 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.001402
K_8973 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.001410
K_8974 X_NUC_46.L_CORE X_NUC_65.L_CORE 0.004445
K_8975 X_NUC_46.L_CORE X_NUC_66.L_CORE 0.004528
K_8976 X_NUC_46.L_CORE X_NUC_67.L_CORE 0.004473
K_8977 X_NUC_46.L_CORE X_NUC_68.L_CORE 0.004443
K_8978 X_NUC_46.L_CORE X_NUC_69.L_CORE 0.001728
K_8979 X_NUC_46.L_CORE X_NUC_70.L_CORE 0.001725
K_8980 X_NUC_46.L_CORE X_NUC_71.L_CORE 0.001718
K_8981 X_NUC_46.L_CORE X_NUC_72.L_CORE 0.001732
K_8982 X_NUC_46.L_CORE X_NUC_73.L_CORE 0.001581
K_8983 X_NUC_46.L_CORE X_NUC_74.L_CORE 0.001591
K_8984 X_NUC_46.L_CORE X_NUC_75.L_CORE 0.001581
K_8985 X_NUC_46.L_CORE X_NUC_76.L_CORE 0.001587
K_8986 X_NUC_46.L_CORE X_NUC_77.L_CORE 0.005212
K_8987 X_NUC_46.L_CORE X_NUC_78.L_CORE 0.005130
K_8988 X_NUC_46.L_CORE X_NUC_79.L_CORE 0.005090
K_8989 X_NUC_46.L_CORE X_NUC_80.L_CORE 0.005118
K_8990 X_NUC_46.L_CORE X_NUC_81.L_CORE 0.001372
K_8991 X_NUC_46.L_CORE X_NUC_82.L_CORE 0.001374
K_8992 X_NUC_46.L_CORE X_NUC_83.L_CORE 0.001367
K_8993 X_NUC_46.L_CORE X_NUC_84.L_CORE 0.001376
K_8994 X_NUC_46.L_CORE X_NUC_85.L_CORE 0.002306
K_8995 X_NUC_46.L_CORE X_NUC_86.L_CORE 0.002329
K_8996 X_NUC_46.L_CORE X_NUC_87.L_CORE 0.002310
K_8997 X_NUC_46.L_CORE X_NUC_88.L_CORE 0.002310
K_8998 X_NUC_46.L_CORE X_NUC_89.L_CORE 0.002126
K_8999 X_NUC_46.L_CORE X_NUC_90.L_CORE 0.002116
K_9000 X_NUC_46.L_CORE X_NUC_91.L_CORE 0.002107
K_9001 X_NUC_46.L_CORE X_NUC_92.L_CORE 0.002123
K_9002 X_NUC_46.L_CORE X_NUC_93.L_CORE 0.001364
K_9003 X_NUC_46.L_CORE X_NUC_94.L_CORE 0.001370
K_9004 X_NUC_46.L_CORE X_NUC_95.L_CORE 0.001362
K_9005 X_NUC_46.L_CORE X_NUC_96.L_CORE 0.001368
K_9006 X_NUC_46.L_CORE X_NUC_97.L_CORE 0.004011
K_9007 X_NUC_46.L_CORE X_NUC_98.L_CORE 0.004030
K_9008 X_NUC_46.L_CORE X_NUC_99.L_CORE 0.003980
K_9009 X_NUC_46.L_CORE X_NUC_100.L_CORE 0.003960
K_9010 X_NUC_46.L_CORE X_NUC_101.L_CORE 0.001462
K_9011 X_NUC_46.L_CORE X_NUC_102.L_CORE 0.001462
K_9012 X_NUC_46.L_CORE X_NUC_103.L_CORE 0.001454
K_9013 X_NUC_46.L_CORE X_NUC_104.L_CORE 0.001464
K_9014 X_NUC_46.L_CORE X_NUC_105.L_CORE 0.001657
K_9015 X_NUC_46.L_CORE X_NUC_106.L_CORE 0.001668
K_9016 X_NUC_46.L_CORE X_NUC_107.L_CORE 0.001656
K_9017 X_NUC_46.L_CORE X_NUC_108.L_CORE 0.001660
K_9018 X_NUC_46.L_CORE X_NUC_109.L_CORE 0.002675
K_9019 X_NUC_46.L_CORE X_NUC_110.L_CORE 0.002658
K_9020 X_NUC_46.L_CORE X_NUC_111.L_CORE 0.002641
K_9021 X_NUC_46.L_CORE X_NUC_112.L_CORE 0.002655
K_9022 X_NUC_46.L_CORE X_NUC_113.L_CORE 0.001303
K_9023 X_NUC_46.L_CORE X_NUC_114.L_CORE 0.001306
K_9024 X_NUC_46.L_CORE X_NUC_115.L_CORE 0.001299
K_9025 X_NUC_46.L_CORE X_NUC_116.L_CORE 0.001305
K_9026 X_NUC_46.L_CORE X_NUC_117.L_CORE 0.002378
K_9027 X_NUC_46.L_CORE X_NUC_118.L_CORE 0.002396
K_9028 X_NUC_46.L_CORE X_NUC_119.L_CORE 0.002374
K_9029 X_NUC_46.L_CORE X_NUC_120.L_CORE 0.002371
K_9030 X_NUC_46.L_CORE X_NUC_121.L_CORE 0.001662
K_9031 X_NUC_46.L_CORE X_NUC_122.L_CORE 0.001659
K_9032 X_NUC_46.L_CORE X_NUC_123.L_CORE 0.001650
K_9033 X_NUC_46.L_CORE X_NUC_124.L_CORE 0.001660
K_9034 X_NUC_46.L_CORE X_NUC_125.L_CORE 0.001398
K_9035 X_NUC_46.L_CORE X_NUC_126.L_CORE 0.001405
K_9036 X_NUC_46.L_CORE X_NUC_127.L_CORE 0.001396
K_9037 X_NUC_46.L_CORE X_NUC_128.L_CORE 0.001400
K_9038 X_NUC_46.L_CORE X_NUC_129.L_CORE 0.002649
K_9039 X_NUC_46.L_CORE X_NUC_130.L_CORE 0.002646
K_9040 X_NUC_46.L_CORE X_NUC_131.L_CORE 0.002623
K_9041 X_NUC_46.L_CORE X_NUC_132.L_CORE 0.002626
K_9042 X_NUC_46.L_CORE X_NUC_133.L_CORE 0.001348
K_9043 X_NUC_46.L_CORE X_NUC_134.L_CORE 0.001349
K_9044 X_NUC_46.L_CORE X_NUC_135.L_CORE 0.001342
K_9045 X_NUC_46.L_CORE X_NUC_136.L_CORE 0.001349
K_9046 X_NUC_46.L_CORE X_NUC_137.L_CORE 0.001725
K_9047 X_NUC_46.L_CORE X_NUC_138.L_CORE 0.001735
K_9048 X_NUC_46.L_CORE X_NUC_139.L_CORE 0.001721
K_9049 X_NUC_46.L_CORE X_NUC_140.L_CORE 0.001724
K_9050 X_NUC_46.L_CORE X_NUC_141.L_CORE 0.001875
K_9051 X_NUC_46.L_CORE X_NUC_142.L_CORE 0.001871
K_9052 X_NUC_46.L_CORE X_NUC_143.L_CORE 0.001859
K_9053 X_NUC_46.L_CORE X_NUC_144.L_CORE 0.001868
K_9054 X_NUC_46.L_CORE X_NUC_145.L_CORE 0.001322
K_9055 X_NUC_46.L_CORE X_NUC_146.L_CORE 0.001326
K_9056 X_NUC_46.L_CORE X_NUC_147.L_CORE 0.001318
K_9057 X_NUC_46.L_CORE X_NUC_148.L_CORE 0.001323
K_9058 X_NUC_46.L_CORE X_NUC_149.L_CORE 0.002041
K_9059 X_NUC_46.L_CORE X_NUC_150.L_CORE 0.002047
K_9060 X_NUC_46.L_CORE X_NUC_151.L_CORE 0.002029
K_9061 X_NUC_46.L_CORE X_NUC_152.L_CORE 0.002031
K_9062 X_NUC_46.L_CORE X_NUC_153.L_CORE 0.001466
K_9063 X_NUC_46.L_CORE X_NUC_154.L_CORE 0.001466
K_9064 X_NUC_46.L_CORE X_NUC_155.L_CORE 0.001457
K_9065 X_NUC_46.L_CORE X_NUC_156.L_CORE 0.001465
K_9066 X_NUC_46.L_CORE X_NUC_157.L_CORE 0.001472
K_9067 X_NUC_46.L_CORE X_NUC_158.L_CORE 0.001477
K_9068 X_NUC_46.L_CORE X_NUC_159.L_CORE 0.001467
K_9069 X_NUC_46.L_CORE X_NUC_160.L_CORE 0.001471
K_9070 X_NUC_46.L_CORE X_NUC_161.L_CORE 0.001801
K_9071 X_NUC_46.L_CORE X_NUC_162.L_CORE 0.001802
K_9072 X_NUC_46.L_CORE X_NUC_163.L_CORE 0.001789
K_9073 X_NUC_46.L_CORE X_NUC_164.L_CORE 0.001794
K_9074 X_NUC_46.L_CORE X_NUC_165.L_CORE 0.001391
K_9075 X_NUC_46.L_CORE X_NUC_166.L_CORE 0.001393
K_9076 X_NUC_46.L_CORE X_NUC_167.L_CORE 0.001384
K_9077 X_NUC_46.L_CORE X_NUC_168.L_CORE 0.001390
K_9078 X_NUC_46.L_CORE X_NUC_169.L_CORE 0.001580
K_9079 X_NUC_46.L_CORE X_NUC_170.L_CORE 0.001584
K_9080 X_NUC_46.L_CORE X_NUC_171.L_CORE 0.001572
K_9081 X_NUC_46.L_CORE X_NUC_172.L_CORE 0.001577
K_9082 X_NUC_46.L_CORE X_NUC_173.L_CORE 0.002518
K_9083 X_NUC_46.L_CORE X_NUC_174.L_CORE 0.002684
K_9084 X_NUC_46.L_CORE X_NUC_175.L_CORE 0.001824
K_9085 X_NUC_46.L_CORE X_NUC_176.L_CORE 0.004192
K_9086 X_NUC_46.L_CORE X_NUC_177.L_CORE 0.001918
K_9087 X_NUC_46.L_CORE X_NUC_178.L_CORE 0.001995
K_9088 X_NUC_46.L_CORE X_NUC_179.L_CORE 0.004519
K_9089 X_NUC_46.L_CORE X_NUC_180.L_CORE 0.001553
K_9090 X_NUC_46.L_CORE X_NUC_181.L_CORE 0.003264
K_9091 X_NUC_46.L_CORE X_NUC_182.L_CORE 0.002196
K_9092 X_NUC_46.L_CORE X_NUC_183.L_CORE 0.001572
K_9093 X_NUC_46.L_CORE X_NUC_184.L_CORE 0.022551
K_9094 X_NUC_46.L_CORE X_NUC_185.L_CORE 0.001533
K_9095 X_NUC_46.L_CORE X_NUC_186.L_CORE 0.002078
K_9096 X_NUC_46.L_CORE X_NUC_187.L_CORE 0.003154
K_9097 X_NUC_46.L_CORE X_NUC_188.L_CORE 0.001384
K_9098 X_NUC_46.L_CORE X_NUC_189.L_CORE 0.004643
K_9099 X_NUC_46.L_CORE X_NUC_190.L_CORE 0.001704
K_9100 X_NUC_46.L_CORE X_NUC_191.L_CORE 0.001563
K_9101 X_NUC_46.L_CORE X_NUC_192.L_CORE 0.005964
K_9102 X_NUC_46.L_CORE X_NUC_193.L_CORE 0.001348
K_9103 X_NUC_46.L_CORE X_NUC_194.L_CORE 0.002339
K_9104 X_NUC_46.L_CORE X_NUC_195.L_CORE 0.002132
K_9105 X_NUC_46.L_CORE X_NUC_196.L_CORE 0.001340
K_9106 X_NUC_46.L_CORE X_NUC_197.L_CORE 0.004881
K_9107 X_NUC_46.L_CORE X_NUC_198.L_CORE 0.001436
K_9108 X_NUC_46.L_CORE X_NUC_199.L_CORE 0.001649
K_9109 X_NUC_46.L_CORE X_NUC_200.L_CORE 0.002894
K_9110 X_NUC_46.L_CORE X_NUC_201.L_CORE 0.001269
K_9111 X_NUC_46.L_CORE X_NUC_202.L_CORE 0.002567
K_9112 X_NUC_46.L_CORE X_NUC_203.L_CORE 0.001656
K_9113 X_NUC_46.L_CORE X_NUC_204.L_CORE 0.001366
K_9114 X_NUC_46.L_CORE X_NUC_205.L_CORE 0.003194
K_9115 X_NUC_46.L_CORE X_NUC_206.L_CORE 0.001303
K_9116 X_NUC_46.L_CORE X_NUC_207.L_CORE 0.001763
K_9117 X_NUC_46.L_CORE X_NUC_208.L_CORE 0.001982
K_9118 X_NUC_46.L_CORE X_NUC_209.L_CORE 0.001261
K_9119 X_NUC_46.L_CORE X_NUC_210.L_CORE 0.002399
K_9120 X_NUC_46.L_CORE X_NUC_211.L_CORE 0.001426
K_9121 X_NUC_46.L_CORE X_NUC_212.L_CORE 0.001433
K_9122 X_NUC_46.L_CORE X_NUC_213.L_CORE 0.002150
K_9123 X_NUC_46.L_CORE X_NUC_214.L_CORE 0.001265
K_9124 X_NUC_46.L_CORE X_NUC_215.L_CORE 0.001775
K_9125 X_NUC_46.L_CORE X_NUC_216.L_CORE 0.001585
K_9126 X_NUC_46.L_CORE X_NUC_217.L_CORE 0.001315
K_9127 X_NUC_46.L_CORE X_NUC_218.L_CORE 0.001883
K_9128 X_NUC_46.L_CORE X_NUC_219.L_CORE 0.001352
K_9129 X_NUC_46.L_CORE X_NUC_220.L_CORE 0.001482
K_9130 X_NUC_46.L_CORE X_NUC_221.L_CORE 0.001589
K_9131 X_NUC_46.L_CORE X_NUC_222.L_CORE 0.001382
K_9132 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_9133 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.001563
K_9134 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.001564
K_9135 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.001557
K_9136 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.001569
K_9137 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.002112
K_9138 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.002133
K_9139 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.002119
K_9140 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.002124
K_9141 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.003201
K_9142 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.003169
K_9143 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.003161
K_9144 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.003198
K_9145 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.001411
K_9146 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.001416
K_9147 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.001409
K_9148 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.001417
K_9149 X_NUC_47.L_CORE X_NUC_65.L_CORE 0.004497
K_9150 X_NUC_47.L_CORE X_NUC_66.L_CORE 0.004582
K_9151 X_NUC_47.L_CORE X_NUC_67.L_CORE 0.004528
K_9152 X_NUC_47.L_CORE X_NUC_68.L_CORE 0.004495
K_9153 X_NUC_47.L_CORE X_NUC_69.L_CORE 0.001735
K_9154 X_NUC_47.L_CORE X_NUC_70.L_CORE 0.001732
K_9155 X_NUC_47.L_CORE X_NUC_71.L_CORE 0.001725
K_9156 X_NUC_47.L_CORE X_NUC_72.L_CORE 0.001739
K_9157 X_NUC_47.L_CORE X_NUC_73.L_CORE 0.001591
K_9158 X_NUC_47.L_CORE X_NUC_74.L_CORE 0.001601
K_9159 X_NUC_47.L_CORE X_NUC_75.L_CORE 0.001591
K_9160 X_NUC_47.L_CORE X_NUC_76.L_CORE 0.001597
K_9161 X_NUC_47.L_CORE X_NUC_77.L_CORE 0.005254
K_9162 X_NUC_47.L_CORE X_NUC_78.L_CORE 0.005168
K_9163 X_NUC_47.L_CORE X_NUC_79.L_CORE 0.005130
K_9164 X_NUC_47.L_CORE X_NUC_80.L_CORE 0.005157
K_9165 X_NUC_47.L_CORE X_NUC_81.L_CORE 0.001379
K_9166 X_NUC_47.L_CORE X_NUC_82.L_CORE 0.001381
K_9167 X_NUC_47.L_CORE X_NUC_83.L_CORE 0.001374
K_9168 X_NUC_47.L_CORE X_NUC_84.L_CORE 0.001383
K_9169 X_NUC_47.L_CORE X_NUC_85.L_CORE 0.002325
K_9170 X_NUC_47.L_CORE X_NUC_86.L_CORE 0.002349
K_9171 X_NUC_47.L_CORE X_NUC_87.L_CORE 0.002329
K_9172 X_NUC_47.L_CORE X_NUC_88.L_CORE 0.002329
K_9173 X_NUC_47.L_CORE X_NUC_89.L_CORE 0.002136
K_9174 X_NUC_47.L_CORE X_NUC_90.L_CORE 0.002126
K_9175 X_NUC_47.L_CORE X_NUC_91.L_CORE 0.002116
K_9176 X_NUC_47.L_CORE X_NUC_92.L_CORE 0.002133
K_9177 X_NUC_47.L_CORE X_NUC_93.L_CORE 0.001372
K_9178 X_NUC_47.L_CORE X_NUC_94.L_CORE 0.001378
K_9179 X_NUC_47.L_CORE X_NUC_95.L_CORE 0.001370
K_9180 X_NUC_47.L_CORE X_NUC_96.L_CORE 0.001376
K_9181 X_NUC_47.L_CORE X_NUC_97.L_CORE 0.004062
K_9182 X_NUC_47.L_CORE X_NUC_98.L_CORE 0.004081
K_9183 X_NUC_47.L_CORE X_NUC_99.L_CORE 0.004030
K_9184 X_NUC_47.L_CORE X_NUC_100.L_CORE 0.004009
K_9185 X_NUC_47.L_CORE X_NUC_101.L_CORE 0.001469
K_9186 X_NUC_47.L_CORE X_NUC_102.L_CORE 0.001469
K_9187 X_NUC_47.L_CORE X_NUC_103.L_CORE 0.001462
K_9188 X_NUC_47.L_CORE X_NUC_104.L_CORE 0.001471
K_9189 X_NUC_47.L_CORE X_NUC_105.L_CORE 0.001668
K_9190 X_NUC_47.L_CORE X_NUC_106.L_CORE 0.001680
K_9191 X_NUC_47.L_CORE X_NUC_107.L_CORE 0.001668
K_9192 X_NUC_47.L_CORE X_NUC_108.L_CORE 0.001672
K_9193 X_NUC_47.L_CORE X_NUC_109.L_CORE 0.002693
K_9194 X_NUC_47.L_CORE X_NUC_110.L_CORE 0.002675
K_9195 X_NUC_47.L_CORE X_NUC_111.L_CORE 0.002658
K_9196 X_NUC_47.L_CORE X_NUC_112.L_CORE 0.002673
K_9197 X_NUC_47.L_CORE X_NUC_113.L_CORE 0.001310
K_9198 X_NUC_47.L_CORE X_NUC_114.L_CORE 0.001313
K_9199 X_NUC_47.L_CORE X_NUC_115.L_CORE 0.001306
K_9200 X_NUC_47.L_CORE X_NUC_116.L_CORE 0.001313
K_9201 X_NUC_47.L_CORE X_NUC_117.L_CORE 0.002401
K_9202 X_NUC_47.L_CORE X_NUC_118.L_CORE 0.002418
K_9203 X_NUC_47.L_CORE X_NUC_119.L_CORE 0.002396
K_9204 X_NUC_47.L_CORE X_NUC_120.L_CORE 0.002393
K_9205 X_NUC_47.L_CORE X_NUC_121.L_CORE 0.001671
K_9206 X_NUC_47.L_CORE X_NUC_122.L_CORE 0.001668
K_9207 X_NUC_47.L_CORE X_NUC_123.L_CORE 0.001659
K_9208 X_NUC_47.L_CORE X_NUC_124.L_CORE 0.001670
K_9209 X_NUC_47.L_CORE X_NUC_125.L_CORE 0.001407
K_9210 X_NUC_47.L_CORE X_NUC_126.L_CORE 0.001414
K_9211 X_NUC_47.L_CORE X_NUC_127.L_CORE 0.001405
K_9212 X_NUC_47.L_CORE X_NUC_128.L_CORE 0.001410
K_9213 X_NUC_47.L_CORE X_NUC_129.L_CORE 0.002673
K_9214 X_NUC_47.L_CORE X_NUC_130.L_CORE 0.002670
K_9215 X_NUC_47.L_CORE X_NUC_131.L_CORE 0.002646
K_9216 X_NUC_47.L_CORE X_NUC_132.L_CORE 0.002649
K_9217 X_NUC_47.L_CORE X_NUC_133.L_CORE 0.001355
K_9218 X_NUC_47.L_CORE X_NUC_134.L_CORE 0.001357
K_9219 X_NUC_47.L_CORE X_NUC_135.L_CORE 0.001349
K_9220 X_NUC_47.L_CORE X_NUC_136.L_CORE 0.001356
K_9221 X_NUC_47.L_CORE X_NUC_137.L_CORE 0.001738
K_9222 X_NUC_47.L_CORE X_NUC_138.L_CORE 0.001748
K_9223 X_NUC_47.L_CORE X_NUC_139.L_CORE 0.001735
K_9224 X_NUC_47.L_CORE X_NUC_140.L_CORE 0.001737
K_9225 X_NUC_47.L_CORE X_NUC_141.L_CORE 0.001887
K_9226 X_NUC_47.L_CORE X_NUC_142.L_CORE 0.001883
K_9227 X_NUC_47.L_CORE X_NUC_143.L_CORE 0.001871
K_9228 X_NUC_47.L_CORE X_NUC_144.L_CORE 0.001880
K_9229 X_NUC_47.L_CORE X_NUC_145.L_CORE 0.001330
K_9230 X_NUC_47.L_CORE X_NUC_146.L_CORE 0.001334
K_9231 X_NUC_47.L_CORE X_NUC_147.L_CORE 0.001326
K_9232 X_NUC_47.L_CORE X_NUC_148.L_CORE 0.001331
K_9233 X_NUC_47.L_CORE X_NUC_149.L_CORE 0.002058
K_9234 X_NUC_47.L_CORE X_NUC_150.L_CORE 0.002064
K_9235 X_NUC_47.L_CORE X_NUC_151.L_CORE 0.002047
K_9236 X_NUC_47.L_CORE X_NUC_152.L_CORE 0.002048
K_9237 X_NUC_47.L_CORE X_NUC_153.L_CORE 0.001475
K_9238 X_NUC_47.L_CORE X_NUC_154.L_CORE 0.001475
K_9239 X_NUC_47.L_CORE X_NUC_155.L_CORE 0.001466
K_9240 X_NUC_47.L_CORE X_NUC_156.L_CORE 0.001474
K_9241 X_NUC_47.L_CORE X_NUC_157.L_CORE 0.001482
K_9242 X_NUC_47.L_CORE X_NUC_158.L_CORE 0.001488
K_9243 X_NUC_47.L_CORE X_NUC_159.L_CORE 0.001477
K_9244 X_NUC_47.L_CORE X_NUC_160.L_CORE 0.001482
K_9245 X_NUC_47.L_CORE X_NUC_161.L_CORE 0.001815
K_9246 X_NUC_47.L_CORE X_NUC_162.L_CORE 0.001815
K_9247 X_NUC_47.L_CORE X_NUC_163.L_CORE 0.001802
K_9248 X_NUC_47.L_CORE X_NUC_164.L_CORE 0.001807
K_9249 X_NUC_47.L_CORE X_NUC_165.L_CORE 0.001400
K_9250 X_NUC_47.L_CORE X_NUC_166.L_CORE 0.001402
K_9251 X_NUC_47.L_CORE X_NUC_167.L_CORE 0.001393
K_9252 X_NUC_47.L_CORE X_NUC_168.L_CORE 0.001399
K_9253 X_NUC_47.L_CORE X_NUC_169.L_CORE 0.001592
K_9254 X_NUC_47.L_CORE X_NUC_170.L_CORE 0.001595
K_9255 X_NUC_47.L_CORE X_NUC_171.L_CORE 0.001584
K_9256 X_NUC_47.L_CORE X_NUC_172.L_CORE 0.001588
K_9257 X_NUC_47.L_CORE X_NUC_173.L_CORE 0.002523
K_9258 X_NUC_47.L_CORE X_NUC_174.L_CORE 0.002686
K_9259 X_NUC_47.L_CORE X_NUC_175.L_CORE 0.001831
K_9260 X_NUC_47.L_CORE X_NUC_176.L_CORE 0.004187
K_9261 X_NUC_47.L_CORE X_NUC_177.L_CORE 0.001923
K_9262 X_NUC_47.L_CORE X_NUC_178.L_CORE 0.002004
K_9263 X_NUC_47.L_CORE X_NUC_179.L_CORE 0.004496
K_9264 X_NUC_47.L_CORE X_NUC_180.L_CORE 0.001559
K_9265 X_NUC_47.L_CORE X_NUC_181.L_CORE 0.003279
K_9266 X_NUC_47.L_CORE X_NUC_182.L_CORE 0.002201
K_9267 X_NUC_47.L_CORE X_NUC_183.L_CORE 0.001579
K_9268 X_NUC_47.L_CORE X_NUC_184.L_CORE 0.020704
K_9269 X_NUC_47.L_CORE X_NUC_185.L_CORE 0.001539
K_9270 X_NUC_47.L_CORE X_NUC_186.L_CORE 0.002090
K_9271 X_NUC_47.L_CORE X_NUC_187.L_CORE 0.003156
K_9272 X_NUC_47.L_CORE X_NUC_188.L_CORE 0.001391
K_9273 X_NUC_47.L_CORE X_NUC_189.L_CORE 0.004681
K_9274 X_NUC_47.L_CORE X_NUC_190.L_CORE 0.001710
K_9275 X_NUC_47.L_CORE X_NUC_191.L_CORE 0.001572
K_9276 X_NUC_47.L_CORE X_NUC_192.L_CORE 0.005970
K_9277 X_NUC_47.L_CORE X_NUC_193.L_CORE 0.001354
K_9278 X_NUC_47.L_CORE X_NUC_194.L_CORE 0.002357
K_9279 X_NUC_47.L_CORE X_NUC_195.L_CORE 0.002140
K_9280 X_NUC_47.L_CORE X_NUC_196.L_CORE 0.001347
K_9281 X_NUC_47.L_CORE X_NUC_197.L_CORE 0.004935
K_9282 X_NUC_47.L_CORE X_NUC_198.L_CORE 0.001442
K_9283 X_NUC_47.L_CORE X_NUC_199.L_CORE 0.001660
K_9284 X_NUC_47.L_CORE X_NUC_200.L_CORE 0.002908
K_9285 X_NUC_47.L_CORE X_NUC_201.L_CORE 0.001275
K_9286 X_NUC_47.L_CORE X_NUC_202.L_CORE 0.002590
K_9287 X_NUC_47.L_CORE X_NUC_203.L_CORE 0.001664
K_9288 X_NUC_47.L_CORE X_NUC_204.L_CORE 0.001374
K_9289 X_NUC_47.L_CORE X_NUC_205.L_CORE 0.003221
K_9290 X_NUC_47.L_CORE X_NUC_206.L_CORE 0.001310
K_9291 X_NUC_47.L_CORE X_NUC_207.L_CORE 0.001776
K_9292 X_NUC_47.L_CORE X_NUC_208.L_CORE 0.001993
K_9293 X_NUC_47.L_CORE X_NUC_209.L_CORE 0.001268
K_9294 X_NUC_47.L_CORE X_NUC_210.L_CORE 0.002420
K_9295 X_NUC_47.L_CORE X_NUC_211.L_CORE 0.001433
K_9296 X_NUC_47.L_CORE X_NUC_212.L_CORE 0.001443
K_9297 X_NUC_47.L_CORE X_NUC_213.L_CORE 0.002165
K_9298 X_NUC_47.L_CORE X_NUC_214.L_CORE 0.001273
K_9299 X_NUC_47.L_CORE X_NUC_215.L_CORE 0.001789
K_9300 X_NUC_47.L_CORE X_NUC_216.L_CORE 0.001594
K_9301 X_NUC_47.L_CORE X_NUC_217.L_CORE 0.001324
K_9302 X_NUC_47.L_CORE X_NUC_218.L_CORE 0.001897
K_9303 X_NUC_47.L_CORE X_NUC_219.L_CORE 0.001361
K_9304 X_NUC_47.L_CORE X_NUC_220.L_CORE 0.001492
K_9305 X_NUC_47.L_CORE X_NUC_221.L_CORE 0.001600
K_9306 X_NUC_47.L_CORE X_NUC_222.L_CORE 0.001391
K_9307 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.001551
K_9308 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.001552
K_9309 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.001546
K_9310 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.001557
K_9311 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.002107
K_9312 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.002128
K_9313 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.002114
K_9314 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.002119
K_9315 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.003164
K_9316 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.003133
K_9317 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.003125
K_9318 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.003161
K_9319 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.001403
K_9320 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.001408
K_9321 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.001401
K_9322 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.001409
K_9323 X_NUC_48.L_CORE X_NUC_65.L_CORE 0.004528
K_9324 X_NUC_48.L_CORE X_NUC_66.L_CORE 0.004615
K_9325 X_NUC_48.L_CORE X_NUC_67.L_CORE 0.004559
K_9326 X_NUC_48.L_CORE X_NUC_68.L_CORE 0.004528
K_9327 X_NUC_48.L_CORE X_NUC_69.L_CORE 0.001722
K_9328 X_NUC_48.L_CORE X_NUC_70.L_CORE 0.001719
K_9329 X_NUC_48.L_CORE X_NUC_71.L_CORE 0.001711
K_9330 X_NUC_48.L_CORE X_NUC_72.L_CORE 0.001725
K_9331 X_NUC_48.L_CORE X_NUC_73.L_CORE 0.001585
K_9332 X_NUC_48.L_CORE X_NUC_74.L_CORE 0.001595
K_9333 X_NUC_48.L_CORE X_NUC_75.L_CORE 0.001585
K_9334 X_NUC_48.L_CORE X_NUC_76.L_CORE 0.001591
K_9335 X_NUC_48.L_CORE X_NUC_77.L_CORE 0.005223
K_9336 X_NUC_48.L_CORE X_NUC_78.L_CORE 0.005140
K_9337 X_NUC_48.L_CORE X_NUC_79.L_CORE 0.005101
K_9338 X_NUC_48.L_CORE X_NUC_80.L_CORE 0.005130
K_9339 X_NUC_48.L_CORE X_NUC_81.L_CORE 0.001370
K_9340 X_NUC_48.L_CORE X_NUC_82.L_CORE 0.001372
K_9341 X_NUC_48.L_CORE X_NUC_83.L_CORE 0.001366
K_9342 X_NUC_48.L_CORE X_NUC_84.L_CORE 0.001374
K_9343 X_NUC_48.L_CORE X_NUC_85.L_CORE 0.002325
K_9344 X_NUC_48.L_CORE X_NUC_86.L_CORE 0.002349
K_9345 X_NUC_48.L_CORE X_NUC_87.L_CORE 0.002330
K_9346 X_NUC_48.L_CORE X_NUC_88.L_CORE 0.002329
K_9347 X_NUC_48.L_CORE X_NUC_89.L_CORE 0.002119
K_9348 X_NUC_48.L_CORE X_NUC_90.L_CORE 0.002109
K_9349 X_NUC_48.L_CORE X_NUC_91.L_CORE 0.002100
K_9350 X_NUC_48.L_CORE X_NUC_92.L_CORE 0.002116
K_9351 X_NUC_48.L_CORE X_NUC_93.L_CORE 0.001366
K_9352 X_NUC_48.L_CORE X_NUC_94.L_CORE 0.001372
K_9353 X_NUC_48.L_CORE X_NUC_95.L_CORE 0.001364
K_9354 X_NUC_48.L_CORE X_NUC_96.L_CORE 0.001370
K_9355 X_NUC_48.L_CORE X_NUC_97.L_CORE 0.004083
K_9356 X_NUC_48.L_CORE X_NUC_98.L_CORE 0.004102
K_9357 X_NUC_48.L_CORE X_NUC_99.L_CORE 0.004050
K_9358 X_NUC_48.L_CORE X_NUC_100.L_CORE 0.004030
K_9359 X_NUC_48.L_CORE X_NUC_101.L_CORE 0.001460
K_9360 X_NUC_48.L_CORE X_NUC_102.L_CORE 0.001459
K_9361 X_NUC_48.L_CORE X_NUC_103.L_CORE 0.001452
K_9362 X_NUC_48.L_CORE X_NUC_104.L_CORE 0.001462
K_9363 X_NUC_48.L_CORE X_NUC_105.L_CORE 0.001664
K_9364 X_NUC_48.L_CORE X_NUC_106.L_CORE 0.001676
K_9365 X_NUC_48.L_CORE X_NUC_107.L_CORE 0.001664
K_9366 X_NUC_48.L_CORE X_NUC_108.L_CORE 0.001668
K_9367 X_NUC_48.L_CORE X_NUC_109.L_CORE 0.002677
K_9368 X_NUC_48.L_CORE X_NUC_110.L_CORE 0.002661
K_9369 X_NUC_48.L_CORE X_NUC_111.L_CORE 0.002644
K_9370 X_NUC_48.L_CORE X_NUC_112.L_CORE 0.002658
K_9371 X_NUC_48.L_CORE X_NUC_113.L_CORE 0.001303
K_9372 X_NUC_48.L_CORE X_NUC_114.L_CORE 0.001307
K_9373 X_NUC_48.L_CORE X_NUC_115.L_CORE 0.001299
K_9374 X_NUC_48.L_CORE X_NUC_116.L_CORE 0.001306
K_9375 X_NUC_48.L_CORE X_NUC_117.L_CORE 0.002403
K_9376 X_NUC_48.L_CORE X_NUC_118.L_CORE 0.002421
K_9377 X_NUC_48.L_CORE X_NUC_119.L_CORE 0.002398
K_9378 X_NUC_48.L_CORE X_NUC_120.L_CORE 0.002396
K_9379 X_NUC_48.L_CORE X_NUC_121.L_CORE 0.001661
K_9380 X_NUC_48.L_CORE X_NUC_122.L_CORE 0.001657
K_9381 X_NUC_48.L_CORE X_NUC_123.L_CORE 0.001649
K_9382 X_NUC_48.L_CORE X_NUC_124.L_CORE 0.001659
K_9383 X_NUC_48.L_CORE X_NUC_125.L_CORE 0.001402
K_9384 X_NUC_48.L_CORE X_NUC_126.L_CORE 0.001409
K_9385 X_NUC_48.L_CORE X_NUC_127.L_CORE 0.001400
K_9386 X_NUC_48.L_CORE X_NUC_128.L_CORE 0.001405
K_9387 X_NUC_48.L_CORE X_NUC_129.L_CORE 0.002670
K_9388 X_NUC_48.L_CORE X_NUC_130.L_CORE 0.002667
K_9389 X_NUC_48.L_CORE X_NUC_131.L_CORE 0.002643
K_9390 X_NUC_48.L_CORE X_NUC_132.L_CORE 0.002646
K_9391 X_NUC_48.L_CORE X_NUC_133.L_CORE 0.001348
K_9392 X_NUC_48.L_CORE X_NUC_134.L_CORE 0.001349
K_9393 X_NUC_48.L_CORE X_NUC_135.L_CORE 0.001342
K_9394 X_NUC_48.L_CORE X_NUC_136.L_CORE 0.001349
K_9395 X_NUC_48.L_CORE X_NUC_137.L_CORE 0.001736
K_9396 X_NUC_48.L_CORE X_NUC_138.L_CORE 0.001746
K_9397 X_NUC_48.L_CORE X_NUC_139.L_CORE 0.001732
K_9398 X_NUC_48.L_CORE X_NUC_140.L_CORE 0.001735
K_9399 X_NUC_48.L_CORE X_NUC_141.L_CORE 0.001878
K_9400 X_NUC_48.L_CORE X_NUC_142.L_CORE 0.001873
K_9401 X_NUC_48.L_CORE X_NUC_143.L_CORE 0.001862
K_9402 X_NUC_48.L_CORE X_NUC_144.L_CORE 0.001871
K_9403 X_NUC_48.L_CORE X_NUC_145.L_CORE 0.001325
K_9404 X_NUC_48.L_CORE X_NUC_146.L_CORE 0.001329
K_9405 X_NUC_48.L_CORE X_NUC_147.L_CORE 0.001320
K_9406 X_NUC_48.L_CORE X_NUC_148.L_CORE 0.001326
K_9407 X_NUC_48.L_CORE X_NUC_149.L_CORE 0.002056
K_9408 X_NUC_48.L_CORE X_NUC_150.L_CORE 0.002062
K_9409 X_NUC_48.L_CORE X_NUC_151.L_CORE 0.002045
K_9410 X_NUC_48.L_CORE X_NUC_152.L_CORE 0.002047
K_9411 X_NUC_48.L_CORE X_NUC_153.L_CORE 0.001468
K_9412 X_NUC_48.L_CORE X_NUC_154.L_CORE 0.001468
K_9413 X_NUC_48.L_CORE X_NUC_155.L_CORE 0.001459
K_9414 X_NUC_48.L_CORE X_NUC_156.L_CORE 0.001466
K_9415 X_NUC_48.L_CORE X_NUC_157.L_CORE 0.001478
K_9416 X_NUC_48.L_CORE X_NUC_158.L_CORE 0.001484
K_9417 X_NUC_48.L_CORE X_NUC_159.L_CORE 0.001473
K_9418 X_NUC_48.L_CORE X_NUC_160.L_CORE 0.001477
K_9419 X_NUC_48.L_CORE X_NUC_161.L_CORE 0.001809
K_9420 X_NUC_48.L_CORE X_NUC_162.L_CORE 0.001809
K_9421 X_NUC_48.L_CORE X_NUC_163.L_CORE 0.001796
K_9422 X_NUC_48.L_CORE X_NUC_164.L_CORE 0.001802
K_9423 X_NUC_48.L_CORE X_NUC_165.L_CORE 0.001394
K_9424 X_NUC_48.L_CORE X_NUC_166.L_CORE 0.001396
K_9425 X_NUC_48.L_CORE X_NUC_167.L_CORE 0.001387
K_9426 X_NUC_48.L_CORE X_NUC_168.L_CORE 0.001393
K_9427 X_NUC_48.L_CORE X_NUC_169.L_CORE 0.001587
K_9428 X_NUC_48.L_CORE X_NUC_170.L_CORE 0.001591
K_9429 X_NUC_48.L_CORE X_NUC_171.L_CORE 0.001579
K_9430 X_NUC_48.L_CORE X_NUC_172.L_CORE 0.001584
K_9431 X_NUC_48.L_CORE X_NUC_173.L_CORE 0.002505
K_9432 X_NUC_48.L_CORE X_NUC_174.L_CORE 0.002657
K_9433 X_NUC_48.L_CORE X_NUC_175.L_CORE 0.001819
K_9434 X_NUC_48.L_CORE X_NUC_176.L_CORE 0.004155
K_9435 X_NUC_48.L_CORE X_NUC_177.L_CORE 0.001906
K_9436 X_NUC_48.L_CORE X_NUC_178.L_CORE 0.001995
K_9437 X_NUC_48.L_CORE X_NUC_179.L_CORE 0.004427
K_9438 X_NUC_48.L_CORE X_NUC_180.L_CORE 0.001548
K_9439 X_NUC_48.L_CORE X_NUC_181.L_CORE 0.003276
K_9440 X_NUC_48.L_CORE X_NUC_182.L_CORE 0.002179
K_9441 X_NUC_48.L_CORE X_NUC_183.L_CORE 0.001571
K_9442 X_NUC_48.L_CORE X_NUC_184.L_CORE 0.021054
K_9443 X_NUC_48.L_CORE X_NUC_185.L_CORE 0.001527
K_9444 X_NUC_48.L_CORE X_NUC_186.L_CORE 0.002085
K_9445 X_NUC_48.L_CORE X_NUC_187.L_CORE 0.003121
K_9446 X_NUC_48.L_CORE X_NUC_188.L_CORE 0.001383
K_9447 X_NUC_48.L_CORE X_NUC_189.L_CORE 0.004725
K_9448 X_NUC_48.L_CORE X_NUC_190.L_CORE 0.001697
K_9449 X_NUC_48.L_CORE X_NUC_191.L_CORE 0.001566
K_9450 X_NUC_48.L_CORE X_NUC_192.L_CORE 0.005940
K_9451 X_NUC_48.L_CORE X_NUC_193.L_CORE 0.001346
K_9452 X_NUC_48.L_CORE X_NUC_194.L_CORE 0.002358
K_9453 X_NUC_48.L_CORE X_NUC_195.L_CORE 0.002122
K_9454 X_NUC_48.L_CORE X_NUC_196.L_CORE 0.001341
K_9455 X_NUC_48.L_CORE X_NUC_197.L_CORE 0.004994
K_9456 X_NUC_48.L_CORE X_NUC_198.L_CORE 0.001433
K_9457 X_NUC_48.L_CORE X_NUC_199.L_CORE 0.001656
K_9458 X_NUC_48.L_CORE X_NUC_200.L_CORE 0.002891
K_9459 X_NUC_48.L_CORE X_NUC_201.L_CORE 0.001268
K_9460 X_NUC_48.L_CORE X_NUC_202.L_CORE 0.002597
K_9461 X_NUC_48.L_CORE X_NUC_203.L_CORE 0.001652
K_9462 X_NUC_48.L_CORE X_NUC_204.L_CORE 0.001369
K_9463 X_NUC_48.L_CORE X_NUC_205.L_CORE 0.003225
K_9464 X_NUC_48.L_CORE X_NUC_206.L_CORE 0.001302
K_9465 X_NUC_48.L_CORE X_NUC_207.L_CORE 0.001775
K_9466 X_NUC_48.L_CORE X_NUC_208.L_CORE 0.001982
K_9467 X_NUC_48.L_CORE X_NUC_209.L_CORE 0.001262
K_9468 X_NUC_48.L_CORE X_NUC_210.L_CORE 0.002424
K_9469 X_NUC_48.L_CORE X_NUC_211.L_CORE 0.001425
K_9470 X_NUC_48.L_CORE X_NUC_212.L_CORE 0.001439
K_9471 X_NUC_48.L_CORE X_NUC_213.L_CORE 0.002159
K_9472 X_NUC_48.L_CORE X_NUC_214.L_CORE 0.001267
K_9473 X_NUC_48.L_CORE X_NUC_215.L_CORE 0.001788
K_9474 X_NUC_48.L_CORE X_NUC_216.L_CORE 0.001587
K_9475 X_NUC_48.L_CORE X_NUC_217.L_CORE 0.001319
K_9476 X_NUC_48.L_CORE X_NUC_218.L_CORE 0.001894
K_9477 X_NUC_48.L_CORE X_NUC_219.L_CORE 0.001354
K_9478 X_NUC_48.L_CORE X_NUC_220.L_CORE 0.001489
K_9479 X_NUC_48.L_CORE X_NUC_221.L_CORE 0.001594
K_9480 X_NUC_48.L_CORE X_NUC_222.L_CORE 0.001386
K_9481 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_9482 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_9483 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_9484 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.001521
K_9485 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.001527
K_9486 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.001528
K_9487 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.001519
K_9488 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.002073
K_9489 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.002062
K_9490 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.002075
K_9491 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.002058
K_9492 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.003101
K_9493 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.003147
K_9494 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.003121
K_9495 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.003115
K_9496 X_NUC_49.L_CORE X_NUC_65.L_CORE 0.001383
K_9497 X_NUC_49.L_CORE X_NUC_66.L_CORE 0.001385
K_9498 X_NUC_49.L_CORE X_NUC_67.L_CORE 0.001388
K_9499 X_NUC_49.L_CORE X_NUC_68.L_CORE 0.001379
K_9500 X_NUC_49.L_CORE X_NUC_69.L_CORE 0.004476
K_9501 X_NUC_49.L_CORE X_NUC_70.L_CORE 0.004396
K_9502 X_NUC_49.L_CORE X_NUC_71.L_CORE 0.004426
K_9503 X_NUC_49.L_CORE X_NUC_72.L_CORE 0.004392
K_9504 X_NUC_49.L_CORE X_NUC_73.L_CORE 0.001699
K_9505 X_NUC_49.L_CORE X_NUC_74.L_CORE 0.001710
K_9506 X_NUC_49.L_CORE X_NUC_75.L_CORE 0.001706
K_9507 X_NUC_49.L_CORE X_NUC_76.L_CORE 0.001698
K_9508 X_NUC_49.L_CORE X_NUC_77.L_CORE 0.001569
K_9509 X_NUC_49.L_CORE X_NUC_78.L_CORE 0.001565
K_9510 X_NUC_49.L_CORE X_NUC_79.L_CORE 0.001571
K_9511 X_NUC_49.L_CORE X_NUC_80.L_CORE 0.001560
K_9512 X_NUC_49.L_CORE X_NUC_81.L_CORE 0.005139
K_9513 X_NUC_49.L_CORE X_NUC_82.L_CORE 0.005220
K_9514 X_NUC_49.L_CORE X_NUC_83.L_CORE 0.005098
K_9515 X_NUC_49.L_CORE X_NUC_84.L_CORE 0.005126
K_9516 X_NUC_49.L_CORE X_NUC_85.L_CORE 0.001358
K_9517 X_NUC_49.L_CORE X_NUC_86.L_CORE 0.001361
K_9518 X_NUC_49.L_CORE X_NUC_87.L_CORE 0.001362
K_9519 X_NUC_49.L_CORE X_NUC_88.L_CORE 0.001354
K_9520 X_NUC_49.L_CORE X_NUC_89.L_CORE 0.002311
K_9521 X_NUC_49.L_CORE X_NUC_90.L_CORE 0.002294
K_9522 X_NUC_49.L_CORE X_NUC_91.L_CORE 0.002303
K_9523 X_NUC_49.L_CORE X_NUC_92.L_CORE 0.002287
K_9524 X_NUC_49.L_CORE X_NUC_93.L_CORE 0.002101
K_9525 X_NUC_49.L_CORE X_NUC_94.L_CORE 0.002119
K_9526 X_NUC_49.L_CORE X_NUC_95.L_CORE 0.002107
K_9527 X_NUC_49.L_CORE X_NUC_96.L_CORE 0.002101
K_9528 X_NUC_49.L_CORE X_NUC_97.L_CORE 0.001359
K_9529 X_NUC_49.L_CORE X_NUC_98.L_CORE 0.001359
K_9530 X_NUC_49.L_CORE X_NUC_99.L_CORE 0.001361
K_9531 X_NUC_49.L_CORE X_NUC_100.L_CORE 0.001353
K_9532 X_NUC_49.L_CORE X_NUC_101.L_CORE 0.004053
K_9533 X_NUC_49.L_CORE X_NUC_102.L_CORE 0.004026
K_9534 X_NUC_49.L_CORE X_NUC_103.L_CORE 0.003988
K_9535 X_NUC_49.L_CORE X_NUC_104.L_CORE 0.003988
K_9536 X_NUC_49.L_CORE X_NUC_105.L_CORE 0.001453
K_9537 X_NUC_49.L_CORE X_NUC_106.L_CORE 0.001460
K_9538 X_NUC_49.L_CORE X_NUC_107.L_CORE 0.001457
K_9539 X_NUC_49.L_CORE X_NUC_108.L_CORE 0.001450
K_9540 X_NUC_49.L_CORE X_NUC_109.L_CORE 0.001661
K_9541 X_NUC_49.L_CORE X_NUC_110.L_CORE 0.001655
K_9542 X_NUC_49.L_CORE X_NUC_111.L_CORE 0.001659
K_9543 X_NUC_49.L_CORE X_NUC_112.L_CORE 0.001649
K_9544 X_NUC_49.L_CORE X_NUC_113.L_CORE 0.002658
K_9545 X_NUC_49.L_CORE X_NUC_114.L_CORE 0.002681
K_9546 X_NUC_49.L_CORE X_NUC_115.L_CORE 0.002651
K_9547 X_NUC_49.L_CORE X_NUC_116.L_CORE 0.002651
K_9548 X_NUC_49.L_CORE X_NUC_117.L_CORE 0.001303
K_9549 X_NUC_49.L_CORE X_NUC_118.L_CORE 0.001305
K_9550 X_NUC_49.L_CORE X_NUC_119.L_CORE 0.001305
K_9551 X_NUC_49.L_CORE X_NUC_120.L_CORE 0.001298
K_9552 X_NUC_49.L_CORE X_NUC_121.L_CORE 0.002396
K_9553 X_NUC_49.L_CORE X_NUC_122.L_CORE 0.002382
K_9554 X_NUC_49.L_CORE X_NUC_123.L_CORE 0.002379
K_9555 X_NUC_49.L_CORE X_NUC_124.L_CORE 0.002369
K_9556 X_NUC_49.L_CORE X_NUC_125.L_CORE 0.001659
K_9557 X_NUC_49.L_CORE X_NUC_126.L_CORE 0.001668
K_9558 X_NUC_49.L_CORE X_NUC_127.L_CORE 0.001661
K_9559 X_NUC_49.L_CORE X_NUC_128.L_CORE 0.001655
K_9560 X_NUC_49.L_CORE X_NUC_129.L_CORE 0.001406
K_9561 X_NUC_49.L_CORE X_NUC_130.L_CORE 0.001405
K_9562 X_NUC_49.L_CORE X_NUC_131.L_CORE 0.001406
K_9563 X_NUC_49.L_CORE X_NUC_132.L_CORE 0.001398
K_9564 X_NUC_49.L_CORE X_NUC_133.L_CORE 0.002639
K_9565 X_NUC_49.L_CORE X_NUC_134.L_CORE 0.002643
K_9566 X_NUC_49.L_CORE X_NUC_135.L_CORE 0.002619
K_9567 X_NUC_49.L_CORE X_NUC_136.L_CORE 0.002617
K_9568 X_NUC_49.L_CORE X_NUC_137.L_CORE 0.001355
K_9569 X_NUC_49.L_CORE X_NUC_138.L_CORE 0.001359
K_9570 X_NUC_49.L_CORE X_NUC_139.L_CORE 0.001357
K_9571 X_NUC_49.L_CORE X_NUC_140.L_CORE 0.001350
K_9572 X_NUC_49.L_CORE X_NUC_141.L_CORE 0.001739
K_9573 X_NUC_49.L_CORE X_NUC_142.L_CORE 0.001734
K_9574 X_NUC_49.L_CORE X_NUC_143.L_CORE 0.001733
K_9575 X_NUC_49.L_CORE X_NUC_144.L_CORE 0.001725
K_9576 X_NUC_49.L_CORE X_NUC_145.L_CORE 0.001871
K_9577 X_NUC_49.L_CORE X_NUC_146.L_CORE 0.001880
K_9578 X_NUC_49.L_CORE X_NUC_147.L_CORE 0.001868
K_9579 X_NUC_49.L_CORE X_NUC_148.L_CORE 0.001864
K_9580 X_NUC_49.L_CORE X_NUC_149.L_CORE 0.001340
K_9581 X_NUC_49.L_CORE X_NUC_150.L_CORE 0.001340
K_9582 X_NUC_49.L_CORE X_NUC_151.L_CORE 0.001340
K_9583 X_NUC_49.L_CORE X_NUC_152.L_CORE 0.001333
K_9584 X_NUC_49.L_CORE X_NUC_153.L_CORE 0.002026
K_9585 X_NUC_49.L_CORE X_NUC_154.L_CORE 0.002023
K_9586 X_NUC_49.L_CORE X_NUC_155.L_CORE 0.002014
K_9587 X_NUC_49.L_CORE X_NUC_156.L_CORE 0.002008
K_9588 X_NUC_49.L_CORE X_NUC_157.L_CORE 0.001483
K_9589 X_NUC_49.L_CORE X_NUC_158.L_CORE 0.001487
K_9590 X_NUC_49.L_CORE X_NUC_159.L_CORE 0.001483
K_9591 X_NUC_49.L_CORE X_NUC_160.L_CORE 0.001477
K_9592 X_NUC_49.L_CORE X_NUC_161.L_CORE 0.001497
K_9593 X_NUC_49.L_CORE X_NUC_162.L_CORE 0.001496
K_9594 X_NUC_49.L_CORE X_NUC_163.L_CORE 0.001494
K_9595 X_NUC_49.L_CORE X_NUC_164.L_CORE 0.001487
K_9596 X_NUC_49.L_CORE X_NUC_165.L_CORE 0.001760
K_9597 X_NUC_49.L_CORE X_NUC_166.L_CORE 0.001763
K_9598 X_NUC_49.L_CORE X_NUC_167.L_CORE 0.001755
K_9599 X_NUC_49.L_CORE X_NUC_168.L_CORE 0.001749
K_9600 X_NUC_49.L_CORE X_NUC_169.L_CORE 0.001457
K_9601 X_NUC_49.L_CORE X_NUC_170.L_CORE 0.001459
K_9602 X_NUC_49.L_CORE X_NUC_171.L_CORE 0.001455
K_9603 X_NUC_49.L_CORE X_NUC_172.L_CORE 0.001449
K_9604 X_NUC_49.L_CORE X_NUC_173.L_CORE 0.002054
K_9605 X_NUC_49.L_CORE X_NUC_174.L_CORE 0.002469
K_9606 X_NUC_49.L_CORE X_NUC_175.L_CORE 0.002634
K_9607 X_NUC_49.L_CORE X_NUC_176.L_CORE 0.001714
K_9608 X_NUC_49.L_CORE X_NUC_177.L_CORE 0.004295
K_9609 X_NUC_49.L_CORE X_NUC_178.L_CORE 0.001836
K_9610 X_NUC_49.L_CORE X_NUC_179.L_CORE 0.001919
K_9611 X_NUC_49.L_CORE X_NUC_180.L_CORE 0.004449
K_9612 X_NUC_49.L_CORE X_NUC_181.L_CORE 0.001501
K_9613 X_NUC_49.L_CORE X_NUC_182.L_CORE 0.003172
K_9614 X_NUC_49.L_CORE X_NUC_183.L_CORE 0.002136
K_9615 X_NUC_49.L_CORE X_NUC_184.L_CORE 0.001530
K_9616 X_NUC_49.L_CORE X_NUC_185.L_CORE 0.021631
K_9617 X_NUC_49.L_CORE X_NUC_186.L_CORE 0.001498
K_9618 X_NUC_49.L_CORE X_NUC_187.L_CORE 0.002034
K_9619 X_NUC_49.L_CORE X_NUC_188.L_CORE 0.003094
K_9620 X_NUC_49.L_CORE X_NUC_189.L_CORE 0.001359
K_9621 X_NUC_49.L_CORE X_NUC_190.L_CORE 0.004578
K_9622 X_NUC_49.L_CORE X_NUC_191.L_CORE 0.001678
K_9623 X_NUC_49.L_CORE X_NUC_192.L_CORE 0.001541
K_9624 X_NUC_49.L_CORE X_NUC_193.L_CORE 0.005991
K_9625 X_NUC_49.L_CORE X_NUC_194.L_CORE 0.001331
K_9626 X_NUC_49.L_CORE X_NUC_195.L_CORE 0.002318
K_9627 X_NUC_49.L_CORE X_NUC_196.L_CORE 0.002116
K_9628 X_NUC_49.L_CORE X_NUC_197.L_CORE 0.001327
K_9629 X_NUC_49.L_CORE X_NUC_198.L_CORE 0.004956
K_9630 X_NUC_49.L_CORE X_NUC_199.L_CORE 0.001426
K_9631 X_NUC_49.L_CORE X_NUC_200.L_CORE 0.001640
K_9632 X_NUC_49.L_CORE X_NUC_201.L_CORE 0.002904
K_9633 X_NUC_49.L_CORE X_NUC_202.L_CORE 0.001262
K_9634 X_NUC_49.L_CORE X_NUC_203.L_CORE 0.002575
K_9635 X_NUC_49.L_CORE X_NUC_204.L_CORE 0.001654
K_9636 X_NUC_49.L_CORE X_NUC_205.L_CORE 0.001364
K_9637 X_NUC_49.L_CORE X_NUC_206.L_CORE 0.003227
K_9638 X_NUC_49.L_CORE X_NUC_207.L_CORE 0.001303
K_9639 X_NUC_49.L_CORE X_NUC_208.L_CORE 0.001767
K_9640 X_NUC_49.L_CORE X_NUC_209.L_CORE 0.001990
K_9641 X_NUC_49.L_CORE X_NUC_210.L_CORE 0.001264
K_9642 X_NUC_49.L_CORE X_NUC_211.L_CORE 0.002409
K_9643 X_NUC_49.L_CORE X_NUC_212.L_CORE 0.001433
K_9644 X_NUC_49.L_CORE X_NUC_213.L_CORE 0.001442
K_9645 X_NUC_49.L_CORE X_NUC_214.L_CORE 0.002153
K_9646 X_NUC_49.L_CORE X_NUC_215.L_CORE 0.001277
K_9647 X_NUC_49.L_CORE X_NUC_216.L_CORE 0.001781
K_9648 X_NUC_49.L_CORE X_NUC_217.L_CORE 0.001596
K_9649 X_NUC_49.L_CORE X_NUC_218.L_CORE 0.001335
K_9650 X_NUC_49.L_CORE X_NUC_219.L_CORE 0.001861
K_9651 X_NUC_49.L_CORE X_NUC_220.L_CORE 0.001379
K_9652 X_NUC_49.L_CORE X_NUC_221.L_CORE 0.001497
K_9653 X_NUC_49.L_CORE X_NUC_222.L_CORE 0.001557
K_9654 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_9655 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_9656 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.001514
K_9657 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.001521
K_9658 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.001522
K_9659 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.001513
K_9660 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.002085
K_9661 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.002073
K_9662 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.002087
K_9663 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.002069
K_9664 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.003056
K_9665 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.003101
K_9666 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.003076
K_9667 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.003070
K_9668 X_NUC_50.L_CORE X_NUC_65.L_CORE 0.001381
K_9669 X_NUC_50.L_CORE X_NUC_66.L_CORE 0.001383
K_9670 X_NUC_50.L_CORE X_NUC_67.L_CORE 0.001386
K_9671 X_NUC_50.L_CORE X_NUC_68.L_CORE 0.001377
K_9672 X_NUC_50.L_CORE X_NUC_69.L_CORE 0.004558
K_9673 X_NUC_50.L_CORE X_NUC_70.L_CORE 0.004476
K_9674 X_NUC_50.L_CORE X_NUC_71.L_CORE 0.004506
K_9675 X_NUC_50.L_CORE X_NUC_72.L_CORE 0.004471
K_9676 X_NUC_50.L_CORE X_NUC_73.L_CORE 0.001688
K_9677 X_NUC_50.L_CORE X_NUC_74.L_CORE 0.001699
K_9678 X_NUC_50.L_CORE X_NUC_75.L_CORE 0.001695
K_9679 X_NUC_50.L_CORE X_NUC_76.L_CORE 0.001687
K_9680 X_NUC_50.L_CORE X_NUC_77.L_CORE 0.001572
K_9681 X_NUC_50.L_CORE X_NUC_78.L_CORE 0.001569
K_9682 X_NUC_50.L_CORE X_NUC_79.L_CORE 0.001574
K_9683 X_NUC_50.L_CORE X_NUC_80.L_CORE 0.001563
K_9684 X_NUC_50.L_CORE X_NUC_81.L_CORE 0.005058
K_9685 X_NUC_50.L_CORE X_NUC_82.L_CORE 0.005139
K_9686 X_NUC_50.L_CORE X_NUC_83.L_CORE 0.005020
K_9687 X_NUC_50.L_CORE X_NUC_84.L_CORE 0.005048
K_9688 X_NUC_50.L_CORE X_NUC_85.L_CORE 0.001354
K_9689 X_NUC_50.L_CORE X_NUC_86.L_CORE 0.001358
K_9690 X_NUC_50.L_CORE X_NUC_87.L_CORE 0.001358
K_9691 X_NUC_50.L_CORE X_NUC_88.L_CORE 0.001350
K_9692 X_NUC_50.L_CORE X_NUC_89.L_CORE 0.002328
K_9693 X_NUC_50.L_CORE X_NUC_90.L_CORE 0.002311
K_9694 X_NUC_50.L_CORE X_NUC_91.L_CORE 0.002320
K_9695 X_NUC_50.L_CORE X_NUC_92.L_CORE 0.002304
K_9696 X_NUC_50.L_CORE X_NUC_93.L_CORE 0.002082
K_9697 X_NUC_50.L_CORE X_NUC_94.L_CORE 0.002101
K_9698 X_NUC_50.L_CORE X_NUC_95.L_CORE 0.002088
K_9699 X_NUC_50.L_CORE X_NUC_96.L_CORE 0.002082
K_9700 X_NUC_50.L_CORE X_NUC_97.L_CORE 0.001359
K_9701 X_NUC_50.L_CORE X_NUC_98.L_CORE 0.001359
K_9702 X_NUC_50.L_CORE X_NUC_99.L_CORE 0.001361
K_9703 X_NUC_50.L_CORE X_NUC_100.L_CORE 0.001353
K_9704 X_NUC_50.L_CORE X_NUC_101.L_CORE 0.004079
K_9705 X_NUC_50.L_CORE X_NUC_102.L_CORE 0.004053
K_9706 X_NUC_50.L_CORE X_NUC_103.L_CORE 0.004014
K_9707 X_NUC_50.L_CORE X_NUC_104.L_CORE 0.004013
K_9708 X_NUC_50.L_CORE X_NUC_105.L_CORE 0.001447
K_9709 X_NUC_50.L_CORE X_NUC_106.L_CORE 0.001453
K_9710 X_NUC_50.L_CORE X_NUC_107.L_CORE 0.001451
K_9711 X_NUC_50.L_CORE X_NUC_108.L_CORE 0.001444
K_9712 X_NUC_50.L_CORE X_NUC_109.L_CORE 0.001666
K_9713 X_NUC_50.L_CORE X_NUC_110.L_CORE 0.001661
K_9714 X_NUC_50.L_CORE X_NUC_111.L_CORE 0.001665
K_9715 X_NUC_50.L_CORE X_NUC_112.L_CORE 0.001654
K_9716 X_NUC_50.L_CORE X_NUC_113.L_CORE 0.002636
K_9717 X_NUC_50.L_CORE X_NUC_114.L_CORE 0.002658
K_9718 X_NUC_50.L_CORE X_NUC_115.L_CORE 0.002630
K_9719 X_NUC_50.L_CORE X_NUC_116.L_CORE 0.002629
K_9720 X_NUC_50.L_CORE X_NUC_117.L_CORE 0.001301
K_9721 X_NUC_50.L_CORE X_NUC_118.L_CORE 0.001303
K_9722 X_NUC_50.L_CORE X_NUC_119.L_CORE 0.001303
K_9723 X_NUC_50.L_CORE X_NUC_120.L_CORE 0.001296
K_9724 X_NUC_50.L_CORE X_NUC_121.L_CORE 0.002410
K_9725 X_NUC_50.L_CORE X_NUC_122.L_CORE 0.002396
K_9726 X_NUC_50.L_CORE X_NUC_123.L_CORE 0.002393
K_9727 X_NUC_50.L_CORE X_NUC_124.L_CORE 0.002382
K_9728 X_NUC_50.L_CORE X_NUC_125.L_CORE 0.001650
K_9729 X_NUC_50.L_CORE X_NUC_126.L_CORE 0.001659
K_9730 X_NUC_50.L_CORE X_NUC_127.L_CORE 0.001652
K_9731 X_NUC_50.L_CORE X_NUC_128.L_CORE 0.001646
K_9732 X_NUC_50.L_CORE X_NUC_129.L_CORE 0.001408
K_9733 X_NUC_50.L_CORE X_NUC_130.L_CORE 0.001406
K_9734 X_NUC_50.L_CORE X_NUC_131.L_CORE 0.001408
K_9735 X_NUC_50.L_CORE X_NUC_132.L_CORE 0.001400
K_9736 X_NUC_50.L_CORE X_NUC_133.L_CORE 0.002634
K_9737 X_NUC_50.L_CORE X_NUC_134.L_CORE 0.002639
K_9738 X_NUC_50.L_CORE X_NUC_135.L_CORE 0.002614
K_9739 X_NUC_50.L_CORE X_NUC_136.L_CORE 0.002613
K_9740 X_NUC_50.L_CORE X_NUC_137.L_CORE 0.001351
K_9741 X_NUC_50.L_CORE X_NUC_138.L_CORE 0.001355
K_9742 X_NUC_50.L_CORE X_NUC_139.L_CORE 0.001353
K_9743 X_NUC_50.L_CORE X_NUC_140.L_CORE 0.001346
K_9744 X_NUC_50.L_CORE X_NUC_141.L_CORE 0.001744
K_9745 X_NUC_50.L_CORE X_NUC_142.L_CORE 0.001739
K_9746 X_NUC_50.L_CORE X_NUC_143.L_CORE 0.001738
K_9747 X_NUC_50.L_CORE X_NUC_144.L_CORE 0.001730
K_9748 X_NUC_50.L_CORE X_NUC_145.L_CORE 0.001862
K_9749 X_NUC_50.L_CORE X_NUC_146.L_CORE 0.001871
K_9750 X_NUC_50.L_CORE X_NUC_147.L_CORE 0.001859
K_9751 X_NUC_50.L_CORE X_NUC_148.L_CORE 0.001855
K_9752 X_NUC_50.L_CORE X_NUC_149.L_CORE 0.001339
K_9753 X_NUC_50.L_CORE X_NUC_150.L_CORE 0.001340
K_9754 X_NUC_50.L_CORE X_NUC_151.L_CORE 0.001339
K_9755 X_NUC_50.L_CORE X_NUC_152.L_CORE 0.001332
K_9756 X_NUC_50.L_CORE X_NUC_153.L_CORE 0.002028
K_9757 X_NUC_50.L_CORE X_NUC_154.L_CORE 0.002026
K_9758 X_NUC_50.L_CORE X_NUC_155.L_CORE 0.002017
K_9759 X_NUC_50.L_CORE X_NUC_156.L_CORE 0.002011
K_9760 X_NUC_50.L_CORE X_NUC_157.L_CORE 0.001478
K_9761 X_NUC_50.L_CORE X_NUC_158.L_CORE 0.001483
K_9762 X_NUC_50.L_CORE X_NUC_159.L_CORE 0.001478
K_9763 X_NUC_50.L_CORE X_NUC_160.L_CORE 0.001472
K_9764 X_NUC_50.L_CORE X_NUC_161.L_CORE 0.001497
K_9765 X_NUC_50.L_CORE X_NUC_162.L_CORE 0.001497
K_9766 X_NUC_50.L_CORE X_NUC_163.L_CORE 0.001495
K_9767 X_NUC_50.L_CORE X_NUC_164.L_CORE 0.001488
K_9768 X_NUC_50.L_CORE X_NUC_165.L_CORE 0.001757
K_9769 X_NUC_50.L_CORE X_NUC_166.L_CORE 0.001760
K_9770 X_NUC_50.L_CORE X_NUC_167.L_CORE 0.001752
K_9771 X_NUC_50.L_CORE X_NUC_168.L_CORE 0.001746
K_9772 X_NUC_50.L_CORE X_NUC_169.L_CORE 0.001455
K_9773 X_NUC_50.L_CORE X_NUC_170.L_CORE 0.001457
K_9774 X_NUC_50.L_CORE X_NUC_171.L_CORE 0.001453
K_9775 X_NUC_50.L_CORE X_NUC_172.L_CORE 0.001447
K_9776 X_NUC_50.L_CORE X_NUC_173.L_CORE 0.002048
K_9777 X_NUC_50.L_CORE X_NUC_174.L_CORE 0.002473
K_9778 X_NUC_50.L_CORE X_NUC_175.L_CORE 0.002614
K_9779 X_NUC_50.L_CORE X_NUC_176.L_CORE 0.001713
K_9780 X_NUC_50.L_CORE X_NUC_177.L_CORE 0.004313
K_9781 X_NUC_50.L_CORE X_NUC_178.L_CORE 0.001826
K_9782 X_NUC_50.L_CORE X_NUC_179.L_CORE 0.001924
K_9783 X_NUC_50.L_CORE X_NUC_180.L_CORE 0.004375
K_9784 X_NUC_50.L_CORE X_NUC_181.L_CORE 0.001497
K_9785 X_NUC_50.L_CORE X_NUC_182.L_CORE 0.003205
K_9786 X_NUC_50.L_CORE X_NUC_183.L_CORE 0.002117
K_9787 X_NUC_50.L_CORE X_NUC_184.L_CORE 0.001531
K_9788 X_NUC_50.L_CORE X_NUC_185.L_CORE 0.021761
K_9789 X_NUC_50.L_CORE X_NUC_186.L_CORE 0.001492
K_9790 X_NUC_50.L_CORE X_NUC_187.L_CORE 0.002045
K_9791 X_NUC_50.L_CORE X_NUC_188.L_CORE 0.003049
K_9792 X_NUC_50.L_CORE X_NUC_189.L_CORE 0.001358
K_9793 X_NUC_50.L_CORE X_NUC_190.L_CORE 0.004674
K_9794 X_NUC_50.L_CORE X_NUC_191.L_CORE 0.001667
K_9795 X_NUC_50.L_CORE X_NUC_192.L_CORE 0.001544
K_9796 X_NUC_50.L_CORE X_NUC_193.L_CORE 0.005864
K_9797 X_NUC_50.L_CORE X_NUC_194.L_CORE 0.001328
K_9798 X_NUC_50.L_CORE X_NUC_195.L_CORE 0.002338
K_9799 X_NUC_50.L_CORE X_NUC_196.L_CORE 0.002096
K_9800 X_NUC_50.L_CORE X_NUC_197.L_CORE 0.001328
K_9801 X_NUC_50.L_CORE X_NUC_198.L_CORE 0.005016
K_9802 X_NUC_50.L_CORE X_NUC_199.L_CORE 0.001419
K_9803 X_NUC_50.L_CORE X_NUC_200.L_CORE 0.001646
K_9804 X_NUC_50.L_CORE X_NUC_201.L_CORE 0.002873
K_9805 X_NUC_50.L_CORE X_NUC_202.L_CORE 0.001260
K_9806 X_NUC_50.L_CORE X_NUC_203.L_CORE 0.002596
K_9807 X_NUC_50.L_CORE X_NUC_204.L_CORE 0.001644
K_9808 X_NUC_50.L_CORE X_NUC_205.L_CORE 0.001365
K_9809 X_NUC_50.L_CORE X_NUC_206.L_CORE 0.003221
K_9810 X_NUC_50.L_CORE X_NUC_207.L_CORE 0.001299
K_9811 X_NUC_50.L_CORE X_NUC_208.L_CORE 0.001775
K_9812 X_NUC_50.L_CORE X_NUC_209.L_CORE 0.001977
K_9813 X_NUC_50.L_CORE X_NUC_210.L_CORE 0.001264
K_9814 X_NUC_50.L_CORE X_NUC_211.L_CORE 0.002418
K_9815 X_NUC_50.L_CORE X_NUC_212.L_CORE 0.001427
K_9816 X_NUC_50.L_CORE X_NUC_213.L_CORE 0.001444
K_9817 X_NUC_50.L_CORE X_NUC_214.L_CORE 0.002145
K_9818 X_NUC_50.L_CORE X_NUC_215.L_CORE 0.001275
K_9819 X_NUC_50.L_CORE X_NUC_216.L_CORE 0.001786
K_9820 X_NUC_50.L_CORE X_NUC_217.L_CORE 0.001589
K_9821 X_NUC_50.L_CORE X_NUC_218.L_CORE 0.001335
K_9822 X_NUC_50.L_CORE X_NUC_219.L_CORE 0.001861
K_9823 X_NUC_50.L_CORE X_NUC_220.L_CORE 0.001376
K_9824 X_NUC_50.L_CORE X_NUC_221.L_CORE 0.001498
K_9825 X_NUC_50.L_CORE X_NUC_222.L_CORE 0.001554
K_9826 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_9827 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.001513
K_9828 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.001520
K_9829 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.001521
K_9830 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.001512
K_9831 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.002072
K_9832 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.002060
K_9833 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.002073
K_9834 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.002056
K_9835 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.003080
K_9836 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.003126
K_9837 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.003101
K_9838 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.003094
K_9839 X_NUC_51.L_CORE X_NUC_65.L_CORE 0.001378
K_9840 X_NUC_51.L_CORE X_NUC_66.L_CORE 0.001380
K_9841 X_NUC_51.L_CORE X_NUC_67.L_CORE 0.001383
K_9842 X_NUC_51.L_CORE X_NUC_68.L_CORE 0.001374
K_9843 X_NUC_51.L_CORE X_NUC_69.L_CORE 0.004526
K_9844 X_NUC_51.L_CORE X_NUC_70.L_CORE 0.004444
K_9845 X_NUC_51.L_CORE X_NUC_71.L_CORE 0.004476
K_9846 X_NUC_51.L_CORE X_NUC_72.L_CORE 0.004440
K_9847 X_NUC_51.L_CORE X_NUC_73.L_CORE 0.001691
K_9848 X_NUC_51.L_CORE X_NUC_74.L_CORE 0.001702
K_9849 X_NUC_51.L_CORE X_NUC_75.L_CORE 0.001699
K_9850 X_NUC_51.L_CORE X_NUC_76.L_CORE 0.001691
K_9851 X_NUC_51.L_CORE X_NUC_77.L_CORE 0.001567
K_9852 X_NUC_51.L_CORE X_NUC_78.L_CORE 0.001563
K_9853 X_NUC_51.L_CORE X_NUC_79.L_CORE 0.001569
K_9854 X_NUC_51.L_CORE X_NUC_80.L_CORE 0.001558
K_9855 X_NUC_51.L_CORE X_NUC_81.L_CORE 0.005178
K_9856 X_NUC_51.L_CORE X_NUC_82.L_CORE 0.005263
K_9857 X_NUC_51.L_CORE X_NUC_83.L_CORE 0.005139
K_9858 X_NUC_51.L_CORE X_NUC_84.L_CORE 0.005167
K_9859 X_NUC_51.L_CORE X_NUC_85.L_CORE 0.001353
K_9860 X_NUC_51.L_CORE X_NUC_86.L_CORE 0.001357
K_9861 X_NUC_51.L_CORE X_NUC_87.L_CORE 0.001358
K_9862 X_NUC_51.L_CORE X_NUC_88.L_CORE 0.001350
K_9863 X_NUC_51.L_CORE X_NUC_89.L_CORE 0.002319
K_9864 X_NUC_51.L_CORE X_NUC_90.L_CORE 0.002302
K_9865 X_NUC_51.L_CORE X_NUC_91.L_CORE 0.002311
K_9866 X_NUC_51.L_CORE X_NUC_92.L_CORE 0.002295
K_9867 X_NUC_51.L_CORE X_NUC_93.L_CORE 0.002095
K_9868 X_NUC_51.L_CORE X_NUC_94.L_CORE 0.002113
K_9869 X_NUC_51.L_CORE X_NUC_95.L_CORE 0.002101
K_9870 X_NUC_51.L_CORE X_NUC_96.L_CORE 0.002095
K_9871 X_NUC_51.L_CORE X_NUC_97.L_CORE 0.001356
K_9872 X_NUC_51.L_CORE X_NUC_98.L_CORE 0.001356
K_9873 X_NUC_51.L_CORE X_NUC_99.L_CORE 0.001359
K_9874 X_NUC_51.L_CORE X_NUC_100.L_CORE 0.001350
K_9875 X_NUC_51.L_CORE X_NUC_101.L_CORE 0.004120
K_9876 X_NUC_51.L_CORE X_NUC_102.L_CORE 0.004092
K_9877 X_NUC_51.L_CORE X_NUC_103.L_CORE 0.004053
K_9878 X_NUC_51.L_CORE X_NUC_104.L_CORE 0.004052
K_9879 X_NUC_51.L_CORE X_NUC_105.L_CORE 0.001449
K_9880 X_NUC_51.L_CORE X_NUC_106.L_CORE 0.001456
K_9881 X_NUC_51.L_CORE X_NUC_107.L_CORE 0.001453
K_9882 X_NUC_51.L_CORE X_NUC_108.L_CORE 0.001446
K_9883 X_NUC_51.L_CORE X_NUC_109.L_CORE 0.001663
K_9884 X_NUC_51.L_CORE X_NUC_110.L_CORE 0.001657
K_9885 X_NUC_51.L_CORE X_NUC_111.L_CORE 0.001661
K_9886 X_NUC_51.L_CORE X_NUC_112.L_CORE 0.001651
K_9887 X_NUC_51.L_CORE X_NUC_113.L_CORE 0.002665
K_9888 X_NUC_51.L_CORE X_NUC_114.L_CORE 0.002688
K_9889 X_NUC_51.L_CORE X_NUC_115.L_CORE 0.002658
K_9890 X_NUC_51.L_CORE X_NUC_116.L_CORE 0.002658
K_9891 X_NUC_51.L_CORE X_NUC_117.L_CORE 0.001300
K_9892 X_NUC_51.L_CORE X_NUC_118.L_CORE 0.001302
K_9893 X_NUC_51.L_CORE X_NUC_119.L_CORE 0.001303
K_9894 X_NUC_51.L_CORE X_NUC_120.L_CORE 0.001295
K_9895 X_NUC_51.L_CORE X_NUC_121.L_CORE 0.002413
K_9896 X_NUC_51.L_CORE X_NUC_122.L_CORE 0.002398
K_9897 X_NUC_51.L_CORE X_NUC_123.L_CORE 0.002396
K_9898 X_NUC_51.L_CORE X_NUC_124.L_CORE 0.002385
K_9899 X_NUC_51.L_CORE X_NUC_125.L_CORE 0.001657
K_9900 X_NUC_51.L_CORE X_NUC_126.L_CORE 0.001666
K_9901 X_NUC_51.L_CORE X_NUC_127.L_CORE 0.001659
K_9902 X_NUC_51.L_CORE X_NUC_128.L_CORE 0.001653
K_9903 X_NUC_51.L_CORE X_NUC_129.L_CORE 0.001406
K_9904 X_NUC_51.L_CORE X_NUC_130.L_CORE 0.001405
K_9905 X_NUC_51.L_CORE X_NUC_131.L_CORE 0.001406
K_9906 X_NUC_51.L_CORE X_NUC_132.L_CORE 0.001398
K_9907 X_NUC_51.L_CORE X_NUC_133.L_CORE 0.002659
K_9908 X_NUC_51.L_CORE X_NUC_134.L_CORE 0.002664
K_9909 X_NUC_51.L_CORE X_NUC_135.L_CORE 0.002639
K_9910 X_NUC_51.L_CORE X_NUC_136.L_CORE 0.002637
K_9911 X_NUC_51.L_CORE X_NUC_137.L_CORE 0.001353
K_9912 X_NUC_51.L_CORE X_NUC_138.L_CORE 0.001357
K_9913 X_NUC_51.L_CORE X_NUC_139.L_CORE 0.001355
K_9914 X_NUC_51.L_CORE X_NUC_140.L_CORE 0.001349
K_9915 X_NUC_51.L_CORE X_NUC_141.L_CORE 0.001744
K_9916 X_NUC_51.L_CORE X_NUC_142.L_CORE 0.001739
K_9917 X_NUC_51.L_CORE X_NUC_143.L_CORE 0.001739
K_9918 X_NUC_51.L_CORE X_NUC_144.L_CORE 0.001730
K_9919 X_NUC_51.L_CORE X_NUC_145.L_CORE 0.001874
K_9920 X_NUC_51.L_CORE X_NUC_146.L_CORE 0.001883
K_9921 X_NUC_51.L_CORE X_NUC_147.L_CORE 0.001871
K_9922 X_NUC_51.L_CORE X_NUC_148.L_CORE 0.001866
K_9923 X_NUC_51.L_CORE X_NUC_149.L_CORE 0.001339
K_9924 X_NUC_51.L_CORE X_NUC_150.L_CORE 0.001340
K_9925 X_NUC_51.L_CORE X_NUC_151.L_CORE 0.001340
K_9926 X_NUC_51.L_CORE X_NUC_152.L_CORE 0.001333
K_9927 X_NUC_51.L_CORE X_NUC_153.L_CORE 0.002037
K_9928 X_NUC_51.L_CORE X_NUC_154.L_CORE 0.002034
K_9929 X_NUC_51.L_CORE X_NUC_155.L_CORE 0.002026
K_9930 X_NUC_51.L_CORE X_NUC_156.L_CORE 0.002019
K_9931 X_NUC_51.L_CORE X_NUC_157.L_CORE 0.001483
K_9932 X_NUC_51.L_CORE X_NUC_158.L_CORE 0.001487
K_9933 X_NUC_51.L_CORE X_NUC_159.L_CORE 0.001483
K_9934 X_NUC_51.L_CORE X_NUC_160.L_CORE 0.001477
K_9935 X_NUC_51.L_CORE X_NUC_161.L_CORE 0.001499
K_9936 X_NUC_51.L_CORE X_NUC_162.L_CORE 0.001498
K_9937 X_NUC_51.L_CORE X_NUC_163.L_CORE 0.001497
K_9938 X_NUC_51.L_CORE X_NUC_164.L_CORE 0.001489
K_9939 X_NUC_51.L_CORE X_NUC_165.L_CORE 0.001765
K_9940 X_NUC_51.L_CORE X_NUC_166.L_CORE 0.001769
K_9941 X_NUC_51.L_CORE X_NUC_167.L_CORE 0.001760
K_9942 X_NUC_51.L_CORE X_NUC_168.L_CORE 0.001755
K_9943 X_NUC_51.L_CORE X_NUC_169.L_CORE 0.001459
K_9944 X_NUC_51.L_CORE X_NUC_170.L_CORE 0.001460
K_9945 X_NUC_51.L_CORE X_NUC_171.L_CORE 0.001457
K_9946 X_NUC_51.L_CORE X_NUC_172.L_CORE 0.001451
K_9947 X_NUC_51.L_CORE X_NUC_173.L_CORE 0.002036
K_9948 X_NUC_51.L_CORE X_NUC_174.L_CORE 0.002448
K_9949 X_NUC_51.L_CORE X_NUC_175.L_CORE 0.002601
K_9950 X_NUC_51.L_CORE X_NUC_176.L_CORE 0.001704
K_9951 X_NUC_51.L_CORE X_NUC_177.L_CORE 0.004230
K_9952 X_NUC_51.L_CORE X_NUC_178.L_CORE 0.001822
K_9953 X_NUC_51.L_CORE X_NUC_179.L_CORE 0.001910
K_9954 X_NUC_51.L_CORE X_NUC_180.L_CORE 0.004363
K_9955 X_NUC_51.L_CORE X_NUC_181.L_CORE 0.001493
K_9956 X_NUC_51.L_CORE X_NUC_182.L_CORE 0.003162
K_9957 X_NUC_51.L_CORE X_NUC_183.L_CORE 0.002118
K_9958 X_NUC_51.L_CORE X_NUC_184.L_CORE 0.001525
K_9959 X_NUC_51.L_CORE X_NUC_185.L_CORE 0.020442
K_9960 X_NUC_51.L_CORE X_NUC_186.L_CORE 0.001491
K_9961 X_NUC_51.L_CORE X_NUC_187.L_CORE 0.002031
K_9962 X_NUC_51.L_CORE X_NUC_188.L_CORE 0.003070
K_9963 X_NUC_51.L_CORE X_NUC_189.L_CORE 0.001354
K_9964 X_NUC_51.L_CORE X_NUC_190.L_CORE 0.004621
K_9965 X_NUC_51.L_CORE X_NUC_191.L_CORE 0.001670
K_9966 X_NUC_51.L_CORE X_NUC_192.L_CORE 0.001538
K_9967 X_NUC_51.L_CORE X_NUC_193.L_CORE 0.006024
K_9968 X_NUC_51.L_CORE X_NUC_194.L_CORE 0.001327
K_9969 X_NUC_51.L_CORE X_NUC_195.L_CORE 0.002325
K_9970 X_NUC_51.L_CORE X_NUC_196.L_CORE 0.002108
K_9971 X_NUC_51.L_CORE X_NUC_197.L_CORE 0.001325
K_9972 X_NUC_51.L_CORE X_NUC_198.L_CORE 0.005068
K_9973 X_NUC_51.L_CORE X_NUC_199.L_CORE 0.001421
K_9974 X_NUC_51.L_CORE X_NUC_200.L_CORE 0.001641
K_9975 X_NUC_51.L_CORE X_NUC_201.L_CORE 0.002909
K_9976 X_NUC_51.L_CORE X_NUC_202.L_CORE 0.001260
K_9977 X_NUC_51.L_CORE X_NUC_203.L_CORE 0.002595
K_9978 X_NUC_51.L_CORE X_NUC_204.L_CORE 0.001650
K_9979 X_NUC_51.L_CORE X_NUC_205.L_CORE 0.001363
K_9980 X_NUC_51.L_CORE X_NUC_206.L_CORE 0.003263
K_9981 X_NUC_51.L_CORE X_NUC_207.L_CORE 0.001300
K_9982 X_NUC_51.L_CORE X_NUC_208.L_CORE 0.001772
K_9983 X_NUC_51.L_CORE X_NUC_209.L_CORE 0.001991
K_9984 X_NUC_51.L_CORE X_NUC_210.L_CORE 0.001263
K_9985 X_NUC_51.L_CORE X_NUC_211.L_CORE 0.002429
K_9986 X_NUC_51.L_CORE X_NUC_212.L_CORE 0.001431
K_9987 X_NUC_51.L_CORE X_NUC_213.L_CORE 0.001443
K_9988 X_NUC_51.L_CORE X_NUC_214.L_CORE 0.002163
K_9989 X_NUC_51.L_CORE X_NUC_215.L_CORE 0.001276
K_9990 X_NUC_51.L_CORE X_NUC_216.L_CORE 0.001789
K_9991 X_NUC_51.L_CORE X_NUC_217.L_CORE 0.001597
K_9992 X_NUC_51.L_CORE X_NUC_218.L_CORE 0.001336
K_9993 X_NUC_51.L_CORE X_NUC_219.L_CORE 0.001870
K_9994 X_NUC_51.L_CORE X_NUC_220.L_CORE 0.001380
K_9995 X_NUC_51.L_CORE X_NUC_221.L_CORE 0.001500
K_9996 X_NUC_51.L_CORE X_NUC_222.L_CORE 0.001560
K_9997 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.001522
K_9998 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.001529
K_9999 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.001530
K_10000 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.001521
K_10001 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.002089
K_10002 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.002077
K_10003 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.002091
K_10004 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.002073
K_10005 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.003087
K_10006 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.003132
K_10007 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.003107
K_10008 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.003101
K_10009 X_NUC_52.L_CORE X_NUC_65.L_CORE 0.001387
K_10010 X_NUC_52.L_CORE X_NUC_66.L_CORE 0.001389
K_10011 X_NUC_52.L_CORE X_NUC_67.L_CORE 0.001392
K_10012 X_NUC_52.L_CORE X_NUC_68.L_CORE 0.001383
K_10013 X_NUC_52.L_CORE X_NUC_69.L_CORE 0.004563
K_10014 X_NUC_52.L_CORE X_NUC_70.L_CORE 0.004479
K_10015 X_NUC_52.L_CORE X_NUC_71.L_CORE 0.004510
K_10016 X_NUC_52.L_CORE X_NUC_72.L_CORE 0.004476
K_10017 X_NUC_52.L_CORE X_NUC_73.L_CORE 0.001699
K_10018 X_NUC_52.L_CORE X_NUC_74.L_CORE 0.001710
K_10019 X_NUC_52.L_CORE X_NUC_75.L_CORE 0.001707
K_10020 X_NUC_52.L_CORE X_NUC_76.L_CORE 0.001699
K_10021 X_NUC_52.L_CORE X_NUC_77.L_CORE 0.001578
K_10022 X_NUC_52.L_CORE X_NUC_78.L_CORE 0.001574
K_10023 X_NUC_52.L_CORE X_NUC_79.L_CORE 0.001580
K_10024 X_NUC_52.L_CORE X_NUC_80.L_CORE 0.001569
K_10025 X_NUC_52.L_CORE X_NUC_81.L_CORE 0.005148
K_10026 X_NUC_52.L_CORE X_NUC_82.L_CORE 0.005231
K_10027 X_NUC_52.L_CORE X_NUC_83.L_CORE 0.005108
K_10028 X_NUC_52.L_CORE X_NUC_84.L_CORE 0.005139
K_10029 X_NUC_52.L_CORE X_NUC_85.L_CORE 0.001361
K_10030 X_NUC_52.L_CORE X_NUC_86.L_CORE 0.001365
K_10031 X_NUC_52.L_CORE X_NUC_87.L_CORE 0.001365
K_10032 X_NUC_52.L_CORE X_NUC_88.L_CORE 0.001358
K_10033 X_NUC_52.L_CORE X_NUC_89.L_CORE 0.002335
K_10034 X_NUC_52.L_CORE X_NUC_90.L_CORE 0.002318
K_10035 X_NUC_52.L_CORE X_NUC_91.L_CORE 0.002327
K_10036 X_NUC_52.L_CORE X_NUC_92.L_CORE 0.002311
K_10037 X_NUC_52.L_CORE X_NUC_93.L_CORE 0.002100
K_10038 X_NUC_52.L_CORE X_NUC_94.L_CORE 0.002119
K_10039 X_NUC_52.L_CORE X_NUC_95.L_CORE 0.002106
K_10040 X_NUC_52.L_CORE X_NUC_96.L_CORE 0.002101
K_10041 X_NUC_52.L_CORE X_NUC_97.L_CORE 0.001365
K_10042 X_NUC_52.L_CORE X_NUC_98.L_CORE 0.001365
K_10043 X_NUC_52.L_CORE X_NUC_99.L_CORE 0.001367
K_10044 X_NUC_52.L_CORE X_NUC_100.L_CORE 0.001359
K_10045 X_NUC_52.L_CORE X_NUC_101.L_CORE 0.004120
K_10046 X_NUC_52.L_CORE X_NUC_102.L_CORE 0.004092
K_10047 X_NUC_52.L_CORE X_NUC_103.L_CORE 0.004053
K_10048 X_NUC_52.L_CORE X_NUC_104.L_CORE 0.004053
K_10049 X_NUC_52.L_CORE X_NUC_105.L_CORE 0.001456
K_10050 X_NUC_52.L_CORE X_NUC_106.L_CORE 0.001463
K_10051 X_NUC_52.L_CORE X_NUC_107.L_CORE 0.001460
K_10052 X_NUC_52.L_CORE X_NUC_108.L_CORE 0.001453
K_10053 X_NUC_52.L_CORE X_NUC_109.L_CORE 0.001673
K_10054 X_NUC_52.L_CORE X_NUC_110.L_CORE 0.001668
K_10055 X_NUC_52.L_CORE X_NUC_111.L_CORE 0.001672
K_10056 X_NUC_52.L_CORE X_NUC_112.L_CORE 0.001661
K_10057 X_NUC_52.L_CORE X_NUC_113.L_CORE 0.002666
K_10058 X_NUC_52.L_CORE X_NUC_114.L_CORE 0.002688
K_10059 X_NUC_52.L_CORE X_NUC_115.L_CORE 0.002659
K_10060 X_NUC_52.L_CORE X_NUC_116.L_CORE 0.002658
K_10061 X_NUC_52.L_CORE X_NUC_117.L_CORE 0.001307
K_10062 X_NUC_52.L_CORE X_NUC_118.L_CORE 0.001310
K_10063 X_NUC_52.L_CORE X_NUC_119.L_CORE 0.001310
K_10064 X_NUC_52.L_CORE X_NUC_120.L_CORE 0.001303
K_10065 X_NUC_52.L_CORE X_NUC_121.L_CORE 0.002424
K_10066 X_NUC_52.L_CORE X_NUC_122.L_CORE 0.002409
K_10067 X_NUC_52.L_CORE X_NUC_123.L_CORE 0.002406
K_10068 X_NUC_52.L_CORE X_NUC_124.L_CORE 0.002396
K_10069 X_NUC_52.L_CORE X_NUC_125.L_CORE 0.001662
K_10070 X_NUC_52.L_CORE X_NUC_126.L_CORE 0.001672
K_10071 X_NUC_52.L_CORE X_NUC_127.L_CORE 0.001665
K_10072 X_NUC_52.L_CORE X_NUC_128.L_CORE 0.001659
K_10073 X_NUC_52.L_CORE X_NUC_129.L_CORE 0.001415
K_10074 X_NUC_52.L_CORE X_NUC_130.L_CORE 0.001413
K_10075 X_NUC_52.L_CORE X_NUC_131.L_CORE 0.001415
K_10076 X_NUC_52.L_CORE X_NUC_132.L_CORE 0.001406
K_10077 X_NUC_52.L_CORE X_NUC_133.L_CORE 0.002661
K_10078 X_NUC_52.L_CORE X_NUC_134.L_CORE 0.002666
K_10079 X_NUC_52.L_CORE X_NUC_135.L_CORE 0.002641
K_10080 X_NUC_52.L_CORE X_NUC_136.L_CORE 0.002639
K_10081 X_NUC_52.L_CORE X_NUC_137.L_CORE 0.001359
K_10082 X_NUC_52.L_CORE X_NUC_138.L_CORE 0.001363
K_10083 X_NUC_52.L_CORE X_NUC_139.L_CORE 0.001361
K_10084 X_NUC_52.L_CORE X_NUC_140.L_CORE 0.001355
K_10085 X_NUC_52.L_CORE X_NUC_141.L_CORE 0.001753
K_10086 X_NUC_52.L_CORE X_NUC_142.L_CORE 0.001748
K_10087 X_NUC_52.L_CORE X_NUC_143.L_CORE 0.001748
K_10088 X_NUC_52.L_CORE X_NUC_144.L_CORE 0.001739
K_10089 X_NUC_52.L_CORE X_NUC_145.L_CORE 0.001878
K_10090 X_NUC_52.L_CORE X_NUC_146.L_CORE 0.001887
K_10091 X_NUC_52.L_CORE X_NUC_147.L_CORE 0.001875
K_10092 X_NUC_52.L_CORE X_NUC_148.L_CORE 0.001871
K_10093 X_NUC_52.L_CORE X_NUC_149.L_CORE 0.001346
K_10094 X_NUC_52.L_CORE X_NUC_150.L_CORE 0.001347
K_10095 X_NUC_52.L_CORE X_NUC_151.L_CORE 0.001346
K_10096 X_NUC_52.L_CORE X_NUC_152.L_CORE 0.001340
K_10097 X_NUC_52.L_CORE X_NUC_153.L_CORE 0.002043
K_10098 X_NUC_52.L_CORE X_NUC_154.L_CORE 0.002041
K_10099 X_NUC_52.L_CORE X_NUC_155.L_CORE 0.002032
K_10100 X_NUC_52.L_CORE X_NUC_156.L_CORE 0.002026
K_10101 X_NUC_52.L_CORE X_NUC_157.L_CORE 0.001489
K_10102 X_NUC_52.L_CORE X_NUC_158.L_CORE 0.001493
K_10103 X_NUC_52.L_CORE X_NUC_159.L_CORE 0.001488
K_10104 X_NUC_52.L_CORE X_NUC_160.L_CORE 0.001483
K_10105 X_NUC_52.L_CORE X_NUC_161.L_CORE 0.001506
K_10106 X_NUC_52.L_CORE X_NUC_162.L_CORE 0.001505
K_10107 X_NUC_52.L_CORE X_NUC_163.L_CORE 0.001504
K_10108 X_NUC_52.L_CORE X_NUC_164.L_CORE 0.001497
K_10109 X_NUC_52.L_CORE X_NUC_165.L_CORE 0.001771
K_10110 X_NUC_52.L_CORE X_NUC_166.L_CORE 0.001774
K_10111 X_NUC_52.L_CORE X_NUC_167.L_CORE 0.001765
K_10112 X_NUC_52.L_CORE X_NUC_168.L_CORE 0.001760
K_10113 X_NUC_52.L_CORE X_NUC_169.L_CORE 0.001465
K_10114 X_NUC_52.L_CORE X_NUC_170.L_CORE 0.001467
K_10115 X_NUC_52.L_CORE X_NUC_171.L_CORE 0.001463
K_10116 X_NUC_52.L_CORE X_NUC_172.L_CORE 0.001457
K_10117 X_NUC_52.L_CORE X_NUC_173.L_CORE 0.002052
K_10118 X_NUC_52.L_CORE X_NUC_174.L_CORE 0.002471
K_10119 X_NUC_52.L_CORE X_NUC_175.L_CORE 0.002620
K_10120 X_NUC_52.L_CORE X_NUC_176.L_CORE 0.001717
K_10121 X_NUC_52.L_CORE X_NUC_177.L_CORE 0.004283
K_10122 X_NUC_52.L_CORE X_NUC_178.L_CORE 0.001833
K_10123 X_NUC_52.L_CORE X_NUC_179.L_CORE 0.001926
K_10124 X_NUC_52.L_CORE X_NUC_180.L_CORE 0.004385
K_10125 X_NUC_52.L_CORE X_NUC_181.L_CORE 0.001503
K_10126 X_NUC_52.L_CORE X_NUC_182.L_CORE 0.003194
K_10127 X_NUC_52.L_CORE X_NUC_183.L_CORE 0.002129
K_10128 X_NUC_52.L_CORE X_NUC_184.L_CORE 0.001536
K_10129 X_NUC_52.L_CORE X_NUC_185.L_CORE 0.020044
K_10130 X_NUC_52.L_CORE X_NUC_186.L_CORE 0.001499
K_10131 X_NUC_52.L_CORE X_NUC_187.L_CORE 0.002047
K_10132 X_NUC_52.L_CORE X_NUC_188.L_CORE 0.003074
K_10133 X_NUC_52.L_CORE X_NUC_189.L_CORE 0.001363
K_10134 X_NUC_52.L_CORE X_NUC_190.L_CORE 0.004654
K_10135 X_NUC_52.L_CORE X_NUC_191.L_CORE 0.001677
K_10136 X_NUC_52.L_CORE X_NUC_192.L_CORE 0.001549
K_10137 X_NUC_52.L_CORE X_NUC_193.L_CORE 0.005953
K_10138 X_NUC_52.L_CORE X_NUC_194.L_CORE 0.001334
K_10139 X_NUC_52.L_CORE X_NUC_195.L_CORE 0.002341
K_10140 X_NUC_52.L_CORE X_NUC_196.L_CORE 0.002113
K_10141 X_NUC_52.L_CORE X_NUC_197.L_CORE 0.001333
K_10142 X_NUC_52.L_CORE X_NUC_198.L_CORE 0.005049
K_10143 X_NUC_52.L_CORE X_NUC_199.L_CORE 0.001428
K_10144 X_NUC_52.L_CORE X_NUC_200.L_CORE 0.001651
K_10145 X_NUC_52.L_CORE X_NUC_201.L_CORE 0.002905
K_10146 X_NUC_52.L_CORE X_NUC_202.L_CORE 0.001267
K_10147 X_NUC_52.L_CORE X_NUC_203.L_CORE 0.002606
K_10148 X_NUC_52.L_CORE X_NUC_204.L_CORE 0.001656
K_10149 X_NUC_52.L_CORE X_NUC_205.L_CORE 0.001371
K_10150 X_NUC_52.L_CORE X_NUC_206.L_CORE 0.003255
K_10151 X_NUC_52.L_CORE X_NUC_207.L_CORE 0.001307
K_10152 X_NUC_52.L_CORE X_NUC_208.L_CORE 0.001782
K_10153 X_NUC_52.L_CORE X_NUC_209.L_CORE 0.001994
K_10154 X_NUC_52.L_CORE X_NUC_210.L_CORE 0.001270
K_10155 X_NUC_52.L_CORE X_NUC_211.L_CORE 0.002434
K_10156 X_NUC_52.L_CORE X_NUC_212.L_CORE 0.001437
K_10157 X_NUC_52.L_CORE X_NUC_213.L_CORE 0.001451
K_10158 X_NUC_52.L_CORE X_NUC_214.L_CORE 0.002165
K_10159 X_NUC_52.L_CORE X_NUC_215.L_CORE 0.001282
K_10160 X_NUC_52.L_CORE X_NUC_216.L_CORE 0.001796
K_10161 X_NUC_52.L_CORE X_NUC_217.L_CORE 0.001601
K_10162 X_NUC_52.L_CORE X_NUC_218.L_CORE 0.001342
K_10163 X_NUC_52.L_CORE X_NUC_219.L_CORE 0.001875
K_10164 X_NUC_52.L_CORE X_NUC_220.L_CORE 0.001385
K_10165 X_NUC_52.L_CORE X_NUC_221.L_CORE 0.001507
K_10166 X_NUC_52.L_CORE X_NUC_222.L_CORE 0.001565
K_10167 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_10168 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_10169 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_10170 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.001491
K_10171 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.001480
K_10172 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.001484
K_10173 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.001486
K_10174 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.002036
K_10175 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.002032
K_10176 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.002023
K_10177 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.002043
K_10178 X_NUC_53.L_CORE X_NUC_65.L_CORE 0.003051
K_10179 X_NUC_53.L_CORE X_NUC_66.L_CORE 0.003015
K_10180 X_NUC_53.L_CORE X_NUC_67.L_CORE 0.003040
K_10181 X_NUC_53.L_CORE X_NUC_68.L_CORE 0.003016
K_10182 X_NUC_53.L_CORE X_NUC_69.L_CORE 0.001362
K_10183 X_NUC_53.L_CORE X_NUC_70.L_CORE 0.001355
K_10184 X_NUC_53.L_CORE X_NUC_71.L_CORE 0.001355
K_10185 X_NUC_53.L_CORE X_NUC_72.L_CORE 0.001360
K_10186 X_NUC_53.L_CORE X_NUC_73.L_CORE 0.004432
K_10187 X_NUC_53.L_CORE X_NUC_74.L_CORE 0.004465
K_10188 X_NUC_53.L_CORE X_NUC_75.L_CORE 0.004382
K_10189 X_NUC_53.L_CORE X_NUC_76.L_CORE 0.004462
K_10190 X_NUC_53.L_CORE X_NUC_77.L_CORE 0.001677
K_10191 X_NUC_53.L_CORE X_NUC_78.L_CORE 0.001664
K_10192 X_NUC_53.L_CORE X_NUC_79.L_CORE 0.001670
K_10193 X_NUC_53.L_CORE X_NUC_80.L_CORE 0.001668
K_10194 X_NUC_53.L_CORE X_NUC_81.L_CORE 0.001551
K_10195 X_NUC_53.L_CORE X_NUC_82.L_CORE 0.001546
K_10196 X_NUC_53.L_CORE X_NUC_83.L_CORE 0.001542
K_10197 X_NUC_53.L_CORE X_NUC_84.L_CORE 0.001552
K_10198 X_NUC_53.L_CORE X_NUC_85.L_CORE 0.005144
K_10199 X_NUC_53.L_CORE X_NUC_86.L_CORE 0.005099
K_10200 X_NUC_53.L_CORE X_NUC_87.L_CORE 0.005092
K_10201 X_NUC_53.L_CORE X_NUC_88.L_CORE 0.005022
K_10202 X_NUC_53.L_CORE X_NUC_89.L_CORE 0.001345
K_10203 X_NUC_53.L_CORE X_NUC_90.L_CORE 0.001337
K_10204 X_NUC_53.L_CORE X_NUC_91.L_CORE 0.001338
K_10205 X_NUC_53.L_CORE X_NUC_92.L_CORE 0.001341
K_10206 X_NUC_53.L_CORE X_NUC_93.L_CORE 0.002296
K_10207 X_NUC_53.L_CORE X_NUC_94.L_CORE 0.002298
K_10208 X_NUC_53.L_CORE X_NUC_95.L_CORE 0.002278
K_10209 X_NUC_53.L_CORE X_NUC_96.L_CORE 0.002301
K_10210 X_NUC_53.L_CORE X_NUC_97.L_CORE 0.002089
K_10211 X_NUC_53.L_CORE X_NUC_98.L_CORE 0.002072
K_10212 X_NUC_53.L_CORE X_NUC_99.L_CORE 0.002078
K_10213 X_NUC_53.L_CORE X_NUC_100.L_CORE 0.002071
K_10214 X_NUC_53.L_CORE X_NUC_101.L_CORE 0.001351
K_10215 X_NUC_53.L_CORE X_NUC_102.L_CORE 0.001345
K_10216 X_NUC_53.L_CORE X_NUC_103.L_CORE 0.001343
K_10217 X_NUC_53.L_CORE X_NUC_104.L_CORE 0.001349
K_10218 X_NUC_53.L_CORE X_NUC_105.L_CORE 0.004068
K_10219 X_NUC_53.L_CORE X_NUC_106.L_CORE 0.004084
K_10220 X_NUC_53.L_CORE X_NUC_107.L_CORE 0.004013
K_10221 X_NUC_53.L_CORE X_NUC_108.L_CORE 0.004033
K_10222 X_NUC_53.L_CORE X_NUC_109.L_CORE 0.001448
K_10223 X_NUC_53.L_CORE X_NUC_110.L_CORE 0.001439
K_10224 X_NUC_53.L_CORE X_NUC_111.L_CORE 0.001441
K_10225 X_NUC_53.L_CORE X_NUC_112.L_CORE 0.001441
K_10226 X_NUC_53.L_CORE X_NUC_113.L_CORE 0.001658
K_10227 X_NUC_53.L_CORE X_NUC_114.L_CORE 0.001654
K_10228 X_NUC_53.L_CORE X_NUC_115.L_CORE 0.001646
K_10229 X_NUC_53.L_CORE X_NUC_116.L_CORE 0.001657
K_10230 X_NUC_53.L_CORE X_NUC_117.L_CORE 0.002659
K_10231 X_NUC_53.L_CORE X_NUC_118.L_CORE 0.002641
K_10232 X_NUC_53.L_CORE X_NUC_119.L_CORE 0.002638
K_10233 X_NUC_53.L_CORE X_NUC_120.L_CORE 0.002625
K_10234 X_NUC_53.L_CORE X_NUC_121.L_CORE 0.001303
K_10235 X_NUC_53.L_CORE X_NUC_122.L_CORE 0.001296
K_10236 X_NUC_53.L_CORE X_NUC_123.L_CORE 0.001295
K_10237 X_NUC_53.L_CORE X_NUC_124.L_CORE 0.001299
K_10238 X_NUC_53.L_CORE X_NUC_125.L_CORE 0.002396
K_10239 X_NUC_53.L_CORE X_NUC_126.L_CORE 0.002398
K_10240 X_NUC_53.L_CORE X_NUC_127.L_CORE 0.002373
K_10241 X_NUC_53.L_CORE X_NUC_128.L_CORE 0.002390
K_10242 X_NUC_53.L_CORE X_NUC_129.L_CORE 0.001662
K_10243 X_NUC_53.L_CORE X_NUC_130.L_CORE 0.001651
K_10244 X_NUC_53.L_CORE X_NUC_131.L_CORE 0.001652
K_10245 X_NUC_53.L_CORE X_NUC_132.L_CORE 0.001651
K_10246 X_NUC_53.L_CORE X_NUC_133.L_CORE 0.001412
K_10247 X_NUC_53.L_CORE X_NUC_134.L_CORE 0.001407
K_10248 X_NUC_53.L_CORE X_NUC_135.L_CORE 0.001403
K_10249 X_NUC_53.L_CORE X_NUC_136.L_CORE 0.001409
K_10250 X_NUC_53.L_CORE X_NUC_137.L_CORE 0.002624
K_10251 X_NUC_53.L_CORE X_NUC_138.L_CORE 0.002618
K_10252 X_NUC_53.L_CORE X_NUC_139.L_CORE 0.002599
K_10253 X_NUC_53.L_CORE X_NUC_140.L_CORE 0.002598
K_10254 X_NUC_53.L_CORE X_NUC_141.L_CORE 0.001365
K_10255 X_NUC_53.L_CORE X_NUC_142.L_CORE 0.001357
K_10256 X_NUC_53.L_CORE X_NUC_143.L_CORE 0.001357
K_10257 X_NUC_53.L_CORE X_NUC_144.L_CORE 0.001359
K_10258 X_NUC_53.L_CORE X_NUC_145.L_CORE 0.001745
K_10259 X_NUC_53.L_CORE X_NUC_146.L_CORE 0.001742
K_10260 X_NUC_53.L_CORE X_NUC_147.L_CORE 0.001731
K_10261 X_NUC_53.L_CORE X_NUC_148.L_CORE 0.001741
K_10262 X_NUC_53.L_CORE X_NUC_149.L_CORE 0.001871
K_10263 X_NUC_53.L_CORE X_NUC_150.L_CORE 0.001861
K_10264 X_NUC_53.L_CORE X_NUC_151.L_CORE 0.001857
K_10265 X_NUC_53.L_CORE X_NUC_152.L_CORE 0.001855
K_10266 X_NUC_53.L_CORE X_NUC_153.L_CORE 0.001359
K_10267 X_NUC_53.L_CORE X_NUC_154.L_CORE 0.001354
K_10268 X_NUC_53.L_CORE X_NUC_155.L_CORE 0.001350
K_10269 X_NUC_53.L_CORE X_NUC_156.L_CORE 0.001355
K_10270 X_NUC_53.L_CORE X_NUC_157.L_CORE 0.001996
K_10271 X_NUC_53.L_CORE X_NUC_158.L_CORE 0.001993
K_10272 X_NUC_53.L_CORE X_NUC_159.L_CORE 0.001979
K_10273 X_NUC_53.L_CORE X_NUC_160.L_CORE 0.001985
K_10274 X_NUC_53.L_CORE X_NUC_161.L_CORE 0.001505
K_10275 X_NUC_53.L_CORE X_NUC_162.L_CORE 0.001498
K_10276 X_NUC_53.L_CORE X_NUC_163.L_CORE 0.001495
K_10277 X_NUC_53.L_CORE X_NUC_164.L_CORE 0.001497
K_10278 X_NUC_53.L_CORE X_NUC_165.L_CORE 0.001523
K_10279 X_NUC_53.L_CORE X_NUC_166.L_CORE 0.001519
K_10280 X_NUC_53.L_CORE X_NUC_167.L_CORE 0.001512
K_10281 X_NUC_53.L_CORE X_NUC_168.L_CORE 0.001518
K_10282 X_NUC_53.L_CORE X_NUC_169.L_CORE 0.001690
K_10283 X_NUC_53.L_CORE X_NUC_170.L_CORE 0.001684
K_10284 X_NUC_53.L_CORE X_NUC_171.L_CORE 0.001677
K_10285 X_NUC_53.L_CORE X_NUC_172.L_CORE 0.001680
K_10286 X_NUC_53.L_CORE X_NUC_173.L_CORE 0.002616
K_10287 X_NUC_53.L_CORE X_NUC_174.L_CORE 0.001836
K_10288 X_NUC_53.L_CORE X_NUC_175.L_CORE 0.002396
K_10289 X_NUC_53.L_CORE X_NUC_176.L_CORE 0.002545
K_10290 X_NUC_53.L_CORE X_NUC_177.L_CORE 0.001622
K_10291 X_NUC_53.L_CORE X_NUC_178.L_CORE 0.004350
K_10292 X_NUC_53.L_CORE X_NUC_179.L_CORE 0.001753
K_10293 X_NUC_53.L_CORE X_NUC_180.L_CORE 0.001851
K_10294 X_NUC_53.L_CORE X_NUC_181.L_CORE 0.004296
K_10295 X_NUC_53.L_CORE X_NUC_182.L_CORE 0.001448
K_10296 X_NUC_53.L_CORE X_NUC_183.L_CORE 0.003105
K_10297 X_NUC_53.L_CORE X_NUC_184.L_CORE 0.002060
K_10298 X_NUC_53.L_CORE X_NUC_185.L_CORE 0.001490
K_10299 X_NUC_53.L_CORE X_NUC_186.L_CORE 0.021206
K_10300 X_NUC_53.L_CORE X_NUC_187.L_CORE 0.001458
K_10301 X_NUC_53.L_CORE X_NUC_188.L_CORE 0.001997
K_10302 X_NUC_53.L_CORE X_NUC_189.L_CORE 0.002998
K_10303 X_NUC_53.L_CORE X_NUC_190.L_CORE 0.001331
K_10304 X_NUC_53.L_CORE X_NUC_191.L_CORE 0.004593
K_10305 X_NUC_53.L_CORE X_NUC_192.L_CORE 0.001641
K_10306 X_NUC_53.L_CORE X_NUC_193.L_CORE 0.001519
K_10307 X_NUC_53.L_CORE X_NUC_194.L_CORE 0.005931
K_10308 X_NUC_53.L_CORE X_NUC_195.L_CORE 0.001310
K_10309 X_NUC_53.L_CORE X_NUC_196.L_CORE 0.002310
K_10310 X_NUC_53.L_CORE X_NUC_197.L_CORE 0.002081
K_10311 X_NUC_53.L_CORE X_NUC_198.L_CORE 0.001313
K_10312 X_NUC_53.L_CORE X_NUC_199.L_CORE 0.005098
K_10313 X_NUC_53.L_CORE X_NUC_200.L_CORE 0.001408
K_10314 X_NUC_53.L_CORE X_NUC_201.L_CORE 0.001633
K_10315 X_NUC_53.L_CORE X_NUC_202.L_CORE 0.002887
K_10316 X_NUC_53.L_CORE X_NUC_203.L_CORE 0.001252
K_10317 X_NUC_53.L_CORE X_NUC_204.L_CORE 0.002597
K_10318 X_NUC_53.L_CORE X_NUC_205.L_CORE 0.001641
K_10319 X_NUC_53.L_CORE X_NUC_206.L_CORE 0.001360
K_10320 X_NUC_53.L_CORE X_NUC_207.L_CORE 0.003253
K_10321 X_NUC_53.L_CORE X_NUC_208.L_CORE 0.001298
K_10322 X_NUC_53.L_CORE X_NUC_209.L_CORE 0.001774
K_10323 X_NUC_53.L_CORE X_NUC_210.L_CORE 0.001984
K_10324 X_NUC_53.L_CORE X_NUC_211.L_CORE 0.001266
K_10325 X_NUC_53.L_CORE X_NUC_212.L_CORE 0.002421
K_10326 X_NUC_53.L_CORE X_NUC_213.L_CORE 0.001434
K_10327 X_NUC_53.L_CORE X_NUC_214.L_CORE 0.001450
K_10328 X_NUC_53.L_CORE X_NUC_215.L_CORE 0.002143
K_10329 X_NUC_53.L_CORE X_NUC_216.L_CORE 0.001287
K_10330 X_NUC_53.L_CORE X_NUC_217.L_CORE 0.001785
K_10331 X_NUC_53.L_CORE X_NUC_218.L_CORE 0.001598
K_10332 X_NUC_53.L_CORE X_NUC_219.L_CORE 0.001356
K_10333 X_NUC_53.L_CORE X_NUC_220.L_CORE 0.001826
K_10334 X_NUC_53.L_CORE X_NUC_221.L_CORE 0.001410
K_10335 X_NUC_53.L_CORE X_NUC_222.L_CORE 0.001510
K_10336 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_10337 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_10338 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.001501
K_10339 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.001491
K_10340 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.001495
K_10341 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.001497
K_10342 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.002039
K_10343 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.002036
K_10344 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.002026
K_10345 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.002046
K_10346 X_NUC_54.L_CORE X_NUC_65.L_CORE 0.003088
K_10347 X_NUC_54.L_CORE X_NUC_66.L_CORE 0.003051
K_10348 X_NUC_54.L_CORE X_NUC_67.L_CORE 0.003076
K_10349 X_NUC_54.L_CORE X_NUC_68.L_CORE 0.003052
K_10350 X_NUC_54.L_CORE X_NUC_69.L_CORE 0.001369
K_10351 X_NUC_54.L_CORE X_NUC_70.L_CORE 0.001362
K_10352 X_NUC_54.L_CORE X_NUC_71.L_CORE 0.001362
K_10353 X_NUC_54.L_CORE X_NUC_72.L_CORE 0.001367
K_10354 X_NUC_54.L_CORE X_NUC_73.L_CORE 0.004398
K_10355 X_NUC_54.L_CORE X_NUC_74.L_CORE 0.004432
K_10356 X_NUC_54.L_CORE X_NUC_75.L_CORE 0.004350
K_10357 X_NUC_54.L_CORE X_NUC_76.L_CORE 0.004428
K_10358 X_NUC_54.L_CORE X_NUC_77.L_CORE 0.001690
K_10359 X_NUC_54.L_CORE X_NUC_78.L_CORE 0.001677
K_10360 X_NUC_54.L_CORE X_NUC_79.L_CORE 0.001683
K_10361 X_NUC_54.L_CORE X_NUC_80.L_CORE 0.001681
K_10362 X_NUC_54.L_CORE X_NUC_81.L_CORE 0.001555
K_10363 X_NUC_54.L_CORE X_NUC_82.L_CORE 0.001551
K_10364 X_NUC_54.L_CORE X_NUC_83.L_CORE 0.001546
K_10365 X_NUC_54.L_CORE X_NUC_84.L_CORE 0.001557
K_10366 X_NUC_54.L_CORE X_NUC_85.L_CORE 0.005187
K_10367 X_NUC_54.L_CORE X_NUC_86.L_CORE 0.005144
K_10368 X_NUC_54.L_CORE X_NUC_87.L_CORE 0.005135
K_10369 X_NUC_54.L_CORE X_NUC_88.L_CORE 0.005063
K_10370 X_NUC_54.L_CORE X_NUC_89.L_CORE 0.001353
K_10371 X_NUC_54.L_CORE X_NUC_90.L_CORE 0.001345
K_10372 X_NUC_54.L_CORE X_NUC_91.L_CORE 0.001346
K_10373 X_NUC_54.L_CORE X_NUC_92.L_CORE 0.001349
K_10374 X_NUC_54.L_CORE X_NUC_93.L_CORE 0.002295
K_10375 X_NUC_54.L_CORE X_NUC_94.L_CORE 0.002296
K_10376 X_NUC_54.L_CORE X_NUC_95.L_CORE 0.002277
K_10377 X_NUC_54.L_CORE X_NUC_96.L_CORE 0.002300
K_10378 X_NUC_54.L_CORE X_NUC_97.L_CORE 0.002107
K_10379 X_NUC_54.L_CORE X_NUC_98.L_CORE 0.002089
K_10380 X_NUC_54.L_CORE X_NUC_99.L_CORE 0.002096
K_10381 X_NUC_54.L_CORE X_NUC_100.L_CORE 0.002088
K_10382 X_NUC_54.L_CORE X_NUC_101.L_CORE 0.001356
K_10383 X_NUC_54.L_CORE X_NUC_102.L_CORE 0.001351
K_10384 X_NUC_54.L_CORE X_NUC_103.L_CORE 0.001349
K_10385 X_NUC_54.L_CORE X_NUC_104.L_CORE 0.001355
K_10386 X_NUC_54.L_CORE X_NUC_105.L_CORE 0.004051
K_10387 X_NUC_54.L_CORE X_NUC_106.L_CORE 0.004068
K_10388 X_NUC_54.L_CORE X_NUC_107.L_CORE 0.003998
K_10389 X_NUC_54.L_CORE X_NUC_108.L_CORE 0.004017
K_10390 X_NUC_54.L_CORE X_NUC_109.L_CORE 0.001458
K_10391 X_NUC_54.L_CORE X_NUC_110.L_CORE 0.001448
K_10392 X_NUC_54.L_CORE X_NUC_111.L_CORE 0.001450
K_10393 X_NUC_54.L_CORE X_NUC_112.L_CORE 0.001451
K_10394 X_NUC_54.L_CORE X_NUC_113.L_CORE 0.001661
K_10395 X_NUC_54.L_CORE X_NUC_114.L_CORE 0.001658
K_10396 X_NUC_54.L_CORE X_NUC_115.L_CORE 0.001649
K_10397 X_NUC_54.L_CORE X_NUC_116.L_CORE 0.001661
K_10398 X_NUC_54.L_CORE X_NUC_117.L_CORE 0.002676
K_10399 X_NUC_54.L_CORE X_NUC_118.L_CORE 0.002659
K_10400 X_NUC_54.L_CORE X_NUC_119.L_CORE 0.002656
K_10401 X_NUC_54.L_CORE X_NUC_120.L_CORE 0.002642
K_10402 X_NUC_54.L_CORE X_NUC_121.L_CORE 0.001309
K_10403 X_NUC_54.L_CORE X_NUC_122.L_CORE 0.001303
K_10404 X_NUC_54.L_CORE X_NUC_123.L_CORE 0.001302
K_10405 X_NUC_54.L_CORE X_NUC_124.L_CORE 0.001305
K_10406 X_NUC_54.L_CORE X_NUC_125.L_CORE 0.002394
K_10407 X_NUC_54.L_CORE X_NUC_126.L_CORE 0.002396
K_10408 X_NUC_54.L_CORE X_NUC_127.L_CORE 0.002371
K_10409 X_NUC_54.L_CORE X_NUC_128.L_CORE 0.002388
K_10410 X_NUC_54.L_CORE X_NUC_129.L_CORE 0.001673
K_10411 X_NUC_54.L_CORE X_NUC_130.L_CORE 0.001662
K_10412 X_NUC_54.L_CORE X_NUC_131.L_CORE 0.001663
K_10413 X_NUC_54.L_CORE X_NUC_132.L_CORE 0.001661
K_10414 X_NUC_54.L_CORE X_NUC_133.L_CORE 0.001416
K_10415 X_NUC_54.L_CORE X_NUC_134.L_CORE 0.001412
K_10416 X_NUC_54.L_CORE X_NUC_135.L_CORE 0.001407
K_10417 X_NUC_54.L_CORE X_NUC_136.L_CORE 0.001414
K_10418 X_NUC_54.L_CORE X_NUC_137.L_CORE 0.002630
K_10419 X_NUC_54.L_CORE X_NUC_138.L_CORE 0.002624
K_10420 X_NUC_54.L_CORE X_NUC_139.L_CORE 0.002604
K_10421 X_NUC_54.L_CORE X_NUC_140.L_CORE 0.002604
K_10422 X_NUC_54.L_CORE X_NUC_141.L_CORE 0.001372
K_10423 X_NUC_54.L_CORE X_NUC_142.L_CORE 0.001365
K_10424 X_NUC_54.L_CORE X_NUC_143.L_CORE 0.001364
K_10425 X_NUC_54.L_CORE X_NUC_144.L_CORE 0.001366
K_10426 X_NUC_54.L_CORE X_NUC_145.L_CORE 0.001747
K_10427 X_NUC_54.L_CORE X_NUC_146.L_CORE 0.001745
K_10428 X_NUC_54.L_CORE X_NUC_147.L_CORE 0.001734
K_10429 X_NUC_54.L_CORE X_NUC_148.L_CORE 0.001744
K_10430 X_NUC_54.L_CORE X_NUC_149.L_CORE 0.001881
K_10431 X_NUC_54.L_CORE X_NUC_150.L_CORE 0.001871
K_10432 X_NUC_54.L_CORE X_NUC_151.L_CORE 0.001867
K_10433 X_NUC_54.L_CORE X_NUC_152.L_CORE 0.001865
K_10434 X_NUC_54.L_CORE X_NUC_153.L_CORE 0.001364
K_10435 X_NUC_54.L_CORE X_NUC_154.L_CORE 0.001359
K_10436 X_NUC_54.L_CORE X_NUC_155.L_CORE 0.001356
K_10437 X_NUC_54.L_CORE X_NUC_156.L_CORE 0.001360
K_10438 X_NUC_54.L_CORE X_NUC_157.L_CORE 0.002000
K_10439 X_NUC_54.L_CORE X_NUC_158.L_CORE 0.001996
K_10440 X_NUC_54.L_CORE X_NUC_159.L_CORE 0.001982
K_10441 X_NUC_54.L_CORE X_NUC_160.L_CORE 0.001989
K_10442 X_NUC_54.L_CORE X_NUC_161.L_CORE 0.001512
K_10443 X_NUC_54.L_CORE X_NUC_162.L_CORE 0.001505
K_10444 X_NUC_54.L_CORE X_NUC_163.L_CORE 0.001502
K_10445 X_NUC_54.L_CORE X_NUC_164.L_CORE 0.001504
K_10446 X_NUC_54.L_CORE X_NUC_165.L_CORE 0.001528
K_10447 X_NUC_54.L_CORE X_NUC_166.L_CORE 0.001523
K_10448 X_NUC_54.L_CORE X_NUC_167.L_CORE 0.001517
K_10449 X_NUC_54.L_CORE X_NUC_168.L_CORE 0.001522
K_10450 X_NUC_54.L_CORE X_NUC_169.L_CORE 0.001696
K_10451 X_NUC_54.L_CORE X_NUC_170.L_CORE 0.001690
K_10452 X_NUC_54.L_CORE X_NUC_171.L_CORE 0.001683
K_10453 X_NUC_54.L_CORE X_NUC_172.L_CORE 0.001686
K_10454 X_NUC_54.L_CORE X_NUC_173.L_CORE 0.002637
K_10455 X_NUC_54.L_CORE X_NUC_174.L_CORE 0.001850
K_10456 X_NUC_54.L_CORE X_NUC_175.L_CORE 0.002407
K_10457 X_NUC_54.L_CORE X_NUC_176.L_CORE 0.002571
K_10458 X_NUC_54.L_CORE X_NUC_177.L_CORE 0.001631
K_10459 X_NUC_54.L_CORE X_NUC_178.L_CORE 0.004369
K_10460 X_NUC_54.L_CORE X_NUC_179.L_CORE 0.001767
K_10461 X_NUC_54.L_CORE X_NUC_180.L_CORE 0.001858
K_10462 X_NUC_54.L_CORE X_NUC_181.L_CORE 0.004362
K_10463 X_NUC_54.L_CORE X_NUC_182.L_CORE 0.001457
K_10464 X_NUC_54.L_CORE X_NUC_183.L_CORE 0.003102
K_10465 X_NUC_54.L_CORE X_NUC_184.L_CORE 0.002080
K_10466 X_NUC_54.L_CORE X_NUC_185.L_CORE 0.001496
K_10467 X_NUC_54.L_CORE X_NUC_186.L_CORE 0.020768
K_10468 X_NUC_54.L_CORE X_NUC_187.L_CORE 0.001468
K_10469 X_NUC_54.L_CORE X_NUC_188.L_CORE 0.002000
K_10470 X_NUC_54.L_CORE X_NUC_189.L_CORE 0.003033
K_10471 X_NUC_54.L_CORE X_NUC_190.L_CORE 0.001338
K_10472 X_NUC_54.L_CORE X_NUC_191.L_CORE 0.004547
K_10473 X_NUC_54.L_CORE X_NUC_192.L_CORE 0.001654
K_10474 X_NUC_54.L_CORE X_NUC_193.L_CORE 0.001523
K_10475 X_NUC_54.L_CORE X_NUC_194.L_CORE 0.005983
K_10476 X_NUC_54.L_CORE X_NUC_195.L_CORE 0.001317
K_10477 X_NUC_54.L_CORE X_NUC_196.L_CORE 0.002307
K_10478 X_NUC_54.L_CORE X_NUC_197.L_CORE 0.002099
K_10479 X_NUC_54.L_CORE X_NUC_198.L_CORE 0.001318
K_10480 X_NUC_54.L_CORE X_NUC_199.L_CORE 0.005042
K_10481 X_NUC_54.L_CORE X_NUC_200.L_CORE 0.001417
K_10482 X_NUC_54.L_CORE X_NUC_201.L_CORE 0.001636
K_10483 X_NUC_54.L_CORE X_NUC_202.L_CORE 0.002908
K_10484 X_NUC_54.L_CORE X_NUC_203.L_CORE 0.001259
K_10485 X_NUC_54.L_CORE X_NUC_204.L_CORE 0.002589
K_10486 X_NUC_54.L_CORE X_NUC_205.L_CORE 0.001652
K_10487 X_NUC_54.L_CORE X_NUC_206.L_CORE 0.001365
K_10488 X_NUC_54.L_CORE X_NUC_207.L_CORE 0.003254
K_10489 X_NUC_54.L_CORE X_NUC_208.L_CORE 0.001305
K_10490 X_NUC_54.L_CORE X_NUC_209.L_CORE 0.001775
K_10491 X_NUC_54.L_CORE X_NUC_210.L_CORE 0.001996
K_10492 X_NUC_54.L_CORE X_NUC_211.L_CORE 0.001271
K_10493 X_NUC_54.L_CORE X_NUC_212.L_CORE 0.002418
K_10494 X_NUC_54.L_CORE X_NUC_213.L_CORE 0.001442
K_10495 X_NUC_54.L_CORE X_NUC_214.L_CORE 0.001454
K_10496 X_NUC_54.L_CORE X_NUC_215.L_CORE 0.002151
K_10497 X_NUC_54.L_CORE X_NUC_216.L_CORE 0.001293
K_10498 X_NUC_54.L_CORE X_NUC_217.L_CORE 0.001787
K_10499 X_NUC_54.L_CORE X_NUC_218.L_CORE 0.001606
K_10500 X_NUC_54.L_CORE X_NUC_219.L_CORE 0.001360
K_10501 X_NUC_54.L_CORE X_NUC_220.L_CORE 0.001830
K_10502 X_NUC_54.L_CORE X_NUC_221.L_CORE 0.001416
K_10503 X_NUC_54.L_CORE X_NUC_222.L_CORE 0.001515
K_10504 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_10505 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.001497
K_10506 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.001487
K_10507 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.001491
K_10508 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.001493
K_10509 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.002048
K_10510 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.002045
K_10511 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.002036
K_10512 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.002055
K_10513 X_NUC_55.L_CORE X_NUC_65.L_CORE 0.003062
K_10514 X_NUC_55.L_CORE X_NUC_66.L_CORE 0.003026
K_10515 X_NUC_55.L_CORE X_NUC_67.L_CORE 0.003051
K_10516 X_NUC_55.L_CORE X_NUC_68.L_CORE 0.003026
K_10517 X_NUC_55.L_CORE X_NUC_69.L_CORE 0.001368
K_10518 X_NUC_55.L_CORE X_NUC_70.L_CORE 0.001361
K_10519 X_NUC_55.L_CORE X_NUC_71.L_CORE 0.001362
K_10520 X_NUC_55.L_CORE X_NUC_72.L_CORE 0.001367
K_10521 X_NUC_55.L_CORE X_NUC_73.L_CORE 0.004482
K_10522 X_NUC_55.L_CORE X_NUC_74.L_CORE 0.004517
K_10523 X_NUC_55.L_CORE X_NUC_75.L_CORE 0.004432
K_10524 X_NUC_55.L_CORE X_NUC_76.L_CORE 0.004514
K_10525 X_NUC_55.L_CORE X_NUC_77.L_CORE 0.001685
K_10526 X_NUC_55.L_CORE X_NUC_78.L_CORE 0.001671
K_10527 X_NUC_55.L_CORE X_NUC_79.L_CORE 0.001677
K_10528 X_NUC_55.L_CORE X_NUC_80.L_CORE 0.001676
K_10529 X_NUC_55.L_CORE X_NUC_81.L_CORE 0.001560
K_10530 X_NUC_55.L_CORE X_NUC_82.L_CORE 0.001555
K_10531 X_NUC_55.L_CORE X_NUC_83.L_CORE 0.001551
K_10532 X_NUC_55.L_CORE X_NUC_84.L_CORE 0.001561
K_10533 X_NUC_55.L_CORE X_NUC_85.L_CORE 0.005194
K_10534 X_NUC_55.L_CORE X_NUC_86.L_CORE 0.005149
K_10535 X_NUC_55.L_CORE X_NUC_87.L_CORE 0.005144
K_10536 X_NUC_55.L_CORE X_NUC_88.L_CORE 0.005070
K_10537 X_NUC_55.L_CORE X_NUC_89.L_CORE 0.001352
K_10538 X_NUC_55.L_CORE X_NUC_90.L_CORE 0.001344
K_10539 X_NUC_55.L_CORE X_NUC_91.L_CORE 0.001345
K_10540 X_NUC_55.L_CORE X_NUC_92.L_CORE 0.001348
K_10541 X_NUC_55.L_CORE X_NUC_93.L_CORE 0.002315
K_10542 X_NUC_55.L_CORE X_NUC_94.L_CORE 0.002316
K_10543 X_NUC_55.L_CORE X_NUC_95.L_CORE 0.002296
K_10544 X_NUC_55.L_CORE X_NUC_96.L_CORE 0.002320
K_10545 X_NUC_55.L_CORE X_NUC_97.L_CORE 0.002100
K_10546 X_NUC_55.L_CORE X_NUC_98.L_CORE 0.002082
K_10547 X_NUC_55.L_CORE X_NUC_99.L_CORE 0.002089
K_10548 X_NUC_55.L_CORE X_NUC_100.L_CORE 0.002081
K_10549 X_NUC_55.L_CORE X_NUC_101.L_CORE 0.001358
K_10550 X_NUC_55.L_CORE X_NUC_102.L_CORE 0.001353
K_10551 X_NUC_55.L_CORE X_NUC_103.L_CORE 0.001351
K_10552 X_NUC_55.L_CORE X_NUC_104.L_CORE 0.001357
K_10553 X_NUC_55.L_CORE X_NUC_105.L_CORE 0.004124
K_10554 X_NUC_55.L_CORE X_NUC_106.L_CORE 0.004141
K_10555 X_NUC_55.L_CORE X_NUC_107.L_CORE 0.004068
K_10556 X_NUC_55.L_CORE X_NUC_108.L_CORE 0.004088
K_10557 X_NUC_55.L_CORE X_NUC_109.L_CORE 0.001456
K_10558 X_NUC_55.L_CORE X_NUC_110.L_CORE 0.001446
K_10559 X_NUC_55.L_CORE X_NUC_111.L_CORE 0.001448
K_10560 X_NUC_55.L_CORE X_NUC_112.L_CORE 0.001449
K_10561 X_NUC_55.L_CORE X_NUC_113.L_CORE 0.001669
K_10562 X_NUC_55.L_CORE X_NUC_114.L_CORE 0.001666
K_10563 X_NUC_55.L_CORE X_NUC_115.L_CORE 0.001658
K_10564 X_NUC_55.L_CORE X_NUC_116.L_CORE 0.001669
K_10565 X_NUC_55.L_CORE X_NUC_117.L_CORE 0.002679
K_10566 X_NUC_55.L_CORE X_NUC_118.L_CORE 0.002661
K_10567 X_NUC_55.L_CORE X_NUC_119.L_CORE 0.002659
K_10568 X_NUC_55.L_CORE X_NUC_120.L_CORE 0.002645
K_10569 X_NUC_55.L_CORE X_NUC_121.L_CORE 0.001310
K_10570 X_NUC_55.L_CORE X_NUC_122.L_CORE 0.001304
K_10571 X_NUC_55.L_CORE X_NUC_123.L_CORE 0.001303
K_10572 X_NUC_55.L_CORE X_NUC_124.L_CORE 0.001307
K_10573 X_NUC_55.L_CORE X_NUC_125.L_CORE 0.002419
K_10574 X_NUC_55.L_CORE X_NUC_126.L_CORE 0.002421
K_10575 X_NUC_55.L_CORE X_NUC_127.L_CORE 0.002396
K_10576 X_NUC_55.L_CORE X_NUC_128.L_CORE 0.002413
K_10577 X_NUC_55.L_CORE X_NUC_129.L_CORE 0.001672
K_10578 X_NUC_55.L_CORE X_NUC_130.L_CORE 0.001661
K_10579 X_NUC_55.L_CORE X_NUC_131.L_CORE 0.001662
K_10580 X_NUC_55.L_CORE X_NUC_132.L_CORE 0.001660
K_10581 X_NUC_55.L_CORE X_NUC_133.L_CORE 0.001421
K_10582 X_NUC_55.L_CORE X_NUC_134.L_CORE 0.001416
K_10583 X_NUC_55.L_CORE X_NUC_135.L_CORE 0.001412
K_10584 X_NUC_55.L_CORE X_NUC_136.L_CORE 0.001419
K_10585 X_NUC_55.L_CORE X_NUC_137.L_CORE 0.002650
K_10586 X_NUC_55.L_CORE X_NUC_138.L_CORE 0.002644
K_10587 X_NUC_55.L_CORE X_NUC_139.L_CORE 0.002624
K_10588 X_NUC_55.L_CORE X_NUC_140.L_CORE 0.002624
K_10589 X_NUC_55.L_CORE X_NUC_141.L_CORE 0.001373
K_10590 X_NUC_55.L_CORE X_NUC_142.L_CORE 0.001366
K_10591 X_NUC_55.L_CORE X_NUC_143.L_CORE 0.001365
K_10592 X_NUC_55.L_CORE X_NUC_144.L_CORE 0.001367
K_10593 X_NUC_55.L_CORE X_NUC_145.L_CORE 0.001759
K_10594 X_NUC_55.L_CORE X_NUC_146.L_CORE 0.001756
K_10595 X_NUC_55.L_CORE X_NUC_147.L_CORE 0.001745
K_10596 X_NUC_55.L_CORE X_NUC_148.L_CORE 0.001755
K_10597 X_NUC_55.L_CORE X_NUC_149.L_CORE 0.001884
K_10598 X_NUC_55.L_CORE X_NUC_150.L_CORE 0.001874
K_10599 X_NUC_55.L_CORE X_NUC_151.L_CORE 0.001871
K_10600 X_NUC_55.L_CORE X_NUC_152.L_CORE 0.001869
K_10601 X_NUC_55.L_CORE X_NUC_153.L_CORE 0.001368
K_10602 X_NUC_55.L_CORE X_NUC_154.L_CORE 0.001362
K_10603 X_NUC_55.L_CORE X_NUC_155.L_CORE 0.001359
K_10604 X_NUC_55.L_CORE X_NUC_156.L_CORE 0.001364
K_10605 X_NUC_55.L_CORE X_NUC_157.L_CORE 0.002014
K_10606 X_NUC_55.L_CORE X_NUC_158.L_CORE 0.002010
K_10607 X_NUC_55.L_CORE X_NUC_159.L_CORE 0.001996
K_10608 X_NUC_55.L_CORE X_NUC_160.L_CORE 0.002003
K_10609 X_NUC_55.L_CORE X_NUC_161.L_CORE 0.001515
K_10610 X_NUC_55.L_CORE X_NUC_162.L_CORE 0.001508
K_10611 X_NUC_55.L_CORE X_NUC_163.L_CORE 0.001505
K_10612 X_NUC_55.L_CORE X_NUC_164.L_CORE 0.001507
K_10613 X_NUC_55.L_CORE X_NUC_165.L_CORE 0.001534
K_10614 X_NUC_55.L_CORE X_NUC_166.L_CORE 0.001530
K_10615 X_NUC_55.L_CORE X_NUC_167.L_CORE 0.001523
K_10616 X_NUC_55.L_CORE X_NUC_168.L_CORE 0.001529
K_10617 X_NUC_55.L_CORE X_NUC_169.L_CORE 0.001703
K_10618 X_NUC_55.L_CORE X_NUC_170.L_CORE 0.001697
K_10619 X_NUC_55.L_CORE X_NUC_171.L_CORE 0.001690
K_10620 X_NUC_55.L_CORE X_NUC_172.L_CORE 0.001693
K_10621 X_NUC_55.L_CORE X_NUC_173.L_CORE 0.002616
K_10622 X_NUC_55.L_CORE X_NUC_174.L_CORE 0.001841
K_10623 X_NUC_55.L_CORE X_NUC_175.L_CORE 0.002401
K_10624 X_NUC_55.L_CORE X_NUC_176.L_CORE 0.002545
K_10625 X_NUC_55.L_CORE X_NUC_177.L_CORE 0.001628
K_10626 X_NUC_55.L_CORE X_NUC_178.L_CORE 0.004336
K_10627 X_NUC_55.L_CORE X_NUC_179.L_CORE 0.001758
K_10628 X_NUC_55.L_CORE X_NUC_180.L_CORE 0.001859
K_10629 X_NUC_55.L_CORE X_NUC_181.L_CORE 0.004276
K_10630 X_NUC_55.L_CORE X_NUC_182.L_CORE 0.001454
K_10631 X_NUC_55.L_CORE X_NUC_183.L_CORE 0.003116
K_10632 X_NUC_55.L_CORE X_NUC_184.L_CORE 0.002065
K_10633 X_NUC_55.L_CORE X_NUC_185.L_CORE 0.001496
K_10634 X_NUC_55.L_CORE X_NUC_186.L_CORE 0.019511
K_10635 X_NUC_55.L_CORE X_NUC_187.L_CORE 0.001463
K_10636 X_NUC_55.L_CORE X_NUC_188.L_CORE 0.002007
K_10637 X_NUC_55.L_CORE X_NUC_189.L_CORE 0.003003
K_10638 X_NUC_55.L_CORE X_NUC_190.L_CORE 0.001337
K_10639 X_NUC_55.L_CORE X_NUC_191.L_CORE 0.004626
K_10640 X_NUC_55.L_CORE X_NUC_192.L_CORE 0.001648
K_10641 X_NUC_55.L_CORE X_NUC_193.L_CORE 0.001527
K_10642 X_NUC_55.L_CORE X_NUC_194.L_CORE 0.005950
K_10643 X_NUC_55.L_CORE X_NUC_195.L_CORE 0.001316
K_10644 X_NUC_55.L_CORE X_NUC_196.L_CORE 0.002326
K_10645 X_NUC_55.L_CORE X_NUC_197.L_CORE 0.002089
K_10646 X_NUC_55.L_CORE X_NUC_198.L_CORE 0.001320
K_10647 X_NUC_55.L_CORE X_NUC_199.L_CORE 0.005162
K_10648 X_NUC_55.L_CORE X_NUC_200.L_CORE 0.001415
K_10649 X_NUC_55.L_CORE X_NUC_201.L_CORE 0.001644
K_10650 X_NUC_55.L_CORE X_NUC_202.L_CORE 0.002904
K_10651 X_NUC_55.L_CORE X_NUC_203.L_CORE 0.001259
K_10652 X_NUC_55.L_CORE X_NUC_204.L_CORE 0.002620
K_10653 X_NUC_55.L_CORE X_NUC_205.L_CORE 0.001649
K_10654 X_NUC_55.L_CORE X_NUC_206.L_CORE 0.001368
K_10655 X_NUC_55.L_CORE X_NUC_207.L_CORE 0.003284
K_10656 X_NUC_55.L_CORE X_NUC_208.L_CORE 0.001305
K_10657 X_NUC_55.L_CORE X_NUC_209.L_CORE 0.001787
K_10658 X_NUC_55.L_CORE X_NUC_210.L_CORE 0.001996
K_10659 X_NUC_55.L_CORE X_NUC_211.L_CORE 0.001273
K_10660 X_NUC_55.L_CORE X_NUC_212.L_CORE 0.002443
K_10661 X_NUC_55.L_CORE X_NUC_213.L_CORE 0.001442
K_10662 X_NUC_55.L_CORE X_NUC_214.L_CORE 0.001460
K_10663 X_NUC_55.L_CORE X_NUC_215.L_CORE 0.002160
K_10664 X_NUC_55.L_CORE X_NUC_216.L_CORE 0.001295
K_10665 X_NUC_55.L_CORE X_NUC_217.L_CORE 0.001800
K_10666 X_NUC_55.L_CORE X_NUC_218.L_CORE 0.001609
K_10667 X_NUC_55.L_CORE X_NUC_219.L_CORE 0.001365
K_10668 X_NUC_55.L_CORE X_NUC_220.L_CORE 0.001840
K_10669 X_NUC_55.L_CORE X_NUC_221.L_CORE 0.001419
K_10670 X_NUC_55.L_CORE X_NUC_222.L_CORE 0.001521
K_10671 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.001495
K_10672 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.001484
K_10673 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.001488
K_10674 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.001491
K_10675 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.002028
K_10676 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.002025
K_10677 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.002016
K_10678 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.002036
K_10679 X_NUC_56.L_CORE X_NUC_65.L_CORE 0.003087
K_10680 X_NUC_56.L_CORE X_NUC_66.L_CORE 0.003050
K_10681 X_NUC_56.L_CORE X_NUC_67.L_CORE 0.003076
K_10682 X_NUC_56.L_CORE X_NUC_68.L_CORE 0.003051
K_10683 X_NUC_56.L_CORE X_NUC_69.L_CORE 0.001363
K_10684 X_NUC_56.L_CORE X_NUC_70.L_CORE 0.001356
K_10685 X_NUC_56.L_CORE X_NUC_71.L_CORE 0.001356
K_10686 X_NUC_56.L_CORE X_NUC_72.L_CORE 0.001362
K_10687 X_NUC_56.L_CORE X_NUC_73.L_CORE 0.004401
K_10688 X_NUC_56.L_CORE X_NUC_74.L_CORE 0.004435
K_10689 X_NUC_56.L_CORE X_NUC_75.L_CORE 0.004353
K_10690 X_NUC_56.L_CORE X_NUC_76.L_CORE 0.004432
K_10691 X_NUC_56.L_CORE X_NUC_77.L_CORE 0.001686
K_10692 X_NUC_56.L_CORE X_NUC_78.L_CORE 0.001673
K_10693 X_NUC_56.L_CORE X_NUC_79.L_CORE 0.001679
K_10694 X_NUC_56.L_CORE X_NUC_80.L_CORE 0.001677
K_10695 X_NUC_56.L_CORE X_NUC_81.L_CORE 0.001549
K_10696 X_NUC_56.L_CORE X_NUC_82.L_CORE 0.001545
K_10697 X_NUC_56.L_CORE X_NUC_83.L_CORE 0.001540
K_10698 X_NUC_56.L_CORE X_NUC_84.L_CORE 0.001551
K_10699 X_NUC_56.L_CORE X_NUC_85.L_CORE 0.005272
K_10700 X_NUC_56.L_CORE X_NUC_86.L_CORE 0.005225
K_10701 X_NUC_56.L_CORE X_NUC_87.L_CORE 0.005218
K_10702 X_NUC_56.L_CORE X_NUC_88.L_CORE 0.005144
K_10703 X_NUC_56.L_CORE X_NUC_89.L_CORE 0.001349
K_10704 X_NUC_56.L_CORE X_NUC_90.L_CORE 0.001341
K_10705 X_NUC_56.L_CORE X_NUC_91.L_CORE 0.001342
K_10706 X_NUC_56.L_CORE X_NUC_92.L_CORE 0.001345
K_10707 X_NUC_56.L_CORE X_NUC_93.L_CORE 0.002291
K_10708 X_NUC_56.L_CORE X_NUC_94.L_CORE 0.002293
K_10709 X_NUC_56.L_CORE X_NUC_95.L_CORE 0.002274
K_10710 X_NUC_56.L_CORE X_NUC_96.L_CORE 0.002296
K_10711 X_NUC_56.L_CORE X_NUC_97.L_CORE 0.002108
K_10712 X_NUC_56.L_CORE X_NUC_98.L_CORE 0.002090
K_10713 X_NUC_56.L_CORE X_NUC_99.L_CORE 0.002097
K_10714 X_NUC_56.L_CORE X_NUC_100.L_CORE 0.002089
K_10715 X_NUC_56.L_CORE X_NUC_101.L_CORE 0.001352
K_10716 X_NUC_56.L_CORE X_NUC_102.L_CORE 0.001347
K_10717 X_NUC_56.L_CORE X_NUC_103.L_CORE 0.001344
K_10718 X_NUC_56.L_CORE X_NUC_104.L_CORE 0.001351
K_10719 X_NUC_56.L_CORE X_NUC_105.L_CORE 0.004103
K_10720 X_NUC_56.L_CORE X_NUC_106.L_CORE 0.004120
K_10721 X_NUC_56.L_CORE X_NUC_107.L_CORE 0.004047
K_10722 X_NUC_56.L_CORE X_NUC_108.L_CORE 0.004068
K_10723 X_NUC_56.L_CORE X_NUC_109.L_CORE 0.001455
K_10724 X_NUC_56.L_CORE X_NUC_110.L_CORE 0.001446
K_10725 X_NUC_56.L_CORE X_NUC_111.L_CORE 0.001447
K_10726 X_NUC_56.L_CORE X_NUC_112.L_CORE 0.001448
K_10727 X_NUC_56.L_CORE X_NUC_113.L_CORE 0.001658
K_10728 X_NUC_56.L_CORE X_NUC_114.L_CORE 0.001654
K_10729 X_NUC_56.L_CORE X_NUC_115.L_CORE 0.001646
K_10730 X_NUC_56.L_CORE X_NUC_116.L_CORE 0.001658
K_10731 X_NUC_56.L_CORE X_NUC_117.L_CORE 0.002693
K_10732 X_NUC_56.L_CORE X_NUC_118.L_CORE 0.002675
K_10733 X_NUC_56.L_CORE X_NUC_119.L_CORE 0.002672
K_10734 X_NUC_56.L_CORE X_NUC_120.L_CORE 0.002659
K_10735 X_NUC_56.L_CORE X_NUC_121.L_CORE 0.001306
K_10736 X_NUC_56.L_CORE X_NUC_122.L_CORE 0.001300
K_10737 X_NUC_56.L_CORE X_NUC_123.L_CORE 0.001299
K_10738 X_NUC_56.L_CORE X_NUC_124.L_CORE 0.001303
K_10739 X_NUC_56.L_CORE X_NUC_125.L_CORE 0.002401
K_10740 X_NUC_56.L_CORE X_NUC_126.L_CORE 0.002403
K_10741 X_NUC_56.L_CORE X_NUC_127.L_CORE 0.002378
K_10742 X_NUC_56.L_CORE X_NUC_128.L_CORE 0.002396
K_10743 X_NUC_56.L_CORE X_NUC_129.L_CORE 0.001674
K_10744 X_NUC_56.L_CORE X_NUC_130.L_CORE 0.001663
K_10745 X_NUC_56.L_CORE X_NUC_131.L_CORE 0.001664
K_10746 X_NUC_56.L_CORE X_NUC_132.L_CORE 0.001662
K_10747 X_NUC_56.L_CORE X_NUC_133.L_CORE 0.001414
K_10748 X_NUC_56.L_CORE X_NUC_134.L_CORE 0.001409
K_10749 X_NUC_56.L_CORE X_NUC_135.L_CORE 0.001405
K_10750 X_NUC_56.L_CORE X_NUC_136.L_CORE 0.001412
K_10751 X_NUC_56.L_CORE X_NUC_137.L_CORE 0.002651
K_10752 X_NUC_56.L_CORE X_NUC_138.L_CORE 0.002645
K_10753 X_NUC_56.L_CORE X_NUC_139.L_CORE 0.002625
K_10754 X_NUC_56.L_CORE X_NUC_140.L_CORE 0.002624
K_10755 X_NUC_56.L_CORE X_NUC_141.L_CORE 0.001371
K_10756 X_NUC_56.L_CORE X_NUC_142.L_CORE 0.001363
K_10757 X_NUC_56.L_CORE X_NUC_143.L_CORE 0.001362
K_10758 X_NUC_56.L_CORE X_NUC_144.L_CORE 0.001365
K_10759 X_NUC_56.L_CORE X_NUC_145.L_CORE 0.001749
K_10760 X_NUC_56.L_CORE X_NUC_146.L_CORE 0.001746
K_10761 X_NUC_56.L_CORE X_NUC_147.L_CORE 0.001735
K_10762 X_NUC_56.L_CORE X_NUC_148.L_CORE 0.001745
K_10763 X_NUC_56.L_CORE X_NUC_149.L_CORE 0.001886
K_10764 X_NUC_56.L_CORE X_NUC_150.L_CORE 0.001876
K_10765 X_NUC_56.L_CORE X_NUC_151.L_CORE 0.001873
K_10766 X_NUC_56.L_CORE X_NUC_152.L_CORE 0.001871
K_10767 X_NUC_56.L_CORE X_NUC_153.L_CORE 0.001363
K_10768 X_NUC_56.L_CORE X_NUC_154.L_CORE 0.001358
K_10769 X_NUC_56.L_CORE X_NUC_155.L_CORE 0.001355
K_10770 X_NUC_56.L_CORE X_NUC_156.L_CORE 0.001359
K_10771 X_NUC_56.L_CORE X_NUC_157.L_CORE 0.002008
K_10772 X_NUC_56.L_CORE X_NUC_158.L_CORE 0.002004
K_10773 X_NUC_56.L_CORE X_NUC_159.L_CORE 0.001990
K_10774 X_NUC_56.L_CORE X_NUC_160.L_CORE 0.001996
K_10775 X_NUC_56.L_CORE X_NUC_161.L_CORE 0.001514
K_10776 X_NUC_56.L_CORE X_NUC_162.L_CORE 0.001506
K_10777 X_NUC_56.L_CORE X_NUC_163.L_CORE 0.001504
K_10778 X_NUC_56.L_CORE X_NUC_164.L_CORE 0.001505
K_10779 X_NUC_56.L_CORE X_NUC_165.L_CORE 0.001529
K_10780 X_NUC_56.L_CORE X_NUC_166.L_CORE 0.001524
K_10781 X_NUC_56.L_CORE X_NUC_167.L_CORE 0.001518
K_10782 X_NUC_56.L_CORE X_NUC_168.L_CORE 0.001523
K_10783 X_NUC_56.L_CORE X_NUC_169.L_CORE 0.001700
K_10784 X_NUC_56.L_CORE X_NUC_170.L_CORE 0.001694
K_10785 X_NUC_56.L_CORE X_NUC_171.L_CORE 0.001687
K_10786 X_NUC_56.L_CORE X_NUC_172.L_CORE 0.001690
K_10787 X_NUC_56.L_CORE X_NUC_173.L_CORE 0.002605
K_10788 X_NUC_56.L_CORE X_NUC_174.L_CORE 0.001835
K_10789 X_NUC_56.L_CORE X_NUC_175.L_CORE 0.002381
K_10790 X_NUC_56.L_CORE X_NUC_176.L_CORE 0.002547
K_10791 X_NUC_56.L_CORE X_NUC_177.L_CORE 0.001620
K_10792 X_NUC_56.L_CORE X_NUC_178.L_CORE 0.004284
K_10793 X_NUC_56.L_CORE X_NUC_179.L_CORE 0.001756
K_10794 X_NUC_56.L_CORE X_NUC_180.L_CORE 0.001844
K_10795 X_NUC_56.L_CORE X_NUC_181.L_CORE 0.004310
K_10796 X_NUC_56.L_CORE X_NUC_182.L_CORE 0.001449
K_10797 X_NUC_56.L_CORE X_NUC_183.L_CORE 0.003072
K_10798 X_NUC_56.L_CORE X_NUC_184.L_CORE 0.002070
K_10799 X_NUC_56.L_CORE X_NUC_185.L_CORE 0.001488
K_10800 X_NUC_56.L_CORE X_NUC_186.L_CORE 0.019741
K_10801 X_NUC_56.L_CORE X_NUC_187.L_CORE 0.001462
K_10802 X_NUC_56.L_CORE X_NUC_188.L_CORE 0.001988
K_10803 X_NUC_56.L_CORE X_NUC_189.L_CORE 0.003029
K_10804 X_NUC_56.L_CORE X_NUC_190.L_CORE 0.001332
K_10805 X_NUC_56.L_CORE X_NUC_191.L_CORE 0.004538
K_10806 X_NUC_56.L_CORE X_NUC_192.L_CORE 0.001649
K_10807 X_NUC_56.L_CORE X_NUC_193.L_CORE 0.001517
K_10808 X_NUC_56.L_CORE X_NUC_194.L_CORE 0.006090
K_10809 X_NUC_56.L_CORE X_NUC_195.L_CORE 0.001313
K_10810 X_NUC_56.L_CORE X_NUC_196.L_CORE 0.002301
K_10811 X_NUC_56.L_CORE X_NUC_197.L_CORE 0.002098
K_10812 X_NUC_56.L_CORE X_NUC_198.L_CORE 0.001313
K_10813 X_NUC_56.L_CORE X_NUC_199.L_CORE 0.005130
K_10814 X_NUC_56.L_CORE X_NUC_200.L_CORE 0.001414
K_10815 X_NUC_56.L_CORE X_NUC_201.L_CORE 0.001632
K_10816 X_NUC_56.L_CORE X_NUC_202.L_CORE 0.002927
K_10817 X_NUC_56.L_CORE X_NUC_203.L_CORE 0.001255
K_10818 X_NUC_56.L_CORE X_NUC_204.L_CORE 0.002596
K_10819 X_NUC_56.L_CORE X_NUC_205.L_CORE 0.001652
K_10820 X_NUC_56.L_CORE X_NUC_206.L_CORE 0.001361
K_10821 X_NUC_56.L_CORE X_NUC_207.L_CORE 0.003294
K_10822 X_NUC_56.L_CORE X_NUC_208.L_CORE 0.001303
K_10823 X_NUC_56.L_CORE X_NUC_209.L_CORE 0.001775
K_10824 X_NUC_56.L_CORE X_NUC_210.L_CORE 0.002002
K_10825 X_NUC_56.L_CORE X_NUC_211.L_CORE 0.001269
K_10826 X_NUC_56.L_CORE X_NUC_212.L_CORE 0.002433
K_10827 X_NUC_56.L_CORE X_NUC_213.L_CORE 0.001442
K_10828 X_NUC_56.L_CORE X_NUC_214.L_CORE 0.001453
K_10829 X_NUC_56.L_CORE X_NUC_215.L_CORE 0.002163
K_10830 X_NUC_56.L_CORE X_NUC_216.L_CORE 0.001292
K_10831 X_NUC_56.L_CORE X_NUC_217.L_CORE 0.001791
K_10832 X_NUC_56.L_CORE X_NUC_218.L_CORE 0.001609
K_10833 X_NUC_56.L_CORE X_NUC_219.L_CORE 0.001360
K_10834 X_NUC_56.L_CORE X_NUC_220.L_CORE 0.001837
K_10835 X_NUC_56.L_CORE X_NUC_221.L_CORE 0.001417
K_10836 X_NUC_56.L_CORE X_NUC_222.L_CORE 0.001517
K_10837 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.207973
K_10838 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.207973
K_10839 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.207973
K_10840 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.001465
K_10841 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.001474
K_10842 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.001467
K_10843 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.001472
K_10844 X_NUC_57.L_CORE X_NUC_65.L_CORE 0.002004
K_10845 X_NUC_57.L_CORE X_NUC_66.L_CORE 0.002020
K_10846 X_NUC_57.L_CORE X_NUC_67.L_CORE 0.002017
K_10847 X_NUC_57.L_CORE X_NUC_68.L_CORE 0.002005
K_10848 X_NUC_57.L_CORE X_NUC_69.L_CORE 0.003010
K_10849 X_NUC_57.L_CORE X_NUC_70.L_CORE 0.003020
K_10850 X_NUC_57.L_CORE X_NUC_71.L_CORE 0.002989
K_10851 X_NUC_57.L_CORE X_NUC_72.L_CORE 0.003031
K_10852 X_NUC_57.L_CORE X_NUC_73.L_CORE 0.001344
K_10853 X_NUC_57.L_CORE X_NUC_74.L_CORE 0.001353
K_10854 X_NUC_57.L_CORE X_NUC_75.L_CORE 0.001347
K_10855 X_NUC_57.L_CORE X_NUC_76.L_CORE 0.001348
K_10856 X_NUC_57.L_CORE X_NUC_77.L_CORE 0.004397
K_10857 X_NUC_57.L_CORE X_NUC_78.L_CORE 0.004427
K_10858 X_NUC_57.L_CORE X_NUC_79.L_CORE 0.004425
K_10859 X_NUC_57.L_CORE X_NUC_80.L_CORE 0.004346
K_10860 X_NUC_57.L_CORE X_NUC_81.L_CORE 0.001660
K_10861 X_NUC_57.L_CORE X_NUC_82.L_CORE 0.001669
K_10862 X_NUC_57.L_CORE X_NUC_83.L_CORE 0.001658
K_10863 X_NUC_57.L_CORE X_NUC_84.L_CORE 0.001668
K_10864 X_NUC_57.L_CORE X_NUC_85.L_CORE 0.001537
K_10865 X_NUC_57.L_CORE X_NUC_86.L_CORE 0.001547
K_10866 X_NUC_57.L_CORE X_NUC_87.L_CORE 0.001542
K_10867 X_NUC_57.L_CORE X_NUC_88.L_CORE 0.001538
K_10868 X_NUC_57.L_CORE X_NUC_89.L_CORE 0.005147
K_10869 X_NUC_57.L_CORE X_NUC_90.L_CORE 0.005133
K_10870 X_NUC_57.L_CORE X_NUC_91.L_CORE 0.005034
K_10871 X_NUC_57.L_CORE X_NUC_92.L_CORE 0.005116
K_10872 X_NUC_57.L_CORE X_NUC_93.L_CORE 0.001336
K_10873 X_NUC_57.L_CORE X_NUC_94.L_CORE 0.001343
K_10874 X_NUC_57.L_CORE X_NUC_95.L_CORE 0.001337
K_10875 X_NUC_57.L_CORE X_NUC_96.L_CORE 0.001340
K_10876 X_NUC_57.L_CORE X_NUC_97.L_CORE 0.002286
K_10877 X_NUC_57.L_CORE X_NUC_98.L_CORE 0.002301
K_10878 X_NUC_57.L_CORE X_NUC_99.L_CORE 0.002295
K_10879 X_NUC_57.L_CORE X_NUC_100.L_CORE 0.002278
K_10880 X_NUC_57.L_CORE X_NUC_101.L_CORE 0.002081
K_10881 X_NUC_57.L_CORE X_NUC_102.L_CORE 0.002089
K_10882 X_NUC_57.L_CORE X_NUC_103.L_CORE 0.002071
K_10883 X_NUC_57.L_CORE X_NUC_104.L_CORE 0.002088
K_10884 X_NUC_57.L_CORE X_NUC_105.L_CORE 0.001346
K_10885 X_NUC_57.L_CORE X_NUC_106.L_CORE 0.001354
K_10886 X_NUC_57.L_CORE X_NUC_107.L_CORE 0.001349
K_10887 X_NUC_57.L_CORE X_NUC_108.L_CORE 0.001348
K_10888 X_NUC_57.L_CORE X_NUC_109.L_CORE 0.004076
K_10889 X_NUC_57.L_CORE X_NUC_110.L_CORE 0.004080
K_10890 X_NUC_57.L_CORE X_NUC_111.L_CORE 0.004037
K_10891 X_NUC_57.L_CORE X_NUC_112.L_CORE 0.004013
K_10892 X_NUC_57.L_CORE X_NUC_113.L_CORE 0.001447
K_10893 X_NUC_57.L_CORE X_NUC_114.L_CORE 0.001454
K_10894 X_NUC_57.L_CORE X_NUC_115.L_CORE 0.001445
K_10895 X_NUC_57.L_CORE X_NUC_116.L_CORE 0.001451
K_10896 X_NUC_57.L_CORE X_NUC_117.L_CORE 0.001658
K_10897 X_NUC_57.L_CORE X_NUC_118.L_CORE 0.001668
K_10898 X_NUC_57.L_CORE X_NUC_119.L_CORE 0.001662
K_10899 X_NUC_57.L_CORE X_NUC_120.L_CORE 0.001655
K_10900 X_NUC_57.L_CORE X_NUC_121.L_CORE 0.002658
K_10901 X_NUC_57.L_CORE X_NUC_122.L_CORE 0.002663
K_10902 X_NUC_57.L_CORE X_NUC_123.L_CORE 0.002632
K_10903 X_NUC_57.L_CORE X_NUC_124.L_CORE 0.002653
K_10904 X_NUC_57.L_CORE X_NUC_125.L_CORE 0.001306
K_10905 X_NUC_57.L_CORE X_NUC_126.L_CORE 0.001313
K_10906 X_NUC_57.L_CORE X_NUC_127.L_CORE 0.001307
K_10907 X_NUC_57.L_CORE X_NUC_128.L_CORE 0.001308
K_10908 X_NUC_57.L_CORE X_NUC_129.L_CORE 0.002396
K_10909 X_NUC_57.L_CORE X_NUC_130.L_CORE 0.002407
K_10910 X_NUC_57.L_CORE X_NUC_131.L_CORE 0.002393
K_10911 X_NUC_57.L_CORE X_NUC_132.L_CORE 0.002379
K_10912 X_NUC_57.L_CORE X_NUC_133.L_CORE 0.001668
K_10913 X_NUC_57.L_CORE X_NUC_134.L_CORE 0.001675
K_10914 X_NUC_57.L_CORE X_NUC_135.L_CORE 0.001662
K_10915 X_NUC_57.L_CORE X_NUC_136.L_CORE 0.001671
K_10916 X_NUC_57.L_CORE X_NUC_137.L_CORE 0.001421
K_10917 X_NUC_57.L_CORE X_NUC_138.L_CORE 0.001429
K_10918 X_NUC_57.L_CORE X_NUC_139.L_CORE 0.001422
K_10919 X_NUC_57.L_CORE X_NUC_140.L_CORE 0.001420
K_10920 X_NUC_57.L_CORE X_NUC_141.L_CORE 0.002602
K_10921 X_NUC_57.L_CORE X_NUC_142.L_CORE 0.002607
K_10922 X_NUC_57.L_CORE X_NUC_143.L_CORE 0.002580
K_10923 X_NUC_57.L_CORE X_NUC_144.L_CORE 0.002584
K_10924 X_NUC_57.L_CORE X_NUC_145.L_CORE 0.001379
K_10925 X_NUC_57.L_CORE X_NUC_146.L_CORE 0.001386
K_10926 X_NUC_57.L_CORE X_NUC_147.L_CORE 0.001377
K_10927 X_NUC_57.L_CORE X_NUC_148.L_CORE 0.001380
K_10928 X_NUC_57.L_CORE X_NUC_149.L_CORE 0.001753
K_10929 X_NUC_57.L_CORE X_NUC_150.L_CORE 0.001762
K_10930 X_NUC_57.L_CORE X_NUC_151.L_CORE 0.001752
K_10931 X_NUC_57.L_CORE X_NUC_152.L_CORE 0.001747
K_10932 X_NUC_57.L_CORE X_NUC_153.L_CORE 0.001870
K_10933 X_NUC_57.L_CORE X_NUC_154.L_CORE 0.001876
K_10934 X_NUC_57.L_CORE X_NUC_155.L_CORE 0.001860
K_10935 X_NUC_57.L_CORE X_NUC_156.L_CORE 0.001867
K_10936 X_NUC_57.L_CORE X_NUC_157.L_CORE 0.001386
K_10937 X_NUC_57.L_CORE X_NUC_158.L_CORE 0.001393
K_10938 X_NUC_57.L_CORE X_NUC_159.L_CORE 0.001385
K_10939 X_NUC_57.L_CORE X_NUC_160.L_CORE 0.001386
K_10940 X_NUC_57.L_CORE X_NUC_161.L_CORE 0.001956
K_10941 X_NUC_57.L_CORE X_NUC_162.L_CORE 0.001964
K_10942 X_NUC_57.L_CORE X_NUC_163.L_CORE 0.001949
K_10943 X_NUC_57.L_CORE X_NUC_164.L_CORE 0.001947
K_10944 X_NUC_57.L_CORE X_NUC_165.L_CORE 0.001536
K_10945 X_NUC_57.L_CORE X_NUC_166.L_CORE 0.001543
K_10946 X_NUC_57.L_CORE X_NUC_167.L_CORE 0.001532
K_10947 X_NUC_57.L_CORE X_NUC_168.L_CORE 0.001535
K_10948 X_NUC_57.L_CORE X_NUC_169.L_CORE 0.001564
K_10949 X_NUC_57.L_CORE X_NUC_170.L_CORE 0.001571
K_10950 X_NUC_57.L_CORE X_NUC_171.L_CORE 0.001561
K_10951 X_NUC_57.L_CORE X_NUC_172.L_CORE 0.001561
K_10952 X_NUC_57.L_CORE X_NUC_173.L_CORE 0.002003
K_10953 X_NUC_57.L_CORE X_NUC_174.L_CORE 0.002891
K_10954 X_NUC_57.L_CORE X_NUC_175.L_CORE 0.001724
K_10955 X_NUC_57.L_CORE X_NUC_176.L_CORE 0.002345
K_10956 X_NUC_57.L_CORE X_NUC_177.L_CORE 0.002504
K_10957 X_NUC_57.L_CORE X_NUC_178.L_CORE 0.001563
K_10958 X_NUC_57.L_CORE X_NUC_179.L_CORE 0.004417
K_10959 X_NUC_57.L_CORE X_NUC_180.L_CORE 0.001707
K_10960 X_NUC_57.L_CORE X_NUC_181.L_CORE 0.001805
K_10961 X_NUC_57.L_CORE X_NUC_182.L_CORE 0.004262
K_10962 X_NUC_57.L_CORE X_NUC_183.L_CORE 0.001418
K_10963 X_NUC_57.L_CORE X_NUC_184.L_CORE 0.003044
K_10964 X_NUC_57.L_CORE X_NUC_185.L_CORE 0.002028
K_10965 X_NUC_57.L_CORE X_NUC_186.L_CORE 0.001466
K_10966 X_NUC_57.L_CORE X_NUC_187.L_CORE 0.020041
K_10967 X_NUC_57.L_CORE X_NUC_188.L_CORE 0.001440
K_10968 X_NUC_57.L_CORE X_NUC_189.L_CORE 0.001971
K_10969 X_NUC_57.L_CORE X_NUC_190.L_CORE 0.002972
K_10970 X_NUC_57.L_CORE X_NUC_191.L_CORE 0.001319
K_10971 X_NUC_57.L_CORE X_NUC_192.L_CORE 0.004537
K_10972 X_NUC_57.L_CORE X_NUC_193.L_CORE 0.001631
K_10973 X_NUC_57.L_CORE X_NUC_194.L_CORE 0.001508
K_10974 X_NUC_57.L_CORE X_NUC_195.L_CORE 0.005962
K_10975 X_NUC_57.L_CORE X_NUC_196.L_CORE 0.001304
K_10976 X_NUC_57.L_CORE X_NUC_197.L_CORE 0.002301
K_10977 X_NUC_57.L_CORE X_NUC_198.L_CORE 0.002080
K_10978 X_NUC_57.L_CORE X_NUC_199.L_CORE 0.001310
K_10979 X_NUC_57.L_CORE X_NUC_200.L_CORE 0.005140
K_10980 X_NUC_57.L_CORE X_NUC_201.L_CORE 0.001409
K_10981 X_NUC_57.L_CORE X_NUC_202.L_CORE 0.001634
K_10982 X_NUC_57.L_CORE X_NUC_203.L_CORE 0.002907
K_10983 X_NUC_57.L_CORE X_NUC_204.L_CORE 0.001256
K_10984 X_NUC_57.L_CORE X_NUC_205.L_CORE 0.002607
K_10985 X_NUC_57.L_CORE X_NUC_206.L_CORE 0.001650
K_10986 X_NUC_57.L_CORE X_NUC_207.L_CORE 0.001367
K_10987 X_NUC_57.L_CORE X_NUC_208.L_CORE 0.003275
K_10988 X_NUC_57.L_CORE X_NUC_209.L_CORE 0.001308
K_10989 X_NUC_57.L_CORE X_NUC_210.L_CORE 0.001786
K_10990 X_NUC_57.L_CORE X_NUC_211.L_CORE 0.002000
K_10991 X_NUC_57.L_CORE X_NUC_212.L_CORE 0.001279
K_10992 X_NUC_57.L_CORE X_NUC_213.L_CORE 0.002425
K_10993 X_NUC_57.L_CORE X_NUC_214.L_CORE 0.001452
K_10994 X_NUC_57.L_CORE X_NUC_215.L_CORE 0.001468
K_10995 X_NUC_57.L_CORE X_NUC_216.L_CORE 0.002142
K_10996 X_NUC_57.L_CORE X_NUC_217.L_CORE 0.001312
K_10997 X_NUC_57.L_CORE X_NUC_218.L_CORE 0.001792
K_10998 X_NUC_57.L_CORE X_NUC_219.L_CORE 0.001616
K_10999 X_NUC_57.L_CORE X_NUC_220.L_CORE 0.001393
K_11000 X_NUC_57.L_CORE X_NUC_221.L_CORE 0.001781
K_11001 X_NUC_57.L_CORE X_NUC_222.L_CORE 0.001472
K_11002 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.207973
K_11003 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.207973
K_11004 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.001457
K_11005 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.001465
K_11006 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.001458
K_11007 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.001464
K_11008 X_NUC_58.L_CORE X_NUC_65.L_CORE 0.001989
K_11009 X_NUC_58.L_CORE X_NUC_66.L_CORE 0.002004
K_11010 X_NUC_58.L_CORE X_NUC_67.L_CORE 0.002002
K_11011 X_NUC_58.L_CORE X_NUC_68.L_CORE 0.001990
K_11012 X_NUC_58.L_CORE X_NUC_69.L_CORE 0.002999
K_11013 X_NUC_58.L_CORE X_NUC_70.L_CORE 0.003010
K_11014 X_NUC_58.L_CORE X_NUC_71.L_CORE 0.002979
K_11015 X_NUC_58.L_CORE X_NUC_72.L_CORE 0.003020
K_11016 X_NUC_58.L_CORE X_NUC_73.L_CORE 0.001336
K_11017 X_NUC_58.L_CORE X_NUC_74.L_CORE 0.001344
K_11018 X_NUC_58.L_CORE X_NUC_75.L_CORE 0.001339
K_11019 X_NUC_58.L_CORE X_NUC_76.L_CORE 0.001340
K_11020 X_NUC_58.L_CORE X_NUC_77.L_CORE 0.004365
K_11021 X_NUC_58.L_CORE X_NUC_78.L_CORE 0.004397
K_11022 X_NUC_58.L_CORE X_NUC_79.L_CORE 0.004394
K_11023 X_NUC_58.L_CORE X_NUC_80.L_CORE 0.004317
K_11024 X_NUC_58.L_CORE X_NUC_81.L_CORE 0.001652
K_11025 X_NUC_58.L_CORE X_NUC_82.L_CORE 0.001660
K_11026 X_NUC_58.L_CORE X_NUC_83.L_CORE 0.001649
K_11027 X_NUC_58.L_CORE X_NUC_84.L_CORE 0.001659
K_11028 X_NUC_58.L_CORE X_NUC_85.L_CORE 0.001526
K_11029 X_NUC_58.L_CORE X_NUC_86.L_CORE 0.001537
K_11030 X_NUC_58.L_CORE X_NUC_87.L_CORE 0.001532
K_11031 X_NUC_58.L_CORE X_NUC_88.L_CORE 0.001528
K_11032 X_NUC_58.L_CORE X_NUC_89.L_CORE 0.005159
K_11033 X_NUC_58.L_CORE X_NUC_90.L_CORE 0.005147
K_11034 X_NUC_58.L_CORE X_NUC_91.L_CORE 0.005046
K_11035 X_NUC_58.L_CORE X_NUC_92.L_CORE 0.005129
K_11036 X_NUC_58.L_CORE X_NUC_93.L_CORE 0.001328
K_11037 X_NUC_58.L_CORE X_NUC_94.L_CORE 0.001336
K_11038 X_NUC_58.L_CORE X_NUC_95.L_CORE 0.001329
K_11039 X_NUC_58.L_CORE X_NUC_96.L_CORE 0.001332
K_11040 X_NUC_58.L_CORE X_NUC_97.L_CORE 0.002271
K_11041 X_NUC_58.L_CORE X_NUC_98.L_CORE 0.002286
K_11042 X_NUC_58.L_CORE X_NUC_99.L_CORE 0.002280
K_11043 X_NUC_58.L_CORE X_NUC_100.L_CORE 0.002263
K_11044 X_NUC_58.L_CORE X_NUC_101.L_CORE 0.002073
K_11045 X_NUC_58.L_CORE X_NUC_102.L_CORE 0.002081
K_11046 X_NUC_58.L_CORE X_NUC_103.L_CORE 0.002063
K_11047 X_NUC_58.L_CORE X_NUC_104.L_CORE 0.002080
K_11048 X_NUC_58.L_CORE X_NUC_105.L_CORE 0.001338
K_11049 X_NUC_58.L_CORE X_NUC_106.L_CORE 0.001346
K_11050 X_NUC_58.L_CORE X_NUC_107.L_CORE 0.001340
K_11051 X_NUC_58.L_CORE X_NUC_108.L_CORE 0.001340
K_11052 X_NUC_58.L_CORE X_NUC_109.L_CORE 0.004070
K_11053 X_NUC_58.L_CORE X_NUC_110.L_CORE 0.004076
K_11054 X_NUC_58.L_CORE X_NUC_111.L_CORE 0.004032
K_11055 X_NUC_58.L_CORE X_NUC_112.L_CORE 0.004008
K_11056 X_NUC_58.L_CORE X_NUC_113.L_CORE 0.001439
K_11057 X_NUC_58.L_CORE X_NUC_114.L_CORE 0.001447
K_11058 X_NUC_58.L_CORE X_NUC_115.L_CORE 0.001437
K_11059 X_NUC_58.L_CORE X_NUC_116.L_CORE 0.001443
K_11060 X_NUC_58.L_CORE X_NUC_117.L_CORE 0.001647
K_11061 X_NUC_58.L_CORE X_NUC_118.L_CORE 0.001658
K_11062 X_NUC_58.L_CORE X_NUC_119.L_CORE 0.001651
K_11063 X_NUC_58.L_CORE X_NUC_120.L_CORE 0.001645
K_11064 X_NUC_58.L_CORE X_NUC_121.L_CORE 0.002653
K_11065 X_NUC_58.L_CORE X_NUC_122.L_CORE 0.002658
K_11066 X_NUC_58.L_CORE X_NUC_123.L_CORE 0.002627
K_11067 X_NUC_58.L_CORE X_NUC_124.L_CORE 0.002648
K_11068 X_NUC_58.L_CORE X_NUC_125.L_CORE 0.001299
K_11069 X_NUC_58.L_CORE X_NUC_126.L_CORE 0.001306
K_11070 X_NUC_58.L_CORE X_NUC_127.L_CORE 0.001299
K_11071 X_NUC_58.L_CORE X_NUC_128.L_CORE 0.001301
K_11072 X_NUC_58.L_CORE X_NUC_129.L_CORE 0.002385
K_11073 X_NUC_58.L_CORE X_NUC_130.L_CORE 0.002396
K_11074 X_NUC_58.L_CORE X_NUC_131.L_CORE 0.002382
K_11075 X_NUC_58.L_CORE X_NUC_132.L_CORE 0.002369
K_11076 X_NUC_58.L_CORE X_NUC_133.L_CORE 0.001661
K_11077 X_NUC_58.L_CORE X_NUC_134.L_CORE 0.001668
K_11078 X_NUC_58.L_CORE X_NUC_135.L_CORE 0.001655
K_11079 X_NUC_58.L_CORE X_NUC_136.L_CORE 0.001664
K_11080 X_NUC_58.L_CORE X_NUC_137.L_CORE 0.001413
K_11081 X_NUC_58.L_CORE X_NUC_138.L_CORE 0.001421
K_11082 X_NUC_58.L_CORE X_NUC_139.L_CORE 0.001414
K_11083 X_NUC_58.L_CORE X_NUC_140.L_CORE 0.001412
K_11084 X_NUC_58.L_CORE X_NUC_141.L_CORE 0.002596
K_11085 X_NUC_58.L_CORE X_NUC_142.L_CORE 0.002602
K_11086 X_NUC_58.L_CORE X_NUC_143.L_CORE 0.002575
K_11087 X_NUC_58.L_CORE X_NUC_144.L_CORE 0.002579
K_11088 X_NUC_58.L_CORE X_NUC_145.L_CORE 0.001372
K_11089 X_NUC_58.L_CORE X_NUC_146.L_CORE 0.001379
K_11090 X_NUC_58.L_CORE X_NUC_147.L_CORE 0.001370
K_11091 X_NUC_58.L_CORE X_NUC_148.L_CORE 0.001373
K_11092 X_NUC_58.L_CORE X_NUC_149.L_CORE 0.001744
K_11093 X_NUC_58.L_CORE X_NUC_150.L_CORE 0.001753
K_11094 X_NUC_58.L_CORE X_NUC_151.L_CORE 0.001743
K_11095 X_NUC_58.L_CORE X_NUC_152.L_CORE 0.001738
K_11096 X_NUC_58.L_CORE X_NUC_153.L_CORE 0.001863
K_11097 X_NUC_58.L_CORE X_NUC_154.L_CORE 0.001870
K_11098 X_NUC_58.L_CORE X_NUC_155.L_CORE 0.001853
K_11099 X_NUC_58.L_CORE X_NUC_156.L_CORE 0.001861
K_11100 X_NUC_58.L_CORE X_NUC_157.L_CORE 0.001379
K_11101 X_NUC_58.L_CORE X_NUC_158.L_CORE 0.001386
K_11102 X_NUC_58.L_CORE X_NUC_159.L_CORE 0.001378
K_11103 X_NUC_58.L_CORE X_NUC_160.L_CORE 0.001378
K_11104 X_NUC_58.L_CORE X_NUC_161.L_CORE 0.001949
K_11105 X_NUC_58.L_CORE X_NUC_162.L_CORE 0.001956
K_11106 X_NUC_58.L_CORE X_NUC_163.L_CORE 0.001941
K_11107 X_NUC_58.L_CORE X_NUC_164.L_CORE 0.001940
K_11108 X_NUC_58.L_CORE X_NUC_165.L_CORE 0.001529
K_11109 X_NUC_58.L_CORE X_NUC_166.L_CORE 0.001536
K_11110 X_NUC_58.L_CORE X_NUC_167.L_CORE 0.001525
K_11111 X_NUC_58.L_CORE X_NUC_168.L_CORE 0.001529
K_11112 X_NUC_58.L_CORE X_NUC_169.L_CORE 0.001556
K_11113 X_NUC_58.L_CORE X_NUC_170.L_CORE 0.001564
K_11114 X_NUC_58.L_CORE X_NUC_171.L_CORE 0.001554
K_11115 X_NUC_58.L_CORE X_NUC_172.L_CORE 0.001553
K_11116 X_NUC_58.L_CORE X_NUC_173.L_CORE 0.001987
K_11117 X_NUC_58.L_CORE X_NUC_174.L_CORE 0.002866
K_11118 X_NUC_58.L_CORE X_NUC_175.L_CORE 0.001712
K_11119 X_NUC_58.L_CORE X_NUC_176.L_CORE 0.002325
K_11120 X_NUC_58.L_CORE X_NUC_177.L_CORE 0.002487
K_11121 X_NUC_58.L_CORE X_NUC_178.L_CORE 0.001552
K_11122 X_NUC_58.L_CORE X_NUC_179.L_CORE 0.004369
K_11123 X_NUC_58.L_CORE X_NUC_180.L_CORE 0.001696
K_11124 X_NUC_58.L_CORE X_NUC_181.L_CORE 0.001792
K_11125 X_NUC_58.L_CORE X_NUC_182.L_CORE 0.004241
K_11126 X_NUC_58.L_CORE X_NUC_183.L_CORE 0.001409
K_11127 X_NUC_58.L_CORE X_NUC_184.L_CORE 0.003018
K_11128 X_NUC_58.L_CORE X_NUC_185.L_CORE 0.002017
K_11129 X_NUC_58.L_CORE X_NUC_186.L_CORE 0.001456
K_11130 X_NUC_58.L_CORE X_NUC_187.L_CORE 0.020563
K_11131 X_NUC_58.L_CORE X_NUC_188.L_CORE 0.001431
K_11132 X_NUC_58.L_CORE X_NUC_189.L_CORE 0.001957
K_11133 X_NUC_58.L_CORE X_NUC_190.L_CORE 0.002964
K_11134 X_NUC_58.L_CORE X_NUC_191.L_CORE 0.001310
K_11135 X_NUC_58.L_CORE X_NUC_192.L_CORE 0.004510
K_11136 X_NUC_58.L_CORE X_NUC_193.L_CORE 0.001623
K_11137 X_NUC_58.L_CORE X_NUC_194.L_CORE 0.001498
K_11138 X_NUC_58.L_CORE X_NUC_195.L_CORE 0.006012
K_11139 X_NUC_58.L_CORE X_NUC_196.L_CORE 0.001297
K_11140 X_NUC_58.L_CORE X_NUC_197.L_CORE 0.002286
K_11141 X_NUC_58.L_CORE X_NUC_198.L_CORE 0.002073
K_11142 X_NUC_58.L_CORE X_NUC_199.L_CORE 0.001302
K_11143 X_NUC_58.L_CORE X_NUC_200.L_CORE 0.005156
K_11144 X_NUC_58.L_CORE X_NUC_201.L_CORE 0.001402
K_11145 X_NUC_58.L_CORE X_NUC_202.L_CORE 0.001624
K_11146 X_NUC_58.L_CORE X_NUC_203.L_CORE 0.002906
K_11147 X_NUC_58.L_CORE X_NUC_204.L_CORE 0.001249
K_11148 X_NUC_58.L_CORE X_NUC_205.L_CORE 0.002596
K_11149 X_NUC_58.L_CORE X_NUC_206.L_CORE 0.001644
K_11150 X_NUC_58.L_CORE X_NUC_207.L_CORE 0.001359
K_11151 X_NUC_58.L_CORE X_NUC_208.L_CORE 0.003278
K_11152 X_NUC_58.L_CORE X_NUC_209.L_CORE 0.001301
K_11153 X_NUC_58.L_CORE X_NUC_210.L_CORE 0.001777
K_11154 X_NUC_58.L_CORE X_NUC_211.L_CORE 0.001995
K_11155 X_NUC_58.L_CORE X_NUC_212.L_CORE 0.001272
K_11156 X_NUC_58.L_CORE X_NUC_213.L_CORE 0.002419
K_11157 X_NUC_58.L_CORE X_NUC_214.L_CORE 0.001446
K_11158 X_NUC_58.L_CORE X_NUC_215.L_CORE 0.001461
K_11159 X_NUC_58.L_CORE X_NUC_216.L_CORE 0.002138
K_11160 X_NUC_58.L_CORE X_NUC_217.L_CORE 0.001305
K_11161 X_NUC_58.L_CORE X_NUC_218.L_CORE 0.001784
K_11162 X_NUC_58.L_CORE X_NUC_219.L_CORE 0.001610
K_11163 X_NUC_58.L_CORE X_NUC_220.L_CORE 0.001386
K_11164 X_NUC_58.L_CORE X_NUC_221.L_CORE 0.001775
K_11165 X_NUC_58.L_CORE X_NUC_222.L_CORE 0.001466
K_11166 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.207973
K_11167 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.001464
K_11168 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.001473
K_11169 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.001465
K_11170 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.001471
K_11171 X_NUC_59.L_CORE X_NUC_65.L_CORE 0.001992
K_11172 X_NUC_59.L_CORE X_NUC_66.L_CORE 0.002007
K_11173 X_NUC_59.L_CORE X_NUC_67.L_CORE 0.002004
K_11174 X_NUC_59.L_CORE X_NUC_68.L_CORE 0.001992
K_11175 X_NUC_59.L_CORE X_NUC_69.L_CORE 0.003031
K_11176 X_NUC_59.L_CORE X_NUC_70.L_CORE 0.003041
K_11177 X_NUC_59.L_CORE X_NUC_71.L_CORE 0.003010
K_11178 X_NUC_59.L_CORE X_NUC_72.L_CORE 0.003052
K_11179 X_NUC_59.L_CORE X_NUC_73.L_CORE 0.001341
K_11180 X_NUC_59.L_CORE X_NUC_74.L_CORE 0.001349
K_11181 X_NUC_59.L_CORE X_NUC_75.L_CORE 0.001344
K_11182 X_NUC_59.L_CORE X_NUC_76.L_CORE 0.001345
K_11183 X_NUC_59.L_CORE X_NUC_77.L_CORE 0.004366
K_11184 X_NUC_59.L_CORE X_NUC_78.L_CORE 0.004397
K_11185 X_NUC_59.L_CORE X_NUC_79.L_CORE 0.004397
K_11186 X_NUC_59.L_CORE X_NUC_80.L_CORE 0.004318
K_11187 X_NUC_59.L_CORE X_NUC_81.L_CORE 0.001662
K_11188 X_NUC_59.L_CORE X_NUC_82.L_CORE 0.001671
K_11189 X_NUC_59.L_CORE X_NUC_83.L_CORE 0.001660
K_11190 X_NUC_59.L_CORE X_NUC_84.L_CORE 0.001670
K_11191 X_NUC_59.L_CORE X_NUC_85.L_CORE 0.001531
K_11192 X_NUC_59.L_CORE X_NUC_86.L_CORE 0.001541
K_11193 X_NUC_59.L_CORE X_NUC_87.L_CORE 0.001537
K_11194 X_NUC_59.L_CORE X_NUC_88.L_CORE 0.001532
K_11195 X_NUC_59.L_CORE X_NUC_89.L_CORE 0.005265
K_11196 X_NUC_59.L_CORE X_NUC_90.L_CORE 0.005251
K_11197 X_NUC_59.L_CORE X_NUC_91.L_CORE 0.005147
K_11198 X_NUC_59.L_CORE X_NUC_92.L_CORE 0.005233
K_11199 X_NUC_59.L_CORE X_NUC_93.L_CORE 0.001335
K_11200 X_NUC_59.L_CORE X_NUC_94.L_CORE 0.001342
K_11201 X_NUC_59.L_CORE X_NUC_95.L_CORE 0.001336
K_11202 X_NUC_59.L_CORE X_NUC_96.L_CORE 0.001339
K_11203 X_NUC_59.L_CORE X_NUC_97.L_CORE 0.002277
K_11204 X_NUC_59.L_CORE X_NUC_98.L_CORE 0.002292
K_11205 X_NUC_59.L_CORE X_NUC_99.L_CORE 0.002286
K_11206 X_NUC_59.L_CORE X_NUC_100.L_CORE 0.002269
K_11207 X_NUC_59.L_CORE X_NUC_101.L_CORE 0.002092
K_11208 X_NUC_59.L_CORE X_NUC_102.L_CORE 0.002100
K_11209 X_NUC_59.L_CORE X_NUC_103.L_CORE 0.002081
K_11210 X_NUC_59.L_CORE X_NUC_104.L_CORE 0.002099
K_11211 X_NUC_59.L_CORE X_NUC_105.L_CORE 0.001343
K_11212 X_NUC_59.L_CORE X_NUC_106.L_CORE 0.001352
K_11213 X_NUC_59.L_CORE X_NUC_107.L_CORE 0.001346
K_11214 X_NUC_59.L_CORE X_NUC_108.L_CORE 0.001345
K_11215 X_NUC_59.L_CORE X_NUC_109.L_CORE 0.004114
K_11216 X_NUC_59.L_CORE X_NUC_110.L_CORE 0.004119
K_11217 X_NUC_59.L_CORE X_NUC_111.L_CORE 0.004076
K_11218 X_NUC_59.L_CORE X_NUC_112.L_CORE 0.004050
K_11219 X_NUC_59.L_CORE X_NUC_113.L_CORE 0.001448
K_11220 X_NUC_59.L_CORE X_NUC_114.L_CORE 0.001456
K_11221 X_NUC_59.L_CORE X_NUC_115.L_CORE 0.001447
K_11222 X_NUC_59.L_CORE X_NUC_116.L_CORE 0.001452
K_11223 X_NUC_59.L_CORE X_NUC_117.L_CORE 0.001654
K_11224 X_NUC_59.L_CORE X_NUC_118.L_CORE 0.001664
K_11225 X_NUC_59.L_CORE X_NUC_119.L_CORE 0.001658
K_11226 X_NUC_59.L_CORE X_NUC_120.L_CORE 0.001651
K_11227 X_NUC_59.L_CORE X_NUC_121.L_CORE 0.002685
K_11228 X_NUC_59.L_CORE X_NUC_122.L_CORE 0.002690
K_11229 X_NUC_59.L_CORE X_NUC_123.L_CORE 0.002658
K_11230 X_NUC_59.L_CORE X_NUC_124.L_CORE 0.002680
K_11231 X_NUC_59.L_CORE X_NUC_125.L_CORE 0.001305
K_11232 X_NUC_59.L_CORE X_NUC_126.L_CORE 0.001313
K_11233 X_NUC_59.L_CORE X_NUC_127.L_CORE 0.001306
K_11234 X_NUC_59.L_CORE X_NUC_128.L_CORE 0.001307
K_11235 X_NUC_59.L_CORE X_NUC_129.L_CORE 0.002398
K_11236 X_NUC_59.L_CORE X_NUC_130.L_CORE 0.002409
K_11237 X_NUC_59.L_CORE X_NUC_131.L_CORE 0.002396
K_11238 X_NUC_59.L_CORE X_NUC_132.L_CORE 0.002382
K_11239 X_NUC_59.L_CORE X_NUC_133.L_CORE 0.001674
K_11240 X_NUC_59.L_CORE X_NUC_134.L_CORE 0.001682
K_11241 X_NUC_59.L_CORE X_NUC_135.L_CORE 0.001668
K_11242 X_NUC_59.L_CORE X_NUC_136.L_CORE 0.001677
K_11243 X_NUC_59.L_CORE X_NUC_137.L_CORE 0.001419
K_11244 X_NUC_59.L_CORE X_NUC_138.L_CORE 0.001427
K_11245 X_NUC_59.L_CORE X_NUC_139.L_CORE 0.001421
K_11246 X_NUC_59.L_CORE X_NUC_140.L_CORE 0.001419
K_11247 X_NUC_59.L_CORE X_NUC_141.L_CORE 0.002624
K_11248 X_NUC_59.L_CORE X_NUC_142.L_CORE 0.002629
K_11249 X_NUC_59.L_CORE X_NUC_143.L_CORE 0.002602
K_11250 X_NUC_59.L_CORE X_NUC_144.L_CORE 0.002606
K_11251 X_NUC_59.L_CORE X_NUC_145.L_CORE 0.001380
K_11252 X_NUC_59.L_CORE X_NUC_146.L_CORE 0.001388
K_11253 X_NUC_59.L_CORE X_NUC_147.L_CORE 0.001379
K_11254 X_NUC_59.L_CORE X_NUC_148.L_CORE 0.001382
K_11255 X_NUC_59.L_CORE X_NUC_149.L_CORE 0.001753
K_11256 X_NUC_59.L_CORE X_NUC_150.L_CORE 0.001762
K_11257 X_NUC_59.L_CORE X_NUC_151.L_CORE 0.001753
K_11258 X_NUC_59.L_CORE X_NUC_152.L_CORE 0.001748
K_11259 X_NUC_59.L_CORE X_NUC_153.L_CORE 0.001880
K_11260 X_NUC_59.L_CORE X_NUC_154.L_CORE 0.001887
K_11261 X_NUC_59.L_CORE X_NUC_155.L_CORE 0.001870
K_11262 X_NUC_59.L_CORE X_NUC_156.L_CORE 0.001877
K_11263 X_NUC_59.L_CORE X_NUC_157.L_CORE 0.001386
K_11264 X_NUC_59.L_CORE X_NUC_158.L_CORE 0.001394
K_11265 X_NUC_59.L_CORE X_NUC_159.L_CORE 0.001386
K_11266 X_NUC_59.L_CORE X_NUC_160.L_CORE 0.001386
K_11267 X_NUC_59.L_CORE X_NUC_161.L_CORE 0.001963
K_11268 X_NUC_59.L_CORE X_NUC_162.L_CORE 0.001971
K_11269 X_NUC_59.L_CORE X_NUC_163.L_CORE 0.001956
K_11270 X_NUC_59.L_CORE X_NUC_164.L_CORE 0.001955
K_11271 X_NUC_59.L_CORE X_NUC_165.L_CORE 0.001540
K_11272 X_NUC_59.L_CORE X_NUC_166.L_CORE 0.001547
K_11273 X_NUC_59.L_CORE X_NUC_167.L_CORE 0.001536
K_11274 X_NUC_59.L_CORE X_NUC_168.L_CORE 0.001540
K_11275 X_NUC_59.L_CORE X_NUC_169.L_CORE 0.001566
K_11276 X_NUC_59.L_CORE X_NUC_170.L_CORE 0.001574
K_11277 X_NUC_59.L_CORE X_NUC_171.L_CORE 0.001564
K_11278 X_NUC_59.L_CORE X_NUC_172.L_CORE 0.001563
K_11279 X_NUC_59.L_CORE X_NUC_173.L_CORE 0.001987
K_11280 X_NUC_59.L_CORE X_NUC_174.L_CORE 0.002861
K_11281 X_NUC_59.L_CORE X_NUC_175.L_CORE 0.001716
K_11282 X_NUC_59.L_CORE X_NUC_176.L_CORE 0.002320
K_11283 X_NUC_59.L_CORE X_NUC_177.L_CORE 0.002494
K_11284 X_NUC_59.L_CORE X_NUC_178.L_CORE 0.001555
K_11285 X_NUC_59.L_CORE X_NUC_179.L_CORE 0.004326
K_11286 X_NUC_59.L_CORE X_NUC_180.L_CORE 0.001703
K_11287 X_NUC_59.L_CORE X_NUC_181.L_CORE 0.001792
K_11288 X_NUC_59.L_CORE X_NUC_182.L_CORE 0.004251
K_11289 X_NUC_59.L_CORE X_NUC_183.L_CORE 0.001414
K_11290 X_NUC_59.L_CORE X_NUC_184.L_CORE 0.003005
K_11291 X_NUC_59.L_CORE X_NUC_185.L_CORE 0.002028
K_11292 X_NUC_59.L_CORE X_NUC_186.L_CORE 0.001459
K_11293 X_NUC_59.L_CORE X_NUC_187.L_CORE 0.018993
K_11294 X_NUC_59.L_CORE X_NUC_188.L_CORE 0.001438
K_11295 X_NUC_59.L_CORE X_NUC_189.L_CORE 0.001957
K_11296 X_NUC_59.L_CORE X_NUC_190.L_CORE 0.002989
K_11297 X_NUC_59.L_CORE X_NUC_191.L_CORE 0.001315
K_11298 X_NUC_59.L_CORE X_NUC_192.L_CORE 0.004488
K_11299 X_NUC_59.L_CORE X_NUC_193.L_CORE 0.001633
K_11300 X_NUC_59.L_CORE X_NUC_194.L_CORE 0.001502
K_11301 X_NUC_59.L_CORE X_NUC_195.L_CORE 0.006122
K_11302 X_NUC_59.L_CORE X_NUC_196.L_CORE 0.001303
K_11303 X_NUC_59.L_CORE X_NUC_197.L_CORE 0.002288
K_11304 X_NUC_59.L_CORE X_NUC_198.L_CORE 0.002090
K_11305 X_NUC_59.L_CORE X_NUC_199.L_CORE 0.001307
K_11306 X_NUC_59.L_CORE X_NUC_200.L_CORE 0.005195
K_11307 X_NUC_59.L_CORE X_NUC_201.L_CORE 0.001410
K_11308 X_NUC_59.L_CORE X_NUC_202.L_CORE 0.001629
K_11309 X_NUC_59.L_CORE X_NUC_203.L_CORE 0.002941
K_11310 X_NUC_59.L_CORE X_NUC_204.L_CORE 0.001255
K_11311 X_NUC_59.L_CORE X_NUC_205.L_CORE 0.002605
K_11312 X_NUC_59.L_CORE X_NUC_206.L_CORE 0.001656
K_11313 X_NUC_59.L_CORE X_NUC_207.L_CORE 0.001364
K_11314 X_NUC_59.L_CORE X_NUC_208.L_CORE 0.003317
K_11315 X_NUC_59.L_CORE X_NUC_209.L_CORE 0.001309
K_11316 X_NUC_59.L_CORE X_NUC_210.L_CORE 0.001784
K_11317 X_NUC_59.L_CORE X_NUC_211.L_CORE 0.002014
K_11318 X_NUC_59.L_CORE X_NUC_212.L_CORE 0.001278
K_11319 X_NUC_59.L_CORE X_NUC_213.L_CORE 0.002436
K_11320 X_NUC_59.L_CORE X_NUC_214.L_CORE 0.001455
K_11321 X_NUC_59.L_CORE X_NUC_215.L_CORE 0.001468
K_11322 X_NUC_59.L_CORE X_NUC_216.L_CORE 0.002158
K_11323 X_NUC_59.L_CORE X_NUC_217.L_CORE 0.001313
K_11324 X_NUC_59.L_CORE X_NUC_218.L_CORE 0.001795
K_11325 X_NUC_59.L_CORE X_NUC_219.L_CORE 0.001623
K_11326 X_NUC_59.L_CORE X_NUC_220.L_CORE 0.001394
K_11327 X_NUC_59.L_CORE X_NUC_221.L_CORE 0.001789
K_11328 X_NUC_59.L_CORE X_NUC_222.L_CORE 0.001476
K_11329 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.001459
K_11330 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.001467
K_11331 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.001460
K_11332 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.001465
K_11333 X_NUC_60.L_CORE X_NUC_65.L_CORE 0.002004
K_11334 X_NUC_60.L_CORE X_NUC_66.L_CORE 0.002019
K_11335 X_NUC_60.L_CORE X_NUC_67.L_CORE 0.002016
K_11336 X_NUC_60.L_CORE X_NUC_68.L_CORE 0.002004
K_11337 X_NUC_60.L_CORE X_NUC_69.L_CORE 0.002989
K_11338 X_NUC_60.L_CORE X_NUC_70.L_CORE 0.002999
K_11339 X_NUC_60.L_CORE X_NUC_71.L_CORE 0.002969
K_11340 X_NUC_60.L_CORE X_NUC_72.L_CORE 0.003010
K_11341 X_NUC_60.L_CORE X_NUC_73.L_CORE 0.001340
K_11342 X_NUC_60.L_CORE X_NUC_74.L_CORE 0.001349
K_11343 X_NUC_60.L_CORE X_NUC_75.L_CORE 0.001343
K_11344 X_NUC_60.L_CORE X_NUC_76.L_CORE 0.001344
K_11345 X_NUC_60.L_CORE X_NUC_77.L_CORE 0.004447
K_11346 X_NUC_60.L_CORE X_NUC_78.L_CORE 0.004479
K_11347 X_NUC_60.L_CORE X_NUC_79.L_CORE 0.004478
K_11348 X_NUC_60.L_CORE X_NUC_80.L_CORE 0.004397
K_11349 X_NUC_60.L_CORE X_NUC_81.L_CORE 0.001653
K_11350 X_NUC_60.L_CORE X_NUC_82.L_CORE 0.001661
K_11351 X_NUC_60.L_CORE X_NUC_83.L_CORE 0.001650
K_11352 X_NUC_60.L_CORE X_NUC_84.L_CORE 0.001660
K_11353 X_NUC_60.L_CORE X_NUC_85.L_CORE 0.001535
K_11354 X_NUC_60.L_CORE X_NUC_86.L_CORE 0.001545
K_11355 X_NUC_60.L_CORE X_NUC_87.L_CORE 0.001541
K_11356 X_NUC_60.L_CORE X_NUC_88.L_CORE 0.001537
K_11357 X_NUC_60.L_CORE X_NUC_89.L_CORE 0.005176
K_11358 X_NUC_60.L_CORE X_NUC_90.L_CORE 0.005163
K_11359 X_NUC_60.L_CORE X_NUC_91.L_CORE 0.005063
K_11360 X_NUC_60.L_CORE X_NUC_92.L_CORE 0.005147
K_11361 X_NUC_60.L_CORE X_NUC_93.L_CORE 0.001332
K_11362 X_NUC_60.L_CORE X_NUC_94.L_CORE 0.001339
K_11363 X_NUC_60.L_CORE X_NUC_95.L_CORE 0.001333
K_11364 X_NUC_60.L_CORE X_NUC_96.L_CORE 0.001336
K_11365 X_NUC_60.L_CORE X_NUC_97.L_CORE 0.002295
K_11366 X_NUC_60.L_CORE X_NUC_98.L_CORE 0.002310
K_11367 X_NUC_60.L_CORE X_NUC_99.L_CORE 0.002304
K_11368 X_NUC_60.L_CORE X_NUC_100.L_CORE 0.002286
K_11369 X_NUC_60.L_CORE X_NUC_101.L_CORE 0.002075
K_11370 X_NUC_60.L_CORE X_NUC_102.L_CORE 0.002083
K_11371 X_NUC_60.L_CORE X_NUC_103.L_CORE 0.002064
K_11372 X_NUC_60.L_CORE X_NUC_104.L_CORE 0.002081
K_11373 X_NUC_60.L_CORE X_NUC_105.L_CORE 0.001344
K_11374 X_NUC_60.L_CORE X_NUC_106.L_CORE 0.001352
K_11375 X_NUC_60.L_CORE X_NUC_107.L_CORE 0.001347
K_11376 X_NUC_60.L_CORE X_NUC_108.L_CORE 0.001346
K_11377 X_NUC_60.L_CORE X_NUC_109.L_CORE 0.004140
K_11378 X_NUC_60.L_CORE X_NUC_110.L_CORE 0.004146
K_11379 X_NUC_60.L_CORE X_NUC_111.L_CORE 0.004100
K_11380 X_NUC_60.L_CORE X_NUC_112.L_CORE 0.004076
K_11381 X_NUC_60.L_CORE X_NUC_113.L_CORE 0.001443
K_11382 X_NUC_60.L_CORE X_NUC_114.L_CORE 0.001450
K_11383 X_NUC_60.L_CORE X_NUC_115.L_CORE 0.001441
K_11384 X_NUC_60.L_CORE X_NUC_116.L_CORE 0.001447
K_11385 X_NUC_60.L_CORE X_NUC_117.L_CORE 0.001660
K_11386 X_NUC_60.L_CORE X_NUC_118.L_CORE 0.001670
K_11387 X_NUC_60.L_CORE X_NUC_119.L_CORE 0.001664
K_11388 X_NUC_60.L_CORE X_NUC_120.L_CORE 0.001658
K_11389 X_NUC_60.L_CORE X_NUC_121.L_CORE 0.002663
K_11390 X_NUC_60.L_CORE X_NUC_122.L_CORE 0.002668
K_11391 X_NUC_60.L_CORE X_NUC_123.L_CORE 0.002637
K_11392 X_NUC_60.L_CORE X_NUC_124.L_CORE 0.002658
K_11393 X_NUC_60.L_CORE X_NUC_125.L_CORE 0.001304
K_11394 X_NUC_60.L_CORE X_NUC_126.L_CORE 0.001311
K_11395 X_NUC_60.L_CORE X_NUC_127.L_CORE 0.001305
K_11396 X_NUC_60.L_CORE X_NUC_128.L_CORE 0.001306
K_11397 X_NUC_60.L_CORE X_NUC_129.L_CORE 0.002412
K_11398 X_NUC_60.L_CORE X_NUC_130.L_CORE 0.002423
K_11399 X_NUC_60.L_CORE X_NUC_131.L_CORE 0.002409
K_11400 X_NUC_60.L_CORE X_NUC_132.L_CORE 0.002396
K_11401 X_NUC_60.L_CORE X_NUC_133.L_CORE 0.001666
K_11402 X_NUC_60.L_CORE X_NUC_134.L_CORE 0.001673
K_11403 X_NUC_60.L_CORE X_NUC_135.L_CORE 0.001660
K_11404 X_NUC_60.L_CORE X_NUC_136.L_CORE 0.001668
K_11405 X_NUC_60.L_CORE X_NUC_137.L_CORE 0.001421
K_11406 X_NUC_60.L_CORE X_NUC_138.L_CORE 0.001429
K_11407 X_NUC_60.L_CORE X_NUC_139.L_CORE 0.001423
K_11408 X_NUC_60.L_CORE X_NUC_140.L_CORE 0.001421
K_11409 X_NUC_60.L_CORE X_NUC_141.L_CORE 0.002619
K_11410 X_NUC_60.L_CORE X_NUC_142.L_CORE 0.002625
K_11411 X_NUC_60.L_CORE X_NUC_143.L_CORE 0.002597
K_11412 X_NUC_60.L_CORE X_NUC_144.L_CORE 0.002602
K_11413 X_NUC_60.L_CORE X_NUC_145.L_CORE 0.001377
K_11414 X_NUC_60.L_CORE X_NUC_146.L_CORE 0.001384
K_11415 X_NUC_60.L_CORE X_NUC_147.L_CORE 0.001376
K_11416 X_NUC_60.L_CORE X_NUC_148.L_CORE 0.001379
K_11417 X_NUC_60.L_CORE X_NUC_149.L_CORE 0.001758
K_11418 X_NUC_60.L_CORE X_NUC_150.L_CORE 0.001767
K_11419 X_NUC_60.L_CORE X_NUC_151.L_CORE 0.001758
K_11420 X_NUC_60.L_CORE X_NUC_152.L_CORE 0.001753
K_11421 X_NUC_60.L_CORE X_NUC_153.L_CORE 0.001872
K_11422 X_NUC_60.L_CORE X_NUC_154.L_CORE 0.001879
K_11423 X_NUC_60.L_CORE X_NUC_155.L_CORE 0.001862
K_11424 X_NUC_60.L_CORE X_NUC_156.L_CORE 0.001870
K_11425 X_NUC_60.L_CORE X_NUC_157.L_CORE 0.001386
K_11426 X_NUC_60.L_CORE X_NUC_158.L_CORE 0.001393
K_11427 X_NUC_60.L_CORE X_NUC_159.L_CORE 0.001385
K_11428 X_NUC_60.L_CORE X_NUC_160.L_CORE 0.001386
K_11429 X_NUC_60.L_CORE X_NUC_161.L_CORE 0.001965
K_11430 X_NUC_60.L_CORE X_NUC_162.L_CORE 0.001973
K_11431 X_NUC_60.L_CORE X_NUC_163.L_CORE 0.001957
K_11432 X_NUC_60.L_CORE X_NUC_164.L_CORE 0.001956
K_11433 X_NUC_60.L_CORE X_NUC_165.L_CORE 0.001537
K_11434 X_NUC_60.L_CORE X_NUC_166.L_CORE 0.001544
K_11435 X_NUC_60.L_CORE X_NUC_167.L_CORE 0.001533
K_11436 X_NUC_60.L_CORE X_NUC_168.L_CORE 0.001536
K_11437 X_NUC_60.L_CORE X_NUC_169.L_CORE 0.001567
K_11438 X_NUC_60.L_CORE X_NUC_170.L_CORE 0.001574
K_11439 X_NUC_60.L_CORE X_NUC_171.L_CORE 0.001564
K_11440 X_NUC_60.L_CORE X_NUC_172.L_CORE 0.001564
K_11441 X_NUC_60.L_CORE X_NUC_173.L_CORE 0.001987
K_11442 X_NUC_60.L_CORE X_NUC_174.L_CORE 0.002853
K_11443 X_NUC_60.L_CORE X_NUC_175.L_CORE 0.001712
K_11444 X_NUC_60.L_CORE X_NUC_176.L_CORE 0.002329
K_11445 X_NUC_60.L_CORE X_NUC_177.L_CORE 0.002475
K_11446 X_NUC_60.L_CORE X_NUC_178.L_CORE 0.001555
K_11447 X_NUC_60.L_CORE X_NUC_179.L_CORE 0.004357
K_11448 X_NUC_60.L_CORE X_NUC_180.L_CORE 0.001695
K_11449 X_NUC_60.L_CORE X_NUC_181.L_CORE 0.001799
K_11450 X_NUC_60.L_CORE X_NUC_182.L_CORE 0.004184
K_11451 X_NUC_60.L_CORE X_NUC_183.L_CORE 0.001411
K_11452 X_NUC_60.L_CORE X_NUC_184.L_CORE 0.003038
K_11453 X_NUC_60.L_CORE X_NUC_185.L_CORE 0.002012
K_11454 X_NUC_60.L_CORE X_NUC_186.L_CORE 0.001461
K_11455 X_NUC_60.L_CORE X_NUC_187.L_CORE 0.019068
K_11456 X_NUC_60.L_CORE X_NUC_188.L_CORE 0.001433
K_11457 X_NUC_60.L_CORE X_NUC_189.L_CORE 0.001969
K_11458 X_NUC_60.L_CORE X_NUC_190.L_CORE 0.002947
K_11459 X_NUC_60.L_CORE X_NUC_191.L_CORE 0.001314
K_11460 X_NUC_60.L_CORE X_NUC_192.L_CORE 0.004582
K_11461 X_NUC_60.L_CORE X_NUC_193.L_CORE 0.001623
K_11462 X_NUC_60.L_CORE X_NUC_194.L_CORE 0.001506
K_11463 X_NUC_60.L_CORE X_NUC_195.L_CORE 0.005978
K_11464 X_NUC_60.L_CORE X_NUC_196.L_CORE 0.001300
K_11465 X_NUC_60.L_CORE X_NUC_197.L_CORE 0.002308
K_11466 X_NUC_60.L_CORE X_NUC_198.L_CORE 0.002072
K_11467 X_NUC_60.L_CORE X_NUC_199.L_CORE 0.001308
K_11468 X_NUC_60.L_CORE X_NUC_200.L_CORE 0.005260
K_11469 X_NUC_60.L_CORE X_NUC_201.L_CORE 0.001405
K_11470 X_NUC_60.L_CORE X_NUC_202.L_CORE 0.001635
K_11471 X_NUC_60.L_CORE X_NUC_203.L_CORE 0.002909
K_11472 X_NUC_60.L_CORE X_NUC_204.L_CORE 0.001253
K_11473 X_NUC_60.L_CORE X_NUC_205.L_CORE 0.002628
K_11474 X_NUC_60.L_CORE X_NUC_206.L_CORE 0.001646
K_11475 X_NUC_60.L_CORE X_NUC_207.L_CORE 0.001367
K_11476 X_NUC_60.L_CORE X_NUC_208.L_CORE 0.003309
K_11477 X_NUC_60.L_CORE X_NUC_209.L_CORE 0.001305
K_11478 X_NUC_60.L_CORE X_NUC_210.L_CORE 0.001792
K_11479 X_NUC_60.L_CORE X_NUC_211.L_CORE 0.002001
K_11480 X_NUC_60.L_CORE X_NUC_212.L_CORE 0.001278
K_11481 X_NUC_60.L_CORE X_NUC_213.L_CORE 0.002445
K_11482 X_NUC_60.L_CORE X_NUC_214.L_CORE 0.001450
K_11483 X_NUC_60.L_CORE X_NUC_215.L_CORE 0.001471
K_11484 X_NUC_60.L_CORE X_NUC_216.L_CORE 0.002151
K_11485 X_NUC_60.L_CORE X_NUC_217.L_CORE 0.001311
K_11486 X_NUC_60.L_CORE X_NUC_218.L_CORE 0.001799
K_11487 X_NUC_60.L_CORE X_NUC_219.L_CORE 0.001618
K_11488 X_NUC_60.L_CORE X_NUC_220.L_CORE 0.001394
K_11489 X_NUC_60.L_CORE X_NUC_221.L_CORE 0.001788
K_11490 X_NUC_60.L_CORE X_NUC_222.L_CORE 0.001474
K_11491 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.207973
K_11492 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.207973
K_11493 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.207973
K_11494 X_NUC_61.L_CORE X_NUC_65.L_CORE 0.001445
K_11495 X_NUC_61.L_CORE X_NUC_66.L_CORE 0.001442
K_11496 X_NUC_61.L_CORE X_NUC_67.L_CORE 0.001448
K_11497 X_NUC_61.L_CORE X_NUC_68.L_CORE 0.001439
K_11498 X_NUC_61.L_CORE X_NUC_69.L_CORE 0.001979
K_11499 X_NUC_61.L_CORE X_NUC_70.L_CORE 0.001961
K_11500 X_NUC_61.L_CORE X_NUC_71.L_CORE 0.001969
K_11501 X_NUC_61.L_CORE X_NUC_72.L_CORE 0.001968
K_11502 X_NUC_61.L_CORE X_NUC_73.L_CORE 0.002977
K_11503 X_NUC_61.L_CORE X_NUC_74.L_CORE 0.002997
K_11504 X_NUC_61.L_CORE X_NUC_75.L_CORE 0.003001
K_11505 X_NUC_61.L_CORE X_NUC_76.L_CORE 0.002963
K_11506 X_NUC_61.L_CORE X_NUC_77.L_CORE 0.001330
K_11507 X_NUC_61.L_CORE X_NUC_78.L_CORE 0.001325
K_11508 X_NUC_61.L_CORE X_NUC_79.L_CORE 0.001330
K_11509 X_NUC_61.L_CORE X_NUC_80.L_CORE 0.001324
K_11510 X_NUC_61.L_CORE X_NUC_81.L_CORE 0.004368
K_11511 X_NUC_61.L_CORE X_NUC_82.L_CORE 0.004293
K_11512 X_NUC_61.L_CORE X_NUC_83.L_CORE 0.004288
K_11513 X_NUC_61.L_CORE X_NUC_84.L_CORE 0.004323
K_11514 X_NUC_61.L_CORE X_NUC_85.L_CORE 0.001647
K_11515 X_NUC_61.L_CORE X_NUC_86.L_CORE 0.001647
K_11516 X_NUC_61.L_CORE X_NUC_87.L_CORE 0.001652
K_11517 X_NUC_61.L_CORE X_NUC_88.L_CORE 0.001639
K_11518 X_NUC_61.L_CORE X_NUC_89.L_CORE 0.001526
K_11519 X_NUC_61.L_CORE X_NUC_90.L_CORE 0.001516
K_11520 X_NUC_61.L_CORE X_NUC_91.L_CORE 0.001522
K_11521 X_NUC_61.L_CORE X_NUC_92.L_CORE 0.001518
K_11522 X_NUC_61.L_CORE X_NUC_93.L_CORE 0.005149
K_11523 X_NUC_61.L_CORE X_NUC_94.L_CORE 0.005213
K_11524 X_NUC_61.L_CORE X_NUC_95.L_CORE 0.005142
K_11525 X_NUC_61.L_CORE X_NUC_96.L_CORE 0.005086
K_11526 X_NUC_61.L_CORE X_NUC_97.L_CORE 0.001330
K_11527 X_NUC_61.L_CORE X_NUC_98.L_CORE 0.001326
K_11528 X_NUC_61.L_CORE X_NUC_99.L_CORE 0.001330
K_11529 X_NUC_61.L_CORE X_NUC_100.L_CORE 0.001323
K_11530 X_NUC_61.L_CORE X_NUC_101.L_CORE 0.002280
K_11531 X_NUC_61.L_CORE X_NUC_102.L_CORE 0.002258
K_11532 X_NUC_61.L_CORE X_NUC_103.L_CORE 0.002261
K_11533 X_NUC_61.L_CORE X_NUC_104.L_CORE 0.002263
K_11534 X_NUC_61.L_CORE X_NUC_105.L_CORE 0.002078
K_11535 X_NUC_61.L_CORE X_NUC_106.L_CORE 0.002083
K_11536 X_NUC_61.L_CORE X_NUC_107.L_CORE 0.002083
K_11537 X_NUC_61.L_CORE X_NUC_108.L_CORE 0.002065
K_11538 X_NUC_61.L_CORE X_NUC_109.L_CORE 0.001344
K_11539 X_NUC_61.L_CORE X_NUC_110.L_CORE 0.001338
K_11540 X_NUC_61.L_CORE X_NUC_111.L_CORE 0.001342
K_11541 X_NUC_61.L_CORE X_NUC_112.L_CORE 0.001337
K_11542 X_NUC_61.L_CORE X_NUC_113.L_CORE 0.004076
K_11543 X_NUC_61.L_CORE X_NUC_114.L_CORE 0.004052
K_11544 X_NUC_61.L_CORE X_NUC_115.L_CORE 0.004006
K_11545 X_NUC_61.L_CORE X_NUC_116.L_CORE 0.004017
K_11546 X_NUC_61.L_CORE X_NUC_117.L_CORE 0.001448
K_11547 X_NUC_61.L_CORE X_NUC_118.L_CORE 0.001446
K_11548 X_NUC_61.L_CORE X_NUC_119.L_CORE 0.001449
K_11549 X_NUC_61.L_CORE X_NUC_120.L_CORE 0.001440
K_11550 X_NUC_61.L_CORE X_NUC_121.L_CORE 0.001661
K_11551 X_NUC_61.L_CORE X_NUC_122.L_CORE 0.001649
K_11552 X_NUC_61.L_CORE X_NUC_123.L_CORE 0.001652
K_11553 X_NUC_61.L_CORE X_NUC_124.L_CORE 0.001650
K_11554 X_NUC_61.L_CORE X_NUC_125.L_CORE 0.002658
K_11555 X_NUC_61.L_CORE X_NUC_126.L_CORE 0.002668
K_11556 X_NUC_61.L_CORE X_NUC_127.L_CORE 0.002655
K_11557 X_NUC_61.L_CORE X_NUC_128.L_CORE 0.002635
K_11558 X_NUC_61.L_CORE X_NUC_129.L_CORE 0.001313
K_11559 X_NUC_61.L_CORE X_NUC_130.L_CORE 0.001308
K_11560 X_NUC_61.L_CORE X_NUC_131.L_CORE 0.001311
K_11561 X_NUC_61.L_CORE X_NUC_132.L_CORE 0.001305
K_11562 X_NUC_61.L_CORE X_NUC_133.L_CORE 0.002395
K_11563 X_NUC_61.L_CORE X_NUC_134.L_CORE 0.002378
K_11564 X_NUC_61.L_CORE X_NUC_135.L_CORE 0.002371
K_11565 X_NUC_61.L_CORE X_NUC_136.L_CORE 0.002372
K_11566 X_NUC_61.L_CORE X_NUC_137.L_CORE 0.001678
K_11567 X_NUC_61.L_CORE X_NUC_138.L_CORE 0.001678
K_11568 X_NUC_61.L_CORE X_NUC_139.L_CORE 0.001678
K_11569 X_NUC_61.L_CORE X_NUC_140.L_CORE 0.001667
K_11570 X_NUC_61.L_CORE X_NUC_141.L_CORE 0.001434
K_11571 X_NUC_61.L_CORE X_NUC_142.L_CORE 0.001427
K_11572 X_NUC_61.L_CORE X_NUC_143.L_CORE 0.001429
K_11573 X_NUC_61.L_CORE X_NUC_144.L_CORE 0.001425
K_11574 X_NUC_61.L_CORE X_NUC_145.L_CORE 0.002571
K_11575 X_NUC_61.L_CORE X_NUC_146.L_CORE 0.002568
K_11576 X_NUC_61.L_CORE X_NUC_147.L_CORE 0.002552
K_11577 X_NUC_61.L_CORE X_NUC_148.L_CORE 0.002544
K_11578 X_NUC_61.L_CORE X_NUC_149.L_CORE 0.001398
K_11579 X_NUC_61.L_CORE X_NUC_150.L_CORE 0.001395
K_11580 X_NUC_61.L_CORE X_NUC_151.L_CORE 0.001397
K_11581 X_NUC_61.L_CORE X_NUC_152.L_CORE 0.001389
K_11582 X_NUC_61.L_CORE X_NUC_153.L_CORE 0.001762
K_11583 X_NUC_61.L_CORE X_NUC_154.L_CORE 0.001752
K_11584 X_NUC_61.L_CORE X_NUC_155.L_CORE 0.001751
K_11585 X_NUC_61.L_CORE X_NUC_156.L_CORE 0.001748
K_11586 X_NUC_61.L_CORE X_NUC_157.L_CORE 0.001867
K_11587 X_NUC_61.L_CORE X_NUC_158.L_CORE 0.001866
K_11588 X_NUC_61.L_CORE X_NUC_159.L_CORE 0.001862
K_11589 X_NUC_61.L_CORE X_NUC_160.L_CORE 0.001852
K_11590 X_NUC_61.L_CORE X_NUC_161.L_CORE 0.001423
K_11591 X_NUC_61.L_CORE X_NUC_162.L_CORE 0.001418
K_11592 X_NUC_61.L_CORE X_NUC_163.L_CORE 0.001419
K_11593 X_NUC_61.L_CORE X_NUC_164.L_CORE 0.001413
K_11594 X_NUC_61.L_CORE X_NUC_165.L_CORE 0.001899
K_11595 X_NUC_61.L_CORE X_NUC_166.L_CORE 0.001893
K_11596 X_NUC_61.L_CORE X_NUC_167.L_CORE 0.001888
K_11597 X_NUC_61.L_CORE X_NUC_168.L_CORE 0.001883
K_11598 X_NUC_61.L_CORE X_NUC_169.L_CORE 0.001584
K_11599 X_NUC_61.L_CORE X_NUC_170.L_CORE 0.001580
K_11600 X_NUC_61.L_CORE X_NUC_171.L_CORE 0.001579
K_11601 X_NUC_61.L_CORE X_NUC_172.L_CORE 0.001572
K_11602 X_NUC_61.L_CORE X_NUC_173.L_CORE 0.002042
K_11603 X_NUC_61.L_CORE X_NUC_174.L_CORE 0.001836
K_11604 X_NUC_61.L_CORE X_NUC_175.L_CORE 0.003032
K_11605 X_NUC_61.L_CORE X_NUC_176.L_CORE 0.001626
K_11606 X_NUC_61.L_CORE X_NUC_177.L_CORE 0.002264
K_11607 X_NUC_61.L_CORE X_NUC_178.L_CORE 0.002439
K_11608 X_NUC_61.L_CORE X_NUC_179.L_CORE 0.001499
K_11609 X_NUC_61.L_CORE X_NUC_180.L_CORE 0.004382
K_11610 X_NUC_61.L_CORE X_NUC_181.L_CORE 0.001652
K_11611 X_NUC_61.L_CORE X_NUC_182.L_CORE 0.001744
K_11612 X_NUC_61.L_CORE X_NUC_183.L_CORE 0.004197
K_11613 X_NUC_61.L_CORE X_NUC_184.L_CORE 0.001378
K_11614 X_NUC_61.L_CORE X_NUC_185.L_CORE 0.002949
K_11615 X_NUC_61.L_CORE X_NUC_186.L_CORE 0.001984
K_11616 X_NUC_61.L_CORE X_NUC_187.L_CORE 0.001430
K_11617 X_NUC_61.L_CORE X_NUC_188.L_CORE 0.019800
K_11618 X_NUC_61.L_CORE X_NUC_189.L_CORE 0.001411
K_11619 X_NUC_61.L_CORE X_NUC_190.L_CORE 0.001926
K_11620 X_NUC_61.L_CORE X_NUC_191.L_CORE 0.002939
K_11621 X_NUC_61.L_CORE X_NUC_192.L_CORE 0.001295
K_11622 X_NUC_61.L_CORE X_NUC_193.L_CORE 0.004445
K_11623 X_NUC_61.L_CORE X_NUC_194.L_CORE 0.001610
K_11624 X_NUC_61.L_CORE X_NUC_195.L_CORE 0.001484
K_11625 X_NUC_61.L_CORE X_NUC_196.L_CORE 0.006084
K_11626 X_NUC_61.L_CORE X_NUC_197.L_CORE 0.001289
K_11627 X_NUC_61.L_CORE X_NUC_198.L_CORE 0.002270
K_11628 X_NUC_61.L_CORE X_NUC_199.L_CORE 0.002071
K_11629 X_NUC_61.L_CORE X_NUC_200.L_CORE 0.001296
K_11630 X_NUC_61.L_CORE X_NUC_201.L_CORE 0.005205
K_11631 X_NUC_61.L_CORE X_NUC_202.L_CORE 0.001401
K_11632 X_NUC_61.L_CORE X_NUC_203.L_CORE 0.001621
K_11633 X_NUC_61.L_CORE X_NUC_204.L_CORE 0.002928
K_11634 X_NUC_61.L_CORE X_NUC_205.L_CORE 0.001250
K_11635 X_NUC_61.L_CORE X_NUC_206.L_CORE 0.002600
K_11636 X_NUC_61.L_CORE X_NUC_207.L_CORE 0.001651
K_11637 X_NUC_61.L_CORE X_NUC_208.L_CORE 0.001363
K_11638 X_NUC_61.L_CORE X_NUC_209.L_CORE 0.003297
K_11639 X_NUC_61.L_CORE X_NUC_210.L_CORE 0.001309
K_11640 X_NUC_61.L_CORE X_NUC_211.L_CORE 0.001784
K_11641 X_NUC_61.L_CORE X_NUC_212.L_CORE 0.002009
K_11642 X_NUC_61.L_CORE X_NUC_213.L_CORE 0.001284
K_11643 X_NUC_61.L_CORE X_NUC_214.L_CORE 0.002414
K_11644 X_NUC_61.L_CORE X_NUC_215.L_CORE 0.001462
K_11645 X_NUC_61.L_CORE X_NUC_216.L_CORE 0.001477
K_11646 X_NUC_61.L_CORE X_NUC_217.L_CORE 0.002128
K_11647 X_NUC_61.L_CORE X_NUC_218.L_CORE 0.001331
K_11648 X_NUC_61.L_CORE X_NUC_219.L_CORE 0.001783
K_11649 X_NUC_61.L_CORE X_NUC_220.L_CORE 0.001625
K_11650 X_NUC_61.L_CORE X_NUC_221.L_CORE 0.001430
K_11651 X_NUC_61.L_CORE X_NUC_222.L_CORE 0.001694
K_11652 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.207973
K_11653 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.207973
K_11654 X_NUC_62.L_CORE X_NUC_65.L_CORE 0.001448
K_11655 X_NUC_62.L_CORE X_NUC_66.L_CORE 0.001445
K_11656 X_NUC_62.L_CORE X_NUC_67.L_CORE 0.001451
K_11657 X_NUC_62.L_CORE X_NUC_68.L_CORE 0.001441
K_11658 X_NUC_62.L_CORE X_NUC_69.L_CORE 0.001998
K_11659 X_NUC_62.L_CORE X_NUC_70.L_CORE 0.001979
K_11660 X_NUC_62.L_CORE X_NUC_71.L_CORE 0.001988
K_11661 X_NUC_62.L_CORE X_NUC_72.L_CORE 0.001987
K_11662 X_NUC_62.L_CORE X_NUC_73.L_CORE 0.002957
K_11663 X_NUC_62.L_CORE X_NUC_74.L_CORE 0.002977
K_11664 X_NUC_62.L_CORE X_NUC_75.L_CORE 0.002981
K_11665 X_NUC_62.L_CORE X_NUC_76.L_CORE 0.002944
K_11666 X_NUC_62.L_CORE X_NUC_77.L_CORE 0.001336
K_11667 X_NUC_62.L_CORE X_NUC_78.L_CORE 0.001330
K_11668 X_NUC_62.L_CORE X_NUC_79.L_CORE 0.001336
K_11669 X_NUC_62.L_CORE X_NUC_80.L_CORE 0.001330
K_11670 X_NUC_62.L_CORE X_NUC_81.L_CORE 0.004446
K_11671 X_NUC_62.L_CORE X_NUC_82.L_CORE 0.004368
K_11672 X_NUC_62.L_CORE X_NUC_83.L_CORE 0.004362
K_11673 X_NUC_62.L_CORE X_NUC_84.L_CORE 0.004399
K_11674 X_NUC_62.L_CORE X_NUC_85.L_CORE 0.001647
K_11675 X_NUC_62.L_CORE X_NUC_86.L_CORE 0.001647
K_11676 X_NUC_62.L_CORE X_NUC_87.L_CORE 0.001652
K_11677 X_NUC_62.L_CORE X_NUC_88.L_CORE 0.001639
K_11678 X_NUC_62.L_CORE X_NUC_89.L_CORE 0.001537
K_11679 X_NUC_62.L_CORE X_NUC_90.L_CORE 0.001526
K_11680 X_NUC_62.L_CORE X_NUC_91.L_CORE 0.001532
K_11681 X_NUC_62.L_CORE X_NUC_92.L_CORE 0.001528
K_11682 X_NUC_62.L_CORE X_NUC_93.L_CORE 0.005084
K_11683 X_NUC_62.L_CORE X_NUC_94.L_CORE 0.005149
K_11684 X_NUC_62.L_CORE X_NUC_95.L_CORE 0.005079
K_11685 X_NUC_62.L_CORE X_NUC_96.L_CORE 0.005025
K_11686 X_NUC_62.L_CORE X_NUC_97.L_CORE 0.001333
K_11687 X_NUC_62.L_CORE X_NUC_98.L_CORE 0.001330
K_11688 X_NUC_62.L_CORE X_NUC_99.L_CORE 0.001334
K_11689 X_NUC_62.L_CORE X_NUC_100.L_CORE 0.001326
K_11690 X_NUC_62.L_CORE X_NUC_101.L_CORE 0.002303
K_11691 X_NUC_62.L_CORE X_NUC_102.L_CORE 0.002280
K_11692 X_NUC_62.L_CORE X_NUC_103.L_CORE 0.002283
K_11693 X_NUC_62.L_CORE X_NUC_104.L_CORE 0.002286
K_11694 X_NUC_62.L_CORE X_NUC_105.L_CORE 0.002072
K_11695 X_NUC_62.L_CORE X_NUC_106.L_CORE 0.002078
K_11696 X_NUC_62.L_CORE X_NUC_107.L_CORE 0.002078
K_11697 X_NUC_62.L_CORE X_NUC_108.L_CORE 0.002060
K_11698 X_NUC_62.L_CORE X_NUC_109.L_CORE 0.001351
K_11699 X_NUC_62.L_CORE X_NUC_110.L_CORE 0.001344
K_11700 X_NUC_62.L_CORE X_NUC_111.L_CORE 0.001348
K_11701 X_NUC_62.L_CORE X_NUC_112.L_CORE 0.001343
K_11702 X_NUC_62.L_CORE X_NUC_113.L_CORE 0.004098
K_11703 X_NUC_62.L_CORE X_NUC_114.L_CORE 0.004076
K_11704 X_NUC_62.L_CORE X_NUC_115.L_CORE 0.004028
K_11705 X_NUC_62.L_CORE X_NUC_116.L_CORE 0.004039
K_11706 X_NUC_62.L_CORE X_NUC_117.L_CORE 0.001450
K_11707 X_NUC_62.L_CORE X_NUC_118.L_CORE 0.001448
K_11708 X_NUC_62.L_CORE X_NUC_119.L_CORE 0.001451
K_11709 X_NUC_62.L_CORE X_NUC_120.L_CORE 0.001442
K_11710 X_NUC_62.L_CORE X_NUC_121.L_CORE 0.001673
K_11711 X_NUC_62.L_CORE X_NUC_122.L_CORE 0.001661
K_11712 X_NUC_62.L_CORE X_NUC_123.L_CORE 0.001664
K_11713 X_NUC_62.L_CORE X_NUC_124.L_CORE 0.001661
K_11714 X_NUC_62.L_CORE X_NUC_125.L_CORE 0.002648
K_11715 X_NUC_62.L_CORE X_NUC_126.L_CORE 0.002658
K_11716 X_NUC_62.L_CORE X_NUC_127.L_CORE 0.002645
K_11717 X_NUC_62.L_CORE X_NUC_128.L_CORE 0.002626
K_11718 X_NUC_62.L_CORE X_NUC_129.L_CORE 0.001317
K_11719 X_NUC_62.L_CORE X_NUC_130.L_CORE 0.001313
K_11720 X_NUC_62.L_CORE X_NUC_131.L_CORE 0.001316
K_11721 X_NUC_62.L_CORE X_NUC_132.L_CORE 0.001310
K_11722 X_NUC_62.L_CORE X_NUC_133.L_CORE 0.002413
K_11723 X_NUC_62.L_CORE X_NUC_134.L_CORE 0.002395
K_11724 X_NUC_62.L_CORE X_NUC_135.L_CORE 0.002388
K_11725 X_NUC_62.L_CORE X_NUC_136.L_CORE 0.002390
K_11726 X_NUC_62.L_CORE X_NUC_137.L_CORE 0.001678
K_11727 X_NUC_62.L_CORE X_NUC_138.L_CORE 0.001678
K_11728 X_NUC_62.L_CORE X_NUC_139.L_CORE 0.001678
K_11729 X_NUC_62.L_CORE X_NUC_140.L_CORE 0.001667
K_11730 X_NUC_62.L_CORE X_NUC_141.L_CORE 0.001441
K_11731 X_NUC_62.L_CORE X_NUC_142.L_CORE 0.001434
K_11732 X_NUC_62.L_CORE X_NUC_143.L_CORE 0.001436
K_11733 X_NUC_62.L_CORE X_NUC_144.L_CORE 0.001432
K_11734 X_NUC_62.L_CORE X_NUC_145.L_CORE 0.002573
K_11735 X_NUC_62.L_CORE X_NUC_146.L_CORE 0.002571
K_11736 X_NUC_62.L_CORE X_NUC_147.L_CORE 0.002555
K_11737 X_NUC_62.L_CORE X_NUC_148.L_CORE 0.002547
K_11738 X_NUC_62.L_CORE X_NUC_149.L_CORE 0.001401
K_11739 X_NUC_62.L_CORE X_NUC_150.L_CORE 0.001398
K_11740 X_NUC_62.L_CORE X_NUC_151.L_CORE 0.001400
K_11741 X_NUC_62.L_CORE X_NUC_152.L_CORE 0.001393
K_11742 X_NUC_62.L_CORE X_NUC_153.L_CORE 0.001772
K_11743 X_NUC_62.L_CORE X_NUC_154.L_CORE 0.001762
K_11744 X_NUC_62.L_CORE X_NUC_155.L_CORE 0.001761
K_11745 X_NUC_62.L_CORE X_NUC_156.L_CORE 0.001758
K_11746 X_NUC_62.L_CORE X_NUC_157.L_CORE 0.001868
K_11747 X_NUC_62.L_CORE X_NUC_158.L_CORE 0.001867
K_11748 X_NUC_62.L_CORE X_NUC_159.L_CORE 0.001863
K_11749 X_NUC_62.L_CORE X_NUC_160.L_CORE 0.001853
K_11750 X_NUC_62.L_CORE X_NUC_161.L_CORE 0.001428
K_11751 X_NUC_62.L_CORE X_NUC_162.L_CORE 0.001423
K_11752 X_NUC_62.L_CORE X_NUC_163.L_CORE 0.001424
K_11753 X_NUC_62.L_CORE X_NUC_164.L_CORE 0.001418
K_11754 X_NUC_62.L_CORE X_NUC_165.L_CORE 0.001906
K_11755 X_NUC_62.L_CORE X_NUC_166.L_CORE 0.001899
K_11756 X_NUC_62.L_CORE X_NUC_167.L_CORE 0.001894
K_11757 X_NUC_62.L_CORE X_NUC_168.L_CORE 0.001889
K_11758 X_NUC_62.L_CORE X_NUC_169.L_CORE 0.001587
K_11759 X_NUC_62.L_CORE X_NUC_170.L_CORE 0.001584
K_11760 X_NUC_62.L_CORE X_NUC_171.L_CORE 0.001582
K_11761 X_NUC_62.L_CORE X_NUC_172.L_CORE 0.001575
K_11762 X_NUC_62.L_CORE X_NUC_173.L_CORE 0.002048
K_11763 X_NUC_62.L_CORE X_NUC_174.L_CORE 0.001847
K_11764 X_NUC_62.L_CORE X_NUC_175.L_CORE 0.003044
K_11765 X_NUC_62.L_CORE X_NUC_176.L_CORE 0.001631
K_11766 X_NUC_62.L_CORE X_NUC_177.L_CORE 0.002284
K_11767 X_NUC_62.L_CORE X_NUC_178.L_CORE 0.002437
K_11768 X_NUC_62.L_CORE X_NUC_179.L_CORE 0.001506
K_11769 X_NUC_62.L_CORE X_NUC_180.L_CORE 0.004438
K_11770 X_NUC_62.L_CORE X_NUC_181.L_CORE 0.001654
K_11771 X_NUC_62.L_CORE X_NUC_182.L_CORE 0.001758
K_11772 X_NUC_62.L_CORE X_NUC_183.L_CORE 0.004165
K_11773 X_NUC_62.L_CORE X_NUC_184.L_CORE 0.001383
K_11774 X_NUC_62.L_CORE X_NUC_185.L_CORE 0.002989
K_11775 X_NUC_62.L_CORE X_NUC_186.L_CORE 0.001981
K_11776 X_NUC_62.L_CORE X_NUC_187.L_CORE 0.001438
K_11777 X_NUC_62.L_CORE X_NUC_188.L_CORE 0.019472
K_11778 X_NUC_62.L_CORE X_NUC_189.L_CORE 0.001414
K_11779 X_NUC_62.L_CORE X_NUC_190.L_CORE 0.001944
K_11780 X_NUC_62.L_CORE X_NUC_191.L_CORE 0.002918
K_11781 X_NUC_62.L_CORE X_NUC_192.L_CORE 0.001301
K_11782 X_NUC_62.L_CORE X_NUC_193.L_CORE 0.004527
K_11783 X_NUC_62.L_CORE X_NUC_194.L_CORE 0.001610
K_11784 X_NUC_62.L_CORE X_NUC_195.L_CORE 0.001494
K_11785 X_NUC_62.L_CORE X_NUC_196.L_CORE 0.005953
K_11786 X_NUC_62.L_CORE X_NUC_197.L_CORE 0.001292
K_11787 X_NUC_62.L_CORE X_NUC_198.L_CORE 0.002294
K_11788 X_NUC_62.L_CORE X_NUC_199.L_CORE 0.002065
K_11789 X_NUC_62.L_CORE X_NUC_200.L_CORE 0.001303
K_11790 X_NUC_62.L_CORE X_NUC_201.L_CORE 0.005239
K_11791 X_NUC_62.L_CORE X_NUC_202.L_CORE 0.001402
K_11792 X_NUC_62.L_CORE X_NUC_203.L_CORE 0.001633
K_11793 X_NUC_62.L_CORE X_NUC_204.L_CORE 0.002908
K_11794 X_NUC_62.L_CORE X_NUC_205.L_CORE 0.001254
K_11795 X_NUC_62.L_CORE X_NUC_206.L_CORE 0.002623
K_11796 X_NUC_62.L_CORE X_NUC_207.L_CORE 0.001650
K_11797 X_NUC_62.L_CORE X_NUC_208.L_CORE 0.001370
K_11798 X_NUC_62.L_CORE X_NUC_209.L_CORE 0.003290
K_11799 X_NUC_62.L_CORE X_NUC_210.L_CORE 0.001312
K_11800 X_NUC_62.L_CORE X_NUC_211.L_CORE 0.001796
K_11801 X_NUC_62.L_CORE X_NUC_212.L_CORE 0.002005
K_11802 X_NUC_62.L_CORE X_NUC_213.L_CORE 0.001289
K_11803 X_NUC_62.L_CORE X_NUC_214.L_CORE 0.002425
K_11804 X_NUC_62.L_CORE X_NUC_215.L_CORE 0.001463
K_11805 X_NUC_62.L_CORE X_NUC_216.L_CORE 0.001484
K_11806 X_NUC_62.L_CORE X_NUC_217.L_CORE 0.002128
K_11807 X_NUC_62.L_CORE X_NUC_218.L_CORE 0.001334
K_11808 X_NUC_62.L_CORE X_NUC_219.L_CORE 0.001791
K_11809 X_NUC_62.L_CORE X_NUC_220.L_CORE 0.001626
K_11810 X_NUC_62.L_CORE X_NUC_221.L_CORE 0.001435
K_11811 X_NUC_62.L_CORE X_NUC_222.L_CORE 0.001698
K_11812 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.207973
K_11813 X_NUC_63.L_CORE X_NUC_65.L_CORE 0.001442
K_11814 X_NUC_63.L_CORE X_NUC_66.L_CORE 0.001439
K_11815 X_NUC_63.L_CORE X_NUC_67.L_CORE 0.001445
K_11816 X_NUC_63.L_CORE X_NUC_68.L_CORE 0.001435
K_11817 X_NUC_63.L_CORE X_NUC_69.L_CORE 0.001989
K_11818 X_NUC_63.L_CORE X_NUC_70.L_CORE 0.001970
K_11819 X_NUC_63.L_CORE X_NUC_71.L_CORE 0.001979
K_11820 X_NUC_63.L_CORE X_NUC_72.L_CORE 0.001978
K_11821 X_NUC_63.L_CORE X_NUC_73.L_CORE 0.002953
K_11822 X_NUC_63.L_CORE X_NUC_74.L_CORE 0.002973
K_11823 X_NUC_63.L_CORE X_NUC_75.L_CORE 0.002977
K_11824 X_NUC_63.L_CORE X_NUC_76.L_CORE 0.002940
K_11825 X_NUC_63.L_CORE X_NUC_77.L_CORE 0.001331
K_11826 X_NUC_63.L_CORE X_NUC_78.L_CORE 0.001325
K_11827 X_NUC_63.L_CORE X_NUC_79.L_CORE 0.001330
K_11828 X_NUC_63.L_CORE X_NUC_80.L_CORE 0.001324
K_11829 X_NUC_63.L_CORE X_NUC_81.L_CORE 0.004451
K_11830 X_NUC_63.L_CORE X_NUC_82.L_CORE 0.004373
K_11831 X_NUC_63.L_CORE X_NUC_83.L_CORE 0.004368
K_11832 X_NUC_63.L_CORE X_NUC_84.L_CORE 0.004404
K_11833 X_NUC_63.L_CORE X_NUC_85.L_CORE 0.001642
K_11834 X_NUC_63.L_CORE X_NUC_86.L_CORE 0.001643
K_11835 X_NUC_63.L_CORE X_NUC_87.L_CORE 0.001647
K_11836 X_NUC_63.L_CORE X_NUC_88.L_CORE 0.001635
K_11837 X_NUC_63.L_CORE X_NUC_89.L_CORE 0.001531
K_11838 X_NUC_63.L_CORE X_NUC_90.L_CORE 0.001521
K_11839 X_NUC_63.L_CORE X_NUC_91.L_CORE 0.001526
K_11840 X_NUC_63.L_CORE X_NUC_92.L_CORE 0.001523
K_11841 X_NUC_63.L_CORE X_NUC_93.L_CORE 0.005153
K_11842 X_NUC_63.L_CORE X_NUC_94.L_CORE 0.005219
K_11843 X_NUC_63.L_CORE X_NUC_95.L_CORE 0.005149
K_11844 X_NUC_63.L_CORE X_NUC_96.L_CORE 0.005091
K_11845 X_NUC_63.L_CORE X_NUC_97.L_CORE 0.001329
K_11846 X_NUC_63.L_CORE X_NUC_98.L_CORE 0.001325
K_11847 X_NUC_63.L_CORE X_NUC_99.L_CORE 0.001330
K_11848 X_NUC_63.L_CORE X_NUC_100.L_CORE 0.001322
K_11849 X_NUC_63.L_CORE X_NUC_101.L_CORE 0.002300
K_11850 X_NUC_63.L_CORE X_NUC_102.L_CORE 0.002277
K_11851 X_NUC_63.L_CORE X_NUC_103.L_CORE 0.002280
K_11852 X_NUC_63.L_CORE X_NUC_104.L_CORE 0.002283
K_11853 X_NUC_63.L_CORE X_NUC_105.L_CORE 0.002072
K_11854 X_NUC_63.L_CORE X_NUC_106.L_CORE 0.002077
K_11855 X_NUC_63.L_CORE X_NUC_107.L_CORE 0.002078
K_11856 X_NUC_63.L_CORE X_NUC_108.L_CORE 0.002060
K_11857 X_NUC_63.L_CORE X_NUC_109.L_CORE 0.001347
K_11858 X_NUC_63.L_CORE X_NUC_110.L_CORE 0.001340
K_11859 X_NUC_63.L_CORE X_NUC_111.L_CORE 0.001344
K_11860 X_NUC_63.L_CORE X_NUC_112.L_CORE 0.001339
K_11861 X_NUC_63.L_CORE X_NUC_113.L_CORE 0.004148
K_11862 X_NUC_63.L_CORE X_NUC_114.L_CORE 0.004124
K_11863 X_NUC_63.L_CORE X_NUC_115.L_CORE 0.004076
K_11864 X_NUC_63.L_CORE X_NUC_116.L_CORE 0.004087
K_11865 X_NUC_63.L_CORE X_NUC_117.L_CORE 0.001447
K_11866 X_NUC_63.L_CORE X_NUC_118.L_CORE 0.001445
K_11867 X_NUC_63.L_CORE X_NUC_119.L_CORE 0.001448
K_11868 X_NUC_63.L_CORE X_NUC_120.L_CORE 0.001439
K_11869 X_NUC_63.L_CORE X_NUC_121.L_CORE 0.001670
K_11870 X_NUC_63.L_CORE X_NUC_122.L_CORE 0.001658
K_11871 X_NUC_63.L_CORE X_NUC_123.L_CORE 0.001661
K_11872 X_NUC_63.L_CORE X_NUC_124.L_CORE 0.001658
K_11873 X_NUC_63.L_CORE X_NUC_125.L_CORE 0.002662
K_11874 X_NUC_63.L_CORE X_NUC_126.L_CORE 0.002671
K_11875 X_NUC_63.L_CORE X_NUC_127.L_CORE 0.002658
K_11876 X_NUC_63.L_CORE X_NUC_128.L_CORE 0.002638
K_11877 X_NUC_63.L_CORE X_NUC_129.L_CORE 0.001314
K_11878 X_NUC_63.L_CORE X_NUC_130.L_CORE 0.001310
K_11879 X_NUC_63.L_CORE X_NUC_131.L_CORE 0.001313
K_11880 X_NUC_63.L_CORE X_NUC_132.L_CORE 0.001307
K_11881 X_NUC_63.L_CORE X_NUC_133.L_CORE 0.002420
K_11882 X_NUC_63.L_CORE X_NUC_134.L_CORE 0.002402
K_11883 X_NUC_63.L_CORE X_NUC_135.L_CORE 0.002395
K_11884 X_NUC_63.L_CORE X_NUC_136.L_CORE 0.002397
K_11885 X_NUC_63.L_CORE X_NUC_137.L_CORE 0.001678
K_11886 X_NUC_63.L_CORE X_NUC_138.L_CORE 0.001678
K_11887 X_NUC_63.L_CORE X_NUC_139.L_CORE 0.001678
K_11888 X_NUC_63.L_CORE X_NUC_140.L_CORE 0.001667
K_11889 X_NUC_63.L_CORE X_NUC_141.L_CORE 0.001439
K_11890 X_NUC_63.L_CORE X_NUC_142.L_CORE 0.001432
K_11891 X_NUC_63.L_CORE X_NUC_143.L_CORE 0.001434
K_11892 X_NUC_63.L_CORE X_NUC_144.L_CORE 0.001430
K_11893 X_NUC_63.L_CORE X_NUC_145.L_CORE 0.002590
K_11894 X_NUC_63.L_CORE X_NUC_146.L_CORE 0.002587
K_11895 X_NUC_63.L_CORE X_NUC_147.L_CORE 0.002571
K_11896 X_NUC_63.L_CORE X_NUC_148.L_CORE 0.002563
K_11897 X_NUC_63.L_CORE X_NUC_149.L_CORE 0.001400
K_11898 X_NUC_63.L_CORE X_NUC_150.L_CORE 0.001397
K_11899 X_NUC_63.L_CORE X_NUC_151.L_CORE 0.001398
K_11900 X_NUC_63.L_CORE X_NUC_152.L_CORE 0.001391
K_11901 X_NUC_63.L_CORE X_NUC_153.L_CORE 0.001773
K_11902 X_NUC_63.L_CORE X_NUC_154.L_CORE 0.001763
K_11903 X_NUC_63.L_CORE X_NUC_155.L_CORE 0.001762
K_11904 X_NUC_63.L_CORE X_NUC_156.L_CORE 0.001759
K_11905 X_NUC_63.L_CORE X_NUC_157.L_CORE 0.001872
K_11906 X_NUC_63.L_CORE X_NUC_158.L_CORE 0.001871
K_11907 X_NUC_63.L_CORE X_NUC_159.L_CORE 0.001867
K_11908 X_NUC_63.L_CORE X_NUC_160.L_CORE 0.001857
K_11909 X_NUC_63.L_CORE X_NUC_161.L_CORE 0.001427
K_11910 X_NUC_63.L_CORE X_NUC_162.L_CORE 0.001422
K_11911 X_NUC_63.L_CORE X_NUC_163.L_CORE 0.001423
K_11912 X_NUC_63.L_CORE X_NUC_164.L_CORE 0.001417
K_11913 X_NUC_63.L_CORE X_NUC_165.L_CORE 0.001911
K_11914 X_NUC_63.L_CORE X_NUC_166.L_CORE 0.001904
K_11915 X_NUC_63.L_CORE X_NUC_167.L_CORE 0.001899
K_11916 X_NUC_63.L_CORE X_NUC_168.L_CORE 0.001894
K_11917 X_NUC_63.L_CORE X_NUC_169.L_CORE 0.001588
K_11918 X_NUC_63.L_CORE X_NUC_170.L_CORE 0.001585
K_11919 X_NUC_63.L_CORE X_NUC_171.L_CORE 0.001584
K_11920 X_NUC_63.L_CORE X_NUC_172.L_CORE 0.001577
K_11921 X_NUC_63.L_CORE X_NUC_173.L_CORE 0.002029
K_11922 X_NUC_63.L_CORE X_NUC_174.L_CORE 0.001831
K_11923 X_NUC_63.L_CORE X_NUC_175.L_CORE 0.003002
K_11924 X_NUC_63.L_CORE X_NUC_176.L_CORE 0.001620
K_11925 X_NUC_63.L_CORE X_NUC_177.L_CORE 0.002262
K_11926 X_NUC_63.L_CORE X_NUC_178.L_CORE 0.002416
K_11927 X_NUC_63.L_CORE X_NUC_179.L_CORE 0.001497
K_11928 X_NUC_63.L_CORE X_NUC_180.L_CORE 0.004355
K_11929 X_NUC_63.L_CORE X_NUC_181.L_CORE 0.001644
K_11930 X_NUC_63.L_CORE X_NUC_182.L_CORE 0.001746
K_11931 X_NUC_63.L_CORE X_NUC_183.L_CORE 0.004118
K_11932 X_NUC_63.L_CORE X_NUC_184.L_CORE 0.001376
K_11933 X_NUC_63.L_CORE X_NUC_185.L_CORE 0.002963
K_11934 X_NUC_63.L_CORE X_NUC_186.L_CORE 0.001971
K_11935 X_NUC_63.L_CORE X_NUC_187.L_CORE 0.001431
K_11936 X_NUC_63.L_CORE X_NUC_188.L_CORE 0.018632
K_11937 X_NUC_63.L_CORE X_NUC_189.L_CORE 0.001408
K_11938 X_NUC_63.L_CORE X_NUC_190.L_CORE 0.001934
K_11939 X_NUC_63.L_CORE X_NUC_191.L_CORE 0.002911
K_11940 X_NUC_63.L_CORE X_NUC_192.L_CORE 0.001295
K_11941 X_NUC_63.L_CORE X_NUC_193.L_CORE 0.004520
K_11942 X_NUC_63.L_CORE X_NUC_194.L_CORE 0.001605
K_11943 X_NUC_63.L_CORE X_NUC_195.L_CORE 0.001488
K_11944 X_NUC_63.L_CORE X_NUC_196.L_CORE 0.006041
K_11945 X_NUC_63.L_CORE X_NUC_197.L_CORE 0.001288
K_11946 X_NUC_63.L_CORE X_NUC_198.L_CORE 0.002289
K_11947 X_NUC_63.L_CORE X_NUC_199.L_CORE 0.002063
K_11948 X_NUC_63.L_CORE X_NUC_200.L_CORE 0.001298
K_11949 X_NUC_63.L_CORE X_NUC_201.L_CORE 0.005332
K_11950 X_NUC_63.L_CORE X_NUC_202.L_CORE 0.001399
K_11951 X_NUC_63.L_CORE X_NUC_203.L_CORE 0.001629
K_11952 X_NUC_63.L_CORE X_NUC_204.L_CORE 0.002924
K_11953 X_NUC_63.L_CORE X_NUC_205.L_CORE 0.001250
K_11954 X_NUC_63.L_CORE X_NUC_206.L_CORE 0.002631
K_11955 X_NUC_63.L_CORE X_NUC_207.L_CORE 0.001649
K_11956 X_NUC_63.L_CORE X_NUC_208.L_CORE 0.001367
K_11957 X_NUC_63.L_CORE X_NUC_209.L_CORE 0.003327
K_11958 X_NUC_63.L_CORE X_NUC_210.L_CORE 0.001309
K_11959 X_NUC_63.L_CORE X_NUC_211.L_CORE 0.001796
K_11960 X_NUC_63.L_CORE X_NUC_212.L_CORE 0.002010
K_11961 X_NUC_63.L_CORE X_NUC_213.L_CORE 0.001287
K_11962 X_NUC_63.L_CORE X_NUC_214.L_CORE 0.002439
K_11963 X_NUC_63.L_CORE X_NUC_215.L_CORE 0.001463
K_11964 X_NUC_63.L_CORE X_NUC_216.L_CORE 0.001484
K_11965 X_NUC_63.L_CORE X_NUC_217.L_CORE 0.002138
K_11966 X_NUC_63.L_CORE X_NUC_218.L_CORE 0.001333
K_11967 X_NUC_63.L_CORE X_NUC_219.L_CORE 0.001795
K_11968 X_NUC_63.L_CORE X_NUC_220.L_CORE 0.001629
K_11969 X_NUC_63.L_CORE X_NUC_221.L_CORE 0.001435
K_11970 X_NUC_63.L_CORE X_NUC_222.L_CORE 0.001702
K_11971 X_NUC_64.L_CORE X_NUC_65.L_CORE 0.001451
K_11972 X_NUC_64.L_CORE X_NUC_66.L_CORE 0.001449
K_11973 X_NUC_64.L_CORE X_NUC_67.L_CORE 0.001455
K_11974 X_NUC_64.L_CORE X_NUC_68.L_CORE 0.001445
K_11975 X_NUC_64.L_CORE X_NUC_69.L_CORE 0.001990
K_11976 X_NUC_64.L_CORE X_NUC_70.L_CORE 0.001971
K_11977 X_NUC_64.L_CORE X_NUC_71.L_CORE 0.001980
K_11978 X_NUC_64.L_CORE X_NUC_72.L_CORE 0.001979
K_11979 X_NUC_64.L_CORE X_NUC_73.L_CORE 0.002990
K_11980 X_NUC_64.L_CORE X_NUC_74.L_CORE 0.003011
K_11981 X_NUC_64.L_CORE X_NUC_75.L_CORE 0.003015
K_11982 X_NUC_64.L_CORE X_NUC_76.L_CORE 0.002977
K_11983 X_NUC_64.L_CORE X_NUC_77.L_CORE 0.001337
K_11984 X_NUC_64.L_CORE X_NUC_78.L_CORE 0.001331
K_11985 X_NUC_64.L_CORE X_NUC_79.L_CORE 0.001337
K_11986 X_NUC_64.L_CORE X_NUC_80.L_CORE 0.001330
K_11987 X_NUC_64.L_CORE X_NUC_81.L_CORE 0.004414
K_11988 X_NUC_64.L_CORE X_NUC_82.L_CORE 0.004337
K_11989 X_NUC_64.L_CORE X_NUC_83.L_CORE 0.004332
K_11990 X_NUC_64.L_CORE X_NUC_84.L_CORE 0.004368
K_11991 X_NUC_64.L_CORE X_NUC_85.L_CORE 0.001655
K_11992 X_NUC_64.L_CORE X_NUC_86.L_CORE 0.001656
K_11993 X_NUC_64.L_CORE X_NUC_87.L_CORE 0.001660
K_11994 X_NUC_64.L_CORE X_NUC_88.L_CORE 0.001647
K_11995 X_NUC_64.L_CORE X_NUC_89.L_CORE 0.001535
K_11996 X_NUC_64.L_CORE X_NUC_90.L_CORE 0.001525
K_11997 X_NUC_64.L_CORE X_NUC_91.L_CORE 0.001530
K_11998 X_NUC_64.L_CORE X_NUC_92.L_CORE 0.001526
K_11999 X_NUC_64.L_CORE X_NUC_93.L_CORE 0.005212
K_12000 X_NUC_64.L_CORE X_NUC_94.L_CORE 0.005280
K_12001 X_NUC_64.L_CORE X_NUC_95.L_CORE 0.005206
K_12002 X_NUC_64.L_CORE X_NUC_96.L_CORE 0.005149
K_12003 X_NUC_64.L_CORE X_NUC_97.L_CORE 0.001336
K_12004 X_NUC_64.L_CORE X_NUC_98.L_CORE 0.001333
K_12005 X_NUC_64.L_CORE X_NUC_99.L_CORE 0.001337
K_12006 X_NUC_64.L_CORE X_NUC_100.L_CORE 0.001330
K_12007 X_NUC_64.L_CORE X_NUC_101.L_CORE 0.002298
K_12008 X_NUC_64.L_CORE X_NUC_102.L_CORE 0.002275
K_12009 X_NUC_64.L_CORE X_NUC_103.L_CORE 0.002278
K_12010 X_NUC_64.L_CORE X_NUC_104.L_CORE 0.002280
K_12011 X_NUC_64.L_CORE X_NUC_105.L_CORE 0.002090
K_12012 X_NUC_64.L_CORE X_NUC_106.L_CORE 0.002096
K_12013 X_NUC_64.L_CORE X_NUC_107.L_CORE 0.002096
K_12014 X_NUC_64.L_CORE X_NUC_108.L_CORE 0.002078
K_12015 X_NUC_64.L_CORE X_NUC_109.L_CORE 0.001352
K_12016 X_NUC_64.L_CORE X_NUC_110.L_CORE 0.001345
K_12017 X_NUC_64.L_CORE X_NUC_111.L_CORE 0.001349
K_12018 X_NUC_64.L_CORE X_NUC_112.L_CORE 0.001344
K_12019 X_NUC_64.L_CORE X_NUC_113.L_CORE 0.004135
K_12020 X_NUC_64.L_CORE X_NUC_114.L_CORE 0.004112
K_12021 X_NUC_64.L_CORE X_NUC_115.L_CORE 0.004063
K_12022 X_NUC_64.L_CORE X_NUC_116.L_CORE 0.004076
K_12023 X_NUC_64.L_CORE X_NUC_117.L_CORE 0.001456
K_12024 X_NUC_64.L_CORE X_NUC_118.L_CORE 0.001455
K_12025 X_NUC_64.L_CORE X_NUC_119.L_CORE 0.001458
K_12026 X_NUC_64.L_CORE X_NUC_120.L_CORE 0.001448
K_12027 X_NUC_64.L_CORE X_NUC_121.L_CORE 0.001672
K_12028 X_NUC_64.L_CORE X_NUC_122.L_CORE 0.001661
K_12029 X_NUC_64.L_CORE X_NUC_123.L_CORE 0.001663
K_12030 X_NUC_64.L_CORE X_NUC_124.L_CORE 0.001661
K_12031 X_NUC_64.L_CORE X_NUC_125.L_CORE 0.002682
K_12032 X_NUC_64.L_CORE X_NUC_126.L_CORE 0.002692
K_12033 X_NUC_64.L_CORE X_NUC_127.L_CORE 0.002678
K_12034 X_NUC_64.L_CORE X_NUC_128.L_CORE 0.002658
K_12035 X_NUC_64.L_CORE X_NUC_129.L_CORE 0.001321
K_12036 X_NUC_64.L_CORE X_NUC_130.L_CORE 0.001316
K_12037 X_NUC_64.L_CORE X_NUC_131.L_CORE 0.001319
K_12038 X_NUC_64.L_CORE X_NUC_132.L_CORE 0.001313
K_12039 X_NUC_64.L_CORE X_NUC_133.L_CORE 0.002418
K_12040 X_NUC_64.L_CORE X_NUC_134.L_CORE 0.002400
K_12041 X_NUC_64.L_CORE X_NUC_135.L_CORE 0.002393
K_12042 X_NUC_64.L_CORE X_NUC_136.L_CORE 0.002395
K_12043 X_NUC_64.L_CORE X_NUC_137.L_CORE 0.001689
K_12044 X_NUC_64.L_CORE X_NUC_138.L_CORE 0.001689
K_12045 X_NUC_64.L_CORE X_NUC_139.L_CORE 0.001689
K_12046 X_NUC_64.L_CORE X_NUC_140.L_CORE 0.001678
K_12047 X_NUC_64.L_CORE X_NUC_141.L_CORE 0.001443
K_12048 X_NUC_64.L_CORE X_NUC_142.L_CORE 0.001436
K_12049 X_NUC_64.L_CORE X_NUC_143.L_CORE 0.001438
K_12050 X_NUC_64.L_CORE X_NUC_144.L_CORE 0.001434
K_12051 X_NUC_64.L_CORE X_NUC_145.L_CORE 0.002598
K_12052 X_NUC_64.L_CORE X_NUC_146.L_CORE 0.002596
K_12053 X_NUC_64.L_CORE X_NUC_147.L_CORE 0.002579
K_12054 X_NUC_64.L_CORE X_NUC_148.L_CORE 0.002571
K_12055 X_NUC_64.L_CORE X_NUC_149.L_CORE 0.001407
K_12056 X_NUC_64.L_CORE X_NUC_150.L_CORE 0.001404
K_12057 X_NUC_64.L_CORE X_NUC_151.L_CORE 0.001405
K_12058 X_NUC_64.L_CORE X_NUC_152.L_CORE 0.001398
K_12059 X_NUC_64.L_CORE X_NUC_153.L_CORE 0.001776
K_12060 X_NUC_64.L_CORE X_NUC_154.L_CORE 0.001766
K_12061 X_NUC_64.L_CORE X_NUC_155.L_CORE 0.001765
K_12062 X_NUC_64.L_CORE X_NUC_156.L_CORE 0.001762
K_12063 X_NUC_64.L_CORE X_NUC_157.L_CORE 0.001882
K_12064 X_NUC_64.L_CORE X_NUC_158.L_CORE 0.001881
K_12065 X_NUC_64.L_CORE X_NUC_159.L_CORE 0.001877
K_12066 X_NUC_64.L_CORE X_NUC_160.L_CORE 0.001867
K_12067 X_NUC_64.L_CORE X_NUC_161.L_CORE 0.001433
K_12068 X_NUC_64.L_CORE X_NUC_162.L_CORE 0.001427
K_12069 X_NUC_64.L_CORE X_NUC_163.L_CORE 0.001428
K_12070 X_NUC_64.L_CORE X_NUC_164.L_CORE 0.001423
K_12071 X_NUC_64.L_CORE X_NUC_165.L_CORE 0.001916
K_12072 X_NUC_64.L_CORE X_NUC_166.L_CORE 0.001910
K_12073 X_NUC_64.L_CORE X_NUC_167.L_CORE 0.001904
K_12074 X_NUC_64.L_CORE X_NUC_168.L_CORE 0.001899
K_12075 X_NUC_64.L_CORE X_NUC_169.L_CORE 0.001595
K_12076 X_NUC_64.L_CORE X_NUC_170.L_CORE 0.001592
K_12077 X_NUC_64.L_CORE X_NUC_171.L_CORE 0.001590
K_12078 X_NUC_64.L_CORE X_NUC_172.L_CORE 0.001584
K_12079 X_NUC_64.L_CORE X_NUC_173.L_CORE 0.002044
K_12080 X_NUC_64.L_CORE X_NUC_174.L_CORE 0.001840
K_12081 X_NUC_64.L_CORE X_NUC_175.L_CORE 0.003025
K_12082 X_NUC_64.L_CORE X_NUC_176.L_CORE 0.001630
K_12083 X_NUC_64.L_CORE X_NUC_177.L_CORE 0.002268
K_12084 X_NUC_64.L_CORE X_NUC_178.L_CORE 0.002440
K_12085 X_NUC_64.L_CORE X_NUC_179.L_CORE 0.001504
K_12086 X_NUC_64.L_CORE X_NUC_180.L_CORE 0.004359
K_12087 X_NUC_64.L_CORE X_NUC_181.L_CORE 0.001656
K_12088 X_NUC_64.L_CORE X_NUC_182.L_CORE 0.001751
K_12089 X_NUC_64.L_CORE X_NUC_183.L_CORE 0.004179
K_12090 X_NUC_64.L_CORE X_NUC_184.L_CORE 0.001384
K_12091 X_NUC_64.L_CORE X_NUC_185.L_CORE 0.002956
K_12092 X_NUC_64.L_CORE X_NUC_186.L_CORE 0.001989
K_12093 X_NUC_64.L_CORE X_NUC_187.L_CORE 0.001436
K_12094 X_NUC_64.L_CORE X_NUC_188.L_CORE 0.018279
K_12095 X_NUC_64.L_CORE X_NUC_189.L_CORE 0.001417
K_12096 X_NUC_64.L_CORE X_NUC_190.L_CORE 0.001935
K_12097 X_NUC_64.L_CORE X_NUC_191.L_CORE 0.002946
K_12098 X_NUC_64.L_CORE X_NUC_192.L_CORE 0.001301
K_12099 X_NUC_64.L_CORE X_NUC_193.L_CORE 0.004471
K_12100 X_NUC_64.L_CORE X_NUC_194.L_CORE 0.001617
K_12101 X_NUC_64.L_CORE X_NUC_195.L_CORE 0.001492
K_12102 X_NUC_64.L_CORE X_NUC_196.L_CORE 0.006118
K_12103 X_NUC_64.L_CORE X_NUC_197.L_CORE 0.001295
K_12104 X_NUC_64.L_CORE X_NUC_198.L_CORE 0.002285
K_12105 X_NUC_64.L_CORE X_NUC_199.L_CORE 0.002081
K_12106 X_NUC_64.L_CORE X_NUC_200.L_CORE 0.001303
K_12107 X_NUC_64.L_CORE X_NUC_201.L_CORE 0.005275
K_12108 X_NUC_64.L_CORE X_NUC_202.L_CORE 0.001408
K_12109 X_NUC_64.L_CORE X_NUC_203.L_CORE 0.001630
K_12110 X_NUC_64.L_CORE X_NUC_204.L_CORE 0.002949
K_12111 X_NUC_64.L_CORE X_NUC_205.L_CORE 0.001256
K_12112 X_NUC_64.L_CORE X_NUC_206.L_CORE 0.002623
K_12113 X_NUC_64.L_CORE X_NUC_207.L_CORE 0.001660
K_12114 X_NUC_64.L_CORE X_NUC_208.L_CORE 0.001371
K_12115 X_NUC_64.L_CORE X_NUC_209.L_CORE 0.003333
K_12116 X_NUC_64.L_CORE X_NUC_210.L_CORE 0.001316
K_12117 X_NUC_64.L_CORE X_NUC_211.L_CORE 0.001797
K_12118 X_NUC_64.L_CORE X_NUC_212.L_CORE 0.002023
K_12119 X_NUC_64.L_CORE X_NUC_213.L_CORE 0.001291
K_12120 X_NUC_64.L_CORE X_NUC_214.L_CORE 0.002438
K_12121 X_NUC_64.L_CORE X_NUC_215.L_CORE 0.001471
K_12122 X_NUC_64.L_CORE X_NUC_216.L_CORE 0.001487
K_12123 X_NUC_64.L_CORE X_NUC_217.L_CORE 0.002147
K_12124 X_NUC_64.L_CORE X_NUC_218.L_CORE 0.001339
K_12125 X_NUC_64.L_CORE X_NUC_219.L_CORE 0.001798
K_12126 X_NUC_64.L_CORE X_NUC_220.L_CORE 0.001637
K_12127 X_NUC_64.L_CORE X_NUC_221.L_CORE 0.001440
K_12128 X_NUC_64.L_CORE X_NUC_222.L_CORE 0.001707
K_12129 X_NUC_65.L_CORE X_NUC_66.L_CORE 0.207973
K_12130 X_NUC_65.L_CORE X_NUC_67.L_CORE 0.207973
K_12131 X_NUC_65.L_CORE X_NUC_68.L_CORE 0.207973
K_12132 X_NUC_65.L_CORE X_NUC_69.L_CORE 0.001429
K_12133 X_NUC_65.L_CORE X_NUC_70.L_CORE 0.001424
K_12134 X_NUC_65.L_CORE X_NUC_71.L_CORE 0.001422
K_12135 X_NUC_65.L_CORE X_NUC_72.L_CORE 0.001431
K_12136 X_NUC_65.L_CORE X_NUC_73.L_CORE 0.001959
K_12137 X_NUC_65.L_CORE X_NUC_74.L_CORE 0.001972
K_12138 X_NUC_65.L_CORE X_NUC_75.L_CORE 0.001958
K_12139 X_NUC_65.L_CORE X_NUC_76.L_CORE 0.001971
K_12140 X_NUC_65.L_CORE X_NUC_77.L_CORE 0.002952
K_12141 X_NUC_65.L_CORE X_NUC_78.L_CORE 0.002913
K_12142 X_NUC_65.L_CORE X_NUC_79.L_CORE 0.002921
K_12143 X_NUC_65.L_CORE X_NUC_80.L_CORE 0.002934
K_12144 X_NUC_65.L_CORE X_NUC_81.L_CORE 0.001320
K_12145 X_NUC_65.L_CORE X_NUC_82.L_CORE 0.001320
K_12146 X_NUC_65.L_CORE X_NUC_83.L_CORE 0.001315
K_12147 X_NUC_65.L_CORE X_NUC_84.L_CORE 0.001324
K_12148 X_NUC_65.L_CORE X_NUC_85.L_CORE 0.004347
K_12149 X_NUC_65.L_CORE X_NUC_86.L_CORE 0.004428
K_12150 X_NUC_65.L_CORE X_NUC_87.L_CORE 0.004348
K_12151 X_NUC_65.L_CORE X_NUC_88.L_CORE 0.004375
K_12152 X_NUC_65.L_CORE X_NUC_89.L_CORE 0.001638
K_12153 X_NUC_65.L_CORE X_NUC_90.L_CORE 0.001630
K_12154 X_NUC_65.L_CORE X_NUC_91.L_CORE 0.001628
K_12155 X_NUC_65.L_CORE X_NUC_92.L_CORE 0.001637
K_12156 X_NUC_65.L_CORE X_NUC_93.L_CORE 0.001520
K_12157 X_NUC_65.L_CORE X_NUC_94.L_CORE 0.001525
K_12158 X_NUC_65.L_CORE X_NUC_95.L_CORE 0.001516
K_12159 X_NUC_65.L_CORE X_NUC_96.L_CORE 0.001526
K_12160 X_NUC_65.L_CORE X_NUC_97.L_CORE 0.005150
K_12161 X_NUC_65.L_CORE X_NUC_98.L_CORE 0.005064
K_12162 X_NUC_65.L_CORE X_NUC_99.L_CORE 0.005041
K_12163 X_NUC_65.L_CORE X_NUC_100.L_CORE 0.005044
K_12164 X_NUC_65.L_CORE X_NUC_101.L_CORE 0.001327
K_12165 X_NUC_65.L_CORE X_NUC_102.L_CORE 0.001324
K_12166 X_NUC_65.L_CORE X_NUC_103.L_CORE 0.001320
K_12167 X_NUC_65.L_CORE X_NUC_104.L_CORE 0.001328
K_12168 X_NUC_65.L_CORE X_NUC_105.L_CORE 0.002278
K_12169 X_NUC_65.L_CORE X_NUC_106.L_CORE 0.002297
K_12170 X_NUC_65.L_CORE X_NUC_107.L_CORE 0.002273
K_12171 X_NUC_65.L_CORE X_NUC_108.L_CORE 0.002287
K_12172 X_NUC_65.L_CORE X_NUC_109.L_CORE 0.002078
K_12173 X_NUC_65.L_CORE X_NUC_110.L_CORE 0.002062
K_12174 X_NUC_65.L_CORE X_NUC_111.L_CORE 0.002059
K_12175 X_NUC_65.L_CORE X_NUC_112.L_CORE 0.002069
K_12176 X_NUC_65.L_CORE X_NUC_113.L_CORE 0.001346
K_12177 X_NUC_65.L_CORE X_NUC_114.L_CORE 0.001347
K_12178 X_NUC_65.L_CORE X_NUC_115.L_CORE 0.001341
K_12179 X_NUC_65.L_CORE X_NUC_116.L_CORE 0.001349
K_12180 X_NUC_65.L_CORE X_NUC_117.L_CORE 0.004068
K_12181 X_NUC_65.L_CORE X_NUC_118.L_CORE 0.004092
K_12182 X_NUC_65.L_CORE X_NUC_119.L_CORE 0.004022
K_12183 X_NUC_65.L_CORE X_NUC_120.L_CORE 0.004032
K_12184 X_NUC_65.L_CORE X_NUC_121.L_CORE 0.001453
K_12185 X_NUC_65.L_CORE X_NUC_122.L_CORE 0.001448
K_12186 X_NUC_65.L_CORE X_NUC_123.L_CORE 0.001444
K_12187 X_NUC_65.L_CORE X_NUC_124.L_CORE 0.001452
K_12188 X_NUC_65.L_CORE X_NUC_125.L_CORE 0.001668
K_12189 X_NUC_65.L_CORE X_NUC_126.L_CORE 0.001675
K_12190 X_NUC_65.L_CORE X_NUC_127.L_CORE 0.001662
K_12191 X_NUC_65.L_CORE X_NUC_128.L_CORE 0.001672
K_12192 X_NUC_65.L_CORE X_NUC_129.L_CORE 0.002658
K_12193 X_NUC_65.L_CORE X_NUC_130.L_CORE 0.002638
K_12194 X_NUC_65.L_CORE X_NUC_131.L_CORE 0.002625
K_12195 X_NUC_65.L_CORE X_NUC_132.L_CORE 0.002634
K_12196 X_NUC_65.L_CORE X_NUC_133.L_CORE 0.001323
K_12197 X_NUC_65.L_CORE X_NUC_134.L_CORE 0.001322
K_12198 X_NUC_65.L_CORE X_NUC_135.L_CORE 0.001317
K_12199 X_NUC_65.L_CORE X_NUC_136.L_CORE 0.001324
K_12200 X_NUC_65.L_CORE X_NUC_137.L_CORE 0.002394
K_12201 X_NUC_65.L_CORE X_NUC_138.L_CORE 0.002407
K_12202 X_NUC_65.L_CORE X_NUC_139.L_CORE 0.002380
K_12203 X_NUC_65.L_CORE X_NUC_140.L_CORE 0.002391
K_12204 X_NUC_65.L_CORE X_NUC_141.L_CORE 0.001691
K_12205 X_NUC_65.L_CORE X_NUC_142.L_CORE 0.001684
K_12206 X_NUC_65.L_CORE X_NUC_143.L_CORE 0.001678
K_12207 X_NUC_65.L_CORE X_NUC_144.L_CORE 0.001686
K_12208 X_NUC_65.L_CORE X_NUC_145.L_CORE 0.001452
K_12209 X_NUC_65.L_CORE X_NUC_146.L_CORE 0.001454
K_12210 X_NUC_65.L_CORE X_NUC_147.L_CORE 0.001445
K_12211 X_NUC_65.L_CORE X_NUC_148.L_CORE 0.001453
K_12212 X_NUC_65.L_CORE X_NUC_149.L_CORE 0.002531
K_12213 X_NUC_65.L_CORE X_NUC_150.L_CORE 0.002527
K_12214 X_NUC_65.L_CORE X_NUC_151.L_CORE 0.002504
K_12215 X_NUC_65.L_CORE X_NUC_152.L_CORE 0.002513
K_12216 X_NUC_65.L_CORE X_NUC_153.L_CORE 0.001424
K_12217 X_NUC_65.L_CORE X_NUC_154.L_CORE 0.001421
K_12218 X_NUC_65.L_CORE X_NUC_155.L_CORE 0.001415
K_12219 X_NUC_65.L_CORE X_NUC_156.L_CORE 0.001422
K_12220 X_NUC_65.L_CORE X_NUC_157.L_CORE 0.001773
K_12221 X_NUC_65.L_CORE X_NUC_158.L_CORE 0.001778
K_12222 X_NUC_65.L_CORE X_NUC_159.L_CORE 0.001763
K_12223 X_NUC_65.L_CORE X_NUC_160.L_CORE 0.001773
K_12224 X_NUC_65.L_CORE X_NUC_161.L_CORE 0.001861
K_12225 X_NUC_65.L_CORE X_NUC_162.L_CORE 0.001855
K_12226 X_NUC_65.L_CORE X_NUC_163.L_CORE 0.001845
K_12227 X_NUC_65.L_CORE X_NUC_164.L_CORE 0.001853
K_12228 X_NUC_65.L_CORE X_NUC_165.L_CORE 0.001476
K_12229 X_NUC_65.L_CORE X_NUC_166.L_CORE 0.001476
K_12230 X_NUC_65.L_CORE X_NUC_167.L_CORE 0.001467
K_12231 X_NUC_65.L_CORE X_NUC_168.L_CORE 0.001475
K_12232 X_NUC_65.L_CORE X_NUC_169.L_CORE 0.001807
K_12233 X_NUC_65.L_CORE X_NUC_170.L_CORE 0.001808
K_12234 X_NUC_65.L_CORE X_NUC_171.L_CORE 0.001794
K_12235 X_NUC_65.L_CORE X_NUC_172.L_CORE 0.001802
K_12236 X_NUC_65.L_CORE X_NUC_173.L_CORE 0.002245
K_12237 X_NUC_65.L_CORE X_NUC_174.L_CORE 0.001949
K_12238 X_NUC_65.L_CORE X_NUC_175.L_CORE 0.001744
K_12239 X_NUC_65.L_CORE X_NUC_176.L_CORE 0.003151
K_12240 X_NUC_65.L_CORE X_NUC_177.L_CORE 0.001558
K_12241 X_NUC_65.L_CORE X_NUC_178.L_CORE 0.002226
K_12242 X_NUC_65.L_CORE X_NUC_179.L_CORE 0.002378
K_12243 X_NUC_65.L_CORE X_NUC_180.L_CORE 0.001457
K_12244 X_NUC_65.L_CORE X_NUC_181.L_CORE 0.004435
K_12245 X_NUC_65.L_CORE X_NUC_182.L_CORE 0.001608
K_12246 X_NUC_65.L_CORE X_NUC_183.L_CORE 0.001715
K_12247 X_NUC_65.L_CORE X_NUC_184.L_CORE 0.004085
K_12248 X_NUC_65.L_CORE X_NUC_185.L_CORE 0.001352
K_12249 X_NUC_65.L_CORE X_NUC_186.L_CORE 0.002932
K_12250 X_NUC_65.L_CORE X_NUC_187.L_CORE 0.001941
K_12251 X_NUC_65.L_CORE X_NUC_188.L_CORE 0.001412
K_12252 X_NUC_65.L_CORE X_NUC_189.L_CORE 0.019016
K_12253 X_NUC_65.L_CORE X_NUC_190.L_CORE 0.001391
K_12254 X_NUC_65.L_CORE X_NUC_191.L_CORE 0.001917
K_12255 X_NUC_65.L_CORE X_NUC_192.L_CORE 0.002876
K_12256 X_NUC_65.L_CORE X_NUC_193.L_CORE 0.001284
K_12257 X_NUC_65.L_CORE X_NUC_194.L_CORE 0.004502
K_12258 X_NUC_65.L_CORE X_NUC_195.L_CORE 0.001593
K_12259 X_NUC_65.L_CORE X_NUC_196.L_CORE 0.001481
K_12260 X_NUC_65.L_CORE X_NUC_197.L_CORE 0.005976
K_12261 X_NUC_65.L_CORE X_NUC_198.L_CORE 0.001282
K_12262 X_NUC_65.L_CORE X_NUC_199.L_CORE 0.002285
K_12263 X_NUC_65.L_CORE X_NUC_200.L_CORE 0.002054
K_12264 X_NUC_65.L_CORE X_NUC_201.L_CORE 0.001296
K_12265 X_NUC_65.L_CORE X_NUC_202.L_CORE 0.005322
K_12266 X_NUC_65.L_CORE X_NUC_203.L_CORE 0.001398
K_12267 X_NUC_65.L_CORE X_NUC_204.L_CORE 0.001631
K_12268 X_NUC_65.L_CORE X_NUC_205.L_CORE 0.002915
K_12269 X_NUC_65.L_CORE X_NUC_206.L_CORE 0.001253
K_12270 X_NUC_65.L_CORE X_NUC_207.L_CORE 0.002635
K_12271 X_NUC_65.L_CORE X_NUC_208.L_CORE 0.001652
K_12272 X_NUC_65.L_CORE X_NUC_209.L_CORE 0.001374
K_12273 X_NUC_65.L_CORE X_NUC_210.L_CORE 0.003300
K_12274 X_NUC_65.L_CORE X_NUC_211.L_CORE 0.001318
K_12275 X_NUC_65.L_CORE X_NUC_212.L_CORE 0.001806
K_12276 X_NUC_65.L_CORE X_NUC_213.L_CORE 0.002012
K_12277 X_NUC_65.L_CORE X_NUC_214.L_CORE 0.001301
K_12278 X_NUC_65.L_CORE X_NUC_215.L_CORE 0.002417
K_12279 X_NUC_65.L_CORE X_NUC_216.L_CORE 0.001479
K_12280 X_NUC_65.L_CORE X_NUC_217.L_CORE 0.001502
K_12281 X_NUC_65.L_CORE X_NUC_218.L_CORE 0.002107
K_12282 X_NUC_65.L_CORE X_NUC_219.L_CORE 0.001363
K_12283 X_NUC_65.L_CORE X_NUC_220.L_CORE 0.001785
K_12284 X_NUC_65.L_CORE X_NUC_221.L_CORE 0.001636
K_12285 X_NUC_65.L_CORE X_NUC_222.L_CORE 0.001504
K_12286 X_NUC_66.L_CORE X_NUC_67.L_CORE 0.207973
K_12287 X_NUC_66.L_CORE X_NUC_68.L_CORE 0.207973
K_12288 X_NUC_66.L_CORE X_NUC_69.L_CORE 0.001433
K_12289 X_NUC_66.L_CORE X_NUC_70.L_CORE 0.001429
K_12290 X_NUC_66.L_CORE X_NUC_71.L_CORE 0.001426
K_12291 X_NUC_66.L_CORE X_NUC_72.L_CORE 0.001435
K_12292 X_NUC_66.L_CORE X_NUC_73.L_CORE 0.001947
K_12293 X_NUC_66.L_CORE X_NUC_74.L_CORE 0.001959
K_12294 X_NUC_66.L_CORE X_NUC_75.L_CORE 0.001945
K_12295 X_NUC_66.L_CORE X_NUC_76.L_CORE 0.001958
K_12296 X_NUC_66.L_CORE X_NUC_77.L_CORE 0.002991
K_12297 X_NUC_66.L_CORE X_NUC_78.L_CORE 0.002952
K_12298 X_NUC_66.L_CORE X_NUC_79.L_CORE 0.002959
K_12299 X_NUC_66.L_CORE X_NUC_80.L_CORE 0.002973
K_12300 X_NUC_66.L_CORE X_NUC_81.L_CORE 0.001320
K_12301 X_NUC_66.L_CORE X_NUC_82.L_CORE 0.001320
K_12302 X_NUC_66.L_CORE X_NUC_83.L_CORE 0.001315
K_12303 X_NUC_66.L_CORE X_NUC_84.L_CORE 0.001324
K_12304 X_NUC_66.L_CORE X_NUC_85.L_CORE 0.004269
K_12305 X_NUC_66.L_CORE X_NUC_86.L_CORE 0.004347
K_12306 X_NUC_66.L_CORE X_NUC_87.L_CORE 0.004271
K_12307 X_NUC_66.L_CORE X_NUC_88.L_CORE 0.004296
K_12308 X_NUC_66.L_CORE X_NUC_89.L_CORE 0.001647
K_12309 X_NUC_66.L_CORE X_NUC_90.L_CORE 0.001638
K_12310 X_NUC_66.L_CORE X_NUC_91.L_CORE 0.001636
K_12311 X_NUC_66.L_CORE X_NUC_92.L_CORE 0.001646
K_12312 X_NUC_66.L_CORE X_NUC_93.L_CORE 0.001515
K_12313 X_NUC_66.L_CORE X_NUC_94.L_CORE 0.001520
K_12314 X_NUC_66.L_CORE X_NUC_95.L_CORE 0.001511
K_12315 X_NUC_66.L_CORE X_NUC_96.L_CORE 0.001521
K_12316 X_NUC_66.L_CORE X_NUC_97.L_CORE 0.005237
K_12317 X_NUC_66.L_CORE X_NUC_98.L_CORE 0.005150
K_12318 X_NUC_66.L_CORE X_NUC_99.L_CORE 0.005124
K_12319 X_NUC_66.L_CORE X_NUC_100.L_CORE 0.005127
K_12320 X_NUC_66.L_CORE X_NUC_101.L_CORE 0.001329
K_12321 X_NUC_66.L_CORE X_NUC_102.L_CORE 0.001327
K_12322 X_NUC_66.L_CORE X_NUC_103.L_CORE 0.001322
K_12323 X_NUC_66.L_CORE X_NUC_104.L_CORE 0.001330
K_12324 X_NUC_66.L_CORE X_NUC_105.L_CORE 0.002260
K_12325 X_NUC_66.L_CORE X_NUC_106.L_CORE 0.002278
K_12326 X_NUC_66.L_CORE X_NUC_107.L_CORE 0.002255
K_12327 X_NUC_66.L_CORE X_NUC_108.L_CORE 0.002269
K_12328 X_NUC_66.L_CORE X_NUC_109.L_CORE 0.002094
K_12329 X_NUC_66.L_CORE X_NUC_110.L_CORE 0.002078
K_12330 X_NUC_66.L_CORE X_NUC_111.L_CORE 0.002075
K_12331 X_NUC_66.L_CORE X_NUC_112.L_CORE 0.002085
K_12332 X_NUC_66.L_CORE X_NUC_113.L_CORE 0.001345
K_12333 X_NUC_66.L_CORE X_NUC_114.L_CORE 0.001346
K_12334 X_NUC_66.L_CORE X_NUC_115.L_CORE 0.001339
K_12335 X_NUC_66.L_CORE X_NUC_116.L_CORE 0.001348
K_12336 X_NUC_66.L_CORE X_NUC_117.L_CORE 0.004044
K_12337 X_NUC_66.L_CORE X_NUC_118.L_CORE 0.004068
K_12338 X_NUC_66.L_CORE X_NUC_119.L_CORE 0.003999
K_12339 X_NUC_66.L_CORE X_NUC_120.L_CORE 0.004009
K_12340 X_NUC_66.L_CORE X_NUC_121.L_CORE 0.001458
K_12341 X_NUC_66.L_CORE X_NUC_122.L_CORE 0.001453
K_12342 X_NUC_66.L_CORE X_NUC_123.L_CORE 0.001449
K_12343 X_NUC_66.L_CORE X_NUC_124.L_CORE 0.001457
K_12344 X_NUC_66.L_CORE X_NUC_125.L_CORE 0.001661
K_12345 X_NUC_66.L_CORE X_NUC_126.L_CORE 0.001668
K_12346 X_NUC_66.L_CORE X_NUC_127.L_CORE 0.001655
K_12347 X_NUC_66.L_CORE X_NUC_128.L_CORE 0.001665
K_12348 X_NUC_66.L_CORE X_NUC_129.L_CORE 0.002678
K_12349 X_NUC_66.L_CORE X_NUC_130.L_CORE 0.002658
K_12350 X_NUC_66.L_CORE X_NUC_131.L_CORE 0.002645
K_12351 X_NUC_66.L_CORE X_NUC_132.L_CORE 0.002654
K_12352 X_NUC_66.L_CORE X_NUC_133.L_CORE 0.001324
K_12353 X_NUC_66.L_CORE X_NUC_134.L_CORE 0.001323
K_12354 X_NUC_66.L_CORE X_NUC_135.L_CORE 0.001317
K_12355 X_NUC_66.L_CORE X_NUC_136.L_CORE 0.001325
K_12356 X_NUC_66.L_CORE X_NUC_137.L_CORE 0.002381
K_12357 X_NUC_66.L_CORE X_NUC_138.L_CORE 0.002394
K_12358 X_NUC_66.L_CORE X_NUC_139.L_CORE 0.002367
K_12359 X_NUC_66.L_CORE X_NUC_140.L_CORE 0.002378
K_12360 X_NUC_66.L_CORE X_NUC_141.L_CORE 0.001699
K_12361 X_NUC_66.L_CORE X_NUC_142.L_CORE 0.001691
K_12362 X_NUC_66.L_CORE X_NUC_143.L_CORE 0.001685
K_12363 X_NUC_66.L_CORE X_NUC_144.L_CORE 0.001693
K_12364 X_NUC_66.L_CORE X_NUC_145.L_CORE 0.001449
K_12365 X_NUC_66.L_CORE X_NUC_146.L_CORE 0.001452
K_12366 X_NUC_66.L_CORE X_NUC_147.L_CORE 0.001443
K_12367 X_NUC_66.L_CORE X_NUC_148.L_CORE 0.001451
K_12368 X_NUC_66.L_CORE X_NUC_149.L_CORE 0.002534
K_12369 X_NUC_66.L_CORE X_NUC_150.L_CORE 0.002531
K_12370 X_NUC_66.L_CORE X_NUC_151.L_CORE 0.002508
K_12371 X_NUC_66.L_CORE X_NUC_152.L_CORE 0.002517
K_12372 X_NUC_66.L_CORE X_NUC_153.L_CORE 0.001426
K_12373 X_NUC_66.L_CORE X_NUC_154.L_CORE 0.001424
K_12374 X_NUC_66.L_CORE X_NUC_155.L_CORE 0.001417
K_12375 X_NUC_66.L_CORE X_NUC_156.L_CORE 0.001425
K_12376 X_NUC_66.L_CORE X_NUC_157.L_CORE 0.001769
K_12377 X_NUC_66.L_CORE X_NUC_158.L_CORE 0.001773
K_12378 X_NUC_66.L_CORE X_NUC_159.L_CORE 0.001759
K_12379 X_NUC_66.L_CORE X_NUC_160.L_CORE 0.001768
K_12380 X_NUC_66.L_CORE X_NUC_161.L_CORE 0.001866
K_12381 X_NUC_66.L_CORE X_NUC_162.L_CORE 0.001861
K_12382 X_NUC_66.L_CORE X_NUC_163.L_CORE 0.001850
K_12383 X_NUC_66.L_CORE X_NUC_164.L_CORE 0.001858
K_12384 X_NUC_66.L_CORE X_NUC_165.L_CORE 0.001476
K_12385 X_NUC_66.L_CORE X_NUC_166.L_CORE 0.001476
K_12386 X_NUC_66.L_CORE X_NUC_167.L_CORE 0.001467
K_12387 X_NUC_66.L_CORE X_NUC_168.L_CORE 0.001475
K_12388 X_NUC_66.L_CORE X_NUC_169.L_CORE 0.001807
K_12389 X_NUC_66.L_CORE X_NUC_170.L_CORE 0.001807
K_12390 X_NUC_66.L_CORE X_NUC_171.L_CORE 0.001794
K_12391 X_NUC_66.L_CORE X_NUC_172.L_CORE 0.001802
K_12392 X_NUC_66.L_CORE X_NUC_173.L_CORE 0.002243
K_12393 X_NUC_66.L_CORE X_NUC_174.L_CORE 0.001955
K_12394 X_NUC_66.L_CORE X_NUC_175.L_CORE 0.001741
K_12395 X_NUC_66.L_CORE X_NUC_176.L_CORE 0.003160
K_12396 X_NUC_66.L_CORE X_NUC_177.L_CORE 0.001561
K_12397 X_NUC_66.L_CORE X_NUC_178.L_CORE 0.002215
K_12398 X_NUC_66.L_CORE X_NUC_179.L_CORE 0.002396
K_12399 X_NUC_66.L_CORE X_NUC_180.L_CORE 0.001456
K_12400 X_NUC_66.L_CORE X_NUC_181.L_CORE 0.004393
K_12401 X_NUC_66.L_CORE X_NUC_182.L_CORE 0.001615
K_12402 X_NUC_66.L_CORE X_NUC_183.L_CORE 0.001708
K_12403 X_NUC_66.L_CORE X_NUC_184.L_CORE 0.004150
K_12404 X_NUC_66.L_CORE X_NUC_185.L_CORE 0.001354
K_12405 X_NUC_66.L_CORE X_NUC_186.L_CORE 0.002899
K_12406 X_NUC_66.L_CORE X_NUC_187.L_CORE 0.001956
K_12407 X_NUC_66.L_CORE X_NUC_188.L_CORE 0.001410
K_12408 X_NUC_66.L_CORE X_NUC_189.L_CORE 0.018970
K_12409 X_NUC_66.L_CORE X_NUC_190.L_CORE 0.001396
K_12410 X_NUC_66.L_CORE X_NUC_191.L_CORE 0.001904
K_12411 X_NUC_66.L_CORE X_NUC_192.L_CORE 0.002915
K_12412 X_NUC_66.L_CORE X_NUC_193.L_CORE 0.001284
K_12413 X_NUC_66.L_CORE X_NUC_194.L_CORE 0.004410
K_12414 X_NUC_66.L_CORE X_NUC_195.L_CORE 0.001601
K_12415 X_NUC_66.L_CORE X_NUC_196.L_CORE 0.001476
K_12416 X_NUC_66.L_CORE X_NUC_197.L_CORE 0.006126
K_12417 X_NUC_66.L_CORE X_NUC_198.L_CORE 0.001284
K_12418 X_NUC_66.L_CORE X_NUC_199.L_CORE 0.002265
K_12419 X_NUC_66.L_CORE X_NUC_200.L_CORE 0.002072
K_12420 X_NUC_66.L_CORE X_NUC_201.L_CORE 0.001295
K_12421 X_NUC_66.L_CORE X_NUC_202.L_CORE 0.005259
K_12422 X_NUC_66.L_CORE X_NUC_203.L_CORE 0.001403
K_12423 X_NUC_66.L_CORE X_NUC_204.L_CORE 0.001623
K_12424 X_NUC_66.L_CORE X_NUC_205.L_CORE 0.002947
K_12425 X_NUC_66.L_CORE X_NUC_206.L_CORE 0.001254
K_12426 X_NUC_66.L_CORE X_NUC_207.L_CORE 0.002612
K_12427 X_NUC_66.L_CORE X_NUC_208.L_CORE 0.001661
K_12428 X_NUC_66.L_CORE X_NUC_209.L_CORE 0.001371
K_12429 X_NUC_66.L_CORE X_NUC_210.L_CORE 0.003308
K_12430 X_NUC_66.L_CORE X_NUC_211.L_CORE 0.001321
K_12431 X_NUC_66.L_CORE X_NUC_212.L_CORE 0.001797
K_12432 X_NUC_66.L_CORE X_NUC_213.L_CORE 0.002023
K_12433 X_NUC_66.L_CORE X_NUC_214.L_CORE 0.001300
K_12434 X_NUC_66.L_CORE X_NUC_215.L_CORE 0.002409
K_12435 X_NUC_66.L_CORE X_NUC_216.L_CORE 0.001483
K_12436 X_NUC_66.L_CORE X_NUC_217.L_CORE 0.001499
K_12437 X_NUC_66.L_CORE X_NUC_218.L_CORE 0.002113
K_12438 X_NUC_66.L_CORE X_NUC_219.L_CORE 0.001365
K_12439 X_NUC_66.L_CORE X_NUC_220.L_CORE 0.001781
K_12440 X_NUC_66.L_CORE X_NUC_221.L_CORE 0.001640
K_12441 X_NUC_66.L_CORE X_NUC_222.L_CORE 0.001503
K_12442 X_NUC_67.L_CORE X_NUC_68.L_CORE 0.207973
K_12443 X_NUC_67.L_CORE X_NUC_69.L_CORE 0.001435
K_12444 X_NUC_67.L_CORE X_NUC_70.L_CORE 0.001431
K_12445 X_NUC_67.L_CORE X_NUC_71.L_CORE 0.001429
K_12446 X_NUC_67.L_CORE X_NUC_72.L_CORE 0.001437
K_12447 X_NUC_67.L_CORE X_NUC_73.L_CORE 0.001960
K_12448 X_NUC_67.L_CORE X_NUC_74.L_CORE 0.001973
K_12449 X_NUC_67.L_CORE X_NUC_75.L_CORE 0.001959
K_12450 X_NUC_67.L_CORE X_NUC_76.L_CORE 0.001973
K_12451 X_NUC_67.L_CORE X_NUC_77.L_CORE 0.002983
K_12452 X_NUC_67.L_CORE X_NUC_78.L_CORE 0.002944
K_12453 X_NUC_67.L_CORE X_NUC_79.L_CORE 0.002952
K_12454 X_NUC_67.L_CORE X_NUC_80.L_CORE 0.002965
K_12455 X_NUC_67.L_CORE X_NUC_81.L_CORE 0.001325
K_12456 X_NUC_67.L_CORE X_NUC_82.L_CORE 0.001325
K_12457 X_NUC_67.L_CORE X_NUC_83.L_CORE 0.001320
K_12458 X_NUC_67.L_CORE X_NUC_84.L_CORE 0.001328
K_12459 X_NUC_67.L_CORE X_NUC_85.L_CORE 0.004345
K_12460 X_NUC_67.L_CORE X_NUC_86.L_CORE 0.004426
K_12461 X_NUC_67.L_CORE X_NUC_87.L_CORE 0.004347
K_12462 X_NUC_67.L_CORE X_NUC_88.L_CORE 0.004373
K_12463 X_NUC_67.L_CORE X_NUC_89.L_CORE 0.001649
K_12464 X_NUC_67.L_CORE X_NUC_90.L_CORE 0.001640
K_12465 X_NUC_67.L_CORE X_NUC_91.L_CORE 0.001638
K_12466 X_NUC_67.L_CORE X_NUC_92.L_CORE 0.001648
K_12467 X_NUC_67.L_CORE X_NUC_93.L_CORE 0.001524
K_12468 X_NUC_67.L_CORE X_NUC_94.L_CORE 0.001529
K_12469 X_NUC_67.L_CORE X_NUC_95.L_CORE 0.001520
K_12470 X_NUC_67.L_CORE X_NUC_96.L_CORE 0.001530
K_12471 X_NUC_67.L_CORE X_NUC_97.L_CORE 0.005263
K_12472 X_NUC_67.L_CORE X_NUC_98.L_CORE 0.005174
K_12473 X_NUC_67.L_CORE X_NUC_99.L_CORE 0.005150
K_12474 X_NUC_67.L_CORE X_NUC_100.L_CORE 0.005152
K_12475 X_NUC_67.L_CORE X_NUC_101.L_CORE 0.001333
K_12476 X_NUC_67.L_CORE X_NUC_102.L_CORE 0.001331
K_12477 X_NUC_67.L_CORE X_NUC_103.L_CORE 0.001327
K_12478 X_NUC_67.L_CORE X_NUC_104.L_CORE 0.001335
K_12479 X_NUC_67.L_CORE X_NUC_105.L_CORE 0.002283
K_12480 X_NUC_67.L_CORE X_NUC_106.L_CORE 0.002302
K_12481 X_NUC_67.L_CORE X_NUC_107.L_CORE 0.002278
K_12482 X_NUC_67.L_CORE X_NUC_108.L_CORE 0.002292
K_12483 X_NUC_67.L_CORE X_NUC_109.L_CORE 0.002097
K_12484 X_NUC_67.L_CORE X_NUC_110.L_CORE 0.002081
K_12485 X_NUC_67.L_CORE X_NUC_111.L_CORE 0.002078
K_12486 X_NUC_67.L_CORE X_NUC_112.L_CORE 0.002088
K_12487 X_NUC_67.L_CORE X_NUC_113.L_CORE 0.001351
K_12488 X_NUC_67.L_CORE X_NUC_114.L_CORE 0.001353
K_12489 X_NUC_67.L_CORE X_NUC_115.L_CORE 0.001346
K_12490 X_NUC_67.L_CORE X_NUC_116.L_CORE 0.001354
K_12491 X_NUC_67.L_CORE X_NUC_117.L_CORE 0.004115
K_12492 X_NUC_67.L_CORE X_NUC_118.L_CORE 0.004140
K_12493 X_NUC_67.L_CORE X_NUC_119.L_CORE 0.004068
K_12494 X_NUC_67.L_CORE X_NUC_120.L_CORE 0.004078
K_12495 X_NUC_67.L_CORE X_NUC_121.L_CORE 0.001462
K_12496 X_NUC_67.L_CORE X_NUC_122.L_CORE 0.001457
K_12497 X_NUC_67.L_CORE X_NUC_123.L_CORE 0.001453
K_12498 X_NUC_67.L_CORE X_NUC_124.L_CORE 0.001461
K_12499 X_NUC_67.L_CORE X_NUC_125.L_CORE 0.001674
K_12500 X_NUC_67.L_CORE X_NUC_126.L_CORE 0.001680
K_12501 X_NUC_67.L_CORE X_NUC_127.L_CORE 0.001668
K_12502 X_NUC_67.L_CORE X_NUC_128.L_CORE 0.001678
K_12503 X_NUC_67.L_CORE X_NUC_129.L_CORE 0.002691
K_12504 X_NUC_67.L_CORE X_NUC_130.L_CORE 0.002670
K_12505 X_NUC_67.L_CORE X_NUC_131.L_CORE 0.002658
K_12506 X_NUC_67.L_CORE X_NUC_132.L_CORE 0.002667
K_12507 X_NUC_67.L_CORE X_NUC_133.L_CORE 0.001330
K_12508 X_NUC_67.L_CORE X_NUC_134.L_CORE 0.001329
K_12509 X_NUC_67.L_CORE X_NUC_135.L_CORE 0.001323
K_12510 X_NUC_67.L_CORE X_NUC_136.L_CORE 0.001331
K_12511 X_NUC_67.L_CORE X_NUC_137.L_CORE 0.002408
K_12512 X_NUC_67.L_CORE X_NUC_138.L_CORE 0.002422
K_12513 X_NUC_67.L_CORE X_NUC_139.L_CORE 0.002394
K_12514 X_NUC_67.L_CORE X_NUC_140.L_CORE 0.002405
K_12515 X_NUC_67.L_CORE X_NUC_141.L_CORE 0.001705
K_12516 X_NUC_67.L_CORE X_NUC_142.L_CORE 0.001697
K_12517 X_NUC_67.L_CORE X_NUC_143.L_CORE 0.001691
K_12518 X_NUC_67.L_CORE X_NUC_144.L_CORE 0.001699
K_12519 X_NUC_67.L_CORE X_NUC_145.L_CORE 0.001458
K_12520 X_NUC_67.L_CORE X_NUC_146.L_CORE 0.001461
K_12521 X_NUC_67.L_CORE X_NUC_147.L_CORE 0.001452
K_12522 X_NUC_67.L_CORE X_NUC_148.L_CORE 0.001460
K_12523 X_NUC_67.L_CORE X_NUC_149.L_CORE 0.002558
K_12524 X_NUC_67.L_CORE X_NUC_150.L_CORE 0.002555
K_12525 X_NUC_67.L_CORE X_NUC_151.L_CORE 0.002531
K_12526 X_NUC_67.L_CORE X_NUC_152.L_CORE 0.002540
K_12527 X_NUC_67.L_CORE X_NUC_153.L_CORE 0.001433
K_12528 X_NUC_67.L_CORE X_NUC_154.L_CORE 0.001430
K_12529 X_NUC_67.L_CORE X_NUC_155.L_CORE 0.001424
K_12530 X_NUC_67.L_CORE X_NUC_156.L_CORE 0.001431
K_12531 X_NUC_67.L_CORE X_NUC_157.L_CORE 0.001784
K_12532 X_NUC_67.L_CORE X_NUC_158.L_CORE 0.001788
K_12533 X_NUC_67.L_CORE X_NUC_159.L_CORE 0.001773
K_12534 X_NUC_67.L_CORE X_NUC_160.L_CORE 0.001783
K_12535 X_NUC_67.L_CORE X_NUC_161.L_CORE 0.001877
K_12536 X_NUC_67.L_CORE X_NUC_162.L_CORE 0.001872
K_12537 X_NUC_67.L_CORE X_NUC_163.L_CORE 0.001861
K_12538 X_NUC_67.L_CORE X_NUC_164.L_CORE 0.001869
K_12539 X_NUC_67.L_CORE X_NUC_165.L_CORE 0.001485
K_12540 X_NUC_67.L_CORE X_NUC_166.L_CORE 0.001485
K_12541 X_NUC_67.L_CORE X_NUC_167.L_CORE 0.001476
K_12542 X_NUC_67.L_CORE X_NUC_168.L_CORE 0.001484
K_12543 X_NUC_67.L_CORE X_NUC_169.L_CORE 0.001821
K_12544 X_NUC_67.L_CORE X_NUC_170.L_CORE 0.001821
K_12545 X_NUC_67.L_CORE X_NUC_171.L_CORE 0.001807
K_12546 X_NUC_67.L_CORE X_NUC_172.L_CORE 0.001816
K_12547 X_NUC_67.L_CORE X_NUC_173.L_CORE 0.002240
K_12548 X_NUC_67.L_CORE X_NUC_174.L_CORE 0.001952
K_12549 X_NUC_67.L_CORE X_NUC_175.L_CORE 0.001743
K_12550 X_NUC_67.L_CORE X_NUC_176.L_CORE 0.003139
K_12551 X_NUC_67.L_CORE X_NUC_177.L_CORE 0.001561
K_12552 X_NUC_67.L_CORE X_NUC_178.L_CORE 0.002220
K_12553 X_NUC_67.L_CORE X_NUC_179.L_CORE 0.002384
K_12554 X_NUC_67.L_CORE X_NUC_180.L_CORE 0.001459
K_12555 X_NUC_67.L_CORE X_NUC_181.L_CORE 0.004379
K_12556 X_NUC_67.L_CORE X_NUC_182.L_CORE 0.001614
K_12557 X_NUC_67.L_CORE X_NUC_183.L_CORE 0.001715
K_12558 X_NUC_67.L_CORE X_NUC_184.L_CORE 0.004096
K_12559 X_NUC_67.L_CORE X_NUC_185.L_CORE 0.001356
K_12560 X_NUC_67.L_CORE X_NUC_186.L_CORE 0.002917
K_12561 X_NUC_67.L_CORE X_NUC_187.L_CORE 0.001952
K_12562 X_NUC_67.L_CORE X_NUC_188.L_CORE 0.001415
K_12563 X_NUC_67.L_CORE X_NUC_189.L_CORE 0.017672
K_12564 X_NUC_67.L_CORE X_NUC_190.L_CORE 0.001397
K_12565 X_NUC_67.L_CORE X_NUC_191.L_CORE 0.001916
K_12566 X_NUC_67.L_CORE X_NUC_192.L_CORE 0.002901
K_12567 X_NUC_67.L_CORE X_NUC_193.L_CORE 0.001289
K_12568 X_NUC_67.L_CORE X_NUC_194.L_CORE 0.004474
K_12569 X_NUC_67.L_CORE X_NUC_195.L_CORE 0.001602
K_12570 X_NUC_67.L_CORE X_NUC_196.L_CORE 0.001483
K_12571 X_NUC_67.L_CORE X_NUC_197.L_CORE 0.006096
K_12572 X_NUC_67.L_CORE X_NUC_198.L_CORE 0.001288
K_12573 X_NUC_67.L_CORE X_NUC_199.L_CORE 0.002286
K_12574 X_NUC_67.L_CORE X_NUC_200.L_CORE 0.002071
K_12575 X_NUC_67.L_CORE X_NUC_201.L_CORE 0.001301
K_12576 X_NUC_67.L_CORE X_NUC_202.L_CORE 0.005368
K_12577 X_NUC_67.L_CORE X_NUC_203.L_CORE 0.001406
K_12578 X_NUC_67.L_CORE X_NUC_204.L_CORE 0.001635
K_12579 X_NUC_67.L_CORE X_NUC_205.L_CORE 0.002952
K_12580 X_NUC_67.L_CORE X_NUC_206.L_CORE 0.001259
K_12581 X_NUC_67.L_CORE X_NUC_207.L_CORE 0.002644
K_12582 X_NUC_67.L_CORE X_NUC_208.L_CORE 0.001665
K_12583 X_NUC_67.L_CORE X_NUC_209.L_CORE 0.001379
K_12584 X_NUC_67.L_CORE X_NUC_210.L_CORE 0.003342
K_12585 X_NUC_67.L_CORE X_NUC_211.L_CORE 0.001325
K_12586 X_NUC_67.L_CORE X_NUC_212.L_CORE 0.001813
K_12587 X_NUC_67.L_CORE X_NUC_213.L_CORE 0.002031
K_12588 X_NUC_67.L_CORE X_NUC_214.L_CORE 0.001307
K_12589 X_NUC_67.L_CORE X_NUC_215.L_CORE 0.002435
K_12590 X_NUC_67.L_CORE X_NUC_216.L_CORE 0.001489
K_12591 X_NUC_67.L_CORE X_NUC_217.L_CORE 0.001509
K_12592 X_NUC_67.L_CORE X_NUC_218.L_CORE 0.002127
K_12593 X_NUC_67.L_CORE X_NUC_219.L_CORE 0.001371
K_12594 X_NUC_67.L_CORE X_NUC_220.L_CORE 0.001796
K_12595 X_NUC_67.L_CORE X_NUC_221.L_CORE 0.001649
K_12596 X_NUC_67.L_CORE X_NUC_222.L_CORE 0.001513
K_12597 X_NUC_68.L_CORE X_NUC_69.L_CORE 0.001426
K_12598 X_NUC_68.L_CORE X_NUC_70.L_CORE 0.001422
K_12599 X_NUC_68.L_CORE X_NUC_71.L_CORE 0.001420
K_12600 X_NUC_68.L_CORE X_NUC_72.L_CORE 0.001429
K_12601 X_NUC_68.L_CORE X_NUC_73.L_CORE 0.001947
K_12602 X_NUC_68.L_CORE X_NUC_74.L_CORE 0.001959
K_12603 X_NUC_68.L_CORE X_NUC_75.L_CORE 0.001946
K_12604 X_NUC_68.L_CORE X_NUC_76.L_CORE 0.001959
K_12605 X_NUC_68.L_CORE X_NUC_77.L_CORE 0.002968
K_12606 X_NUC_68.L_CORE X_NUC_78.L_CORE 0.002930
K_12607 X_NUC_68.L_CORE X_NUC_79.L_CORE 0.002937
K_12608 X_NUC_68.L_CORE X_NUC_80.L_CORE 0.002952
K_12609 X_NUC_68.L_CORE X_NUC_81.L_CORE 0.001316
K_12610 X_NUC_68.L_CORE X_NUC_82.L_CORE 0.001316
K_12611 X_NUC_68.L_CORE X_NUC_83.L_CORE 0.001312
K_12612 X_NUC_68.L_CORE X_NUC_84.L_CORE 0.001320
K_12613 X_NUC_68.L_CORE X_NUC_85.L_CORE 0.004319
K_12614 X_NUC_68.L_CORE X_NUC_86.L_CORE 0.004399
K_12615 X_NUC_68.L_CORE X_NUC_87.L_CORE 0.004320
K_12616 X_NUC_68.L_CORE X_NUC_88.L_CORE 0.004347
K_12617 X_NUC_68.L_CORE X_NUC_89.L_CORE 0.001640
K_12618 X_NUC_68.L_CORE X_NUC_90.L_CORE 0.001631
K_12619 X_NUC_68.L_CORE X_NUC_91.L_CORE 0.001629
K_12620 X_NUC_68.L_CORE X_NUC_92.L_CORE 0.001638
K_12621 X_NUC_68.L_CORE X_NUC_93.L_CORE 0.001514
K_12622 X_NUC_68.L_CORE X_NUC_94.L_CORE 0.001519
K_12623 X_NUC_68.L_CORE X_NUC_95.L_CORE 0.001510
K_12624 X_NUC_68.L_CORE X_NUC_96.L_CORE 0.001520
K_12625 X_NUC_68.L_CORE X_NUC_97.L_CORE 0.005260
K_12626 X_NUC_68.L_CORE X_NUC_98.L_CORE 0.005170
K_12627 X_NUC_68.L_CORE X_NUC_99.L_CORE 0.005145
K_12628 X_NUC_68.L_CORE X_NUC_100.L_CORE 0.005150
K_12629 X_NUC_68.L_CORE X_NUC_101.L_CORE 0.001325
K_12630 X_NUC_68.L_CORE X_NUC_102.L_CORE 0.001323
K_12631 X_NUC_68.L_CORE X_NUC_103.L_CORE 0.001319
K_12632 X_NUC_68.L_CORE X_NUC_104.L_CORE 0.001327
K_12633 X_NUC_68.L_CORE X_NUC_105.L_CORE 0.002269
K_12634 X_NUC_68.L_CORE X_NUC_106.L_CORE 0.002288
K_12635 X_NUC_68.L_CORE X_NUC_107.L_CORE 0.002264
K_12636 X_NUC_68.L_CORE X_NUC_108.L_CORE 0.002278
K_12637 X_NUC_68.L_CORE X_NUC_109.L_CORE 0.002087
K_12638 X_NUC_68.L_CORE X_NUC_110.L_CORE 0.002071
K_12639 X_NUC_68.L_CORE X_NUC_111.L_CORE 0.002068
K_12640 X_NUC_68.L_CORE X_NUC_112.L_CORE 0.002078
K_12641 X_NUC_68.L_CORE X_NUC_113.L_CORE 0.001343
K_12642 X_NUC_68.L_CORE X_NUC_114.L_CORE 0.001344
K_12643 X_NUC_68.L_CORE X_NUC_115.L_CORE 0.001338
K_12644 X_NUC_68.L_CORE X_NUC_116.L_CORE 0.001346
K_12645 X_NUC_68.L_CORE X_NUC_117.L_CORE 0.004104
K_12646 X_NUC_68.L_CORE X_NUC_118.L_CORE 0.004129
K_12647 X_NUC_68.L_CORE X_NUC_119.L_CORE 0.004057
K_12648 X_NUC_68.L_CORE X_NUC_120.L_CORE 0.004068
K_12649 X_NUC_68.L_CORE X_NUC_121.L_CORE 0.001454
K_12650 X_NUC_68.L_CORE X_NUC_122.L_CORE 0.001449
K_12651 X_NUC_68.L_CORE X_NUC_123.L_CORE 0.001445
K_12652 X_NUC_68.L_CORE X_NUC_124.L_CORE 0.001453
K_12653 X_NUC_68.L_CORE X_NUC_125.L_CORE 0.001664
K_12654 X_NUC_68.L_CORE X_NUC_126.L_CORE 0.001670
K_12655 X_NUC_68.L_CORE X_NUC_127.L_CORE 0.001658
K_12656 X_NUC_68.L_CORE X_NUC_128.L_CORE 0.001668
K_12657 X_NUC_68.L_CORE X_NUC_129.L_CORE 0.002681
K_12658 X_NUC_68.L_CORE X_NUC_130.L_CORE 0.002661
K_12659 X_NUC_68.L_CORE X_NUC_131.L_CORE 0.002648
K_12660 X_NUC_68.L_CORE X_NUC_132.L_CORE 0.002658
K_12661 X_NUC_68.L_CORE X_NUC_133.L_CORE 0.001322
K_12662 X_NUC_68.L_CORE X_NUC_134.L_CORE 0.001321
K_12663 X_NUC_68.L_CORE X_NUC_135.L_CORE 0.001316
K_12664 X_NUC_68.L_CORE X_NUC_136.L_CORE 0.001323
K_12665 X_NUC_68.L_CORE X_NUC_137.L_CORE 0.002396
K_12666 X_NUC_68.L_CORE X_NUC_138.L_CORE 0.002410
K_12667 X_NUC_68.L_CORE X_NUC_139.L_CORE 0.002382
K_12668 X_NUC_68.L_CORE X_NUC_140.L_CORE 0.002394
K_12669 X_NUC_68.L_CORE X_NUC_141.L_CORE 0.001696
K_12670 X_NUC_68.L_CORE X_NUC_142.L_CORE 0.001689
K_12671 X_NUC_68.L_CORE X_NUC_143.L_CORE 0.001683
K_12672 X_NUC_68.L_CORE X_NUC_144.L_CORE 0.001691
K_12673 X_NUC_68.L_CORE X_NUC_145.L_CORE 0.001450
K_12674 X_NUC_68.L_CORE X_NUC_146.L_CORE 0.001452
K_12675 X_NUC_68.L_CORE X_NUC_147.L_CORE 0.001443
K_12676 X_NUC_68.L_CORE X_NUC_148.L_CORE 0.001452
K_12677 X_NUC_68.L_CORE X_NUC_149.L_CORE 0.002549
K_12678 X_NUC_68.L_CORE X_NUC_150.L_CORE 0.002545
K_12679 X_NUC_68.L_CORE X_NUC_151.L_CORE 0.002522
K_12680 X_NUC_68.L_CORE X_NUC_152.L_CORE 0.002531
K_12681 X_NUC_68.L_CORE X_NUC_153.L_CORE 0.001425
K_12682 X_NUC_68.L_CORE X_NUC_154.L_CORE 0.001422
K_12683 X_NUC_68.L_CORE X_NUC_155.L_CORE 0.001416
K_12684 X_NUC_68.L_CORE X_NUC_156.L_CORE 0.001424
K_12685 X_NUC_68.L_CORE X_NUC_157.L_CORE 0.001774
K_12686 X_NUC_68.L_CORE X_NUC_158.L_CORE 0.001779
K_12687 X_NUC_68.L_CORE X_NUC_159.L_CORE 0.001764
K_12688 X_NUC_68.L_CORE X_NUC_160.L_CORE 0.001773
K_12689 X_NUC_68.L_CORE X_NUC_161.L_CORE 0.001869
K_12690 X_NUC_68.L_CORE X_NUC_162.L_CORE 0.001863
K_12691 X_NUC_68.L_CORE X_NUC_163.L_CORE 0.001852
K_12692 X_NUC_68.L_CORE X_NUC_164.L_CORE 0.001861
K_12693 X_NUC_68.L_CORE X_NUC_165.L_CORE 0.001477
K_12694 X_NUC_68.L_CORE X_NUC_166.L_CORE 0.001477
K_12695 X_NUC_68.L_CORE X_NUC_167.L_CORE 0.001468
K_12696 X_NUC_68.L_CORE X_NUC_168.L_CORE 0.001476
K_12697 X_NUC_68.L_CORE X_NUC_169.L_CORE 0.001812
K_12698 X_NUC_68.L_CORE X_NUC_170.L_CORE 0.001813
K_12699 X_NUC_68.L_CORE X_NUC_171.L_CORE 0.001799
K_12700 X_NUC_68.L_CORE X_NUC_172.L_CORE 0.001807
K_12701 X_NUC_68.L_CORE X_NUC_173.L_CORE 0.002223
K_12702 X_NUC_68.L_CORE X_NUC_174.L_CORE 0.001938
K_12703 X_NUC_68.L_CORE X_NUC_175.L_CORE 0.001731
K_12704 X_NUC_68.L_CORE X_NUC_176.L_CORE 0.003115
K_12705 X_NUC_68.L_CORE X_NUC_177.L_CORE 0.001551
K_12706 X_NUC_68.L_CORE X_NUC_178.L_CORE 0.002204
K_12707 X_NUC_68.L_CORE X_NUC_179.L_CORE 0.002369
K_12708 X_NUC_68.L_CORE X_NUC_180.L_CORE 0.001450
K_12709 X_NUC_68.L_CORE X_NUC_181.L_CORE 0.004343
K_12710 X_NUC_68.L_CORE X_NUC_182.L_CORE 0.001604
K_12711 X_NUC_68.L_CORE X_NUC_183.L_CORE 0.001703
K_12712 X_NUC_68.L_CORE X_NUC_184.L_CORE 0.004075
K_12713 X_NUC_68.L_CORE X_NUC_185.L_CORE 0.001348
K_12714 X_NUC_68.L_CORE X_NUC_186.L_CORE 0.002897
K_12715 X_NUC_68.L_CORE X_NUC_187.L_CORE 0.001941
K_12716 X_NUC_68.L_CORE X_NUC_188.L_CORE 0.001406
K_12717 X_NUC_68.L_CORE X_NUC_189.L_CORE 0.018123
K_12718 X_NUC_68.L_CORE X_NUC_190.L_CORE 0.001389
K_12719 X_NUC_68.L_CORE X_NUC_191.L_CORE 0.001904
K_12720 X_NUC_68.L_CORE X_NUC_192.L_CORE 0.002890
K_12721 X_NUC_68.L_CORE X_NUC_193.L_CORE 0.001281
K_12722 X_NUC_68.L_CORE X_NUC_194.L_CORE 0.004455
K_12723 X_NUC_68.L_CORE X_NUC_195.L_CORE 0.001593
K_12724 X_NUC_68.L_CORE X_NUC_196.L_CORE 0.001474
K_12725 X_NUC_68.L_CORE X_NUC_197.L_CORE 0.006127
K_12726 X_NUC_68.L_CORE X_NUC_198.L_CORE 0.001280
K_12727 X_NUC_68.L_CORE X_NUC_199.L_CORE 0.002273
K_12728 X_NUC_68.L_CORE X_NUC_200.L_CORE 0.002062
K_12729 X_NUC_68.L_CORE X_NUC_201.L_CORE 0.001293
K_12730 X_NUC_68.L_CORE X_NUC_202.L_CORE 0.005381
K_12731 X_NUC_68.L_CORE X_NUC_203.L_CORE 0.001398
K_12732 X_NUC_68.L_CORE X_NUC_204.L_CORE 0.001625
K_12733 X_NUC_68.L_CORE X_NUC_205.L_CORE 0.002946
K_12734 X_NUC_68.L_CORE X_NUC_206.L_CORE 0.001251
K_12735 X_NUC_68.L_CORE X_NUC_207.L_CORE 0.002633
K_12736 X_NUC_68.L_CORE X_NUC_208.L_CORE 0.001657
K_12737 X_NUC_68.L_CORE X_NUC_209.L_CORE 0.001371
K_12738 X_NUC_68.L_CORE X_NUC_210.L_CORE 0.003340
K_12739 X_NUC_68.L_CORE X_NUC_211.L_CORE 0.001318
K_12740 X_NUC_68.L_CORE X_NUC_212.L_CORE 0.001804
K_12741 X_NUC_68.L_CORE X_NUC_213.L_CORE 0.002024
K_12742 X_NUC_68.L_CORE X_NUC_214.L_CORE 0.001300
K_12743 X_NUC_68.L_CORE X_NUC_215.L_CORE 0.002427
K_12744 X_NUC_68.L_CORE X_NUC_216.L_CORE 0.001482
K_12745 X_NUC_68.L_CORE X_NUC_217.L_CORE 0.001501
K_12746 X_NUC_68.L_CORE X_NUC_218.L_CORE 0.002120
K_12747 X_NUC_68.L_CORE X_NUC_219.L_CORE 0.001364
K_12748 X_NUC_68.L_CORE X_NUC_220.L_CORE 0.001788
K_12749 X_NUC_68.L_CORE X_NUC_221.L_CORE 0.001642
K_12750 X_NUC_68.L_CORE X_NUC_222.L_CORE 0.001506
K_12751 X_NUC_69.L_CORE X_NUC_70.L_CORE 0.207973
K_12752 X_NUC_69.L_CORE X_NUC_71.L_CORE 0.207973
K_12753 X_NUC_69.L_CORE X_NUC_72.L_CORE 0.207973
K_12754 X_NUC_69.L_CORE X_NUC_73.L_CORE 0.001416
K_12755 X_NUC_69.L_CORE X_NUC_74.L_CORE 0.001425
K_12756 X_NUC_69.L_CORE X_NUC_75.L_CORE 0.001422
K_12757 X_NUC_69.L_CORE X_NUC_76.L_CORE 0.001418
K_12758 X_NUC_69.L_CORE X_NUC_77.L_CORE 0.001944
K_12759 X_NUC_69.L_CORE X_NUC_78.L_CORE 0.001944
K_12760 X_NUC_69.L_CORE X_NUC_79.L_CORE 0.001952
K_12761 X_NUC_69.L_CORE X_NUC_80.L_CORE 0.001934
K_12762 X_NUC_69.L_CORE X_NUC_81.L_CORE 0.002933
K_12763 X_NUC_69.L_CORE X_NUC_82.L_CORE 0.002971
K_12764 X_NUC_69.L_CORE X_NUC_83.L_CORE 0.002939
K_12765 X_NUC_69.L_CORE X_NUC_84.L_CORE 0.002955
K_12766 X_NUC_69.L_CORE X_NUC_85.L_CORE 0.001313
K_12767 X_NUC_69.L_CORE X_NUC_86.L_CORE 0.001318
K_12768 X_NUC_69.L_CORE X_NUC_87.L_CORE 0.001318
K_12769 X_NUC_69.L_CORE X_NUC_88.L_CORE 0.001312
K_12770 X_NUC_69.L_CORE X_NUC_89.L_CORE 0.004334
K_12771 X_NUC_69.L_CORE X_NUC_90.L_CORE 0.004294
K_12772 X_NUC_69.L_CORE X_NUC_91.L_CORE 0.004325
K_12773 X_NUC_69.L_CORE X_NUC_92.L_CORE 0.004254
K_12774 X_NUC_69.L_CORE X_NUC_93.L_CORE 0.001633
K_12775 X_NUC_69.L_CORE X_NUC_94.L_CORE 0.001646
K_12776 X_NUC_69.L_CORE X_NUC_95.L_CORE 0.001638
K_12777 X_NUC_69.L_CORE X_NUC_96.L_CORE 0.001637
K_12778 X_NUC_69.L_CORE X_NUC_97.L_CORE 0.001516
K_12779 X_NUC_69.L_CORE X_NUC_98.L_CORE 0.001519
K_12780 X_NUC_69.L_CORE X_NUC_99.L_CORE 0.001522
K_12781 X_NUC_69.L_CORE X_NUC_100.L_CORE 0.001511
K_12782 X_NUC_69.L_CORE X_NUC_101.L_CORE 0.005150
K_12783 X_NUC_69.L_CORE X_NUC_102.L_CORE 0.005219
K_12784 X_NUC_69.L_CORE X_NUC_103.L_CORE 0.005092
K_12785 X_NUC_69.L_CORE X_NUC_104.L_CORE 0.005143
K_12786 X_NUC_69.L_CORE X_NUC_105.L_CORE 0.001327
K_12787 X_NUC_69.L_CORE X_NUC_106.L_CORE 0.001334
K_12788 X_NUC_69.L_CORE X_NUC_107.L_CORE 0.001331
K_12789 X_NUC_69.L_CORE X_NUC_108.L_CORE 0.001327
K_12790 X_NUC_69.L_CORE X_NUC_109.L_CORE 0.002280
K_12791 X_NUC_69.L_CORE X_NUC_110.L_CORE 0.002277
K_12792 X_NUC_69.L_CORE X_NUC_111.L_CORE 0.002282
K_12793 X_NUC_69.L_CORE X_NUC_112.L_CORE 0.002260
K_12794 X_NUC_69.L_CORE X_NUC_113.L_CORE 0.002081
K_12795 X_NUC_69.L_CORE X_NUC_114.L_CORE 0.002100
K_12796 X_NUC_69.L_CORE X_NUC_115.L_CORE 0.002083
K_12797 X_NUC_69.L_CORE X_NUC_116.L_CORE 0.002086
K_12798 X_NUC_69.L_CORE X_NUC_117.L_CORE 0.001351
K_12799 X_NUC_69.L_CORE X_NUC_118.L_CORE 0.001355
K_12800 X_NUC_69.L_CORE X_NUC_119.L_CORE 0.001355
K_12801 X_NUC_69.L_CORE X_NUC_120.L_CORE 0.001348
K_12802 X_NUC_69.L_CORE X_NUC_121.L_CORE 0.004053
K_12803 X_NUC_69.L_CORE X_NUC_122.L_CORE 0.004045
K_12804 X_NUC_69.L_CORE X_NUC_123.L_CORE 0.004009
K_12805 X_NUC_69.L_CORE X_NUC_124.L_CORE 0.003985
K_12806 X_NUC_69.L_CORE X_NUC_125.L_CORE 0.001462
K_12807 X_NUC_69.L_CORE X_NUC_126.L_CORE 0.001471
K_12808 X_NUC_69.L_CORE X_NUC_127.L_CORE 0.001465
K_12809 X_NUC_69.L_CORE X_NUC_128.L_CORE 0.001462
K_12810 X_NUC_69.L_CORE X_NUC_129.L_CORE 0.001678
K_12811 X_NUC_69.L_CORE X_NUC_130.L_CORE 0.001680
K_12812 X_NUC_69.L_CORE X_NUC_131.L_CORE 0.001681
K_12813 X_NUC_69.L_CORE X_NUC_132.L_CORE 0.001669
K_12814 X_NUC_69.L_CORE X_NUC_133.L_CORE 0.002656
K_12815 X_NUC_69.L_CORE X_NUC_134.L_CORE 0.002678
K_12816 X_NUC_69.L_CORE X_NUC_135.L_CORE 0.002646
K_12817 X_NUC_69.L_CORE X_NUC_136.L_CORE 0.002651
K_12818 X_NUC_69.L_CORE X_NUC_137.L_CORE 0.001338
K_12819 X_NUC_69.L_CORE X_NUC_138.L_CORE 0.001344
K_12820 X_NUC_69.L_CORE X_NUC_139.L_CORE 0.001341
K_12821 X_NUC_69.L_CORE X_NUC_140.L_CORE 0.001336
K_12822 X_NUC_69.L_CORE X_NUC_141.L_CORE 0.002392
K_12823 X_NUC_69.L_CORE X_NUC_142.L_CORE 0.002391
K_12824 X_NUC_69.L_CORE X_NUC_143.L_CORE 0.002385
K_12825 X_NUC_69.L_CORE X_NUC_144.L_CORE 0.002368
K_12826 X_NUC_69.L_CORE X_NUC_145.L_CORE 0.001708
K_12827 X_NUC_69.L_CORE X_NUC_146.L_CORE 0.001719
K_12828 X_NUC_69.L_CORE X_NUC_147.L_CORE 0.001708
K_12829 X_NUC_69.L_CORE X_NUC_148.L_CORE 0.001707
K_12830 X_NUC_69.L_CORE X_NUC_149.L_CORE 0.001475
K_12831 X_NUC_69.L_CORE X_NUC_150.L_CORE 0.001479
K_12832 X_NUC_69.L_CORE X_NUC_151.L_CORE 0.001477
K_12833 X_NUC_69.L_CORE X_NUC_152.L_CORE 0.001469
K_12834 X_NUC_69.L_CORE X_NUC_153.L_CORE 0.002481
K_12835 X_NUC_69.L_CORE X_NUC_154.L_CORE 0.002490
K_12836 X_NUC_69.L_CORE X_NUC_155.L_CORE 0.002468
K_12837 X_NUC_69.L_CORE X_NUC_156.L_CORE 0.002463
K_12838 X_NUC_69.L_CORE X_NUC_157.L_CORE 0.001457
K_12839 X_NUC_69.L_CORE X_NUC_158.L_CORE 0.001464
K_12840 X_NUC_69.L_CORE X_NUC_159.L_CORE 0.001459
K_12841 X_NUC_69.L_CORE X_NUC_160.L_CORE 0.001454
K_12842 X_NUC_69.L_CORE X_NUC_161.L_CORE 0.001785
K_12843 X_NUC_69.L_CORE X_NUC_162.L_CORE 0.001789
K_12844 X_NUC_69.L_CORE X_NUC_163.L_CORE 0.001784
K_12845 X_NUC_69.L_CORE X_NUC_164.L_CORE 0.001774
K_12846 X_NUC_69.L_CORE X_NUC_165.L_CORE 0.001847
K_12847 X_NUC_69.L_CORE X_NUC_166.L_CORE 0.001856
K_12848 X_NUC_69.L_CORE X_NUC_167.L_CORE 0.001844
K_12849 X_NUC_69.L_CORE X_NUC_168.L_CORE 0.001841
K_12850 X_NUC_69.L_CORE X_NUC_169.L_CORE 0.001566
K_12851 X_NUC_69.L_CORE X_NUC_170.L_CORE 0.001572
K_12852 X_NUC_69.L_CORE X_NUC_171.L_CORE 0.001566
K_12853 X_NUC_69.L_CORE X_NUC_172.L_CORE 0.001560
K_12854 X_NUC_69.L_CORE X_NUC_173.L_CORE 0.001766
K_12855 X_NUC_69.L_CORE X_NUC_174.L_CORE 0.002355
K_12856 X_NUC_69.L_CORE X_NUC_175.L_CORE 0.001888
K_12857 X_NUC_69.L_CORE X_NUC_176.L_CORE 0.001671
K_12858 X_NUC_69.L_CORE X_NUC_177.L_CORE 0.003256
K_12859 X_NUC_69.L_CORE X_NUC_178.L_CORE 0.001509
K_12860 X_NUC_69.L_CORE X_NUC_179.L_CORE 0.002174
K_12861 X_NUC_69.L_CORE X_NUC_180.L_CORE 0.002352
K_12862 X_NUC_69.L_CORE X_NUC_181.L_CORE 0.001421
K_12863 X_NUC_69.L_CORE X_NUC_182.L_CORE 0.004405
K_12864 X_NUC_69.L_CORE X_NUC_183.L_CORE 0.001583
K_12865 X_NUC_69.L_CORE X_NUC_184.L_CORE 0.001679
K_12866 X_NUC_69.L_CORE X_NUC_185.L_CORE 0.004090
K_12867 X_NUC_69.L_CORE X_NUC_186.L_CORE 0.001333
K_12868 X_NUC_69.L_CORE X_NUC_187.L_CORE 0.002865
K_12869 X_NUC_69.L_CORE X_NUC_188.L_CORE 0.001929
K_12870 X_NUC_69.L_CORE X_NUC_189.L_CORE 0.001394
K_12871 X_NUC_69.L_CORE X_NUC_190.L_CORE 0.018175
K_12872 X_NUC_69.L_CORE X_NUC_191.L_CORE 0.001382
K_12873 X_NUC_69.L_CORE X_NUC_192.L_CORE 0.001891
K_12874 X_NUC_69.L_CORE X_NUC_193.L_CORE 0.002887
K_12875 X_NUC_69.L_CORE X_NUC_194.L_CORE 0.001276
K_12876 X_NUC_69.L_CORE X_NUC_195.L_CORE 0.004406
K_12877 X_NUC_69.L_CORE X_NUC_196.L_CORE 0.001593
K_12878 X_NUC_69.L_CORE X_NUC_197.L_CORE 0.001472
K_12879 X_NUC_69.L_CORE X_NUC_198.L_CORE 0.006133
K_12880 X_NUC_69.L_CORE X_NUC_199.L_CORE 0.001282
K_12881 X_NUC_69.L_CORE X_NUC_200.L_CORE 0.002269
K_12882 X_NUC_69.L_CORE X_NUC_201.L_CORE 0.002071
K_12883 X_NUC_69.L_CORE X_NUC_202.L_CORE 0.001296
K_12884 X_NUC_69.L_CORE X_NUC_203.L_CORE 0.005328
K_12885 X_NUC_69.L_CORE X_NUC_204.L_CORE 0.001406
K_12886 X_NUC_69.L_CORE X_NUC_205.L_CORE 0.001631
K_12887 X_NUC_69.L_CORE X_NUC_206.L_CORE 0.002960
K_12888 X_NUC_69.L_CORE X_NUC_207.L_CORE 0.001261
K_12889 X_NUC_69.L_CORE X_NUC_208.L_CORE 0.002632
K_12890 X_NUC_69.L_CORE X_NUC_209.L_CORE 0.001672
K_12891 X_NUC_69.L_CORE X_NUC_210.L_CORE 0.001384
K_12892 X_NUC_69.L_CORE X_NUC_211.L_CORE 0.003312
K_12893 X_NUC_69.L_CORE X_NUC_212.L_CORE 0.001335
K_12894 X_NUC_69.L_CORE X_NUC_213.L_CORE 0.001816
K_12895 X_NUC_69.L_CORE X_NUC_214.L_CORE 0.002036
K_12896 X_NUC_69.L_CORE X_NUC_215.L_CORE 0.001321
K_12897 X_NUC_69.L_CORE X_NUC_216.L_CORE 0.002401
K_12898 X_NUC_69.L_CORE X_NUC_217.L_CORE 0.001507
K_12899 X_NUC_69.L_CORE X_NUC_218.L_CORE 0.001527
K_12900 X_NUC_69.L_CORE X_NUC_219.L_CORE 0.002087
K_12901 X_NUC_69.L_CORE X_NUC_220.L_CORE 0.001409
K_12902 X_NUC_69.L_CORE X_NUC_221.L_CORE 0.001773
K_12903 X_NUC_69.L_CORE X_NUC_222.L_CORE 0.001651
K_12904 X_NUC_70.L_CORE X_NUC_71.L_CORE 0.207973
K_12905 X_NUC_70.L_CORE X_NUC_72.L_CORE 0.207973
K_12906 X_NUC_70.L_CORE X_NUC_73.L_CORE 0.001407
K_12907 X_NUC_70.L_CORE X_NUC_74.L_CORE 0.001416
K_12908 X_NUC_70.L_CORE X_NUC_75.L_CORE 0.001413
K_12909 X_NUC_70.L_CORE X_NUC_76.L_CORE 0.001409
K_12910 X_NUC_70.L_CORE X_NUC_77.L_CORE 0.001944
K_12911 X_NUC_70.L_CORE X_NUC_78.L_CORE 0.001944
K_12912 X_NUC_70.L_CORE X_NUC_79.L_CORE 0.001952
K_12913 X_NUC_70.L_CORE X_NUC_80.L_CORE 0.001934
K_12914 X_NUC_70.L_CORE X_NUC_81.L_CORE 0.002895
K_12915 X_NUC_70.L_CORE X_NUC_82.L_CORE 0.002933
K_12916 X_NUC_70.L_CORE X_NUC_83.L_CORE 0.002902
K_12917 X_NUC_70.L_CORE X_NUC_84.L_CORE 0.002917
K_12918 X_NUC_70.L_CORE X_NUC_85.L_CORE 0.001307
K_12919 X_NUC_70.L_CORE X_NUC_86.L_CORE 0.001313
K_12920 X_NUC_70.L_CORE X_NUC_87.L_CORE 0.001312
K_12921 X_NUC_70.L_CORE X_NUC_88.L_CORE 0.001306
K_12922 X_NUC_70.L_CORE X_NUC_89.L_CORE 0.004372
K_12923 X_NUC_70.L_CORE X_NUC_90.L_CORE 0.004334
K_12924 X_NUC_70.L_CORE X_NUC_91.L_CORE 0.004365
K_12925 X_NUC_70.L_CORE X_NUC_92.L_CORE 0.004291
K_12926 X_NUC_70.L_CORE X_NUC_93.L_CORE 0.001621
K_12927 X_NUC_70.L_CORE X_NUC_94.L_CORE 0.001633
K_12928 X_NUC_70.L_CORE X_NUC_95.L_CORE 0.001626
K_12929 X_NUC_70.L_CORE X_NUC_96.L_CORE 0.001625
K_12930 X_NUC_70.L_CORE X_NUC_97.L_CORE 0.001513
K_12931 X_NUC_70.L_CORE X_NUC_98.L_CORE 0.001516
K_12932 X_NUC_70.L_CORE X_NUC_99.L_CORE 0.001519
K_12933 X_NUC_70.L_CORE X_NUC_100.L_CORE 0.001508
K_12934 X_NUC_70.L_CORE X_NUC_101.L_CORE 0.005082
K_12935 X_NUC_70.L_CORE X_NUC_102.L_CORE 0.005150
K_12936 X_NUC_70.L_CORE X_NUC_103.L_CORE 0.005027
K_12937 X_NUC_70.L_CORE X_NUC_104.L_CORE 0.005076
K_12938 X_NUC_70.L_CORE X_NUC_105.L_CORE 0.001320
K_12939 X_NUC_70.L_CORE X_NUC_106.L_CORE 0.001327
K_12940 X_NUC_70.L_CORE X_NUC_107.L_CORE 0.001324
K_12941 X_NUC_70.L_CORE X_NUC_108.L_CORE 0.001320
K_12942 X_NUC_70.L_CORE X_NUC_109.L_CORE 0.002284
K_12943 X_NUC_70.L_CORE X_NUC_110.L_CORE 0.002280
K_12944 X_NUC_70.L_CORE X_NUC_111.L_CORE 0.002286
K_12945 X_NUC_70.L_CORE X_NUC_112.L_CORE 0.002264
K_12946 X_NUC_70.L_CORE X_NUC_113.L_CORE 0.002063
K_12947 X_NUC_70.L_CORE X_NUC_114.L_CORE 0.002081
K_12948 X_NUC_70.L_CORE X_NUC_115.L_CORE 0.002065
K_12949 X_NUC_70.L_CORE X_NUC_116.L_CORE 0.002068
K_12950 X_NUC_70.L_CORE X_NUC_117.L_CORE 0.001346
K_12951 X_NUC_70.L_CORE X_NUC_118.L_CORE 0.001351
K_12952 X_NUC_70.L_CORE X_NUC_119.L_CORE 0.001350
K_12953 X_NUC_70.L_CORE X_NUC_120.L_CORE 0.001343
K_12954 X_NUC_70.L_CORE X_NUC_121.L_CORE 0.004060
K_12955 X_NUC_70.L_CORE X_NUC_122.L_CORE 0.004053
K_12956 X_NUC_70.L_CORE X_NUC_123.L_CORE 0.004017
K_12957 X_NUC_70.L_CORE X_NUC_124.L_CORE 0.003992
K_12958 X_NUC_70.L_CORE X_NUC_125.L_CORE 0.001453
K_12959 X_NUC_70.L_CORE X_NUC_126.L_CORE 0.001462
K_12960 X_NUC_70.L_CORE X_NUC_127.L_CORE 0.001456
K_12961 X_NUC_70.L_CORE X_NUC_128.L_CORE 0.001453
K_12962 X_NUC_70.L_CORE X_NUC_129.L_CORE 0.001676
K_12963 X_NUC_70.L_CORE X_NUC_130.L_CORE 0.001678
K_12964 X_NUC_70.L_CORE X_NUC_131.L_CORE 0.001679
K_12965 X_NUC_70.L_CORE X_NUC_132.L_CORE 0.001667
K_12966 X_NUC_70.L_CORE X_NUC_133.L_CORE 0.002635
K_12967 X_NUC_70.L_CORE X_NUC_134.L_CORE 0.002656
K_12968 X_NUC_70.L_CORE X_NUC_135.L_CORE 0.002625
K_12969 X_NUC_70.L_CORE X_NUC_136.L_CORE 0.002630
K_12970 X_NUC_70.L_CORE X_NUC_137.L_CORE 0.001332
K_12971 X_NUC_70.L_CORE X_NUC_138.L_CORE 0.001338
K_12972 X_NUC_70.L_CORE X_NUC_139.L_CORE 0.001335
K_12973 X_NUC_70.L_CORE X_NUC_140.L_CORE 0.001330
K_12974 X_NUC_70.L_CORE X_NUC_141.L_CORE 0.002393
K_12975 X_NUC_70.L_CORE X_NUC_142.L_CORE 0.002392
K_12976 X_NUC_70.L_CORE X_NUC_143.L_CORE 0.002386
K_12977 X_NUC_70.L_CORE X_NUC_144.L_CORE 0.002369
K_12978 X_NUC_70.L_CORE X_NUC_145.L_CORE 0.001697
K_12979 X_NUC_70.L_CORE X_NUC_146.L_CORE 0.001708
K_12980 X_NUC_70.L_CORE X_NUC_147.L_CORE 0.001697
K_12981 X_NUC_70.L_CORE X_NUC_148.L_CORE 0.001696
K_12982 X_NUC_70.L_CORE X_NUC_149.L_CORE 0.001471
K_12983 X_NUC_70.L_CORE X_NUC_150.L_CORE 0.001475
K_12984 X_NUC_70.L_CORE X_NUC_151.L_CORE 0.001473
K_12985 X_NUC_70.L_CORE X_NUC_152.L_CORE 0.001465
K_12986 X_NUC_70.L_CORE X_NUC_153.L_CORE 0.002471
K_12987 X_NUC_70.L_CORE X_NUC_154.L_CORE 0.002481
K_12988 X_NUC_70.L_CORE X_NUC_155.L_CORE 0.002459
K_12989 X_NUC_70.L_CORE X_NUC_156.L_CORE 0.002454
K_12990 X_NUC_70.L_CORE X_NUC_157.L_CORE 0.001450
K_12991 X_NUC_70.L_CORE X_NUC_158.L_CORE 0.001457
K_12992 X_NUC_70.L_CORE X_NUC_159.L_CORE 0.001451
K_12993 X_NUC_70.L_CORE X_NUC_160.L_CORE 0.001447
K_12994 X_NUC_70.L_CORE X_NUC_161.L_CORE 0.001782
K_12995 X_NUC_70.L_CORE X_NUC_162.L_CORE 0.001785
K_12996 X_NUC_70.L_CORE X_NUC_163.L_CORE 0.001781
K_12997 X_NUC_70.L_CORE X_NUC_164.L_CORE 0.001771
K_12998 X_NUC_70.L_CORE X_NUC_165.L_CORE 0.001838
K_12999 X_NUC_70.L_CORE X_NUC_166.L_CORE 0.001847
K_13000 X_NUC_70.L_CORE X_NUC_167.L_CORE 0.001835
K_13001 X_NUC_70.L_CORE X_NUC_168.L_CORE 0.001831
K_13002 X_NUC_70.L_CORE X_NUC_169.L_CORE 0.001560
K_13003 X_NUC_70.L_CORE X_NUC_170.L_CORE 0.001566
K_13004 X_NUC_70.L_CORE X_NUC_171.L_CORE 0.001560
K_13005 X_NUC_70.L_CORE X_NUC_172.L_CORE 0.001554
K_13006 X_NUC_70.L_CORE X_NUC_173.L_CORE 0.001757
K_13007 X_NUC_70.L_CORE X_NUC_174.L_CORE 0.002346
K_13008 X_NUC_70.L_CORE X_NUC_175.L_CORE 0.001875
K_13009 X_NUC_70.L_CORE X_NUC_176.L_CORE 0.001665
K_13010 X_NUC_70.L_CORE X_NUC_177.L_CORE 0.003233
K_13011 X_NUC_70.L_CORE X_NUC_178.L_CORE 0.001500
K_13012 X_NUC_70.L_CORE X_NUC_179.L_CORE 0.002172
K_13013 X_NUC_70.L_CORE X_NUC_180.L_CORE 0.002330
K_13014 X_NUC_70.L_CORE X_NUC_181.L_CORE 0.001416
K_13015 X_NUC_70.L_CORE X_NUC_182.L_CORE 0.004414
K_13016 X_NUC_70.L_CORE X_NUC_183.L_CORE 0.001572
K_13017 X_NUC_70.L_CORE X_NUC_184.L_CORE 0.001676
K_13018 X_NUC_70.L_CORE X_NUC_185.L_CORE 0.004030
K_13019 X_NUC_70.L_CORE X_NUC_186.L_CORE 0.001327
K_13020 X_NUC_70.L_CORE X_NUC_187.L_CORE 0.002875
K_13021 X_NUC_70.L_CORE X_NUC_188.L_CORE 0.001911
K_13022 X_NUC_70.L_CORE X_NUC_189.L_CORE 0.001390
K_13023 X_NUC_70.L_CORE X_NUC_190.L_CORE 0.018574
K_13024 X_NUC_70.L_CORE X_NUC_191.L_CORE 0.001374
K_13025 X_NUC_70.L_CORE X_NUC_192.L_CORE 0.001891
K_13026 X_NUC_70.L_CORE X_NUC_193.L_CORE 0.002852
K_13027 X_NUC_70.L_CORE X_NUC_194.L_CORE 0.001271
K_13028 X_NUC_70.L_CORE X_NUC_195.L_CORE 0.004460
K_13029 X_NUC_70.L_CORE X_NUC_196.L_CORE 0.001581
K_13030 X_NUC_70.L_CORE X_NUC_197.L_CORE 0.001469
K_13031 X_NUC_70.L_CORE X_NUC_198.L_CORE 0.006038
K_13032 X_NUC_70.L_CORE X_NUC_199.L_CORE 0.001275
K_13033 X_NUC_70.L_CORE X_NUC_200.L_CORE 0.002275
K_13034 X_NUC_70.L_CORE X_NUC_201.L_CORE 0.002052
K_13035 X_NUC_70.L_CORE X_NUC_202.L_CORE 0.001292
K_13036 X_NUC_70.L_CORE X_NUC_203.L_CORE 0.005381
K_13037 X_NUC_70.L_CORE X_NUC_204.L_CORE 0.001397
K_13038 X_NUC_70.L_CORE X_NUC_205.L_CORE 0.001630
K_13039 X_NUC_70.L_CORE X_NUC_206.L_CORE 0.002931
K_13040 X_NUC_70.L_CORE X_NUC_207.L_CORE 0.001255
K_13041 X_NUC_70.L_CORE X_NUC_208.L_CORE 0.002641
K_13042 X_NUC_70.L_CORE X_NUC_209.L_CORE 0.001660
K_13043 X_NUC_70.L_CORE X_NUC_210.L_CORE 0.001380
K_13044 X_NUC_70.L_CORE X_NUC_211.L_CORE 0.003303
K_13045 X_NUC_70.L_CORE X_NUC_212.L_CORE 0.001328
K_13046 X_NUC_70.L_CORE X_NUC_213.L_CORE 0.001815
K_13047 X_NUC_70.L_CORE X_NUC_214.L_CORE 0.002022
K_13048 X_NUC_70.L_CORE X_NUC_215.L_CORE 0.001316
K_13049 X_NUC_70.L_CORE X_NUC_216.L_CORE 0.002400
K_13050 X_NUC_70.L_CORE X_NUC_217.L_CORE 0.001499
K_13051 X_NUC_70.L_CORE X_NUC_218.L_CORE 0.001523
K_13052 X_NUC_70.L_CORE X_NUC_219.L_CORE 0.002079
K_13053 X_NUC_70.L_CORE X_NUC_220.L_CORE 0.001403
K_13054 X_NUC_70.L_CORE X_NUC_221.L_CORE 0.001769
K_13055 X_NUC_70.L_CORE X_NUC_222.L_CORE 0.001644
K_13056 X_NUC_71.L_CORE X_NUC_72.L_CORE 0.207973
K_13057 X_NUC_71.L_CORE X_NUC_73.L_CORE 0.001410
K_13058 X_NUC_71.L_CORE X_NUC_74.L_CORE 0.001419
K_13059 X_NUC_71.L_CORE X_NUC_75.L_CORE 0.001416
K_13060 X_NUC_71.L_CORE X_NUC_76.L_CORE 0.001412
K_13061 X_NUC_71.L_CORE X_NUC_77.L_CORE 0.001936
K_13062 X_NUC_71.L_CORE X_NUC_78.L_CORE 0.001936
K_13063 X_NUC_71.L_CORE X_NUC_79.L_CORE 0.001944
K_13064 X_NUC_71.L_CORE X_NUC_80.L_CORE 0.001926
K_13065 X_NUC_71.L_CORE X_NUC_81.L_CORE 0.002926
K_13066 X_NUC_71.L_CORE X_NUC_82.L_CORE 0.002964
K_13067 X_NUC_71.L_CORE X_NUC_83.L_CORE 0.002933
K_13068 X_NUC_71.L_CORE X_NUC_84.L_CORE 0.002948
K_13069 X_NUC_71.L_CORE X_NUC_85.L_CORE 0.001307
K_13070 X_NUC_71.L_CORE X_NUC_86.L_CORE 0.001313
K_13071 X_NUC_71.L_CORE X_NUC_87.L_CORE 0.001313
K_13072 X_NUC_71.L_CORE X_NUC_88.L_CORE 0.001307
K_13073 X_NUC_71.L_CORE X_NUC_89.L_CORE 0.004340
K_13074 X_NUC_71.L_CORE X_NUC_90.L_CORE 0.004301
K_13075 X_NUC_71.L_CORE X_NUC_91.L_CORE 0.004334
K_13076 X_NUC_71.L_CORE X_NUC_92.L_CORE 0.004261
K_13077 X_NUC_71.L_CORE X_NUC_93.L_CORE 0.001628
K_13078 X_NUC_71.L_CORE X_NUC_94.L_CORE 0.001640
K_13079 X_NUC_71.L_CORE X_NUC_95.L_CORE 0.001633
K_13080 X_NUC_71.L_CORE X_NUC_96.L_CORE 0.001632
K_13081 X_NUC_71.L_CORE X_NUC_97.L_CORE 0.001511
K_13082 X_NUC_71.L_CORE X_NUC_98.L_CORE 0.001514
K_13083 X_NUC_71.L_CORE X_NUC_99.L_CORE 0.001516
K_13084 X_NUC_71.L_CORE X_NUC_100.L_CORE 0.001506
K_13085 X_NUC_71.L_CORE X_NUC_101.L_CORE 0.005208
K_13086 X_NUC_71.L_CORE X_NUC_102.L_CORE 0.005281
K_13087 X_NUC_71.L_CORE X_NUC_103.L_CORE 0.005150
K_13088 X_NUC_71.L_CORE X_NUC_104.L_CORE 0.005202
K_13089 X_NUC_71.L_CORE X_NUC_105.L_CORE 0.001322
K_13090 X_NUC_71.L_CORE X_NUC_106.L_CORE 0.001329
K_13091 X_NUC_71.L_CORE X_NUC_107.L_CORE 0.001327
K_13092 X_NUC_71.L_CORE X_NUC_108.L_CORE 0.001322
K_13093 X_NUC_71.L_CORE X_NUC_109.L_CORE 0.002278
K_13094 X_NUC_71.L_CORE X_NUC_110.L_CORE 0.002274
K_13095 X_NUC_71.L_CORE X_NUC_111.L_CORE 0.002280
K_13096 X_NUC_71.L_CORE X_NUC_112.L_CORE 0.002258
K_13097 X_NUC_71.L_CORE X_NUC_113.L_CORE 0.002080
K_13098 X_NUC_71.L_CORE X_NUC_114.L_CORE 0.002099
K_13099 X_NUC_71.L_CORE X_NUC_115.L_CORE 0.002081
K_13100 X_NUC_71.L_CORE X_NUC_116.L_CORE 0.002085
K_13101 X_NUC_71.L_CORE X_NUC_117.L_CORE 0.001347
K_13102 X_NUC_71.L_CORE X_NUC_118.L_CORE 0.001351
K_13103 X_NUC_71.L_CORE X_NUC_119.L_CORE 0.001351
K_13104 X_NUC_71.L_CORE X_NUC_120.L_CORE 0.001344
K_13105 X_NUC_71.L_CORE X_NUC_121.L_CORE 0.004097
K_13106 X_NUC_71.L_CORE X_NUC_122.L_CORE 0.004089
K_13107 X_NUC_71.L_CORE X_NUC_123.L_CORE 0.004053
K_13108 X_NUC_71.L_CORE X_NUC_124.L_CORE 0.004027
K_13109 X_NUC_71.L_CORE X_NUC_125.L_CORE 0.001458
K_13110 X_NUC_71.L_CORE X_NUC_126.L_CORE 0.001468
K_13111 X_NUC_71.L_CORE X_NUC_127.L_CORE 0.001462
K_13112 X_NUC_71.L_CORE X_NUC_128.L_CORE 0.001459
K_13113 X_NUC_71.L_CORE X_NUC_129.L_CORE 0.001676
K_13114 X_NUC_71.L_CORE X_NUC_130.L_CORE 0.001678
K_13115 X_NUC_71.L_CORE X_NUC_131.L_CORE 0.001678
K_13116 X_NUC_71.L_CORE X_NUC_132.L_CORE 0.001666
K_13117 X_NUC_71.L_CORE X_NUC_133.L_CORE 0.002666
K_13118 X_NUC_71.L_CORE X_NUC_134.L_CORE 0.002688
K_13119 X_NUC_71.L_CORE X_NUC_135.L_CORE 0.002656
K_13120 X_NUC_71.L_CORE X_NUC_136.L_CORE 0.002662
K_13121 X_NUC_71.L_CORE X_NUC_137.L_CORE 0.001335
K_13122 X_NUC_71.L_CORE X_NUC_138.L_CORE 0.001341
K_13123 X_NUC_71.L_CORE X_NUC_139.L_CORE 0.001338
K_13124 X_NUC_71.L_CORE X_NUC_140.L_CORE 0.001333
K_13125 X_NUC_71.L_CORE X_NUC_141.L_CORE 0.002398
K_13126 X_NUC_71.L_CORE X_NUC_142.L_CORE 0.002398
K_13127 X_NUC_71.L_CORE X_NUC_143.L_CORE 0.002392
K_13128 X_NUC_71.L_CORE X_NUC_144.L_CORE 0.002374
K_13129 X_NUC_71.L_CORE X_NUC_145.L_CORE 0.001707
K_13130 X_NUC_71.L_CORE X_NUC_146.L_CORE 0.001719
K_13131 X_NUC_71.L_CORE X_NUC_147.L_CORE 0.001708
K_13132 X_NUC_71.L_CORE X_NUC_148.L_CORE 0.001706
K_13133 X_NUC_71.L_CORE X_NUC_149.L_CORE 0.001473
K_13134 X_NUC_71.L_CORE X_NUC_150.L_CORE 0.001477
K_13135 X_NUC_71.L_CORE X_NUC_151.L_CORE 0.001475
K_13136 X_NUC_71.L_CORE X_NUC_152.L_CORE 0.001467
K_13137 X_NUC_71.L_CORE X_NUC_153.L_CORE 0.002493
K_13138 X_NUC_71.L_CORE X_NUC_154.L_CORE 0.002502
K_13139 X_NUC_71.L_CORE X_NUC_155.L_CORE 0.002481
K_13140 X_NUC_71.L_CORE X_NUC_156.L_CORE 0.002475
K_13141 X_NUC_71.L_CORE X_NUC_157.L_CORE 0.001455
K_13142 X_NUC_71.L_CORE X_NUC_158.L_CORE 0.001463
K_13143 X_NUC_71.L_CORE X_NUC_159.L_CORE 0.001457
K_13144 X_NUC_71.L_CORE X_NUC_160.L_CORE 0.001453
K_13145 X_NUC_71.L_CORE X_NUC_161.L_CORE 0.001787
K_13146 X_NUC_71.L_CORE X_NUC_162.L_CORE 0.001790
K_13147 X_NUC_71.L_CORE X_NUC_163.L_CORE 0.001785
K_13148 X_NUC_71.L_CORE X_NUC_164.L_CORE 0.001776
K_13149 X_NUC_71.L_CORE X_NUC_165.L_CORE 0.001850
K_13150 X_NUC_71.L_CORE X_NUC_166.L_CORE 0.001859
K_13151 X_NUC_71.L_CORE X_NUC_167.L_CORE 0.001847
K_13152 X_NUC_71.L_CORE X_NUC_168.L_CORE 0.001843
K_13153 X_NUC_71.L_CORE X_NUC_169.L_CORE 0.001566
K_13154 X_NUC_71.L_CORE X_NUC_170.L_CORE 0.001572
K_13155 X_NUC_71.L_CORE X_NUC_171.L_CORE 0.001566
K_13156 X_NUC_71.L_CORE X_NUC_172.L_CORE 0.001560
K_13157 X_NUC_71.L_CORE X_NUC_173.L_CORE 0.001751
K_13158 X_NUC_71.L_CORE X_NUC_174.L_CORE 0.002329
K_13159 X_NUC_71.L_CORE X_NUC_175.L_CORE 0.001872
K_13160 X_NUC_71.L_CORE X_NUC_176.L_CORE 0.001659
K_13161 X_NUC_71.L_CORE X_NUC_177.L_CORE 0.003209
K_13162 X_NUC_71.L_CORE X_NUC_178.L_CORE 0.001499
K_13163 X_NUC_71.L_CORE X_NUC_179.L_CORE 0.002155
K_13164 X_NUC_71.L_CORE X_NUC_180.L_CORE 0.002332
K_13165 X_NUC_71.L_CORE X_NUC_181.L_CORE 0.001413
K_13166 X_NUC_71.L_CORE X_NUC_182.L_CORE 0.004330
K_13167 X_NUC_71.L_CORE X_NUC_183.L_CORE 0.001574
K_13168 X_NUC_71.L_CORE X_NUC_184.L_CORE 0.001669
K_13169 X_NUC_71.L_CORE X_NUC_185.L_CORE 0.004043
K_13170 X_NUC_71.L_CORE X_NUC_186.L_CORE 0.001326
K_13171 X_NUC_71.L_CORE X_NUC_187.L_CORE 0.002844
K_13172 X_NUC_71.L_CORE X_NUC_188.L_CORE 0.001919
K_13173 X_NUC_71.L_CORE X_NUC_189.L_CORE 0.001387
K_13174 X_NUC_71.L_CORE X_NUC_190.L_CORE 0.017504
K_13175 X_NUC_71.L_CORE X_NUC_191.L_CORE 0.001376
K_13176 X_NUC_71.L_CORE X_NUC_192.L_CORE 0.001882
K_13177 X_NUC_71.L_CORE X_NUC_193.L_CORE 0.002878
K_13178 X_NUC_71.L_CORE X_NUC_194.L_CORE 0.001271
K_13179 X_NUC_71.L_CORE X_NUC_195.L_CORE 0.004404
K_13180 X_NUC_71.L_CORE X_NUC_196.L_CORE 0.001587
K_13181 X_NUC_71.L_CORE X_NUC_197.L_CORE 0.001466
K_13182 X_NUC_71.L_CORE X_NUC_198.L_CORE 0.006211
K_13183 X_NUC_71.L_CORE X_NUC_199.L_CORE 0.001277
K_13184 X_NUC_71.L_CORE X_NUC_200.L_CORE 0.002265
K_13185 X_NUC_71.L_CORE X_NUC_201.L_CORE 0.002067
K_13186 X_NUC_71.L_CORE X_NUC_202.L_CORE 0.001292
K_13187 X_NUC_71.L_CORE X_NUC_203.L_CORE 0.005422
K_13188 X_NUC_71.L_CORE X_NUC_204.L_CORE 0.001402
K_13189 X_NUC_71.L_CORE X_NUC_205.L_CORE 0.001627
K_13190 X_NUC_71.L_CORE X_NUC_206.L_CORE 0.002972
K_13191 X_NUC_71.L_CORE X_NUC_207.L_CORE 0.001257
K_13192 X_NUC_71.L_CORE X_NUC_208.L_CORE 0.002640
K_13193 X_NUC_71.L_CORE X_NUC_209.L_CORE 0.001670
K_13194 X_NUC_71.L_CORE X_NUC_210.L_CORE 0.001381
K_13195 X_NUC_71.L_CORE X_NUC_211.L_CORE 0.003346
K_13196 X_NUC_71.L_CORE X_NUC_212.L_CORE 0.001332
K_13197 X_NUC_71.L_CORE X_NUC_213.L_CORE 0.001816
K_13198 X_NUC_71.L_CORE X_NUC_214.L_CORE 0.002040
K_13199 X_NUC_71.L_CORE X_NUC_215.L_CORE 0.001319
K_13200 X_NUC_71.L_CORE X_NUC_216.L_CORE 0.002413
K_13201 X_NUC_71.L_CORE X_NUC_217.L_CORE 0.001507
K_13202 X_NUC_71.L_CORE X_NUC_218.L_CORE 0.001526
K_13203 X_NUC_71.L_CORE X_NUC_219.L_CORE 0.002095
K_13204 X_NUC_71.L_CORE X_NUC_220.L_CORE 0.001408
K_13205 X_NUC_71.L_CORE X_NUC_221.L_CORE 0.001776
K_13206 X_NUC_71.L_CORE X_NUC_222.L_CORE 0.001653
K_13207 X_NUC_72.L_CORE X_NUC_73.L_CORE 0.001413
K_13208 X_NUC_72.L_CORE X_NUC_74.L_CORE 0.001422
K_13209 X_NUC_72.L_CORE X_NUC_75.L_CORE 0.001419
K_13210 X_NUC_72.L_CORE X_NUC_76.L_CORE 0.001416
K_13211 X_NUC_72.L_CORE X_NUC_77.L_CORE 0.001954
K_13212 X_NUC_72.L_CORE X_NUC_78.L_CORE 0.001954
K_13213 X_NUC_72.L_CORE X_NUC_79.L_CORE 0.001962
K_13214 X_NUC_72.L_CORE X_NUC_80.L_CORE 0.001944
K_13215 X_NUC_72.L_CORE X_NUC_81.L_CORE 0.002911
K_13216 X_NUC_72.L_CORE X_NUC_82.L_CORE 0.002948
K_13217 X_NUC_72.L_CORE X_NUC_83.L_CORE 0.002917
K_13218 X_NUC_72.L_CORE X_NUC_84.L_CORE 0.002933
K_13219 X_NUC_72.L_CORE X_NUC_85.L_CORE 0.001313
K_13220 X_NUC_72.L_CORE X_NUC_86.L_CORE 0.001319
K_13221 X_NUC_72.L_CORE X_NUC_87.L_CORE 0.001319
K_13222 X_NUC_72.L_CORE X_NUC_88.L_CORE 0.001313
K_13223 X_NUC_72.L_CORE X_NUC_89.L_CORE 0.004416
K_13224 X_NUC_72.L_CORE X_NUC_90.L_CORE 0.004375
K_13225 X_NUC_72.L_CORE X_NUC_91.L_CORE 0.004408
K_13226 X_NUC_72.L_CORE X_NUC_92.L_CORE 0.004334
K_13227 X_NUC_72.L_CORE X_NUC_93.L_CORE 0.001629
K_13228 X_NUC_72.L_CORE X_NUC_94.L_CORE 0.001641
K_13229 X_NUC_72.L_CORE X_NUC_95.L_CORE 0.001634
K_13230 X_NUC_72.L_CORE X_NUC_96.L_CORE 0.001633
K_13231 X_NUC_72.L_CORE X_NUC_97.L_CORE 0.001522
K_13232 X_NUC_72.L_CORE X_NUC_98.L_CORE 0.001525
K_13233 X_NUC_72.L_CORE X_NUC_99.L_CORE 0.001527
K_13234 X_NUC_72.L_CORE X_NUC_100.L_CORE 0.001516
K_13235 X_NUC_72.L_CORE X_NUC_101.L_CORE 0.005155
K_13236 X_NUC_72.L_CORE X_NUC_102.L_CORE 0.005225
K_13237 X_NUC_72.L_CORE X_NUC_103.L_CORE 0.005097
K_13238 X_NUC_72.L_CORE X_NUC_104.L_CORE 0.005150
K_13239 X_NUC_72.L_CORE X_NUC_105.L_CORE 0.001326
K_13240 X_NUC_72.L_CORE X_NUC_106.L_CORE 0.001334
K_13241 X_NUC_72.L_CORE X_NUC_107.L_CORE 0.001331
K_13242 X_NUC_72.L_CORE X_NUC_108.L_CORE 0.001327
K_13243 X_NUC_72.L_CORE X_NUC_109.L_CORE 0.002301
K_13244 X_NUC_72.L_CORE X_NUC_110.L_CORE 0.002297
K_13245 X_NUC_72.L_CORE X_NUC_111.L_CORE 0.002303
K_13246 X_NUC_72.L_CORE X_NUC_112.L_CORE 0.002280
K_13247 X_NUC_72.L_CORE X_NUC_113.L_CORE 0.002076
K_13248 X_NUC_72.L_CORE X_NUC_114.L_CORE 0.002095
K_13249 X_NUC_72.L_CORE X_NUC_115.L_CORE 0.002078
K_13250 X_NUC_72.L_CORE X_NUC_116.L_CORE 0.002081
K_13251 X_NUC_72.L_CORE X_NUC_117.L_CORE 0.001354
K_13252 X_NUC_72.L_CORE X_NUC_118.L_CORE 0.001358
K_13253 X_NUC_72.L_CORE X_NUC_119.L_CORE 0.001358
K_13254 X_NUC_72.L_CORE X_NUC_120.L_CORE 0.001351
K_13255 X_NUC_72.L_CORE X_NUC_121.L_CORE 0.004123
K_13256 X_NUC_72.L_CORE X_NUC_122.L_CORE 0.004115
K_13257 X_NUC_72.L_CORE X_NUC_123.L_CORE 0.004078
K_13258 X_NUC_72.L_CORE X_NUC_124.L_CORE 0.004053
K_13259 X_NUC_72.L_CORE X_NUC_125.L_CORE 0.001461
K_13260 X_NUC_72.L_CORE X_NUC_126.L_CORE 0.001470
K_13261 X_NUC_72.L_CORE X_NUC_127.L_CORE 0.001464
K_13262 X_NUC_72.L_CORE X_NUC_128.L_CORE 0.001462
K_13263 X_NUC_72.L_CORE X_NUC_129.L_CORE 0.001688
K_13264 X_NUC_72.L_CORE X_NUC_130.L_CORE 0.001690
K_13265 X_NUC_72.L_CORE X_NUC_131.L_CORE 0.001690
K_13266 X_NUC_72.L_CORE X_NUC_132.L_CORE 0.001678
K_13267 X_NUC_72.L_CORE X_NUC_133.L_CORE 0.002661
K_13268 X_NUC_72.L_CORE X_NUC_134.L_CORE 0.002683
K_13269 X_NUC_72.L_CORE X_NUC_135.L_CORE 0.002651
K_13270 X_NUC_72.L_CORE X_NUC_136.L_CORE 0.002656
K_13271 X_NUC_72.L_CORE X_NUC_137.L_CORE 0.001340
K_13272 X_NUC_72.L_CORE X_NUC_138.L_CORE 0.001346
K_13273 X_NUC_72.L_CORE X_NUC_139.L_CORE 0.001343
K_13274 X_NUC_72.L_CORE X_NUC_140.L_CORE 0.001338
K_13275 X_NUC_72.L_CORE X_NUC_141.L_CORE 0.002416
K_13276 X_NUC_72.L_CORE X_NUC_142.L_CORE 0.002415
K_13277 X_NUC_72.L_CORE X_NUC_143.L_CORE 0.002410
K_13278 X_NUC_72.L_CORE X_NUC_144.L_CORE 0.002392
K_13279 X_NUC_72.L_CORE X_NUC_145.L_CORE 0.001709
K_13280 X_NUC_72.L_CORE X_NUC_146.L_CORE 0.001720
K_13281 X_NUC_72.L_CORE X_NUC_147.L_CORE 0.001709
K_13282 X_NUC_72.L_CORE X_NUC_148.L_CORE 0.001708
K_13283 X_NUC_72.L_CORE X_NUC_149.L_CORE 0.001480
K_13284 X_NUC_72.L_CORE X_NUC_150.L_CORE 0.001485
K_13285 X_NUC_72.L_CORE X_NUC_151.L_CORE 0.001483
K_13286 X_NUC_72.L_CORE X_NUC_152.L_CORE 0.001475
K_13287 X_NUC_72.L_CORE X_NUC_153.L_CORE 0.002498
K_13288 X_NUC_72.L_CORE X_NUC_154.L_CORE 0.002508
K_13289 X_NUC_72.L_CORE X_NUC_155.L_CORE 0.002486
K_13290 X_NUC_72.L_CORE X_NUC_156.L_CORE 0.002481
K_13291 X_NUC_72.L_CORE X_NUC_157.L_CORE 0.001460
K_13292 X_NUC_72.L_CORE X_NUC_158.L_CORE 0.001467
K_13293 X_NUC_72.L_CORE X_NUC_159.L_CORE 0.001461
K_13294 X_NUC_72.L_CORE X_NUC_160.L_CORE 0.001457
K_13295 X_NUC_72.L_CORE X_NUC_161.L_CORE 0.001797
K_13296 X_NUC_72.L_CORE X_NUC_162.L_CORE 0.001800
K_13297 X_NUC_72.L_CORE X_NUC_163.L_CORE 0.001795
K_13298 X_NUC_72.L_CORE X_NUC_164.L_CORE 0.001785
K_13299 X_NUC_72.L_CORE X_NUC_165.L_CORE 0.001853
K_13300 X_NUC_72.L_CORE X_NUC_166.L_CORE 0.001863
K_13301 X_NUC_72.L_CORE X_NUC_167.L_CORE 0.001851
K_13302 X_NUC_72.L_CORE X_NUC_168.L_CORE 0.001847
K_13303 X_NUC_72.L_CORE X_NUC_169.L_CORE 0.001572
K_13304 X_NUC_72.L_CORE X_NUC_170.L_CORE 0.001578
K_13305 X_NUC_72.L_CORE X_NUC_171.L_CORE 0.001572
K_13306 X_NUC_72.L_CORE X_NUC_172.L_CORE 0.001566
K_13307 X_NUC_72.L_CORE X_NUC_173.L_CORE 0.001759
K_13308 X_NUC_72.L_CORE X_NUC_174.L_CORE 0.002344
K_13309 X_NUC_72.L_CORE X_NUC_175.L_CORE 0.001877
K_13310 X_NUC_72.L_CORE X_NUC_176.L_CORE 0.001669
K_13311 X_NUC_72.L_CORE X_NUC_177.L_CORE 0.003219
K_13312 X_NUC_72.L_CORE X_NUC_178.L_CORE 0.001504
K_13313 X_NUC_72.L_CORE X_NUC_179.L_CORE 0.002175
K_13314 X_NUC_72.L_CORE X_NUC_180.L_CORE 0.002331
K_13315 X_NUC_72.L_CORE X_NUC_181.L_CORE 0.001420
K_13316 X_NUC_72.L_CORE X_NUC_182.L_CORE 0.004382
K_13317 X_NUC_72.L_CORE X_NUC_183.L_CORE 0.001576
K_13318 X_NUC_72.L_CORE X_NUC_184.L_CORE 0.001682
K_13319 X_NUC_72.L_CORE X_NUC_185.L_CORE 0.004015
K_13320 X_NUC_72.L_CORE X_NUC_186.L_CORE 0.001332
K_13321 X_NUC_72.L_CORE X_NUC_187.L_CORE 0.002880
K_13322 X_NUC_72.L_CORE X_NUC_188.L_CORE 0.001917
K_13323 X_NUC_72.L_CORE X_NUC_189.L_CORE 0.001396
K_13324 X_NUC_72.L_CORE X_NUC_190.L_CORE 0.017195
K_13325 X_NUC_72.L_CORE X_NUC_191.L_CORE 0.001379
K_13326 X_NUC_72.L_CORE X_NUC_192.L_CORE 0.001899
K_13327 X_NUC_72.L_CORE X_NUC_193.L_CORE 0.002861
K_13328 X_NUC_72.L_CORE X_NUC_194.L_CORE 0.001277
K_13329 X_NUC_72.L_CORE X_NUC_195.L_CORE 0.004481
K_13330 X_NUC_72.L_CORE X_NUC_196.L_CORE 0.001588
K_13331 X_NUC_72.L_CORE X_NUC_197.L_CORE 0.001476
K_13332 X_NUC_72.L_CORE X_NUC_198.L_CORE 0.006085
K_13333 X_NUC_72.L_CORE X_NUC_199.L_CORE 0.001281
K_13334 X_NUC_72.L_CORE X_NUC_200.L_CORE 0.002288
K_13335 X_NUC_72.L_CORE X_NUC_201.L_CORE 0.002062
K_13336 X_NUC_72.L_CORE X_NUC_202.L_CORE 0.001299
K_13337 X_NUC_72.L_CORE X_NUC_203.L_CORE 0.005462
K_13338 X_NUC_72.L_CORE X_NUC_204.L_CORE 0.001404
K_13339 X_NUC_72.L_CORE X_NUC_205.L_CORE 0.001639
K_13340 X_NUC_72.L_CORE X_NUC_206.L_CORE 0.002956
K_13341 X_NUC_72.L_CORE X_NUC_207.L_CORE 0.001262
K_13342 X_NUC_72.L_CORE X_NUC_208.L_CORE 0.002664
K_13343 X_NUC_72.L_CORE X_NUC_209.L_CORE 0.001670
K_13344 X_NUC_72.L_CORE X_NUC_210.L_CORE 0.001388
K_13345 X_NUC_72.L_CORE X_NUC_211.L_CORE 0.003344
K_13346 X_NUC_72.L_CORE X_NUC_212.L_CORE 0.001336
K_13347 X_NUC_72.L_CORE X_NUC_213.L_CORE 0.001829
K_13348 X_NUC_72.L_CORE X_NUC_214.L_CORE 0.002038
K_13349 X_NUC_72.L_CORE X_NUC_215.L_CORE 0.001324
K_13350 X_NUC_72.L_CORE X_NUC_216.L_CORE 0.002425
K_13351 X_NUC_72.L_CORE X_NUC_217.L_CORE 0.001509
K_13352 X_NUC_72.L_CORE X_NUC_218.L_CORE 0.001534
K_13353 X_NUC_72.L_CORE X_NUC_219.L_CORE 0.002098
K_13354 X_NUC_72.L_CORE X_NUC_220.L_CORE 0.001412
K_13355 X_NUC_72.L_CORE X_NUC_221.L_CORE 0.001783
K_13356 X_NUC_72.L_CORE X_NUC_222.L_CORE 0.001657
K_13357 X_NUC_73.L_CORE X_NUC_74.L_CORE 0.207973
K_13358 X_NUC_73.L_CORE X_NUC_75.L_CORE 0.207973
K_13359 X_NUC_73.L_CORE X_NUC_76.L_CORE 0.207973
K_13360 X_NUC_73.L_CORE X_NUC_77.L_CORE 0.001406
K_13361 X_NUC_73.L_CORE X_NUC_78.L_CORE 0.001398
K_13362 X_NUC_73.L_CORE X_NUC_79.L_CORE 0.001404
K_13363 X_NUC_73.L_CORE X_NUC_80.L_CORE 0.001400
K_13364 X_NUC_73.L_CORE X_NUC_81.L_CORE 0.001933
K_13365 X_NUC_73.L_CORE X_NUC_82.L_CORE 0.001921
K_13366 X_NUC_73.L_CORE X_NUC_83.L_CORE 0.001920
K_13367 X_NUC_73.L_CORE X_NUC_84.L_CORE 0.001933
K_13368 X_NUC_73.L_CORE X_NUC_85.L_CORE 0.002920
K_13369 X_NUC_73.L_CORE X_NUC_86.L_CORE 0.002903
K_13370 X_NUC_73.L_CORE X_NUC_87.L_CORE 0.002925
K_13371 X_NUC_73.L_CORE X_NUC_88.L_CORE 0.002889
K_13372 X_NUC_73.L_CORE X_NUC_89.L_CORE 0.001308
K_13373 X_NUC_73.L_CORE X_NUC_90.L_CORE 0.001300
K_13374 X_NUC_73.L_CORE X_NUC_91.L_CORE 0.001303
K_13375 X_NUC_73.L_CORE X_NUC_92.L_CORE 0.001304
K_13376 X_NUC_73.L_CORE X_NUC_93.L_CORE 0.004327
K_13377 X_NUC_73.L_CORE X_NUC_94.L_CORE 0.004304
K_13378 X_NUC_73.L_CORE X_NUC_95.L_CORE 0.004252
K_13379 X_NUC_73.L_CORE X_NUC_96.L_CORE 0.004330
K_13380 X_NUC_73.L_CORE X_NUC_97.L_CORE 0.001631
K_13381 X_NUC_73.L_CORE X_NUC_98.L_CORE 0.001621
K_13382 X_NUC_73.L_CORE X_NUC_99.L_CORE 0.001628
K_13383 X_NUC_73.L_CORE X_NUC_100.L_CORE 0.001621
K_13384 X_NUC_73.L_CORE X_NUC_101.L_CORE 0.001516
K_13385 X_NUC_73.L_CORE X_NUC_102.L_CORE 0.001507
K_13386 X_NUC_73.L_CORE X_NUC_103.L_CORE 0.001507
K_13387 X_NUC_73.L_CORE X_NUC_104.L_CORE 0.001513
K_13388 X_NUC_73.L_CORE X_NUC_105.L_CORE 0.005150
K_13389 X_NUC_73.L_CORE X_NUC_106.L_CORE 0.005129
K_13390 X_NUC_73.L_CORE X_NUC_107.L_CORE 0.005115
K_13391 X_NUC_73.L_CORE X_NUC_108.L_CORE 0.005034
K_13392 X_NUC_73.L_CORE X_NUC_109.L_CORE 0.001330
K_13393 X_NUC_73.L_CORE X_NUC_110.L_CORE 0.001321
K_13394 X_NUC_73.L_CORE X_NUC_111.L_CORE 0.001325
K_13395 X_NUC_73.L_CORE X_NUC_112.L_CORE 0.001323
K_13396 X_NUC_73.L_CORE X_NUC_113.L_CORE 0.002286
K_13397 X_NUC_73.L_CORE X_NUC_114.L_CORE 0.002273
K_13398 X_NUC_73.L_CORE X_NUC_115.L_CORE 0.002263
K_13399 X_NUC_73.L_CORE X_NUC_116.L_CORE 0.002282
K_13400 X_NUC_73.L_CORE X_NUC_117.L_CORE 0.002089
K_13401 X_NUC_73.L_CORE X_NUC_118.L_CORE 0.002077
K_13402 X_NUC_73.L_CORE X_NUC_119.L_CORE 0.002084
K_13403 X_NUC_73.L_CORE X_NUC_120.L_CORE 0.002070
K_13404 X_NUC_73.L_CORE X_NUC_121.L_CORE 0.001359
K_13405 X_NUC_73.L_CORE X_NUC_122.L_CORE 0.001351
K_13406 X_NUC_73.L_CORE X_NUC_123.L_CORE 0.001352
K_13407 X_NUC_73.L_CORE X_NUC_124.L_CORE 0.001354
K_13408 X_NUC_73.L_CORE X_NUC_125.L_CORE 0.004030
K_13409 X_NUC_73.L_CORE X_NUC_126.L_CORE 0.004014
K_13410 X_NUC_73.L_CORE X_NUC_127.L_CORE 0.003960
K_13411 X_NUC_73.L_CORE X_NUC_128.L_CORE 0.003982
K_13412 X_NUC_73.L_CORE X_NUC_129.L_CORE 0.001474
K_13413 X_NUC_73.L_CORE X_NUC_130.L_CORE 0.001465
K_13414 X_NUC_73.L_CORE X_NUC_131.L_CORE 0.001469
K_13415 X_NUC_73.L_CORE X_NUC_132.L_CORE 0.001465
K_13416 X_NUC_73.L_CORE X_NUC_133.L_CORE 0.001693
K_13417 X_NUC_73.L_CORE X_NUC_134.L_CORE 0.001683
K_13418 X_NUC_73.L_CORE X_NUC_135.L_CORE 0.001680
K_13419 X_NUC_73.L_CORE X_NUC_136.L_CORE 0.001687
K_13420 X_NUC_73.L_CORE X_NUC_137.L_CORE 0.002654
K_13421 X_NUC_73.L_CORE X_NUC_138.L_CORE 0.002641
K_13422 X_NUC_73.L_CORE X_NUC_139.L_CORE 0.002638
K_13423 X_NUC_73.L_CORE X_NUC_140.L_CORE 0.002621
K_13424 X_NUC_73.L_CORE X_NUC_141.L_CORE 0.001357
K_13425 X_NUC_73.L_CORE X_NUC_142.L_CORE 0.001349
K_13426 X_NUC_73.L_CORE X_NUC_143.L_CORE 0.001350
K_13427 X_NUC_73.L_CORE X_NUC_144.L_CORE 0.001350
K_13428 X_NUC_73.L_CORE X_NUC_145.L_CORE 0.002388
K_13429 X_NUC_73.L_CORE X_NUC_146.L_CORE 0.002376
K_13430 X_NUC_73.L_CORE X_NUC_147.L_CORE 0.002361
K_13431 X_NUC_73.L_CORE X_NUC_148.L_CORE 0.002373
K_13432 X_NUC_73.L_CORE X_NUC_149.L_CORE 0.001729
K_13433 X_NUC_73.L_CORE X_NUC_150.L_CORE 0.001719
K_13434 X_NUC_73.L_CORE X_NUC_151.L_CORE 0.001721
K_13435 X_NUC_73.L_CORE X_NUC_152.L_CORE 0.001715
K_13436 X_NUC_73.L_CORE X_NUC_153.L_CORE 0.001504
K_13437 X_NUC_73.L_CORE X_NUC_154.L_CORE 0.001495
K_13438 X_NUC_73.L_CORE X_NUC_155.L_CORE 0.001494
K_13439 X_NUC_73.L_CORE X_NUC_156.L_CORE 0.001497
K_13440 X_NUC_73.L_CORE X_NUC_157.L_CORE 0.002417
K_13441 X_NUC_73.L_CORE X_NUC_158.L_CORE 0.002406
K_13442 X_NUC_73.L_CORE X_NUC_159.L_CORE 0.002395
K_13443 X_NUC_73.L_CORE X_NUC_160.L_CORE 0.002393
K_13444 X_NUC_73.L_CORE X_NUC_161.L_CORE 0.001502
K_13445 X_NUC_73.L_CORE X_NUC_162.L_CORE 0.001493
K_13446 X_NUC_73.L_CORE X_NUC_163.L_CORE 0.001494
K_13447 X_NUC_73.L_CORE X_NUC_164.L_CORE 0.001492
K_13448 X_NUC_73.L_CORE X_NUC_165.L_CORE 0.001797
K_13449 X_NUC_73.L_CORE X_NUC_166.L_CORE 0.001787
K_13450 X_NUC_73.L_CORE X_NUC_167.L_CORE 0.001782
K_13451 X_NUC_73.L_CORE X_NUC_168.L_CORE 0.001786
K_13452 X_NUC_73.L_CORE X_NUC_169.L_CORE 0.001814
K_13453 X_NUC_73.L_CORE X_NUC_170.L_CORE 0.001804
K_13454 X_NUC_73.L_CORE X_NUC_171.L_CORE 0.001801
K_13455 X_NUC_73.L_CORE X_NUC_172.L_CORE 0.001799
K_13456 X_NUC_73.L_CORE X_NUC_173.L_CORE 0.002077
K_13457 X_NUC_73.L_CORE X_NUC_174.L_CORE 0.001609
K_13458 X_NUC_73.L_CORE X_NUC_175.L_CORE 0.002395
K_13459 X_NUC_73.L_CORE X_NUC_176.L_CORE 0.001817
K_13460 X_NUC_73.L_CORE X_NUC_177.L_CORE 0.001605
K_13461 X_NUC_73.L_CORE X_NUC_178.L_CORE 0.003302
K_13462 X_NUC_73.L_CORE X_NUC_179.L_CORE 0.001455
K_13463 X_NUC_73.L_CORE X_NUC_180.L_CORE 0.002125
K_13464 X_NUC_73.L_CORE X_NUC_181.L_CORE 0.002293
K_13465 X_NUC_73.L_CORE X_NUC_182.L_CORE 0.001383
K_13466 X_NUC_73.L_CORE X_NUC_183.L_CORE 0.004385
K_13467 X_NUC_73.L_CORE X_NUC_184.L_CORE 0.001543
K_13468 X_NUC_73.L_CORE X_NUC_185.L_CORE 0.001644
K_13469 X_NUC_73.L_CORE X_NUC_186.L_CORE 0.003997
K_13470 X_NUC_73.L_CORE X_NUC_187.L_CORE 0.001307
K_13471 X_NUC_73.L_CORE X_NUC_188.L_CORE 0.002824
K_13472 X_NUC_73.L_CORE X_NUC_189.L_CORE 0.001891
K_13473 X_NUC_73.L_CORE X_NUC_190.L_CORE 0.001372
K_13474 X_NUC_73.L_CORE X_NUC_191.L_CORE 0.018045
K_13475 X_NUC_73.L_CORE X_NUC_192.L_CORE 0.001361
K_13476 X_NUC_73.L_CORE X_NUC_193.L_CORE 0.001870
K_13477 X_NUC_73.L_CORE X_NUC_194.L_CORE 0.002842
K_13478 X_NUC_73.L_CORE X_NUC_195.L_CORE 0.001262
K_13479 X_NUC_73.L_CORE X_NUC_196.L_CORE 0.004411
K_13480 X_NUC_73.L_CORE X_NUC_197.L_CORE 0.001575
K_13481 X_NUC_73.L_CORE X_NUC_198.L_CORE 0.001461
K_13482 X_NUC_73.L_CORE X_NUC_199.L_CORE 0.006129
K_13483 X_NUC_73.L_CORE X_NUC_200.L_CORE 0.001272
K_13484 X_NUC_73.L_CORE X_NUC_201.L_CORE 0.002267
K_13485 X_NUC_73.L_CORE X_NUC_202.L_CORE 0.002057
K_13486 X_NUC_73.L_CORE X_NUC_203.L_CORE 0.001292
K_13487 X_NUC_73.L_CORE X_NUC_204.L_CORE 0.005419
K_13488 X_NUC_73.L_CORE X_NUC_205.L_CORE 0.001401
K_13489 X_NUC_73.L_CORE X_NUC_206.L_CORE 0.001632
K_13490 X_NUC_73.L_CORE X_NUC_207.L_CORE 0.002957
K_13491 X_NUC_73.L_CORE X_NUC_208.L_CORE 0.001261
K_13492 X_NUC_73.L_CORE X_NUC_209.L_CORE 0.002647
K_13493 X_NUC_73.L_CORE X_NUC_210.L_CORE 0.001674
K_13494 X_NUC_73.L_CORE X_NUC_211.L_CORE 0.001390
K_13495 X_NUC_73.L_CORE X_NUC_212.L_CORE 0.003300
K_13496 X_NUC_73.L_CORE X_NUC_213.L_CORE 0.001343
K_13497 X_NUC_73.L_CORE X_NUC_214.L_CORE 0.001828
K_13498 X_NUC_73.L_CORE X_NUC_215.L_CORE 0.002038
K_13499 X_NUC_73.L_CORE X_NUC_216.L_CORE 0.001338
K_13500 X_NUC_73.L_CORE X_NUC_217.L_CORE 0.002378
K_13501 X_NUC_73.L_CORE X_NUC_218.L_CORE 0.001527
K_13502 X_NUC_73.L_CORE X_NUC_219.L_CORE 0.001551
K_13503 X_NUC_73.L_CORE X_NUC_220.L_CORE 0.002040
K_13504 X_NUC_73.L_CORE X_NUC_221.L_CORE 0.001460
K_13505 X_NUC_73.L_CORE X_NUC_222.L_CORE 0.001735
K_13506 X_NUC_74.L_CORE X_NUC_75.L_CORE 0.207973
K_13507 X_NUC_74.L_CORE X_NUC_76.L_CORE 0.207973
K_13508 X_NUC_74.L_CORE X_NUC_77.L_CORE 0.001415
K_13509 X_NUC_74.L_CORE X_NUC_78.L_CORE 0.001406
K_13510 X_NUC_74.L_CORE X_NUC_79.L_CORE 0.001412
K_13511 X_NUC_74.L_CORE X_NUC_80.L_CORE 0.001409
K_13512 X_NUC_74.L_CORE X_NUC_81.L_CORE 0.001945
K_13513 X_NUC_74.L_CORE X_NUC_82.L_CORE 0.001933
K_13514 X_NUC_74.L_CORE X_NUC_83.L_CORE 0.001932
K_13515 X_NUC_74.L_CORE X_NUC_84.L_CORE 0.001945
K_13516 X_NUC_74.L_CORE X_NUC_85.L_CORE 0.002938
K_13517 X_NUC_74.L_CORE X_NUC_86.L_CORE 0.002920
K_13518 X_NUC_74.L_CORE X_NUC_87.L_CORE 0.002943
K_13519 X_NUC_74.L_CORE X_NUC_88.L_CORE 0.002906
K_13520 X_NUC_74.L_CORE X_NUC_89.L_CORE 0.001317
K_13521 X_NUC_74.L_CORE X_NUC_90.L_CORE 0.001308
K_13522 X_NUC_74.L_CORE X_NUC_91.L_CORE 0.001312
K_13523 X_NUC_74.L_CORE X_NUC_92.L_CORE 0.001312
K_13524 X_NUC_74.L_CORE X_NUC_93.L_CORE 0.004348
K_13525 X_NUC_74.L_CORE X_NUC_94.L_CORE 0.004327
K_13526 X_NUC_74.L_CORE X_NUC_95.L_CORE 0.004273
K_13527 X_NUC_74.L_CORE X_NUC_96.L_CORE 0.004353
K_13528 X_NUC_74.L_CORE X_NUC_97.L_CORE 0.001641
K_13529 X_NUC_74.L_CORE X_NUC_98.L_CORE 0.001631
K_13530 X_NUC_74.L_CORE X_NUC_99.L_CORE 0.001639
K_13531 X_NUC_74.L_CORE X_NUC_100.L_CORE 0.001631
K_13532 X_NUC_74.L_CORE X_NUC_101.L_CORE 0.001526
K_13533 X_NUC_74.L_CORE X_NUC_102.L_CORE 0.001516
K_13534 X_NUC_74.L_CORE X_NUC_103.L_CORE 0.001517
K_13535 X_NUC_74.L_CORE X_NUC_104.L_CORE 0.001522
K_13536 X_NUC_74.L_CORE X_NUC_105.L_CORE 0.005168
K_13537 X_NUC_74.L_CORE X_NUC_106.L_CORE 0.005150
K_13538 X_NUC_74.L_CORE X_NUC_107.L_CORE 0.005134
K_13539 X_NUC_74.L_CORE X_NUC_108.L_CORE 0.005053
K_13540 X_NUC_74.L_CORE X_NUC_109.L_CORE 0.001338
K_13541 X_NUC_74.L_CORE X_NUC_110.L_CORE 0.001330
K_13542 X_NUC_74.L_CORE X_NUC_111.L_CORE 0.001333
K_13543 X_NUC_74.L_CORE X_NUC_112.L_CORE 0.001332
K_13544 X_NUC_74.L_CORE X_NUC_113.L_CORE 0.002299
K_13545 X_NUC_74.L_CORE X_NUC_114.L_CORE 0.002286
K_13546 X_NUC_74.L_CORE X_NUC_115.L_CORE 0.002276
K_13547 X_NUC_74.L_CORE X_NUC_116.L_CORE 0.002295
K_13548 X_NUC_74.L_CORE X_NUC_117.L_CORE 0.002101
K_13549 X_NUC_74.L_CORE X_NUC_118.L_CORE 0.002089
K_13550 X_NUC_74.L_CORE X_NUC_119.L_CORE 0.002096
K_13551 X_NUC_74.L_CORE X_NUC_120.L_CORE 0.002081
K_13552 X_NUC_74.L_CORE X_NUC_121.L_CORE 0.001367
K_13553 X_NUC_74.L_CORE X_NUC_122.L_CORE 0.001359
K_13554 X_NUC_74.L_CORE X_NUC_123.L_CORE 0.001360
K_13555 X_NUC_74.L_CORE X_NUC_124.L_CORE 0.001362
K_13556 X_NUC_74.L_CORE X_NUC_125.L_CORE 0.004044
K_13557 X_NUC_74.L_CORE X_NUC_126.L_CORE 0.004030
K_13558 X_NUC_74.L_CORE X_NUC_127.L_CORE 0.003975
K_13559 X_NUC_74.L_CORE X_NUC_128.L_CORE 0.003997
K_13560 X_NUC_74.L_CORE X_NUC_129.L_CORE 0.001483
K_13561 X_NUC_74.L_CORE X_NUC_130.L_CORE 0.001474
K_13562 X_NUC_74.L_CORE X_NUC_131.L_CORE 0.001478
K_13563 X_NUC_74.L_CORE X_NUC_132.L_CORE 0.001473
K_13564 X_NUC_74.L_CORE X_NUC_133.L_CORE 0.001702
K_13565 X_NUC_74.L_CORE X_NUC_134.L_CORE 0.001693
K_13566 X_NUC_74.L_CORE X_NUC_135.L_CORE 0.001689
K_13567 X_NUC_74.L_CORE X_NUC_136.L_CORE 0.001697
K_13568 X_NUC_74.L_CORE X_NUC_137.L_CORE 0.002667
K_13569 X_NUC_74.L_CORE X_NUC_138.L_CORE 0.002654
K_13570 X_NUC_74.L_CORE X_NUC_139.L_CORE 0.002651
K_13571 X_NUC_74.L_CORE X_NUC_140.L_CORE 0.002634
K_13572 X_NUC_74.L_CORE X_NUC_141.L_CORE 0.001365
K_13573 X_NUC_74.L_CORE X_NUC_142.L_CORE 0.001357
K_13574 X_NUC_74.L_CORE X_NUC_143.L_CORE 0.001358
K_13575 X_NUC_74.L_CORE X_NUC_144.L_CORE 0.001358
K_13576 X_NUC_74.L_CORE X_NUC_145.L_CORE 0.002400
K_13577 X_NUC_74.L_CORE X_NUC_146.L_CORE 0.002388
K_13578 X_NUC_74.L_CORE X_NUC_147.L_CORE 0.002373
K_13579 X_NUC_74.L_CORE X_NUC_148.L_CORE 0.002385
K_13580 X_NUC_74.L_CORE X_NUC_149.L_CORE 0.001739
K_13581 X_NUC_74.L_CORE X_NUC_150.L_CORE 0.001729
K_13582 X_NUC_74.L_CORE X_NUC_151.L_CORE 0.001731
K_13583 X_NUC_74.L_CORE X_NUC_152.L_CORE 0.001724
K_13584 X_NUC_74.L_CORE X_NUC_153.L_CORE 0.001513
K_13585 X_NUC_74.L_CORE X_NUC_154.L_CORE 0.001504
K_13586 X_NUC_74.L_CORE X_NUC_155.L_CORE 0.001503
K_13587 X_NUC_74.L_CORE X_NUC_156.L_CORE 0.001506
K_13588 X_NUC_74.L_CORE X_NUC_157.L_CORE 0.002429
K_13589 X_NUC_74.L_CORE X_NUC_158.L_CORE 0.002417
K_13590 X_NUC_74.L_CORE X_NUC_159.L_CORE 0.002406
K_13591 X_NUC_74.L_CORE X_NUC_160.L_CORE 0.002404
K_13592 X_NUC_74.L_CORE X_NUC_161.L_CORE 0.001510
K_13593 X_NUC_74.L_CORE X_NUC_162.L_CORE 0.001502
K_13594 X_NUC_74.L_CORE X_NUC_163.L_CORE 0.001502
K_13595 X_NUC_74.L_CORE X_NUC_164.L_CORE 0.001500
K_13596 X_NUC_74.L_CORE X_NUC_165.L_CORE 0.001807
K_13597 X_NUC_74.L_CORE X_NUC_166.L_CORE 0.001797
K_13598 X_NUC_74.L_CORE X_NUC_167.L_CORE 0.001792
K_13599 X_NUC_74.L_CORE X_NUC_168.L_CORE 0.001795
K_13600 X_NUC_74.L_CORE X_NUC_169.L_CORE 0.001823
K_13601 X_NUC_74.L_CORE X_NUC_170.L_CORE 0.001814
K_13602 X_NUC_74.L_CORE X_NUC_171.L_CORE 0.001811
K_13603 X_NUC_74.L_CORE X_NUC_172.L_CORE 0.001809
K_13604 X_NUC_74.L_CORE X_NUC_173.L_CORE 0.002091
K_13605 X_NUC_74.L_CORE X_NUC_174.L_CORE 0.001619
K_13606 X_NUC_74.L_CORE X_NUC_175.L_CORE 0.002411
K_13607 X_NUC_74.L_CORE X_NUC_176.L_CORE 0.001829
K_13608 X_NUC_74.L_CORE X_NUC_177.L_CORE 0.001615
K_13609 X_NUC_74.L_CORE X_NUC_178.L_CORE 0.003324
K_13610 X_NUC_74.L_CORE X_NUC_179.L_CORE 0.001465
K_13611 X_NUC_74.L_CORE X_NUC_180.L_CORE 0.002138
K_13612 X_NUC_74.L_CORE X_NUC_181.L_CORE 0.002308
K_13613 X_NUC_74.L_CORE X_NUC_182.L_CORE 0.001391
K_13614 X_NUC_74.L_CORE X_NUC_183.L_CORE 0.004411
K_13615 X_NUC_74.L_CORE X_NUC_184.L_CORE 0.001553
K_13616 X_NUC_74.L_CORE X_NUC_185.L_CORE 0.001655
K_13617 X_NUC_74.L_CORE X_NUC_186.L_CORE 0.004019
K_13618 X_NUC_74.L_CORE X_NUC_187.L_CORE 0.001315
K_13619 X_NUC_74.L_CORE X_NUC_188.L_CORE 0.002840
K_13620 X_NUC_74.L_CORE X_NUC_189.L_CORE 0.001902
K_13621 X_NUC_74.L_CORE X_NUC_190.L_CORE 0.001381
K_13622 X_NUC_74.L_CORE X_NUC_191.L_CORE 0.017502
K_13623 X_NUC_74.L_CORE X_NUC_192.L_CORE 0.001370
K_13624 X_NUC_74.L_CORE X_NUC_193.L_CORE 0.001881
K_13625 X_NUC_74.L_CORE X_NUC_194.L_CORE 0.002856
K_13626 X_NUC_74.L_CORE X_NUC_195.L_CORE 0.001270
K_13627 X_NUC_74.L_CORE X_NUC_196.L_CORE 0.004424
K_13628 X_NUC_74.L_CORE X_NUC_197.L_CORE 0.001585
K_13629 X_NUC_74.L_CORE X_NUC_198.L_CORE 0.001470
K_13630 X_NUC_74.L_CORE X_NUC_199.L_CORE 0.006120
K_13631 X_NUC_74.L_CORE X_NUC_200.L_CORE 0.001280
K_13632 X_NUC_74.L_CORE X_NUC_201.L_CORE 0.002278
K_13633 X_NUC_74.L_CORE X_NUC_202.L_CORE 0.002068
K_13634 X_NUC_74.L_CORE X_NUC_203.L_CORE 0.001299
K_13635 X_NUC_74.L_CORE X_NUC_204.L_CORE 0.005410
K_13636 X_NUC_74.L_CORE X_NUC_205.L_CORE 0.001409
K_13637 X_NUC_74.L_CORE X_NUC_206.L_CORE 0.001641
K_13638 X_NUC_74.L_CORE X_NUC_207.L_CORE 0.002968
K_13639 X_NUC_74.L_CORE X_NUC_208.L_CORE 0.001269
K_13640 X_NUC_74.L_CORE X_NUC_209.L_CORE 0.002657
K_13641 X_NUC_74.L_CORE X_NUC_210.L_CORE 0.001683
K_13642 X_NUC_74.L_CORE X_NUC_211.L_CORE 0.001398
K_13643 X_NUC_74.L_CORE X_NUC_212.L_CORE 0.003308
K_13644 X_NUC_74.L_CORE X_NUC_213.L_CORE 0.001351
K_13645 X_NUC_74.L_CORE X_NUC_214.L_CORE 0.001837
K_13646 X_NUC_74.L_CORE X_NUC_215.L_CORE 0.002047
K_13647 X_NUC_74.L_CORE X_NUC_216.L_CORE 0.001345
K_13648 X_NUC_74.L_CORE X_NUC_217.L_CORE 0.002387
K_13649 X_NUC_74.L_CORE X_NUC_218.L_CORE 0.001535
K_13650 X_NUC_74.L_CORE X_NUC_219.L_CORE 0.001559
K_13651 X_NUC_74.L_CORE X_NUC_220.L_CORE 0.002049
K_13652 X_NUC_74.L_CORE X_NUC_221.L_CORE 0.001468
K_13653 X_NUC_74.L_CORE X_NUC_222.L_CORE 0.001744
K_13654 X_NUC_75.L_CORE X_NUC_76.L_CORE 0.207973
K_13655 X_NUC_75.L_CORE X_NUC_77.L_CORE 0.001409
K_13656 X_NUC_75.L_CORE X_NUC_78.L_CORE 0.001400
K_13657 X_NUC_75.L_CORE X_NUC_79.L_CORE 0.001406
K_13658 X_NUC_75.L_CORE X_NUC_80.L_CORE 0.001403
K_13659 X_NUC_75.L_CORE X_NUC_81.L_CORE 0.001947
K_13660 X_NUC_75.L_CORE X_NUC_82.L_CORE 0.001935
K_13661 X_NUC_75.L_CORE X_NUC_83.L_CORE 0.001933
K_13662 X_NUC_75.L_CORE X_NUC_84.L_CORE 0.001947
K_13663 X_NUC_75.L_CORE X_NUC_85.L_CORE 0.002915
K_13664 X_NUC_75.L_CORE X_NUC_86.L_CORE 0.002898
K_13665 X_NUC_75.L_CORE X_NUC_87.L_CORE 0.002920
K_13666 X_NUC_75.L_CORE X_NUC_88.L_CORE 0.002884
K_13667 X_NUC_75.L_CORE X_NUC_89.L_CORE 0.001313
K_13668 X_NUC_75.L_CORE X_NUC_90.L_CORE 0.001305
K_13669 X_NUC_75.L_CORE X_NUC_91.L_CORE 0.001308
K_13670 X_NUC_75.L_CORE X_NUC_92.L_CORE 0.001309
K_13671 X_NUC_75.L_CORE X_NUC_93.L_CORE 0.004403
K_13672 X_NUC_75.L_CORE X_NUC_94.L_CORE 0.004380
K_13673 X_NUC_75.L_CORE X_NUC_95.L_CORE 0.004327
K_13674 X_NUC_75.L_CORE X_NUC_96.L_CORE 0.004408
K_13675 X_NUC_75.L_CORE X_NUC_97.L_CORE 0.001634
K_13676 X_NUC_75.L_CORE X_NUC_98.L_CORE 0.001624
K_13677 X_NUC_75.L_CORE X_NUC_99.L_CORE 0.001631
K_13678 X_NUC_75.L_CORE X_NUC_100.L_CORE 0.001624
K_13679 X_NUC_75.L_CORE X_NUC_101.L_CORE 0.001525
K_13680 X_NUC_75.L_CORE X_NUC_102.L_CORE 0.001516
K_13681 X_NUC_75.L_CORE X_NUC_103.L_CORE 0.001516
K_13682 X_NUC_75.L_CORE X_NUC_104.L_CORE 0.001522
K_13683 X_NUC_75.L_CORE X_NUC_105.L_CORE 0.005183
K_13684 X_NUC_75.L_CORE X_NUC_106.L_CORE 0.005163
K_13685 X_NUC_75.L_CORE X_NUC_107.L_CORE 0.005150
K_13686 X_NUC_75.L_CORE X_NUC_108.L_CORE 0.005067
K_13687 X_NUC_75.L_CORE X_NUC_109.L_CORE 0.001334
K_13688 X_NUC_75.L_CORE X_NUC_110.L_CORE 0.001326
K_13689 X_NUC_75.L_CORE X_NUC_111.L_CORE 0.001330
K_13690 X_NUC_75.L_CORE X_NUC_112.L_CORE 0.001328
K_13691 X_NUC_75.L_CORE X_NUC_113.L_CORE 0.002310
K_13692 X_NUC_75.L_CORE X_NUC_114.L_CORE 0.002296
K_13693 X_NUC_75.L_CORE X_NUC_115.L_CORE 0.002286
K_13694 X_NUC_75.L_CORE X_NUC_116.L_CORE 0.002305
K_13695 X_NUC_75.L_CORE X_NUC_117.L_CORE 0.002094
K_13696 X_NUC_75.L_CORE X_NUC_118.L_CORE 0.002082
K_13697 X_NUC_75.L_CORE X_NUC_119.L_CORE 0.002089
K_13698 X_NUC_75.L_CORE X_NUC_120.L_CORE 0.002074
K_13699 X_NUC_75.L_CORE X_NUC_121.L_CORE 0.001366
K_13700 X_NUC_75.L_CORE X_NUC_122.L_CORE 0.001357
K_13701 X_NUC_75.L_CORE X_NUC_123.L_CORE 0.001359
K_13702 X_NUC_75.L_CORE X_NUC_124.L_CORE 0.001361
K_13703 X_NUC_75.L_CORE X_NUC_125.L_CORE 0.004102
K_13704 X_NUC_75.L_CORE X_NUC_126.L_CORE 0.004086
K_13705 X_NUC_75.L_CORE X_NUC_127.L_CORE 0.004030
K_13706 X_NUC_75.L_CORE X_NUC_128.L_CORE 0.004052
K_13707 X_NUC_75.L_CORE X_NUC_129.L_CORE 0.001479
K_13708 X_NUC_75.L_CORE X_NUC_130.L_CORE 0.001470
K_13709 X_NUC_75.L_CORE X_NUC_131.L_CORE 0.001474
K_13710 X_NUC_75.L_CORE X_NUC_132.L_CORE 0.001470
K_13711 X_NUC_75.L_CORE X_NUC_133.L_CORE 0.001706
K_13712 X_NUC_75.L_CORE X_NUC_134.L_CORE 0.001696
K_13713 X_NUC_75.L_CORE X_NUC_135.L_CORE 0.001693
K_13714 X_NUC_75.L_CORE X_NUC_136.L_CORE 0.001700
K_13715 X_NUC_75.L_CORE X_NUC_137.L_CORE 0.002670
K_13716 X_NUC_75.L_CORE X_NUC_138.L_CORE 0.002657
K_13717 X_NUC_75.L_CORE X_NUC_139.L_CORE 0.002654
K_13718 X_NUC_75.L_CORE X_NUC_140.L_CORE 0.002636
K_13719 X_NUC_75.L_CORE X_NUC_141.L_CORE 0.001363
K_13720 X_NUC_75.L_CORE X_NUC_142.L_CORE 0.001355
K_13721 X_NUC_75.L_CORE X_NUC_143.L_CORE 0.001357
K_13722 X_NUC_75.L_CORE X_NUC_144.L_CORE 0.001357
K_13723 X_NUC_75.L_CORE X_NUC_145.L_CORE 0.002416
K_13724 X_NUC_75.L_CORE X_NUC_146.L_CORE 0.002403
K_13725 X_NUC_75.L_CORE X_NUC_147.L_CORE 0.002388
K_13726 X_NUC_75.L_CORE X_NUC_148.L_CORE 0.002401
K_13727 X_NUC_75.L_CORE X_NUC_149.L_CORE 0.001736
K_13728 X_NUC_75.L_CORE X_NUC_150.L_CORE 0.001727
K_13729 X_NUC_75.L_CORE X_NUC_151.L_CORE 0.001729
K_13730 X_NUC_75.L_CORE X_NUC_152.L_CORE 0.001722
K_13731 X_NUC_75.L_CORE X_NUC_153.L_CORE 0.001514
K_13732 X_NUC_75.L_CORE X_NUC_154.L_CORE 0.001505
K_13733 X_NUC_75.L_CORE X_NUC_155.L_CORE 0.001504
K_13734 X_NUC_75.L_CORE X_NUC_156.L_CORE 0.001507
K_13735 X_NUC_75.L_CORE X_NUC_157.L_CORE 0.002441
K_13736 X_NUC_75.L_CORE X_NUC_158.L_CORE 0.002429
K_13737 X_NUC_75.L_CORE X_NUC_159.L_CORE 0.002417
K_13738 X_NUC_75.L_CORE X_NUC_160.L_CORE 0.002415
K_13739 X_NUC_75.L_CORE X_NUC_161.L_CORE 0.001510
K_13740 X_NUC_75.L_CORE X_NUC_162.L_CORE 0.001501
K_13741 X_NUC_75.L_CORE X_NUC_163.L_CORE 0.001502
K_13742 X_NUC_75.L_CORE X_NUC_164.L_CORE 0.001500
K_13743 X_NUC_75.L_CORE X_NUC_165.L_CORE 0.001812
K_13744 X_NUC_75.L_CORE X_NUC_166.L_CORE 0.001802
K_13745 X_NUC_75.L_CORE X_NUC_167.L_CORE 0.001797
K_13746 X_NUC_75.L_CORE X_NUC_168.L_CORE 0.001801
K_13747 X_NUC_75.L_CORE X_NUC_169.L_CORE 0.001826
K_13748 X_NUC_75.L_CORE X_NUC_170.L_CORE 0.001816
K_13749 X_NUC_75.L_CORE X_NUC_171.L_CORE 0.001814
K_13750 X_NUC_75.L_CORE X_NUC_172.L_CORE 0.001812
K_13751 X_NUC_75.L_CORE X_NUC_173.L_CORE 0.002072
K_13752 X_NUC_75.L_CORE X_NUC_174.L_CORE 0.001609
K_13753 X_NUC_75.L_CORE X_NUC_175.L_CORE 0.002392
K_13754 X_NUC_75.L_CORE X_NUC_176.L_CORE 0.001814
K_13755 X_NUC_75.L_CORE X_NUC_177.L_CORE 0.001608
K_13756 X_NUC_75.L_CORE X_NUC_178.L_CORE 0.003276
K_13757 X_NUC_75.L_CORE X_NUC_179.L_CORE 0.001456
K_13758 X_NUC_75.L_CORE X_NUC_180.L_CORE 0.002130
K_13759 X_NUC_75.L_CORE X_NUC_181.L_CORE 0.002284
K_13760 X_NUC_75.L_CORE X_NUC_182.L_CORE 0.001386
K_13761 X_NUC_75.L_CORE X_NUC_183.L_CORE 0.004368
K_13762 X_NUC_75.L_CORE X_NUC_184.L_CORE 0.001543
K_13763 X_NUC_75.L_CORE X_NUC_185.L_CORE 0.001651
K_13764 X_NUC_75.L_CORE X_NUC_186.L_CORE 0.003949
K_13765 X_NUC_75.L_CORE X_NUC_187.L_CORE 0.001309
K_13766 X_NUC_75.L_CORE X_NUC_188.L_CORE 0.002841
K_13767 X_NUC_75.L_CORE X_NUC_189.L_CORE 0.001888
K_13768 X_NUC_75.L_CORE X_NUC_190.L_CORE 0.001378
K_13769 X_NUC_75.L_CORE X_NUC_191.L_CORE 0.016815
K_13770 X_NUC_75.L_CORE X_NUC_192.L_CORE 0.001363
K_13771 X_NUC_75.L_CORE X_NUC_193.L_CORE 0.001882
K_13772 X_NUC_75.L_CORE X_NUC_194.L_CORE 0.002831
K_13773 X_NUC_75.L_CORE X_NUC_195.L_CORE 0.001266
K_13774 X_NUC_75.L_CORE X_NUC_196.L_CORE 0.004473
K_13775 X_NUC_75.L_CORE X_NUC_197.L_CORE 0.001577
K_13776 X_NUC_75.L_CORE X_NUC_198.L_CORE 0.001469
K_13777 X_NUC_75.L_CORE X_NUC_199.L_CORE 0.006107
K_13778 X_NUC_75.L_CORE X_NUC_200.L_CORE 0.001276
K_13779 X_NUC_75.L_CORE X_NUC_201.L_CORE 0.002287
K_13780 X_NUC_75.L_CORE X_NUC_202.L_CORE 0.002058
K_13781 X_NUC_75.L_CORE X_NUC_203.L_CORE 0.001298
K_13782 X_NUC_75.L_CORE X_NUC_204.L_CORE 0.005539
K_13783 X_NUC_75.L_CORE X_NUC_205.L_CORE 0.001405
K_13784 X_NUC_75.L_CORE X_NUC_206.L_CORE 0.001644
K_13785 X_NUC_75.L_CORE X_NUC_207.L_CORE 0.002965
K_13786 X_NUC_75.L_CORE X_NUC_208.L_CORE 0.001267
K_13787 X_NUC_75.L_CORE X_NUC_209.L_CORE 0.002679
K_13788 X_NUC_75.L_CORE X_NUC_210.L_CORE 0.001678
K_13789 X_NUC_75.L_CORE X_NUC_211.L_CORE 0.001399
K_13790 X_NUC_75.L_CORE X_NUC_212.L_CORE 0.003337
K_13791 X_NUC_75.L_CORE X_NUC_213.L_CORE 0.001349
K_13792 X_NUC_75.L_CORE X_NUC_214.L_CORE 0.001844
K_13793 X_NUC_75.L_CORE X_NUC_215.L_CORE 0.002047
K_13794 X_NUC_75.L_CORE X_NUC_216.L_CORE 0.001345
K_13795 X_NUC_75.L_CORE X_NUC_217.L_CORE 0.002403
K_13796 X_NUC_75.L_CORE X_NUC_218.L_CORE 0.001534
K_13797 X_NUC_75.L_CORE X_NUC_219.L_CORE 0.001562
K_13798 X_NUC_75.L_CORE X_NUC_220.L_CORE 0.002056
K_13799 X_NUC_75.L_CORE X_NUC_221.L_CORE 0.001468
K_13800 X_NUC_75.L_CORE X_NUC_222.L_CORE 0.001748
K_13801 X_NUC_76.L_CORE X_NUC_77.L_CORE 0.001413
K_13802 X_NUC_76.L_CORE X_NUC_78.L_CORE 0.001404
K_13803 X_NUC_76.L_CORE X_NUC_79.L_CORE 0.001410
K_13804 X_NUC_76.L_CORE X_NUC_80.L_CORE 0.001406
K_13805 X_NUC_76.L_CORE X_NUC_81.L_CORE 0.001933
K_13806 X_NUC_76.L_CORE X_NUC_82.L_CORE 0.001922
K_13807 X_NUC_76.L_CORE X_NUC_83.L_CORE 0.001920
K_13808 X_NUC_76.L_CORE X_NUC_84.L_CORE 0.001933
K_13809 X_NUC_76.L_CORE X_NUC_85.L_CORE 0.002952
K_13810 X_NUC_76.L_CORE X_NUC_86.L_CORE 0.002934
K_13811 X_NUC_76.L_CORE X_NUC_87.L_CORE 0.002957
K_13812 X_NUC_76.L_CORE X_NUC_88.L_CORE 0.002920
K_13813 X_NUC_76.L_CORE X_NUC_89.L_CORE 0.001313
K_13814 X_NUC_76.L_CORE X_NUC_90.L_CORE 0.001304
K_13815 X_NUC_76.L_CORE X_NUC_91.L_CORE 0.001308
K_13816 X_NUC_76.L_CORE X_NUC_92.L_CORE 0.001308
K_13817 X_NUC_76.L_CORE X_NUC_93.L_CORE 0.004322
K_13818 X_NUC_76.L_CORE X_NUC_94.L_CORE 0.004300
K_13819 X_NUC_76.L_CORE X_NUC_95.L_CORE 0.004248
K_13820 X_NUC_76.L_CORE X_NUC_96.L_CORE 0.004327
K_13821 X_NUC_76.L_CORE X_NUC_97.L_CORE 0.001642
K_13822 X_NUC_76.L_CORE X_NUC_98.L_CORE 0.001632
K_13823 X_NUC_76.L_CORE X_NUC_99.L_CORE 0.001639
K_13824 X_NUC_76.L_CORE X_NUC_100.L_CORE 0.001631
K_13825 X_NUC_76.L_CORE X_NUC_101.L_CORE 0.001520
K_13826 X_NUC_76.L_CORE X_NUC_102.L_CORE 0.001510
K_13827 X_NUC_76.L_CORE X_NUC_103.L_CORE 0.001511
K_13828 X_NUC_76.L_CORE X_NUC_104.L_CORE 0.001516
K_13829 X_NUC_76.L_CORE X_NUC_105.L_CORE 0.005271
K_13830 X_NUC_76.L_CORE X_NUC_106.L_CORE 0.005250
K_13831 X_NUC_76.L_CORE X_NUC_107.L_CORE 0.005235
K_13832 X_NUC_76.L_CORE X_NUC_108.L_CORE 0.005150
K_13833 X_NUC_76.L_CORE X_NUC_109.L_CORE 0.001336
K_13834 X_NUC_76.L_CORE X_NUC_110.L_CORE 0.001328
K_13835 X_NUC_76.L_CORE X_NUC_111.L_CORE 0.001331
K_13836 X_NUC_76.L_CORE X_NUC_112.L_CORE 0.001330
K_13837 X_NUC_76.L_CORE X_NUC_113.L_CORE 0.002290
K_13838 X_NUC_76.L_CORE X_NUC_114.L_CORE 0.002278
K_13839 X_NUC_76.L_CORE X_NUC_115.L_CORE 0.002267
K_13840 X_NUC_76.L_CORE X_NUC_116.L_CORE 0.002286
K_13841 X_NUC_76.L_CORE X_NUC_117.L_CORE 0.002109
K_13842 X_NUC_76.L_CORE X_NUC_118.L_CORE 0.002097
K_13843 X_NUC_76.L_CORE X_NUC_119.L_CORE 0.002104
K_13844 X_NUC_76.L_CORE X_NUC_120.L_CORE 0.002089
K_13845 X_NUC_76.L_CORE X_NUC_121.L_CORE 0.001364
K_13846 X_NUC_76.L_CORE X_NUC_122.L_CORE 0.001355
K_13847 X_NUC_76.L_CORE X_NUC_123.L_CORE 0.001357
K_13848 X_NUC_76.L_CORE X_NUC_124.L_CORE 0.001359
K_13849 X_NUC_76.L_CORE X_NUC_125.L_CORE 0.004078
K_13850 X_NUC_76.L_CORE X_NUC_126.L_CORE 0.004062
K_13851 X_NUC_76.L_CORE X_NUC_127.L_CORE 0.004006
K_13852 X_NUC_76.L_CORE X_NUC_128.L_CORE 0.004030
K_13853 X_NUC_76.L_CORE X_NUC_129.L_CORE 0.001483
K_13854 X_NUC_76.L_CORE X_NUC_130.L_CORE 0.001474
K_13855 X_NUC_76.L_CORE X_NUC_131.L_CORE 0.001478
K_13856 X_NUC_76.L_CORE X_NUC_132.L_CORE 0.001474
K_13857 X_NUC_76.L_CORE X_NUC_133.L_CORE 0.001698
K_13858 X_NUC_76.L_CORE X_NUC_134.L_CORE 0.001688
K_13859 X_NUC_76.L_CORE X_NUC_135.L_CORE 0.001685
K_13860 X_NUC_76.L_CORE X_NUC_136.L_CORE 0.001693
K_13861 X_NUC_76.L_CORE X_NUC_137.L_CORE 0.002688
K_13862 X_NUC_76.L_CORE X_NUC_138.L_CORE 0.002675
K_13863 X_NUC_76.L_CORE X_NUC_139.L_CORE 0.002672
K_13864 X_NUC_76.L_CORE X_NUC_140.L_CORE 0.002654
K_13865 X_NUC_76.L_CORE X_NUC_141.L_CORE 0.001363
K_13866 X_NUC_76.L_CORE X_NUC_142.L_CORE 0.001355
K_13867 X_NUC_76.L_CORE X_NUC_143.L_CORE 0.001357
K_13868 X_NUC_76.L_CORE X_NUC_144.L_CORE 0.001357
K_13869 X_NUC_76.L_CORE X_NUC_145.L_CORE 0.002403
K_13870 X_NUC_76.L_CORE X_NUC_146.L_CORE 0.002390
K_13871 X_NUC_76.L_CORE X_NUC_147.L_CORE 0.002375
K_13872 X_NUC_76.L_CORE X_NUC_148.L_CORE 0.002388
K_13873 X_NUC_76.L_CORE X_NUC_149.L_CORE 0.001743
K_13874 X_NUC_76.L_CORE X_NUC_150.L_CORE 0.001733
K_13875 X_NUC_76.L_CORE X_NUC_151.L_CORE 0.001735
K_13876 X_NUC_76.L_CORE X_NUC_152.L_CORE 0.001729
K_13877 X_NUC_76.L_CORE X_NUC_153.L_CORE 0.001511
K_13878 X_NUC_76.L_CORE X_NUC_154.L_CORE 0.001502
K_13879 X_NUC_76.L_CORE X_NUC_155.L_CORE 0.001501
K_13880 X_NUC_76.L_CORE X_NUC_156.L_CORE 0.001504
K_13881 X_NUC_76.L_CORE X_NUC_157.L_CORE 0.002442
K_13882 X_NUC_76.L_CORE X_NUC_158.L_CORE 0.002431
K_13883 X_NUC_76.L_CORE X_NUC_159.L_CORE 0.002419
K_13884 X_NUC_76.L_CORE X_NUC_160.L_CORE 0.002417
K_13885 X_NUC_76.L_CORE X_NUC_161.L_CORE 0.001511
K_13886 X_NUC_76.L_CORE X_NUC_162.L_CORE 0.001503
K_13887 X_NUC_76.L_CORE X_NUC_163.L_CORE 0.001503
K_13888 X_NUC_76.L_CORE X_NUC_164.L_CORE 0.001502
K_13889 X_NUC_76.L_CORE X_NUC_165.L_CORE 0.001808
K_13890 X_NUC_76.L_CORE X_NUC_166.L_CORE 0.001798
K_13891 X_NUC_76.L_CORE X_NUC_167.L_CORE 0.001793
K_13892 X_NUC_76.L_CORE X_NUC_168.L_CORE 0.001797
K_13893 X_NUC_76.L_CORE X_NUC_169.L_CORE 0.001828
K_13894 X_NUC_76.L_CORE X_NUC_170.L_CORE 0.001818
K_13895 X_NUC_76.L_CORE X_NUC_171.L_CORE 0.001816
K_13896 X_NUC_76.L_CORE X_NUC_172.L_CORE 0.001814
K_13897 X_NUC_76.L_CORE X_NUC_173.L_CORE 0.002075
K_13898 X_NUC_76.L_CORE X_NUC_174.L_CORE 0.001609
K_13899 X_NUC_76.L_CORE X_NUC_175.L_CORE 0.002384
K_13900 X_NUC_76.L_CORE X_NUC_176.L_CORE 0.001820
K_13901 X_NUC_76.L_CORE X_NUC_177.L_CORE 0.001604
K_13902 X_NUC_76.L_CORE X_NUC_178.L_CORE 0.003285
K_13903 X_NUC_76.L_CORE X_NUC_179.L_CORE 0.001458
K_13904 X_NUC_76.L_CORE X_NUC_180.L_CORE 0.002117
K_13905 X_NUC_76.L_CORE X_NUC_181.L_CORE 0.002300
K_13906 X_NUC_76.L_CORE X_NUC_182.L_CORE 0.001384
K_13907 X_NUC_76.L_CORE X_NUC_183.L_CORE 0.004322
K_13908 X_NUC_76.L_CORE X_NUC_184.L_CORE 0.001549
K_13909 X_NUC_76.L_CORE X_NUC_185.L_CORE 0.001643
K_13910 X_NUC_76.L_CORE X_NUC_186.L_CORE 0.004009
K_13911 X_NUC_76.L_CORE X_NUC_187.L_CORE 0.001310
K_13912 X_NUC_76.L_CORE X_NUC_188.L_CORE 0.002808
K_13913 X_NUC_76.L_CORE X_NUC_189.L_CORE 0.001901
K_13914 X_NUC_76.L_CORE X_NUC_190.L_CORE 0.001374
K_13915 X_NUC_76.L_CORE X_NUC_191.L_CORE 0.016816
K_13916 X_NUC_76.L_CORE X_NUC_192.L_CORE 0.001367
K_13917 X_NUC_76.L_CORE X_NUC_193.L_CORE 0.001869
K_13918 X_NUC_76.L_CORE X_NUC_194.L_CORE 0.002867
K_13919 X_NUC_76.L_CORE X_NUC_195.L_CORE 0.001266
K_13920 X_NUC_76.L_CORE X_NUC_196.L_CORE 0.004380
K_13921 X_NUC_76.L_CORE X_NUC_197.L_CORE 0.001585
K_13922 X_NUC_76.L_CORE X_NUC_198.L_CORE 0.001463
K_13923 X_NUC_76.L_CORE X_NUC_199.L_CORE 0.006269
K_13924 X_NUC_76.L_CORE X_NUC_200.L_CORE 0.001277
K_13925 X_NUC_76.L_CORE X_NUC_201.L_CORE 0.002266
K_13926 X_NUC_76.L_CORE X_NUC_202.L_CORE 0.002075
K_13927 X_NUC_76.L_CORE X_NUC_203.L_CORE 0.001296
K_13928 X_NUC_76.L_CORE X_NUC_204.L_CORE 0.005470
K_13929 X_NUC_76.L_CORE X_NUC_205.L_CORE 0.001409
K_13930 X_NUC_76.L_CORE X_NUC_206.L_CORE 0.001636
K_13931 X_NUC_76.L_CORE X_NUC_207.L_CORE 0.002997
K_13932 X_NUC_76.L_CORE X_NUC_208.L_CORE 0.001267
K_13933 X_NUC_76.L_CORE X_NUC_209.L_CORE 0.002656
K_13934 X_NUC_76.L_CORE X_NUC_210.L_CORE 0.001686
K_13935 X_NUC_76.L_CORE X_NUC_211.L_CORE 0.001395
K_13936 X_NUC_76.L_CORE X_NUC_212.L_CORE 0.003345
K_13937 X_NUC_76.L_CORE X_NUC_213.L_CORE 0.001351
K_13938 X_NUC_76.L_CORE X_NUC_214.L_CORE 0.001835
K_13939 X_NUC_76.L_CORE X_NUC_215.L_CORE 0.002058
K_13940 X_NUC_76.L_CORE X_NUC_216.L_CORE 0.001344
K_13941 X_NUC_76.L_CORE X_NUC_217.L_CORE 0.002396
K_13942 X_NUC_76.L_CORE X_NUC_218.L_CORE 0.001537
K_13943 X_NUC_76.L_CORE X_NUC_219.L_CORE 0.001559
K_13944 X_NUC_76.L_CORE X_NUC_220.L_CORE 0.002059
K_13945 X_NUC_76.L_CORE X_NUC_221.L_CORE 0.001469
K_13946 X_NUC_76.L_CORE X_NUC_222.L_CORE 0.001747
K_13947 X_NUC_77.L_CORE X_NUC_78.L_CORE 0.207973
K_13948 X_NUC_77.L_CORE X_NUC_79.L_CORE 0.207973
K_13949 X_NUC_77.L_CORE X_NUC_80.L_CORE 0.207973
K_13950 X_NUC_77.L_CORE X_NUC_81.L_CORE 0.001400
K_13951 X_NUC_77.L_CORE X_NUC_82.L_CORE 0.001404
K_13952 X_NUC_77.L_CORE X_NUC_83.L_CORE 0.001398
K_13953 X_NUC_77.L_CORE X_NUC_84.L_CORE 0.001406
K_13954 X_NUC_77.L_CORE X_NUC_85.L_CORE 0.001927
K_13955 X_NUC_77.L_CORE X_NUC_86.L_CORE 0.001945
K_13956 X_NUC_77.L_CORE X_NUC_87.L_CORE 0.001936
K_13957 X_NUC_77.L_CORE X_NUC_88.L_CORE 0.001934
K_13958 X_NUC_77.L_CORE X_NUC_89.L_CORE 0.002914
K_13959 X_NUC_77.L_CORE X_NUC_90.L_CORE 0.002903
K_13960 X_NUC_77.L_CORE X_NUC_91.L_CORE 0.002885
K_13961 X_NUC_77.L_CORE X_NUC_92.L_CORE 0.002923
K_13962 X_NUC_77.L_CORE X_NUC_93.L_CORE 0.001307
K_13963 X_NUC_77.L_CORE X_NUC_94.L_CORE 0.001313
K_13964 X_NUC_77.L_CORE X_NUC_95.L_CORE 0.001307
K_13965 X_NUC_77.L_CORE X_NUC_96.L_CORE 0.001312
K_13966 X_NUC_77.L_CORE X_NUC_97.L_CORE 0.004327
K_13967 X_NUC_77.L_CORE X_NUC_98.L_CORE 0.004399
K_13968 X_NUC_77.L_CORE X_NUC_99.L_CORE 0.004358
K_13969 X_NUC_77.L_CORE X_NUC_100.L_CORE 0.004316
K_13970 X_NUC_77.L_CORE X_NUC_101.L_CORE 0.001633
K_13971 X_NUC_77.L_CORE X_NUC_102.L_CORE 0.001635
K_13972 X_NUC_77.L_CORE X_NUC_103.L_CORE 0.001626
K_13973 X_NUC_77.L_CORE X_NUC_104.L_CORE 0.001639
K_13974 X_NUC_77.L_CORE X_NUC_105.L_CORE 0.001520
K_13975 X_NUC_77.L_CORE X_NUC_106.L_CORE 0.001530
K_13976 X_NUC_77.L_CORE X_NUC_107.L_CORE 0.001522
K_13977 X_NUC_77.L_CORE X_NUC_108.L_CORE 0.001525
K_13978 X_NUC_77.L_CORE X_NUC_109.L_CORE 0.005149
K_13979 X_NUC_77.L_CORE X_NUC_110.L_CORE 0.005110
K_13980 X_NUC_77.L_CORE X_NUC_111.L_CORE 0.005028
K_13981 X_NUC_77.L_CORE X_NUC_112.L_CORE 0.005101
K_13982 X_NUC_77.L_CORE X_NUC_113.L_CORE 0.001336
K_13983 X_NUC_77.L_CORE X_NUC_114.L_CORE 0.001341
K_13984 X_NUC_77.L_CORE X_NUC_115.L_CORE 0.001333
K_13985 X_NUC_77.L_CORE X_NUC_116.L_CORE 0.001340
K_13986 X_NUC_77.L_CORE X_NUC_117.L_CORE 0.002296
K_13987 X_NUC_77.L_CORE X_NUC_118.L_CORE 0.002319
K_13988 X_NUC_77.L_CORE X_NUC_119.L_CORE 0.002303
K_13989 X_NUC_77.L_CORE X_NUC_120.L_CORE 0.002298
K_13990 X_NUC_77.L_CORE X_NUC_121.L_CORE 0.002101
K_13991 X_NUC_77.L_CORE X_NUC_122.L_CORE 0.002100
K_13992 X_NUC_77.L_CORE X_NUC_123.L_CORE 0.002084
K_13993 X_NUC_77.L_CORE X_NUC_124.L_CORE 0.002104
K_13994 X_NUC_77.L_CORE X_NUC_125.L_CORE 0.001370
K_13995 X_NUC_77.L_CORE X_NUC_126.L_CORE 0.001378
K_13996 X_NUC_77.L_CORE X_NUC_127.L_CORE 0.001370
K_13997 X_NUC_77.L_CORE X_NUC_128.L_CORE 0.001374
K_13998 X_NUC_77.L_CORE X_NUC_129.L_CORE 0.003998
K_13999 X_NUC_77.L_CORE X_NUC_130.L_CORE 0.004026
K_14000 X_NUC_77.L_CORE X_NUC_131.L_CORE 0.003964
K_14001 X_NUC_77.L_CORE X_NUC_132.L_CORE 0.003960
K_14002 X_NUC_77.L_CORE X_NUC_133.L_CORE 0.001490
K_14003 X_NUC_77.L_CORE X_NUC_134.L_CORE 0.001494
K_14004 X_NUC_77.L_CORE X_NUC_135.L_CORE 0.001485
K_14005 X_NUC_77.L_CORE X_NUC_136.L_CORE 0.001494
K_14006 X_NUC_77.L_CORE X_NUC_137.L_CORE 0.001711
K_14007 X_NUC_77.L_CORE X_NUC_138.L_CORE 0.001723
K_14008 X_NUC_77.L_CORE X_NUC_139.L_CORE 0.001712
K_14009 X_NUC_77.L_CORE X_NUC_140.L_CORE 0.001713
K_14010 X_NUC_77.L_CORE X_NUC_141.L_CORE 0.002650
K_14011 X_NUC_77.L_CORE X_NUC_142.L_CORE 0.002649
K_14012 X_NUC_77.L_CORE X_NUC_143.L_CORE 0.002621
K_14013 X_NUC_77.L_CORE X_NUC_144.L_CORE 0.002642
K_14014 X_NUC_77.L_CORE X_NUC_145.L_CORE 0.001381
K_14015 X_NUC_77.L_CORE X_NUC_146.L_CORE 0.001387
K_14016 X_NUC_77.L_CORE X_NUC_147.L_CORE 0.001378
K_14017 X_NUC_77.L_CORE X_NUC_148.L_CORE 0.001384
K_14018 X_NUC_77.L_CORE X_NUC_149.L_CORE 0.002381
K_14019 X_NUC_77.L_CORE X_NUC_150.L_CORE 0.002399
K_14020 X_NUC_77.L_CORE X_NUC_151.L_CORE 0.002375
K_14021 X_NUC_77.L_CORE X_NUC_152.L_CORE 0.002375
K_14022 X_NUC_77.L_CORE X_NUC_153.L_CORE 0.001754
K_14023 X_NUC_77.L_CORE X_NUC_154.L_CORE 0.001758
K_14024 X_NUC_77.L_CORE X_NUC_155.L_CORE 0.001744
K_14025 X_NUC_77.L_CORE X_NUC_156.L_CORE 0.001755
K_14026 X_NUC_77.L_CORE X_NUC_157.L_CORE 0.001542
K_14027 X_NUC_77.L_CORE X_NUC_158.L_CORE 0.001550
K_14028 X_NUC_77.L_CORE X_NUC_159.L_CORE 0.001539
K_14029 X_NUC_77.L_CORE X_NUC_160.L_CORE 0.001543
K_14030 X_NUC_77.L_CORE X_NUC_161.L_CORE 0.002338
K_14031 X_NUC_77.L_CORE X_NUC_162.L_CORE 0.002346
K_14032 X_NUC_77.L_CORE X_NUC_163.L_CORE 0.002321
K_14033 X_NUC_77.L_CORE X_NUC_164.L_CORE 0.002330
K_14034 X_NUC_77.L_CORE X_NUC_165.L_CORE 0.001564
K_14035 X_NUC_77.L_CORE X_NUC_166.L_CORE 0.001570
K_14036 X_NUC_77.L_CORE X_NUC_167.L_CORE 0.001558
K_14037 X_NUC_77.L_CORE X_NUC_168.L_CORE 0.001565
K_14038 X_NUC_77.L_CORE X_NUC_169.L_CORE 0.001802
K_14039 X_NUC_77.L_CORE X_NUC_170.L_CORE 0.001811
K_14040 X_NUC_77.L_CORE X_NUC_171.L_CORE 0.001796
K_14041 X_NUC_77.L_CORE X_NUC_172.L_CORE 0.001801
K_14042 X_NUC_77.L_CORE X_NUC_173.L_CORE 0.001856
K_14043 X_NUC_77.L_CORE X_NUC_174.L_CORE 0.002167
K_14044 X_NUC_77.L_CORE X_NUC_175.L_CORE 0.001529
K_14045 X_NUC_77.L_CORE X_NUC_176.L_CORE 0.002441
K_14046 X_NUC_77.L_CORE X_NUC_177.L_CORE 0.001777
K_14047 X_NUC_77.L_CORE X_NUC_178.L_CORE 0.001568
K_14048 X_NUC_77.L_CORE X_NUC_179.L_CORE 0.003370
K_14049 X_NUC_77.L_CORE X_NUC_180.L_CORE 0.001426
K_14050 X_NUC_77.L_CORE X_NUC_181.L_CORE 0.002105
K_14051 X_NUC_77.L_CORE X_NUC_182.L_CORE 0.002265
K_14052 X_NUC_77.L_CORE X_NUC_183.L_CORE 0.001364
K_14053 X_NUC_77.L_CORE X_NUC_184.L_CORE 0.004406
K_14054 X_NUC_77.L_CORE X_NUC_185.L_CORE 0.001526
K_14055 X_NUC_77.L_CORE X_NUC_186.L_CORE 0.001632
K_14056 X_NUC_77.L_CORE X_NUC_187.L_CORE 0.003949
K_14057 X_NUC_77.L_CORE X_NUC_188.L_CORE 0.001297
K_14058 X_NUC_77.L_CORE X_NUC_189.L_CORE 0.002817
K_14059 X_NUC_77.L_CORE X_NUC_190.L_CORE 0.001877
K_14060 X_NUC_77.L_CORE X_NUC_191.L_CORE 0.001369
K_14061 X_NUC_77.L_CORE X_NUC_192.L_CORE 0.016984
K_14062 X_NUC_77.L_CORE X_NUC_193.L_CORE 0.001358
K_14063 X_NUC_77.L_CORE X_NUC_194.L_CORE 0.001873
K_14064 X_NUC_77.L_CORE X_NUC_195.L_CORE 0.002828
K_14065 X_NUC_77.L_CORE X_NUC_196.L_CORE 0.001264
K_14066 X_NUC_77.L_CORE X_NUC_197.L_CORE 0.004446
K_14067 X_NUC_77.L_CORE X_NUC_198.L_CORE 0.001577
K_14068 X_NUC_77.L_CORE X_NUC_199.L_CORE 0.001468
K_14069 X_NUC_77.L_CORE X_NUC_200.L_CORE 0.006113
K_14070 X_NUC_77.L_CORE X_NUC_201.L_CORE 0.001278
K_14071 X_NUC_77.L_CORE X_NUC_202.L_CORE 0.002288
K_14072 X_NUC_77.L_CORE X_NUC_203.L_CORE 0.002067
K_14073 X_NUC_77.L_CORE X_NUC_204.L_CORE 0.001303
K_14074 X_NUC_77.L_CORE X_NUC_205.L_CORE 0.005492
K_14075 X_NUC_77.L_CORE X_NUC_206.L_CORE 0.001414
K_14076 X_NUC_77.L_CORE X_NUC_207.L_CORE 0.001652
K_14077 X_NUC_77.L_CORE X_NUC_208.L_CORE 0.002975
K_14078 X_NUC_77.L_CORE X_NUC_209.L_CORE 0.001278
K_14079 X_NUC_77.L_CORE X_NUC_210.L_CORE 0.002681
K_14080 X_NUC_77.L_CORE X_NUC_211.L_CORE 0.001694
K_14081 X_NUC_77.L_CORE X_NUC_212.L_CORE 0.001414
K_14082 X_NUC_77.L_CORE X_NUC_213.L_CORE 0.003294
K_14083 X_NUC_77.L_CORE X_NUC_214.L_CORE 0.001369
K_14084 X_NUC_77.L_CORE X_NUC_215.L_CORE 0.001859
K_14085 X_NUC_77.L_CORE X_NUC_216.L_CORE 0.002057
K_14086 X_NUC_77.L_CORE X_NUC_217.L_CORE 0.001373
K_14087 X_NUC_77.L_CORE X_NUC_218.L_CORE 0.002362
K_14088 X_NUC_77.L_CORE X_NUC_219.L_CORE 0.001566
K_14089 X_NUC_77.L_CORE X_NUC_220.L_CORE 0.001597
K_14090 X_NUC_77.L_CORE X_NUC_221.L_CORE 0.001991
K_14091 X_NUC_77.L_CORE X_NUC_222.L_CORE 0.001563
K_14092 X_NUC_78.L_CORE X_NUC_79.L_CORE 0.207973
K_14093 X_NUC_78.L_CORE X_NUC_80.L_CORE 0.207973
K_14094 X_NUC_78.L_CORE X_NUC_81.L_CORE 0.001396
K_14095 X_NUC_78.L_CORE X_NUC_82.L_CORE 0.001400
K_14096 X_NUC_78.L_CORE X_NUC_83.L_CORE 0.001394
K_14097 X_NUC_78.L_CORE X_NUC_84.L_CORE 0.001402
K_14098 X_NUC_78.L_CORE X_NUC_85.L_CORE 0.001909
K_14099 X_NUC_78.L_CORE X_NUC_86.L_CORE 0.001927
K_14100 X_NUC_78.L_CORE X_NUC_87.L_CORE 0.001918
K_14101 X_NUC_78.L_CORE X_NUC_88.L_CORE 0.001917
K_14102 X_NUC_78.L_CORE X_NUC_89.L_CORE 0.002925
K_14103 X_NUC_78.L_CORE X_NUC_90.L_CORE 0.002914
K_14104 X_NUC_78.L_CORE X_NUC_91.L_CORE 0.002896
K_14105 X_NUC_78.L_CORE X_NUC_92.L_CORE 0.002935
K_14106 X_NUC_78.L_CORE X_NUC_93.L_CORE 0.001300
K_14107 X_NUC_78.L_CORE X_NUC_94.L_CORE 0.001307
K_14108 X_NUC_78.L_CORE X_NUC_95.L_CORE 0.001301
K_14109 X_NUC_78.L_CORE X_NUC_96.L_CORE 0.001306
K_14110 X_NUC_78.L_CORE X_NUC_97.L_CORE 0.004256
K_14111 X_NUC_78.L_CORE X_NUC_98.L_CORE 0.004327
K_14112 X_NUC_78.L_CORE X_NUC_99.L_CORE 0.004287
K_14113 X_NUC_78.L_CORE X_NUC_100.L_CORE 0.004247
K_14114 X_NUC_78.L_CORE X_NUC_101.L_CORE 0.001631
K_14115 X_NUC_78.L_CORE X_NUC_102.L_CORE 0.001633
K_14116 X_NUC_78.L_CORE X_NUC_103.L_CORE 0.001624
K_14117 X_NUC_78.L_CORE X_NUC_104.L_CORE 0.001636
K_14118 X_NUC_78.L_CORE X_NUC_105.L_CORE 0.001509
K_14119 X_NUC_78.L_CORE X_NUC_106.L_CORE 0.001520
K_14120 X_NUC_78.L_CORE X_NUC_107.L_CORE 0.001512
K_14121 X_NUC_78.L_CORE X_NUC_108.L_CORE 0.001514
K_14122 X_NUC_78.L_CORE X_NUC_109.L_CORE 0.005187
K_14123 X_NUC_78.L_CORE X_NUC_110.L_CORE 0.005149
K_14124 X_NUC_78.L_CORE X_NUC_111.L_CORE 0.005064
K_14125 X_NUC_78.L_CORE X_NUC_112.L_CORE 0.005139
K_14126 X_NUC_78.L_CORE X_NUC_113.L_CORE 0.001331
K_14127 X_NUC_78.L_CORE X_NUC_114.L_CORE 0.001336
K_14128 X_NUC_78.L_CORE X_NUC_115.L_CORE 0.001329
K_14129 X_NUC_78.L_CORE X_NUC_116.L_CORE 0.001335
K_14130 X_NUC_78.L_CORE X_NUC_117.L_CORE 0.002274
K_14131 X_NUC_78.L_CORE X_NUC_118.L_CORE 0.002296
K_14132 X_NUC_78.L_CORE X_NUC_119.L_CORE 0.002280
K_14133 X_NUC_78.L_CORE X_NUC_120.L_CORE 0.002275
K_14134 X_NUC_78.L_CORE X_NUC_121.L_CORE 0.002101
K_14135 X_NUC_78.L_CORE X_NUC_122.L_CORE 0.002101
K_14136 X_NUC_78.L_CORE X_NUC_123.L_CORE 0.002085
K_14137 X_NUC_78.L_CORE X_NUC_124.L_CORE 0.002104
K_14138 X_NUC_78.L_CORE X_NUC_125.L_CORE 0.001363
K_14139 X_NUC_78.L_CORE X_NUC_126.L_CORE 0.001370
K_14140 X_NUC_78.L_CORE X_NUC_127.L_CORE 0.001362
K_14141 X_NUC_78.L_CORE X_NUC_128.L_CORE 0.001367
K_14142 X_NUC_78.L_CORE X_NUC_129.L_CORE 0.003970
K_14143 X_NUC_78.L_CORE X_NUC_130.L_CORE 0.003998
K_14144 X_NUC_78.L_CORE X_NUC_131.L_CORE 0.003936
K_14145 X_NUC_78.L_CORE X_NUC_132.L_CORE 0.003933
K_14146 X_NUC_78.L_CORE X_NUC_133.L_CORE 0.001486
K_14147 X_NUC_78.L_CORE X_NUC_134.L_CORE 0.001490
K_14148 X_NUC_78.L_CORE X_NUC_135.L_CORE 0.001481
K_14149 X_NUC_78.L_CORE X_NUC_136.L_CORE 0.001490
K_14150 X_NUC_78.L_CORE X_NUC_137.L_CORE 0.001699
K_14151 X_NUC_78.L_CORE X_NUC_138.L_CORE 0.001711
K_14152 X_NUC_78.L_CORE X_NUC_139.L_CORE 0.001700
K_14153 X_NUC_78.L_CORE X_NUC_140.L_CORE 0.001701
K_14154 X_NUC_78.L_CORE X_NUC_141.L_CORE 0.002651
K_14155 X_NUC_78.L_CORE X_NUC_142.L_CORE 0.002650
K_14156 X_NUC_78.L_CORE X_NUC_143.L_CORE 0.002622
K_14157 X_NUC_78.L_CORE X_NUC_144.L_CORE 0.002643
K_14158 X_NUC_78.L_CORE X_NUC_145.L_CORE 0.001375
K_14159 X_NUC_78.L_CORE X_NUC_146.L_CORE 0.001381
K_14160 X_NUC_78.L_CORE X_NUC_147.L_CORE 0.001372
K_14161 X_NUC_78.L_CORE X_NUC_148.L_CORE 0.001378
K_14162 X_NUC_78.L_CORE X_NUC_149.L_CORE 0.002364
K_14163 X_NUC_78.L_CORE X_NUC_150.L_CORE 0.002381
K_14164 X_NUC_78.L_CORE X_NUC_151.L_CORE 0.002358
K_14165 X_NUC_78.L_CORE X_NUC_152.L_CORE 0.002358
K_14166 X_NUC_78.L_CORE X_NUC_153.L_CORE 0.001751
K_14167 X_NUC_78.L_CORE X_NUC_154.L_CORE 0.001754
K_14168 X_NUC_78.L_CORE X_NUC_155.L_CORE 0.001741
K_14169 X_NUC_78.L_CORE X_NUC_156.L_CORE 0.001752
K_14170 X_NUC_78.L_CORE X_NUC_157.L_CORE 0.001533
K_14171 X_NUC_78.L_CORE X_NUC_158.L_CORE 0.001542
K_14172 X_NUC_78.L_CORE X_NUC_159.L_CORE 0.001531
K_14173 X_NUC_78.L_CORE X_NUC_160.L_CORE 0.001535
K_14174 X_NUC_78.L_CORE X_NUC_161.L_CORE 0.002329
K_14175 X_NUC_78.L_CORE X_NUC_162.L_CORE 0.002338
K_14176 X_NUC_78.L_CORE X_NUC_163.L_CORE 0.002313
K_14177 X_NUC_78.L_CORE X_NUC_164.L_CORE 0.002322
K_14178 X_NUC_78.L_CORE X_NUC_165.L_CORE 0.001558
K_14179 X_NUC_78.L_CORE X_NUC_166.L_CORE 0.001564
K_14180 X_NUC_78.L_CORE X_NUC_167.L_CORE 0.001552
K_14181 X_NUC_78.L_CORE X_NUC_168.L_CORE 0.001559
K_14182 X_NUC_78.L_CORE X_NUC_169.L_CORE 0.001793
K_14183 X_NUC_78.L_CORE X_NUC_170.L_CORE 0.001802
K_14184 X_NUC_78.L_CORE X_NUC_171.L_CORE 0.001787
K_14185 X_NUC_78.L_CORE X_NUC_172.L_CORE 0.001792
K_14186 X_NUC_78.L_CORE X_NUC_173.L_CORE 0.001845
K_14187 X_NUC_78.L_CORE X_NUC_174.L_CORE 0.002160
K_14188 X_NUC_78.L_CORE X_NUC_175.L_CORE 0.001522
K_14189 X_NUC_78.L_CORE X_NUC_176.L_CORE 0.002423
K_14190 X_NUC_78.L_CORE X_NUC_177.L_CORE 0.001773
K_14191 X_NUC_78.L_CORE X_NUC_178.L_CORE 0.001558
K_14192 X_NUC_78.L_CORE X_NUC_179.L_CORE 0.003362
K_14193 X_NUC_78.L_CORE X_NUC_180.L_CORE 0.001421
K_14194 X_NUC_78.L_CORE X_NUC_181.L_CORE 0.002086
K_14195 X_NUC_78.L_CORE X_NUC_182.L_CORE 0.002266
K_14196 X_NUC_78.L_CORE X_NUC_183.L_CORE 0.001357
K_14197 X_NUC_78.L_CORE X_NUC_184.L_CORE 0.004357
K_14198 X_NUC_78.L_CORE X_NUC_185.L_CORE 0.001522
K_14199 X_NUC_78.L_CORE X_NUC_186.L_CORE 0.001620
K_14200 X_NUC_78.L_CORE X_NUC_187.L_CORE 0.003976
K_14201 X_NUC_78.L_CORE X_NUC_188.L_CORE 0.001292
K_14202 X_NUC_78.L_CORE X_NUC_189.L_CORE 0.002784
K_14203 X_NUC_78.L_CORE X_NUC_190.L_CORE 0.001877
K_14204 X_NUC_78.L_CORE X_NUC_191.L_CORE 0.001360
K_14205 X_NUC_78.L_CORE X_NUC_192.L_CORE 0.017382
K_14206 X_NUC_78.L_CORE X_NUC_193.L_CORE 0.001354
K_14207 X_NUC_78.L_CORE X_NUC_194.L_CORE 0.001856
K_14208 X_NUC_78.L_CORE X_NUC_195.L_CORE 0.002841
K_14209 X_NUC_78.L_CORE X_NUC_196.L_CORE 0.001258
K_14210 X_NUC_78.L_CORE X_NUC_197.L_CORE 0.004374
K_14211 X_NUC_78.L_CORE X_NUC_198.L_CORE 0.001575
K_14212 X_NUC_78.L_CORE X_NUC_199.L_CORE 0.001458
K_14213 X_NUC_78.L_CORE X_NUC_200.L_CORE 0.006225
K_14214 X_NUC_78.L_CORE X_NUC_201.L_CORE 0.001274
K_14215 X_NUC_78.L_CORE X_NUC_202.L_CORE 0.002265
K_14216 X_NUC_78.L_CORE X_NUC_203.L_CORE 0.002070
K_14217 X_NUC_78.L_CORE X_NUC_204.L_CORE 0.001296
K_14218 X_NUC_78.L_CORE X_NUC_205.L_CORE 0.005449
K_14219 X_NUC_78.L_CORE X_NUC_206.L_CORE 0.001410
K_14220 X_NUC_78.L_CORE X_NUC_207.L_CORE 0.001640
K_14221 X_NUC_78.L_CORE X_NUC_208.L_CORE 0.002987
K_14222 X_NUC_78.L_CORE X_NUC_209.L_CORE 0.001272
K_14223 X_NUC_78.L_CORE X_NUC_210.L_CORE 0.002657
K_14224 X_NUC_78.L_CORE X_NUC_211.L_CORE 0.001693
K_14225 X_NUC_78.L_CORE X_NUC_212.L_CORE 0.001406
K_14226 X_NUC_78.L_CORE X_NUC_213.L_CORE 0.003292
K_14227 X_NUC_78.L_CORE X_NUC_214.L_CORE 0.001364
K_14228 X_NUC_78.L_CORE X_NUC_215.L_CORE 0.001845
K_14229 X_NUC_78.L_CORE X_NUC_216.L_CORE 0.002056
K_14230 X_NUC_78.L_CORE X_NUC_217.L_CORE 0.001367
K_14231 X_NUC_78.L_CORE X_NUC_218.L_CORE 0.002350
K_14232 X_NUC_78.L_CORE X_NUC_219.L_CORE 0.001562
K_14233 X_NUC_78.L_CORE X_NUC_220.L_CORE 0.001588
K_14234 X_NUC_78.L_CORE X_NUC_221.L_CORE 0.001986
K_14235 X_NUC_78.L_CORE X_NUC_222.L_CORE 0.001557
K_14236 X_NUC_79.L_CORE X_NUC_80.L_CORE 0.207973
K_14237 X_NUC_79.L_CORE X_NUC_81.L_CORE 0.001403
K_14238 X_NUC_79.L_CORE X_NUC_82.L_CORE 0.001407
K_14239 X_NUC_79.L_CORE X_NUC_83.L_CORE 0.001400
K_14240 X_NUC_79.L_CORE X_NUC_84.L_CORE 0.001409
K_14241 X_NUC_79.L_CORE X_NUC_85.L_CORE 0.001918
K_14242 X_NUC_79.L_CORE X_NUC_86.L_CORE 0.001936
K_14243 X_NUC_79.L_CORE X_NUC_87.L_CORE 0.001927
K_14244 X_NUC_79.L_CORE X_NUC_88.L_CORE 0.001925
K_14245 X_NUC_79.L_CORE X_NUC_89.L_CORE 0.002944
K_14246 X_NUC_79.L_CORE X_NUC_90.L_CORE 0.002932
K_14247 X_NUC_79.L_CORE X_NUC_91.L_CORE 0.002914
K_14248 X_NUC_79.L_CORE X_NUC_92.L_CORE 0.002954
K_14249 X_NUC_79.L_CORE X_NUC_93.L_CORE 0.001307
K_14250 X_NUC_79.L_CORE X_NUC_94.L_CORE 0.001313
K_14251 X_NUC_79.L_CORE X_NUC_95.L_CORE 0.001307
K_14252 X_NUC_79.L_CORE X_NUC_96.L_CORE 0.001312
K_14253 X_NUC_79.L_CORE X_NUC_97.L_CORE 0.004294
K_14254 X_NUC_79.L_CORE X_NUC_98.L_CORE 0.004365
K_14255 X_NUC_79.L_CORE X_NUC_99.L_CORE 0.004327
K_14256 X_NUC_79.L_CORE X_NUC_100.L_CORE 0.004284
K_14257 X_NUC_79.L_CORE X_NUC_101.L_CORE 0.001640
K_14258 X_NUC_79.L_CORE X_NUC_102.L_CORE 0.001642
K_14259 X_NUC_79.L_CORE X_NUC_103.L_CORE 0.001633
K_14260 X_NUC_79.L_CORE X_NUC_104.L_CORE 0.001646
K_14261 X_NUC_79.L_CORE X_NUC_105.L_CORE 0.001517
K_14262 X_NUC_79.L_CORE X_NUC_106.L_CORE 0.001528
K_14263 X_NUC_79.L_CORE X_NUC_107.L_CORE 0.001520
K_14264 X_NUC_79.L_CORE X_NUC_108.L_CORE 0.001522
K_14265 X_NUC_79.L_CORE X_NUC_109.L_CORE 0.005276
K_14266 X_NUC_79.L_CORE X_NUC_110.L_CORE 0.005235
K_14267 X_NUC_79.L_CORE X_NUC_111.L_CORE 0.005149
K_14268 X_NUC_79.L_CORE X_NUC_112.L_CORE 0.005227
K_14269 X_NUC_79.L_CORE X_NUC_113.L_CORE 0.001338
K_14270 X_NUC_79.L_CORE X_NUC_114.L_CORE 0.001343
K_14271 X_NUC_79.L_CORE X_NUC_115.L_CORE 0.001336
K_14272 X_NUC_79.L_CORE X_NUC_116.L_CORE 0.001342
K_14273 X_NUC_79.L_CORE X_NUC_117.L_CORE 0.002290
K_14274 X_NUC_79.L_CORE X_NUC_118.L_CORE 0.002313
K_14275 X_NUC_79.L_CORE X_NUC_119.L_CORE 0.002296
K_14276 X_NUC_79.L_CORE X_NUC_120.L_CORE 0.002291
K_14277 X_NUC_79.L_CORE X_NUC_121.L_CORE 0.002117
K_14278 X_NUC_79.L_CORE X_NUC_122.L_CORE 0.002116
K_14279 X_NUC_79.L_CORE X_NUC_123.L_CORE 0.002101
K_14280 X_NUC_79.L_CORE X_NUC_124.L_CORE 0.002120
K_14281 X_NUC_79.L_CORE X_NUC_125.L_CORE 0.001370
K_14282 X_NUC_79.L_CORE X_NUC_126.L_CORE 0.001378
K_14283 X_NUC_79.L_CORE X_NUC_127.L_CORE 0.001370
K_14284 X_NUC_79.L_CORE X_NUC_128.L_CORE 0.001374
K_14285 X_NUC_79.L_CORE X_NUC_129.L_CORE 0.004033
K_14286 X_NUC_79.L_CORE X_NUC_130.L_CORE 0.004062
K_14287 X_NUC_79.L_CORE X_NUC_131.L_CORE 0.003998
K_14288 X_NUC_79.L_CORE X_NUC_132.L_CORE 0.003994
K_14289 X_NUC_79.L_CORE X_NUC_133.L_CORE 0.001495
K_14290 X_NUC_79.L_CORE X_NUC_134.L_CORE 0.001499
K_14291 X_NUC_79.L_CORE X_NUC_135.L_CORE 0.001490
K_14292 X_NUC_79.L_CORE X_NUC_136.L_CORE 0.001499
K_14293 X_NUC_79.L_CORE X_NUC_137.L_CORE 0.001710
K_14294 X_NUC_79.L_CORE X_NUC_138.L_CORE 0.001722
K_14295 X_NUC_79.L_CORE X_NUC_139.L_CORE 0.001711
K_14296 X_NUC_79.L_CORE X_NUC_140.L_CORE 0.001712
K_14297 X_NUC_79.L_CORE X_NUC_141.L_CORE 0.002680
K_14298 X_NUC_79.L_CORE X_NUC_142.L_CORE 0.002679
K_14299 X_NUC_79.L_CORE X_NUC_143.L_CORE 0.002650
K_14300 X_NUC_79.L_CORE X_NUC_144.L_CORE 0.002672
K_14301 X_NUC_79.L_CORE X_NUC_145.L_CORE 0.001384
K_14302 X_NUC_79.L_CORE X_NUC_146.L_CORE 0.001390
K_14303 X_NUC_79.L_CORE X_NUC_147.L_CORE 0.001381
K_14304 X_NUC_79.L_CORE X_NUC_148.L_CORE 0.001387
K_14305 X_NUC_79.L_CORE X_NUC_149.L_CORE 0.002387
K_14306 X_NUC_79.L_CORE X_NUC_150.L_CORE 0.002405
K_14307 X_NUC_79.L_CORE X_NUC_151.L_CORE 0.002381
K_14308 X_NUC_79.L_CORE X_NUC_152.L_CORE 0.002381
K_14309 X_NUC_79.L_CORE X_NUC_153.L_CORE 0.001764
K_14310 X_NUC_79.L_CORE X_NUC_154.L_CORE 0.001768
K_14311 X_NUC_79.L_CORE X_NUC_155.L_CORE 0.001754
K_14312 X_NUC_79.L_CORE X_NUC_156.L_CORE 0.001766
K_14313 X_NUC_79.L_CORE X_NUC_157.L_CORE 0.001544
K_14314 X_NUC_79.L_CORE X_NUC_158.L_CORE 0.001552
K_14315 X_NUC_79.L_CORE X_NUC_159.L_CORE 0.001542
K_14316 X_NUC_79.L_CORE X_NUC_160.L_CORE 0.001546
K_14317 X_NUC_79.L_CORE X_NUC_161.L_CORE 0.002355
K_14318 X_NUC_79.L_CORE X_NUC_162.L_CORE 0.002363
K_14319 X_NUC_79.L_CORE X_NUC_163.L_CORE 0.002338
K_14320 X_NUC_79.L_CORE X_NUC_164.L_CORE 0.002347
K_14321 X_NUC_79.L_CORE X_NUC_165.L_CORE 0.001570
K_14322 X_NUC_79.L_CORE X_NUC_166.L_CORE 0.001575
K_14323 X_NUC_79.L_CORE X_NUC_167.L_CORE 0.001564
K_14324 X_NUC_79.L_CORE X_NUC_168.L_CORE 0.001571
K_14325 X_NUC_79.L_CORE X_NUC_169.L_CORE 0.001808
K_14326 X_NUC_79.L_CORE X_NUC_170.L_CORE 0.001818
K_14327 X_NUC_79.L_CORE X_NUC_171.L_CORE 0.001802
K_14328 X_NUC_79.L_CORE X_NUC_172.L_CORE 0.001807
K_14329 X_NUC_79.L_CORE X_NUC_173.L_CORE 0.001846
K_14330 X_NUC_79.L_CORE X_NUC_174.L_CORE 0.002158
K_14331 X_NUC_79.L_CORE X_NUC_175.L_CORE 0.001525
K_14332 X_NUC_79.L_CORE X_NUC_176.L_CORE 0.002418
K_14333 X_NUC_79.L_CORE X_NUC_177.L_CORE 0.001775
K_14334 X_NUC_79.L_CORE X_NUC_178.L_CORE 0.001561
K_14335 X_NUC_79.L_CORE X_NUC_179.L_CORE 0.003342
K_14336 X_NUC_79.L_CORE X_NUC_180.L_CORE 0.001424
K_14337 X_NUC_79.L_CORE X_NUC_181.L_CORE 0.002087
K_14338 X_NUC_79.L_CORE X_NUC_182.L_CORE 0.002267
K_14339 X_NUC_79.L_CORE X_NUC_183.L_CORE 0.001361
K_14340 X_NUC_79.L_CORE X_NUC_184.L_CORE 0.004319
K_14341 X_NUC_79.L_CORE X_NUC_185.L_CORE 0.001527
K_14342 X_NUC_79.L_CORE X_NUC_186.L_CORE 0.001624
K_14343 X_NUC_79.L_CORE X_NUC_187.L_CORE 0.003962
K_14344 X_NUC_79.L_CORE X_NUC_188.L_CORE 0.001297
K_14345 X_NUC_79.L_CORE X_NUC_189.L_CORE 0.002785
K_14346 X_NUC_79.L_CORE X_NUC_190.L_CORE 0.001884
K_14347 X_NUC_79.L_CORE X_NUC_191.L_CORE 0.001365
K_14348 X_NUC_79.L_CORE X_NUC_192.L_CORE 0.016143
K_14349 X_NUC_79.L_CORE X_NUC_193.L_CORE 0.001360
K_14350 X_NUC_79.L_CORE X_NUC_194.L_CORE 0.001863
K_14351 X_NUC_79.L_CORE X_NUC_195.L_CORE 0.002852
K_14352 X_NUC_79.L_CORE X_NUC_196.L_CORE 0.001263
K_14353 X_NUC_79.L_CORE X_NUC_197.L_CORE 0.004389
K_14354 X_NUC_79.L_CORE X_NUC_198.L_CORE 0.001583
K_14355 X_NUC_79.L_CORE X_NUC_199.L_CORE 0.001464
K_14356 X_NUC_79.L_CORE X_NUC_200.L_CORE 0.006290
K_14357 X_NUC_79.L_CORE X_NUC_201.L_CORE 0.001280
K_14358 X_NUC_79.L_CORE X_NUC_202.L_CORE 0.002277
K_14359 X_NUC_79.L_CORE X_NUC_203.L_CORE 0.002082
K_14360 X_NUC_79.L_CORE X_NUC_204.L_CORE 0.001302
K_14361 X_NUC_79.L_CORE X_NUC_205.L_CORE 0.005535
K_14362 X_NUC_79.L_CORE X_NUC_206.L_CORE 0.001418
K_14363 X_NUC_79.L_CORE X_NUC_207.L_CORE 0.001649
K_14364 X_NUC_79.L_CORE X_NUC_208.L_CORE 0.003016
K_14365 X_NUC_79.L_CORE X_NUC_209.L_CORE 0.001279
K_14366 X_NUC_79.L_CORE X_NUC_210.L_CORE 0.002680
K_14367 X_NUC_79.L_CORE X_NUC_211.L_CORE 0.001704
K_14368 X_NUC_79.L_CORE X_NUC_212.L_CORE 0.001414
K_14369 X_NUC_79.L_CORE X_NUC_213.L_CORE 0.003336
K_14370 X_NUC_79.L_CORE X_NUC_214.L_CORE 0.001373
K_14371 X_NUC_79.L_CORE X_NUC_215.L_CORE 0.001859
K_14372 X_NUC_79.L_CORE X_NUC_216.L_CORE 0.002074
K_14373 X_NUC_79.L_CORE X_NUC_217.L_CORE 0.001375
K_14374 X_NUC_79.L_CORE X_NUC_218.L_CORE 0.002374
K_14375 X_NUC_79.L_CORE X_NUC_219.L_CORE 0.001574
K_14376 X_NUC_79.L_CORE X_NUC_220.L_CORE 0.001600
K_14377 X_NUC_79.L_CORE X_NUC_221.L_CORE 0.002004
K_14378 X_NUC_79.L_CORE X_NUC_222.L_CORE 0.001569
K_14379 X_NUC_80.L_CORE X_NUC_81.L_CORE 0.001394
K_14380 X_NUC_80.L_CORE X_NUC_82.L_CORE 0.001398
K_14381 X_NUC_80.L_CORE X_NUC_83.L_CORE 0.001392
K_14382 X_NUC_80.L_CORE X_NUC_84.L_CORE 0.001400
K_14383 X_NUC_80.L_CORE X_NUC_85.L_CORE 0.001920
K_14384 X_NUC_80.L_CORE X_NUC_86.L_CORE 0.001938
K_14385 X_NUC_80.L_CORE X_NUC_87.L_CORE 0.001929
K_14386 X_NUC_80.L_CORE X_NUC_88.L_CORE 0.001927
K_14387 X_NUC_80.L_CORE X_NUC_89.L_CORE 0.002905
K_14388 X_NUC_80.L_CORE X_NUC_90.L_CORE 0.002894
K_14389 X_NUC_80.L_CORE X_NUC_91.L_CORE 0.002876
K_14390 X_NUC_80.L_CORE X_NUC_92.L_CORE 0.002914
K_14391 X_NUC_80.L_CORE X_NUC_93.L_CORE 0.001302
K_14392 X_NUC_80.L_CORE X_NUC_94.L_CORE 0.001308
K_14393 X_NUC_80.L_CORE X_NUC_95.L_CORE 0.001302
K_14394 X_NUC_80.L_CORE X_NUC_96.L_CORE 0.001307
K_14395 X_NUC_80.L_CORE X_NUC_97.L_CORE 0.004336
K_14396 X_NUC_80.L_CORE X_NUC_98.L_CORE 0.004410
K_14397 X_NUC_80.L_CORE X_NUC_99.L_CORE 0.004369
K_14398 X_NUC_80.L_CORE X_NUC_100.L_CORE 0.004327
K_14399 X_NUC_80.L_CORE X_NUC_101.L_CORE 0.001627
K_14400 X_NUC_80.L_CORE X_NUC_102.L_CORE 0.001630
K_14401 X_NUC_80.L_CORE X_NUC_103.L_CORE 0.001621
K_14402 X_NUC_80.L_CORE X_NUC_104.L_CORE 0.001633
K_14403 X_NUC_80.L_CORE X_NUC_105.L_CORE 0.001515
K_14404 X_NUC_80.L_CORE X_NUC_106.L_CORE 0.001525
K_14405 X_NUC_80.L_CORE X_NUC_107.L_CORE 0.001518
K_14406 X_NUC_80.L_CORE X_NUC_108.L_CORE 0.001520
K_14407 X_NUC_80.L_CORE X_NUC_109.L_CORE 0.005195
K_14408 X_NUC_80.L_CORE X_NUC_110.L_CORE 0.005156
K_14409 X_NUC_80.L_CORE X_NUC_111.L_CORE 0.005072
K_14410 X_NUC_80.L_CORE X_NUC_112.L_CORE 0.005149
K_14411 X_NUC_80.L_CORE X_NUC_113.L_CORE 0.001331
K_14412 X_NUC_80.L_CORE X_NUC_114.L_CORE 0.001336
K_14413 X_NUC_80.L_CORE X_NUC_115.L_CORE 0.001329
K_14414 X_NUC_80.L_CORE X_NUC_116.L_CORE 0.001336
K_14415 X_NUC_80.L_CORE X_NUC_117.L_CORE 0.002295
K_14416 X_NUC_80.L_CORE X_NUC_118.L_CORE 0.002318
K_14417 X_NUC_80.L_CORE X_NUC_119.L_CORE 0.002301
K_14418 X_NUC_80.L_CORE X_NUC_120.L_CORE 0.002296
K_14419 X_NUC_80.L_CORE X_NUC_121.L_CORE 0.002097
K_14420 X_NUC_80.L_CORE X_NUC_122.L_CORE 0.002097
K_14421 X_NUC_80.L_CORE X_NUC_123.L_CORE 0.002081
K_14422 X_NUC_80.L_CORE X_NUC_124.L_CORE 0.002101
K_14423 X_NUC_80.L_CORE X_NUC_125.L_CORE 0.001366
K_14424 X_NUC_80.L_CORE X_NUC_126.L_CORE 0.001374
K_14425 X_NUC_80.L_CORE X_NUC_127.L_CORE 0.001366
K_14426 X_NUC_80.L_CORE X_NUC_128.L_CORE 0.001370
K_14427 X_NUC_80.L_CORE X_NUC_129.L_CORE 0.004036
K_14428 X_NUC_80.L_CORE X_NUC_130.L_CORE 0.004066
K_14429 X_NUC_80.L_CORE X_NUC_131.L_CORE 0.004001
K_14430 X_NUC_80.L_CORE X_NUC_132.L_CORE 0.003998
K_14431 X_NUC_80.L_CORE X_NUC_133.L_CORE 0.001486
K_14432 X_NUC_80.L_CORE X_NUC_134.L_CORE 0.001490
K_14433 X_NUC_80.L_CORE X_NUC_135.L_CORE 0.001481
K_14434 X_NUC_80.L_CORE X_NUC_136.L_CORE 0.001490
K_14435 X_NUC_80.L_CORE X_NUC_137.L_CORE 0.001709
K_14436 X_NUC_80.L_CORE X_NUC_138.L_CORE 0.001721
K_14437 X_NUC_80.L_CORE X_NUC_139.L_CORE 0.001709
K_14438 X_NUC_80.L_CORE X_NUC_140.L_CORE 0.001711
K_14439 X_NUC_80.L_CORE X_NUC_141.L_CORE 0.002657
K_14440 X_NUC_80.L_CORE X_NUC_142.L_CORE 0.002657
K_14441 X_NUC_80.L_CORE X_NUC_143.L_CORE 0.002628
K_14442 X_NUC_80.L_CORE X_NUC_144.L_CORE 0.002650
K_14443 X_NUC_80.L_CORE X_NUC_145.L_CORE 0.001378
K_14444 X_NUC_80.L_CORE X_NUC_146.L_CORE 0.001384
K_14445 X_NUC_80.L_CORE X_NUC_147.L_CORE 0.001375
K_14446 X_NUC_80.L_CORE X_NUC_148.L_CORE 0.001381
K_14447 X_NUC_80.L_CORE X_NUC_149.L_CORE 0.002387
K_14448 X_NUC_80.L_CORE X_NUC_150.L_CORE 0.002405
K_14449 X_NUC_80.L_CORE X_NUC_151.L_CORE 0.002381
K_14450 X_NUC_80.L_CORE X_NUC_152.L_CORE 0.002381
K_14451 X_NUC_80.L_CORE X_NUC_153.L_CORE 0.001753
K_14452 X_NUC_80.L_CORE X_NUC_154.L_CORE 0.001756
K_14453 X_NUC_80.L_CORE X_NUC_155.L_CORE 0.001743
K_14454 X_NUC_80.L_CORE X_NUC_156.L_CORE 0.001754
K_14455 X_NUC_80.L_CORE X_NUC_157.L_CORE 0.001540
K_14456 X_NUC_80.L_CORE X_NUC_158.L_CORE 0.001548
K_14457 X_NUC_80.L_CORE X_NUC_159.L_CORE 0.001537
K_14458 X_NUC_80.L_CORE X_NUC_160.L_CORE 0.001542
K_14459 X_NUC_80.L_CORE X_NUC_161.L_CORE 0.002345
K_14460 X_NUC_80.L_CORE X_NUC_162.L_CORE 0.002353
K_14461 X_NUC_80.L_CORE X_NUC_163.L_CORE 0.002328
K_14462 X_NUC_80.L_CORE X_NUC_164.L_CORE 0.002338
K_14463 X_NUC_80.L_CORE X_NUC_165.L_CORE 0.001562
K_14464 X_NUC_80.L_CORE X_NUC_166.L_CORE 0.001568
K_14465 X_NUC_80.L_CORE X_NUC_167.L_CORE 0.001556
K_14466 X_NUC_80.L_CORE X_NUC_168.L_CORE 0.001564
K_14467 X_NUC_80.L_CORE X_NUC_169.L_CORE 0.001803
K_14468 X_NUC_80.L_CORE X_NUC_170.L_CORE 0.001812
K_14469 X_NUC_80.L_CORE X_NUC_171.L_CORE 0.001797
K_14470 X_NUC_80.L_CORE X_NUC_172.L_CORE 0.001802
K_14471 X_NUC_80.L_CORE X_NUC_173.L_CORE 0.001840
K_14472 X_NUC_80.L_CORE X_NUC_174.L_CORE 0.002145
K_14473 X_NUC_80.L_CORE X_NUC_175.L_CORE 0.001518
K_14474 X_NUC_80.L_CORE X_NUC_176.L_CORE 0.002415
K_14475 X_NUC_80.L_CORE X_NUC_177.L_CORE 0.001763
K_14476 X_NUC_80.L_CORE X_NUC_178.L_CORE 0.001557
K_14477 X_NUC_80.L_CORE X_NUC_179.L_CORE 0.003321
K_14478 X_NUC_80.L_CORE X_NUC_180.L_CORE 0.001417
K_14479 X_NUC_80.L_CORE X_NUC_181.L_CORE 0.002089
K_14480 X_NUC_80.L_CORE X_NUC_182.L_CORE 0.002246
K_14481 X_NUC_80.L_CORE X_NUC_183.L_CORE 0.001356
K_14482 X_NUC_80.L_CORE X_NUC_184.L_CORE 0.004339
K_14483 X_NUC_80.L_CORE X_NUC_185.L_CORE 0.001517
K_14484 X_NUC_80.L_CORE X_NUC_186.L_CORE 0.001623
K_14485 X_NUC_80.L_CORE X_NUC_187.L_CORE 0.003905
K_14486 X_NUC_80.L_CORE X_NUC_188.L_CORE 0.001291
K_14487 X_NUC_80.L_CORE X_NUC_189.L_CORE 0.002799
K_14488 X_NUC_80.L_CORE X_NUC_190.L_CORE 0.001867
K_14489 X_NUC_80.L_CORE X_NUC_191.L_CORE 0.001362
K_14490 X_NUC_80.L_CORE X_NUC_192.L_CORE 0.016453
K_14491 X_NUC_80.L_CORE X_NUC_193.L_CORE 0.001352
K_14492 X_NUC_80.L_CORE X_NUC_194.L_CORE 0.001865
K_14493 X_NUC_80.L_CORE X_NUC_195.L_CORE 0.002816
K_14494 X_NUC_80.L_CORE X_NUC_196.L_CORE 0.001258
K_14495 X_NUC_80.L_CORE X_NUC_197.L_CORE 0.004448
K_14496 X_NUC_80.L_CORE X_NUC_198.L_CORE 0.001571
K_14497 X_NUC_80.L_CORE X_NUC_199.L_CORE 0.001463
K_14498 X_NUC_80.L_CORE X_NUC_200.L_CORE 0.006173
K_14499 X_NUC_80.L_CORE X_NUC_201.L_CORE 0.001274
K_14500 X_NUC_80.L_CORE X_NUC_202.L_CORE 0.002285
K_14501 X_NUC_80.L_CORE X_NUC_203.L_CORE 0.002062
K_14502 X_NUC_80.L_CORE X_NUC_204.L_CORE 0.001298
K_14503 X_NUC_80.L_CORE X_NUC_205.L_CORE 0.005589
K_14504 X_NUC_80.L_CORE X_NUC_206.L_CORE 0.001409
K_14505 X_NUC_80.L_CORE X_NUC_207.L_CORE 0.001649
K_14506 X_NUC_80.L_CORE X_NUC_208.L_CORE 0.002984
K_14507 X_NUC_80.L_CORE X_NUC_209.L_CORE 0.001274
K_14508 X_NUC_80.L_CORE X_NUC_210.L_CORE 0.002689
K_14509 X_NUC_80.L_CORE X_NUC_211.L_CORE 0.001692
K_14510 X_NUC_80.L_CORE X_NUC_212.L_CORE 0.001411
K_14511 X_NUC_80.L_CORE X_NUC_213.L_CORE 0.003323
K_14512 X_NUC_80.L_CORE X_NUC_214.L_CORE 0.001366
K_14513 X_NUC_80.L_CORE X_NUC_215.L_CORE 0.001859
K_14514 X_NUC_80.L_CORE X_NUC_216.L_CORE 0.002059
K_14515 X_NUC_80.L_CORE X_NUC_217.L_CORE 0.001371
K_14516 X_NUC_80.L_CORE X_NUC_218.L_CORE 0.002371
K_14517 X_NUC_80.L_CORE X_NUC_219.L_CORE 0.001565
K_14518 X_NUC_80.L_CORE X_NUC_220.L_CORE 0.001597
K_14519 X_NUC_80.L_CORE X_NUC_221.L_CORE 0.001996
K_14520 X_NUC_80.L_CORE X_NUC_222.L_CORE 0.001563
K_14521 X_NUC_81.L_CORE X_NUC_82.L_CORE 0.207973
K_14522 X_NUC_81.L_CORE X_NUC_83.L_CORE 0.207973
K_14523 X_NUC_81.L_CORE X_NUC_84.L_CORE 0.207973
K_14524 X_NUC_81.L_CORE X_NUC_85.L_CORE 0.001397
K_14525 X_NUC_81.L_CORE X_NUC_86.L_CORE 0.001400
K_14526 X_NUC_81.L_CORE X_NUC_87.L_CORE 0.001403
K_14527 X_NUC_81.L_CORE X_NUC_88.L_CORE 0.001394
K_14528 X_NUC_81.L_CORE X_NUC_89.L_CORE 0.001925
K_14529 X_NUC_81.L_CORE X_NUC_90.L_CORE 0.001911
K_14530 X_NUC_81.L_CORE X_NUC_91.L_CORE 0.001922
K_14531 X_NUC_81.L_CORE X_NUC_92.L_CORE 0.001912
K_14532 X_NUC_81.L_CORE X_NUC_93.L_CORE 0.002914
K_14533 X_NUC_81.L_CORE X_NUC_94.L_CORE 0.002949
K_14534 X_NUC_81.L_CORE X_NUC_95.L_CORE 0.002938
K_14535 X_NUC_81.L_CORE X_NUC_96.L_CORE 0.002916
K_14536 X_NUC_81.L_CORE X_NUC_97.L_CORE 0.001308
K_14537 X_NUC_81.L_CORE X_NUC_98.L_CORE 0.001307
K_14538 X_NUC_81.L_CORE X_NUC_99.L_CORE 0.001311
K_14539 X_NUC_81.L_CORE X_NUC_100.L_CORE 0.001303
K_14540 X_NUC_81.L_CORE X_NUC_101.L_CORE 0.004334
K_14541 X_NUC_81.L_CORE X_NUC_102.L_CORE 0.004254
K_14542 X_NUC_81.L_CORE X_NUC_103.L_CORE 0.004278
K_14543 X_NUC_81.L_CORE X_NUC_104.L_CORE 0.004260
K_14544 X_NUC_81.L_CORE X_NUC_105.L_CORE 0.001638
K_14545 X_NUC_81.L_CORE X_NUC_106.L_CORE 0.001645
K_14546 X_NUC_81.L_CORE X_NUC_107.L_CORE 0.001646
K_14547 X_NUC_81.L_CORE X_NUC_108.L_CORE 0.001635
K_14548 X_NUC_81.L_CORE X_NUC_109.L_CORE 0.001526
K_14549 X_NUC_81.L_CORE X_NUC_110.L_CORE 0.001520
K_14550 X_NUC_81.L_CORE X_NUC_111.L_CORE 0.001526
K_14551 X_NUC_81.L_CORE X_NUC_112.L_CORE 0.001517
K_14552 X_NUC_81.L_CORE X_NUC_113.L_CORE 0.005147
K_14553 X_NUC_81.L_CORE X_NUC_114.L_CORE 0.005226
K_14554 X_NUC_81.L_CORE X_NUC_115.L_CORE 0.005136
K_14555 X_NUC_81.L_CORE X_NUC_116.L_CORE 0.005102
K_14556 X_NUC_81.L_CORE X_NUC_117.L_CORE 0.001345
K_14557 X_NUC_81.L_CORE X_NUC_118.L_CORE 0.001346
K_14558 X_NUC_81.L_CORE X_NUC_119.L_CORE 0.001348
K_14559 X_NUC_81.L_CORE X_NUC_120.L_CORE 0.001340
K_14560 X_NUC_81.L_CORE X_NUC_121.L_CORE 0.002311
K_14561 X_NUC_81.L_CORE X_NUC_122.L_CORE 0.002291
K_14562 X_NUC_81.L_CORE X_NUC_123.L_CORE 0.002299
K_14563 X_NUC_81.L_CORE X_NUC_124.L_CORE 0.002287
K_14564 X_NUC_81.L_CORE X_NUC_125.L_CORE 0.002116
K_14565 X_NUC_81.L_CORE X_NUC_126.L_CORE 0.002130
K_14566 X_NUC_81.L_CORE X_NUC_127.L_CORE 0.002124
K_14567 X_NUC_81.L_CORE X_NUC_128.L_CORE 0.002110
K_14568 X_NUC_81.L_CORE X_NUC_129.L_CORE 0.001385
K_14569 X_NUC_81.L_CORE X_NUC_130.L_CORE 0.001383
K_14570 X_NUC_81.L_CORE X_NUC_131.L_CORE 0.001386
K_14571 X_NUC_81.L_CORE X_NUC_132.L_CORE 0.001378
K_14572 X_NUC_81.L_CORE X_NUC_133.L_CORE 0.003958
K_14573 X_NUC_81.L_CORE X_NUC_134.L_CORE 0.003935
K_14574 X_NUC_81.L_CORE X_NUC_135.L_CORE 0.003908
K_14575 X_NUC_81.L_CORE X_NUC_136.L_CORE 0.003889
K_14576 X_NUC_81.L_CORE X_NUC_137.L_CORE 0.001511
K_14577 X_NUC_81.L_CORE X_NUC_138.L_CORE 0.001514
K_14578 X_NUC_81.L_CORE X_NUC_139.L_CORE 0.001514
K_14579 X_NUC_81.L_CORE X_NUC_140.L_CORE 0.001505
K_14580 X_NUC_81.L_CORE X_NUC_141.L_CORE 0.001734
K_14581 X_NUC_81.L_CORE X_NUC_142.L_CORE 0.001726
K_14582 X_NUC_81.L_CORE X_NUC_143.L_CORE 0.001730
K_14583 X_NUC_81.L_CORE X_NUC_144.L_CORE 0.001720
K_14584 X_NUC_81.L_CORE X_NUC_145.L_CORE 0.002643
K_14585 X_NUC_81.L_CORE X_NUC_146.L_CORE 0.002657
K_14586 X_NUC_81.L_CORE X_NUC_147.L_CORE 0.002641
K_14587 X_NUC_81.L_CORE X_NUC_148.L_CORE 0.002624
K_14588 X_NUC_81.L_CORE X_NUC_149.L_CORE 0.001412
K_14589 X_NUC_81.L_CORE X_NUC_150.L_CORE 0.001411
K_14590 X_NUC_81.L_CORE X_NUC_151.L_CORE 0.001413
K_14591 X_NUC_81.L_CORE X_NUC_152.L_CORE 0.001404
K_14592 X_NUC_81.L_CORE X_NUC_153.L_CORE 0.002371
K_14593 X_NUC_81.L_CORE X_NUC_154.L_CORE 0.002359
K_14594 X_NUC_81.L_CORE X_NUC_155.L_CORE 0.002357
K_14595 X_NUC_81.L_CORE X_NUC_156.L_CORE 0.002344
K_14596 X_NUC_81.L_CORE X_NUC_157.L_CORE 0.001785
K_14597 X_NUC_81.L_CORE X_NUC_158.L_CORE 0.001790
K_14598 X_NUC_81.L_CORE X_NUC_159.L_CORE 0.001786
K_14599 X_NUC_81.L_CORE X_NUC_160.L_CORE 0.001775
K_14600 X_NUC_81.L_CORE X_NUC_161.L_CORE 0.001590
K_14601 X_NUC_81.L_CORE X_NUC_162.L_CORE 0.001587
K_14602 X_NUC_81.L_CORE X_NUC_163.L_CORE 0.001588
K_14603 X_NUC_81.L_CORE X_NUC_164.L_CORE 0.001579
K_14604 X_NUC_81.L_CORE X_NUC_165.L_CORE 0.002233
K_14605 X_NUC_81.L_CORE X_NUC_166.L_CORE 0.002233
K_14606 X_NUC_81.L_CORE X_NUC_167.L_CORE 0.002225
K_14607 X_NUC_81.L_CORE X_NUC_168.L_CORE 0.002212
K_14608 X_NUC_81.L_CORE X_NUC_169.L_CORE 0.001666
K_14609 X_NUC_81.L_CORE X_NUC_170.L_CORE 0.001666
K_14610 X_NUC_81.L_CORE X_NUC_171.L_CORE 0.001665
K_14611 X_NUC_81.L_CORE X_NUC_172.L_CORE 0.001655
K_14612 X_NUC_81.L_CORE X_NUC_173.L_CORE 0.001705
K_14613 X_NUC_81.L_CORE X_NUC_174.L_CORE 0.001796
K_14614 X_NUC_81.L_CORE X_NUC_175.L_CORE 0.002203
K_14615 X_NUC_81.L_CORE X_NUC_176.L_CORE 0.001462
K_14616 X_NUC_81.L_CORE X_NUC_177.L_CORE 0.002442
K_14617 X_NUC_81.L_CORE X_NUC_178.L_CORE 0.001737
K_14618 X_NUC_81.L_CORE X_NUC_179.L_CORE 0.001522
K_14619 X_NUC_81.L_CORE X_NUC_180.L_CORE 0.003411
K_14620 X_NUC_81.L_CORE X_NUC_181.L_CORE 0.001393
K_14621 X_NUC_81.L_CORE X_NUC_182.L_CORE 0.002057
K_14622 X_NUC_81.L_CORE X_NUC_183.L_CORE 0.002242
K_14623 X_NUC_81.L_CORE X_NUC_184.L_CORE 0.001337
K_14624 X_NUC_81.L_CORE X_NUC_185.L_CORE 0.004336
K_14625 X_NUC_81.L_CORE X_NUC_186.L_CORE 0.001506
K_14626 X_NUC_81.L_CORE X_NUC_187.L_CORE 0.001602
K_14627 X_NUC_81.L_CORE X_NUC_188.L_CORE 0.003951
K_14628 X_NUC_81.L_CORE X_NUC_189.L_CORE 0.001282
K_14629 X_NUC_81.L_CORE X_NUC_190.L_CORE 0.002757
K_14630 X_NUC_81.L_CORE X_NUC_191.L_CORE 0.001868
K_14631 X_NUC_81.L_CORE X_NUC_192.L_CORE 0.001353
K_14632 X_NUC_81.L_CORE X_NUC_193.L_CORE 0.016630
K_14633 X_NUC_81.L_CORE X_NUC_194.L_CORE 0.001350
K_14634 X_NUC_81.L_CORE X_NUC_195.L_CORE 0.001850
K_14635 X_NUC_81.L_CORE X_NUC_196.L_CORE 0.002842
K_14636 X_NUC_81.L_CORE X_NUC_197.L_CORE 0.001257
K_14637 X_NUC_81.L_CORE X_NUC_198.L_CORE 0.004364
K_14638 X_NUC_81.L_CORE X_NUC_199.L_CORE 0.001579
K_14639 X_NUC_81.L_CORE X_NUC_200.L_CORE 0.001460
K_14640 X_NUC_81.L_CORE X_NUC_201.L_CORE 0.006300
K_14641 X_NUC_81.L_CORE X_NUC_202.L_CORE 0.001279
K_14642 X_NUC_81.L_CORE X_NUC_203.L_CORE 0.002274
K_14643 X_NUC_81.L_CORE X_NUC_204.L_CORE 0.002085
K_14644 X_NUC_81.L_CORE X_NUC_205.L_CORE 0.001304
K_14645 X_NUC_81.L_CORE X_NUC_206.L_CORE 0.005488
K_14646 X_NUC_81.L_CORE X_NUC_207.L_CORE 0.001423
K_14647 X_NUC_81.L_CORE X_NUC_208.L_CORE 0.001654
K_14648 X_NUC_81.L_CORE X_NUC_209.L_CORE 0.003017
K_14649 X_NUC_81.L_CORE X_NUC_210.L_CORE 0.001288
K_14650 X_NUC_81.L_CORE X_NUC_211.L_CORE 0.002676
K_14651 X_NUC_81.L_CORE X_NUC_212.L_CORE 0.001716
K_14652 X_NUC_81.L_CORE X_NUC_213.L_CORE 0.001427
K_14653 X_NUC_81.L_CORE X_NUC_214.L_CORE 0.003276
K_14654 X_NUC_81.L_CORE X_NUC_215.L_CORE 0.001391
K_14655 X_NUC_81.L_CORE X_NUC_216.L_CORE 0.001870
K_14656 X_NUC_81.L_CORE X_NUC_217.L_CORE 0.002075
K_14657 X_NUC_81.L_CORE X_NUC_218.L_CORE 0.001405
K_14658 X_NUC_81.L_CORE X_NUC_219.L_CORE 0.002315
K_14659 X_NUC_81.L_CORE X_NUC_220.L_CORE 0.001607
K_14660 X_NUC_81.L_CORE X_NUC_221.L_CORE 0.001639
K_14661 X_NUC_81.L_CORE X_NUC_222.L_CORE 0.001892
K_14662 X_NUC_82.L_CORE X_NUC_83.L_CORE 0.207973
K_14663 X_NUC_82.L_CORE X_NUC_84.L_CORE 0.207973
K_14664 X_NUC_82.L_CORE X_NUC_85.L_CORE 0.001395
K_14665 X_NUC_82.L_CORE X_NUC_86.L_CORE 0.001397
K_14666 X_NUC_82.L_CORE X_NUC_87.L_CORE 0.001400
K_14667 X_NUC_82.L_CORE X_NUC_88.L_CORE 0.001391
K_14668 X_NUC_82.L_CORE X_NUC_89.L_CORE 0.001939
K_14669 X_NUC_82.L_CORE X_NUC_90.L_CORE 0.001925
K_14670 X_NUC_82.L_CORE X_NUC_91.L_CORE 0.001937
K_14671 X_NUC_82.L_CORE X_NUC_92.L_CORE 0.001926
K_14672 X_NUC_82.L_CORE X_NUC_93.L_CORE 0.002880
K_14673 X_NUC_82.L_CORE X_NUC_94.L_CORE 0.002914
K_14674 X_NUC_82.L_CORE X_NUC_95.L_CORE 0.002903
K_14675 X_NUC_82.L_CORE X_NUC_96.L_CORE 0.002882
K_14676 X_NUC_82.L_CORE X_NUC_97.L_CORE 0.001310
K_14677 X_NUC_82.L_CORE X_NUC_98.L_CORE 0.001308
K_14678 X_NUC_82.L_CORE X_NUC_99.L_CORE 0.001313
K_14679 X_NUC_82.L_CORE X_NUC_100.L_CORE 0.001305
K_14680 X_NUC_82.L_CORE X_NUC_101.L_CORE 0.004416
K_14681 X_NUC_82.L_CORE X_NUC_102.L_CORE 0.004334
K_14682 X_NUC_82.L_CORE X_NUC_103.L_CORE 0.004358
K_14683 X_NUC_82.L_CORE X_NUC_104.L_CORE 0.004339
K_14684 X_NUC_82.L_CORE X_NUC_105.L_CORE 0.001632
K_14685 X_NUC_82.L_CORE X_NUC_106.L_CORE 0.001638
K_14686 X_NUC_82.L_CORE X_NUC_107.L_CORE 0.001639
K_14687 X_NUC_82.L_CORE X_NUC_108.L_CORE 0.001628
K_14688 X_NUC_82.L_CORE X_NUC_109.L_CORE 0.001533
K_14689 X_NUC_82.L_CORE X_NUC_110.L_CORE 0.001526
K_14690 X_NUC_82.L_CORE X_NUC_111.L_CORE 0.001533
K_14691 X_NUC_82.L_CORE X_NUC_112.L_CORE 0.001524
K_14692 X_NUC_82.L_CORE X_NUC_113.L_CORE 0.005069
K_14693 X_NUC_82.L_CORE X_NUC_114.L_CORE 0.005147
K_14694 X_NUC_82.L_CORE X_NUC_115.L_CORE 0.005060
K_14695 X_NUC_82.L_CORE X_NUC_116.L_CORE 0.005027
K_14696 X_NUC_82.L_CORE X_NUC_117.L_CORE 0.001344
K_14697 X_NUC_82.L_CORE X_NUC_118.L_CORE 0.001345
K_14698 X_NUC_82.L_CORE X_NUC_119.L_CORE 0.001347
K_14699 X_NUC_82.L_CORE X_NUC_120.L_CORE 0.001339
K_14700 X_NUC_82.L_CORE X_NUC_121.L_CORE 0.002331
K_14701 X_NUC_82.L_CORE X_NUC_122.L_CORE 0.002311
K_14702 X_NUC_82.L_CORE X_NUC_123.L_CORE 0.002319
K_14703 X_NUC_82.L_CORE X_NUC_124.L_CORE 0.002307
K_14704 X_NUC_82.L_CORE X_NUC_125.L_CORE 0.002103
K_14705 X_NUC_82.L_CORE X_NUC_126.L_CORE 0.002116
K_14706 X_NUC_82.L_CORE X_NUC_127.L_CORE 0.002110
K_14707 X_NUC_82.L_CORE X_NUC_128.L_CORE 0.002096
K_14708 X_NUC_82.L_CORE X_NUC_129.L_CORE 0.001388
K_14709 X_NUC_82.L_CORE X_NUC_130.L_CORE 0.001385
K_14710 X_NUC_82.L_CORE X_NUC_131.L_CORE 0.001389
K_14711 X_NUC_82.L_CORE X_NUC_132.L_CORE 0.001381
K_14712 X_NUC_82.L_CORE X_NUC_133.L_CORE 0.003979
K_14713 X_NUC_82.L_CORE X_NUC_134.L_CORE 0.003958
K_14714 X_NUC_82.L_CORE X_NUC_135.L_CORE 0.003929
K_14715 X_NUC_82.L_CORE X_NUC_136.L_CORE 0.003910
K_14716 X_NUC_82.L_CORE X_NUC_137.L_CORE 0.001507
K_14717 X_NUC_82.L_CORE X_NUC_138.L_CORE 0.001511
K_14718 X_NUC_82.L_CORE X_NUC_139.L_CORE 0.001511
K_14719 X_NUC_82.L_CORE X_NUC_140.L_CORE 0.001501
K_14720 X_NUC_82.L_CORE X_NUC_141.L_CORE 0.001742
K_14721 X_NUC_82.L_CORE X_NUC_142.L_CORE 0.001734
K_14722 X_NUC_82.L_CORE X_NUC_143.L_CORE 0.001738
K_14723 X_NUC_82.L_CORE X_NUC_144.L_CORE 0.001728
K_14724 X_NUC_82.L_CORE X_NUC_145.L_CORE 0.002629
K_14725 X_NUC_82.L_CORE X_NUC_146.L_CORE 0.002643
K_14726 X_NUC_82.L_CORE X_NUC_147.L_CORE 0.002626
K_14727 X_NUC_82.L_CORE X_NUC_148.L_CORE 0.002610
K_14728 X_NUC_82.L_CORE X_NUC_149.L_CORE 0.001412
K_14729 X_NUC_82.L_CORE X_NUC_150.L_CORE 0.001412
K_14730 X_NUC_82.L_CORE X_NUC_151.L_CORE 0.001413
K_14731 X_NUC_82.L_CORE X_NUC_152.L_CORE 0.001405
K_14732 X_NUC_82.L_CORE X_NUC_153.L_CORE 0.002382
K_14733 X_NUC_82.L_CORE X_NUC_154.L_CORE 0.002371
K_14734 X_NUC_82.L_CORE X_NUC_155.L_CORE 0.002368
K_14735 X_NUC_82.L_CORE X_NUC_156.L_CORE 0.002355
K_14736 X_NUC_82.L_CORE X_NUC_157.L_CORE 0.001780
K_14737 X_NUC_82.L_CORE X_NUC_158.L_CORE 0.001785
K_14738 X_NUC_82.L_CORE X_NUC_159.L_CORE 0.001782
K_14739 X_NUC_82.L_CORE X_NUC_160.L_CORE 0.001770
K_14740 X_NUC_82.L_CORE X_NUC_161.L_CORE 0.001594
K_14741 X_NUC_82.L_CORE X_NUC_162.L_CORE 0.001590
K_14742 X_NUC_82.L_CORE X_NUC_163.L_CORE 0.001592
K_14743 X_NUC_82.L_CORE X_NUC_164.L_CORE 0.001582
K_14744 X_NUC_82.L_CORE X_NUC_165.L_CORE 0.002233
K_14745 X_NUC_82.L_CORE X_NUC_166.L_CORE 0.002233
K_14746 X_NUC_82.L_CORE X_NUC_167.L_CORE 0.002225
K_14747 X_NUC_82.L_CORE X_NUC_168.L_CORE 0.002212
K_14748 X_NUC_82.L_CORE X_NUC_169.L_CORE 0.001666
K_14749 X_NUC_82.L_CORE X_NUC_170.L_CORE 0.001666
K_14750 X_NUC_82.L_CORE X_NUC_171.L_CORE 0.001665
K_14751 X_NUC_82.L_CORE X_NUC_172.L_CORE 0.001655
K_14752 X_NUC_82.L_CORE X_NUC_173.L_CORE 0.001704
K_14753 X_NUC_82.L_CORE X_NUC_174.L_CORE 0.001801
K_14754 X_NUC_82.L_CORE X_NUC_175.L_CORE 0.002198
K_14755 X_NUC_82.L_CORE X_NUC_176.L_CORE 0.001463
K_14756 X_NUC_82.L_CORE X_NUC_177.L_CORE 0.002454
K_14757 X_NUC_82.L_CORE X_NUC_178.L_CORE 0.001732
K_14758 X_NUC_82.L_CORE X_NUC_179.L_CORE 0.001526
K_14759 X_NUC_82.L_CORE X_NUC_180.L_CORE 0.003400
K_14760 X_NUC_82.L_CORE X_NUC_181.L_CORE 0.001392
K_14761 X_NUC_82.L_CORE X_NUC_182.L_CORE 0.002071
K_14762 X_NUC_82.L_CORE X_NUC_183.L_CORE 0.002227
K_14763 X_NUC_82.L_CORE X_NUC_184.L_CORE 0.001340
K_14764 X_NUC_82.L_CORE X_NUC_185.L_CORE 0.004387
K_14765 X_NUC_82.L_CORE X_NUC_186.L_CORE 0.001502
K_14766 X_NUC_82.L_CORE X_NUC_187.L_CORE 0.001610
K_14767 X_NUC_82.L_CORE X_NUC_188.L_CORE 0.003893
K_14768 X_NUC_82.L_CORE X_NUC_189.L_CORE 0.001282
K_14769 X_NUC_82.L_CORE X_NUC_190.L_CORE 0.002791
K_14770 X_NUC_82.L_CORE X_NUC_191.L_CORE 0.001856
K_14771 X_NUC_82.L_CORE X_NUC_192.L_CORE 0.001357
K_14772 X_NUC_82.L_CORE X_NUC_193.L_CORE 0.016582
K_14773 X_NUC_82.L_CORE X_NUC_194.L_CORE 0.001348
K_14774 X_NUC_82.L_CORE X_NUC_195.L_CORE 0.001863
K_14775 X_NUC_82.L_CORE X_NUC_196.L_CORE 0.002808
K_14776 X_NUC_82.L_CORE X_NUC_197.L_CORE 0.001258
K_14777 X_NUC_82.L_CORE X_NUC_198.L_CORE 0.004456
K_14778 X_NUC_82.L_CORE X_NUC_199.L_CORE 0.001572
K_14779 X_NUC_82.L_CORE X_NUC_200.L_CORE 0.001467
K_14780 X_NUC_82.L_CORE X_NUC_201.L_CORE 0.006138
K_14781 X_NUC_82.L_CORE X_NUC_202.L_CORE 0.001278
K_14782 X_NUC_82.L_CORE X_NUC_203.L_CORE 0.002296
K_14783 X_NUC_82.L_CORE X_NUC_204.L_CORE 0.002070
K_14784 X_NUC_82.L_CORE X_NUC_205.L_CORE 0.001307
K_14785 X_NUC_82.L_CORE X_NUC_206.L_CORE 0.005556
K_14786 X_NUC_82.L_CORE X_NUC_207.L_CORE 0.001420
K_14787 X_NUC_82.L_CORE X_NUC_208.L_CORE 0.001663
K_14788 X_NUC_82.L_CORE X_NUC_209.L_CORE 0.002988
K_14789 X_NUC_82.L_CORE X_NUC_210.L_CORE 0.001288
K_14790 X_NUC_82.L_CORE X_NUC_211.L_CORE 0.002700
K_14791 X_NUC_82.L_CORE X_NUC_212.L_CORE 0.001709
K_14792 X_NUC_82.L_CORE X_NUC_213.L_CORE 0.001432
K_14793 X_NUC_82.L_CORE X_NUC_214.L_CORE 0.003271
K_14794 X_NUC_82.L_CORE X_NUC_215.L_CORE 0.001390
K_14795 X_NUC_82.L_CORE X_NUC_216.L_CORE 0.001880
K_14796 X_NUC_82.L_CORE X_NUC_217.L_CORE 0.002067
K_14797 X_NUC_82.L_CORE X_NUC_218.L_CORE 0.001406
K_14798 X_NUC_82.L_CORE X_NUC_219.L_CORE 0.002322
K_14799 X_NUC_82.L_CORE X_NUC_220.L_CORE 0.001605
K_14800 X_NUC_82.L_CORE X_NUC_221.L_CORE 0.001643
K_14801 X_NUC_82.L_CORE X_NUC_222.L_CORE 0.001892
K_14802 X_NUC_83.L_CORE X_NUC_84.L_CORE 0.207973
K_14803 X_NUC_83.L_CORE X_NUC_85.L_CORE 0.001392
K_14804 X_NUC_83.L_CORE X_NUC_86.L_CORE 0.001394
K_14805 X_NUC_83.L_CORE X_NUC_87.L_CORE 0.001397
K_14806 X_NUC_83.L_CORE X_NUC_88.L_CORE 0.001388
K_14807 X_NUC_83.L_CORE X_NUC_89.L_CORE 0.001927
K_14808 X_NUC_83.L_CORE X_NUC_90.L_CORE 0.001913
K_14809 X_NUC_83.L_CORE X_NUC_91.L_CORE 0.001925
K_14810 X_NUC_83.L_CORE X_NUC_92.L_CORE 0.001914
K_14811 X_NUC_83.L_CORE X_NUC_93.L_CORE 0.002891
K_14812 X_NUC_83.L_CORE X_NUC_94.L_CORE 0.002925
K_14813 X_NUC_83.L_CORE X_NUC_95.L_CORE 0.002914
K_14814 X_NUC_83.L_CORE X_NUC_96.L_CORE 0.002893
K_14815 X_NUC_83.L_CORE X_NUC_97.L_CORE 0.001306
K_14816 X_NUC_83.L_CORE X_NUC_98.L_CORE 0.001304
K_14817 X_NUC_83.L_CORE X_NUC_99.L_CORE 0.001308
K_14818 X_NUC_83.L_CORE X_NUC_100.L_CORE 0.001300
K_14819 X_NUC_83.L_CORE X_NUC_101.L_CORE 0.004390
K_14820 X_NUC_83.L_CORE X_NUC_102.L_CORE 0.004308
K_14821 X_NUC_83.L_CORE X_NUC_103.L_CORE 0.004334
K_14822 X_NUC_83.L_CORE X_NUC_104.L_CORE 0.004314
K_14823 X_NUC_83.L_CORE X_NUC_105.L_CORE 0.001631
K_14824 X_NUC_83.L_CORE X_NUC_106.L_CORE 0.001638
K_14825 X_NUC_83.L_CORE X_NUC_107.L_CORE 0.001638
K_14826 X_NUC_83.L_CORE X_NUC_108.L_CORE 0.001628
K_14827 X_NUC_83.L_CORE X_NUC_109.L_CORE 0.001527
K_14828 X_NUC_83.L_CORE X_NUC_110.L_CORE 0.001520
K_14829 X_NUC_83.L_CORE X_NUC_111.L_CORE 0.001526
K_14830 X_NUC_83.L_CORE X_NUC_112.L_CORE 0.001518
K_14831 X_NUC_83.L_CORE X_NUC_113.L_CORE 0.005155
K_14832 X_NUC_83.L_CORE X_NUC_114.L_CORE 0.005236
K_14833 X_NUC_83.L_CORE X_NUC_115.L_CORE 0.005147
K_14834 X_NUC_83.L_CORE X_NUC_116.L_CORE 0.005111
K_14835 X_NUC_83.L_CORE X_NUC_117.L_CORE 0.001342
K_14836 X_NUC_83.L_CORE X_NUC_118.L_CORE 0.001342
K_14837 X_NUC_83.L_CORE X_NUC_119.L_CORE 0.001345
K_14838 X_NUC_83.L_CORE X_NUC_120.L_CORE 0.001337
K_14839 X_NUC_83.L_CORE X_NUC_121.L_CORE 0.002322
K_14840 X_NUC_83.L_CORE X_NUC_122.L_CORE 0.002302
K_14841 X_NUC_83.L_CORE X_NUC_123.L_CORE 0.002311
K_14842 X_NUC_83.L_CORE X_NUC_124.L_CORE 0.002298
K_14843 X_NUC_83.L_CORE X_NUC_125.L_CORE 0.002109
K_14844 X_NUC_83.L_CORE X_NUC_126.L_CORE 0.002122
K_14845 X_NUC_83.L_CORE X_NUC_127.L_CORE 0.002116
K_14846 X_NUC_83.L_CORE X_NUC_128.L_CORE 0.002102
K_14847 X_NUC_83.L_CORE X_NUC_129.L_CORE 0.001385
K_14848 X_NUC_83.L_CORE X_NUC_130.L_CORE 0.001382
K_14849 X_NUC_83.L_CORE X_NUC_131.L_CORE 0.001385
K_14850 X_NUC_83.L_CORE X_NUC_132.L_CORE 0.001377
K_14851 X_NUC_83.L_CORE X_NUC_133.L_CORE 0.004008
K_14852 X_NUC_83.L_CORE X_NUC_134.L_CORE 0.003985
K_14853 X_NUC_83.L_CORE X_NUC_135.L_CORE 0.003958
K_14854 X_NUC_83.L_CORE X_NUC_136.L_CORE 0.003938
K_14855 X_NUC_83.L_CORE X_NUC_137.L_CORE 0.001507
K_14856 X_NUC_83.L_CORE X_NUC_138.L_CORE 0.001510
K_14857 X_NUC_83.L_CORE X_NUC_139.L_CORE 0.001511
K_14858 X_NUC_83.L_CORE X_NUC_140.L_CORE 0.001501
K_14859 X_NUC_83.L_CORE X_NUC_141.L_CORE 0.001738
K_14860 X_NUC_83.L_CORE X_NUC_142.L_CORE 0.001730
K_14861 X_NUC_83.L_CORE X_NUC_143.L_CORE 0.001734
K_14862 X_NUC_83.L_CORE X_NUC_144.L_CORE 0.001724
K_14863 X_NUC_83.L_CORE X_NUC_145.L_CORE 0.002645
K_14864 X_NUC_83.L_CORE X_NUC_146.L_CORE 0.002660
K_14865 X_NUC_83.L_CORE X_NUC_147.L_CORE 0.002643
K_14866 X_NUC_83.L_CORE X_NUC_148.L_CORE 0.002626
K_14867 X_NUC_83.L_CORE X_NUC_149.L_CORE 0.001411
K_14868 X_NUC_83.L_CORE X_NUC_150.L_CORE 0.001410
K_14869 X_NUC_83.L_CORE X_NUC_151.L_CORE 0.001412
K_14870 X_NUC_83.L_CORE X_NUC_152.L_CORE 0.001403
K_14871 X_NUC_83.L_CORE X_NUC_153.L_CORE 0.002385
K_14872 X_NUC_83.L_CORE X_NUC_154.L_CORE 0.002373
K_14873 X_NUC_83.L_CORE X_NUC_155.L_CORE 0.002371
K_14874 X_NUC_83.L_CORE X_NUC_156.L_CORE 0.002358
K_14875 X_NUC_83.L_CORE X_NUC_157.L_CORE 0.001783
K_14876 X_NUC_83.L_CORE X_NUC_158.L_CORE 0.001788
K_14877 X_NUC_83.L_CORE X_NUC_159.L_CORE 0.001785
K_14878 X_NUC_83.L_CORE X_NUC_160.L_CORE 0.001774
K_14879 X_NUC_83.L_CORE X_NUC_161.L_CORE 0.001592
K_14880 X_NUC_83.L_CORE X_NUC_162.L_CORE 0.001589
K_14881 X_NUC_83.L_CORE X_NUC_163.L_CORE 0.001590
K_14882 X_NUC_83.L_CORE X_NUC_164.L_CORE 0.001581
K_14883 X_NUC_83.L_CORE X_NUC_165.L_CORE 0.002241
K_14884 X_NUC_83.L_CORE X_NUC_166.L_CORE 0.002240
K_14885 X_NUC_83.L_CORE X_NUC_167.L_CORE 0.002233
K_14886 X_NUC_83.L_CORE X_NUC_168.L_CORE 0.002220
K_14887 X_NUC_83.L_CORE X_NUC_169.L_CORE 0.001667
K_14888 X_NUC_83.L_CORE X_NUC_170.L_CORE 0.001667
K_14889 X_NUC_83.L_CORE X_NUC_171.L_CORE 0.001666
K_14890 X_NUC_83.L_CORE X_NUC_172.L_CORE 0.001656
K_14891 X_NUC_83.L_CORE X_NUC_173.L_CORE 0.001693
K_14892 X_NUC_83.L_CORE X_NUC_174.L_CORE 0.001786
K_14893 X_NUC_83.L_CORE X_NUC_175.L_CORE 0.002181
K_14894 X_NUC_83.L_CORE X_NUC_176.L_CORE 0.001454
K_14895 X_NUC_83.L_CORE X_NUC_177.L_CORE 0.002425
K_14896 X_NUC_83.L_CORE X_NUC_178.L_CORE 0.001724
K_14897 X_NUC_83.L_CORE X_NUC_179.L_CORE 0.001516
K_14898 X_NUC_83.L_CORE X_NUC_180.L_CORE 0.003360
K_14899 X_NUC_83.L_CORE X_NUC_181.L_CORE 0.001386
K_14900 X_NUC_83.L_CORE X_NUC_182.L_CORE 0.002052
K_14901 X_NUC_83.L_CORE X_NUC_183.L_CORE 0.002219
K_14902 X_NUC_83.L_CORE X_NUC_184.L_CORE 0.001333
K_14903 X_NUC_83.L_CORE X_NUC_185.L_CORE 0.004302
K_14904 X_NUC_83.L_CORE X_NUC_186.L_CORE 0.001497
K_14905 X_NUC_83.L_CORE X_NUC_187.L_CORE 0.001600
K_14906 X_NUC_83.L_CORE X_NUC_188.L_CORE 0.003882
K_14907 X_NUC_83.L_CORE X_NUC_189.L_CORE 0.001277
K_14908 X_NUC_83.L_CORE X_NUC_190.L_CORE 0.002760
K_14909 X_NUC_83.L_CORE X_NUC_191.L_CORE 0.001854
K_14910 X_NUC_83.L_CORE X_NUC_192.L_CORE 0.001350
K_14911 X_NUC_83.L_CORE X_NUC_193.L_CORE 0.016020
K_14912 X_NUC_83.L_CORE X_NUC_194.L_CORE 0.001345
K_14913 X_NUC_83.L_CORE X_NUC_195.L_CORE 0.001851
K_14914 X_NUC_83.L_CORE X_NUC_196.L_CORE 0.002816
K_14915 X_NUC_83.L_CORE X_NUC_197.L_CORE 0.001254
K_14916 X_NUC_83.L_CORE X_NUC_198.L_CORE 0.004414
K_14917 X_NUC_83.L_CORE X_NUC_199.L_CORE 0.001571
K_14918 X_NUC_83.L_CORE X_NUC_200.L_CORE 0.001460
K_14919 X_NUC_83.L_CORE X_NUC_201.L_CORE 0.006274
K_14920 X_NUC_83.L_CORE X_NUC_202.L_CORE 0.001275
K_14921 X_NUC_83.L_CORE X_NUC_203.L_CORE 0.002284
K_14922 X_NUC_83.L_CORE X_NUC_204.L_CORE 0.002075
K_14923 X_NUC_83.L_CORE X_NUC_205.L_CORE 0.001303
K_14924 X_NUC_83.L_CORE X_NUC_206.L_CORE 0.005617
K_14925 X_NUC_83.L_CORE X_NUC_207.L_CORE 0.001419
K_14926 X_NUC_83.L_CORE X_NUC_208.L_CORE 0.001658
K_14927 X_NUC_83.L_CORE X_NUC_209.L_CORE 0.003013
K_14928 X_NUC_83.L_CORE X_NUC_210.L_CORE 0.001286
K_14929 X_NUC_83.L_CORE X_NUC_211.L_CORE 0.002698
K_14930 X_NUC_83.L_CORE X_NUC_212.L_CORE 0.001712
K_14931 X_NUC_83.L_CORE X_NUC_213.L_CORE 0.001428
K_14932 X_NUC_83.L_CORE X_NUC_214.L_CORE 0.003302
K_14933 X_NUC_83.L_CORE X_NUC_215.L_CORE 0.001389
K_14934 X_NUC_83.L_CORE X_NUC_216.L_CORE 0.001877
K_14935 X_NUC_83.L_CORE X_NUC_217.L_CORE 0.002076
K_14936 X_NUC_83.L_CORE X_NUC_218.L_CORE 0.001405
K_14937 X_NUC_83.L_CORE X_NUC_219.L_CORE 0.002329
K_14938 X_NUC_83.L_CORE X_NUC_220.L_CORE 0.001607
K_14939 X_NUC_83.L_CORE X_NUC_221.L_CORE 0.001642
K_14940 X_NUC_83.L_CORE X_NUC_222.L_CORE 0.001897
K_14941 X_NUC_84.L_CORE X_NUC_85.L_CORE 0.001401
K_14942 X_NUC_84.L_CORE X_NUC_86.L_CORE 0.001403
K_14943 X_NUC_84.L_CORE X_NUC_87.L_CORE 0.001406
K_14944 X_NUC_84.L_CORE X_NUC_88.L_CORE 0.001397
K_14945 X_NUC_84.L_CORE X_NUC_89.L_CORE 0.001938
K_14946 X_NUC_84.L_CORE X_NUC_90.L_CORE 0.001924
K_14947 X_NUC_84.L_CORE X_NUC_91.L_CORE 0.001936
K_14948 X_NUC_84.L_CORE X_NUC_92.L_CORE 0.001925
K_14949 X_NUC_84.L_CORE X_NUC_93.L_CORE 0.002912
K_14950 X_NUC_84.L_CORE X_NUC_94.L_CORE 0.002947
K_14951 X_NUC_84.L_CORE X_NUC_95.L_CORE 0.002935
K_14952 X_NUC_84.L_CORE X_NUC_96.L_CORE 0.002914
K_14953 X_NUC_84.L_CORE X_NUC_97.L_CORE 0.001314
K_14954 X_NUC_84.L_CORE X_NUC_98.L_CORE 0.001312
K_14955 X_NUC_84.L_CORE X_NUC_99.L_CORE 0.001316
K_14956 X_NUC_84.L_CORE X_NUC_100.L_CORE 0.001308
K_14957 X_NUC_84.L_CORE X_NUC_101.L_CORE 0.004409
K_14958 X_NUC_84.L_CORE X_NUC_102.L_CORE 0.004326
K_14959 X_NUC_84.L_CORE X_NUC_103.L_CORE 0.004351
K_14960 X_NUC_84.L_CORE X_NUC_104.L_CORE 0.004334
K_14961 X_NUC_84.L_CORE X_NUC_105.L_CORE 0.001642
K_14962 X_NUC_84.L_CORE X_NUC_106.L_CORE 0.001649
K_14963 X_NUC_84.L_CORE X_NUC_107.L_CORE 0.001649
K_14964 X_NUC_84.L_CORE X_NUC_108.L_CORE 0.001638
K_14965 X_NUC_84.L_CORE X_NUC_109.L_CORE 0.001536
K_14966 X_NUC_84.L_CORE X_NUC_110.L_CORE 0.001529
K_14967 X_NUC_84.L_CORE X_NUC_111.L_CORE 0.001535
K_14968 X_NUC_84.L_CORE X_NUC_112.L_CORE 0.001526
K_14969 X_NUC_84.L_CORE X_NUC_113.L_CORE 0.005191
K_14970 X_NUC_84.L_CORE X_NUC_114.L_CORE 0.005273
K_14971 X_NUC_84.L_CORE X_NUC_115.L_CORE 0.005181
K_14972 X_NUC_84.L_CORE X_NUC_116.L_CORE 0.005147
K_14973 X_NUC_84.L_CORE X_NUC_117.L_CORE 0.001350
K_14974 X_NUC_84.L_CORE X_NUC_118.L_CORE 0.001351
K_14975 X_NUC_84.L_CORE X_NUC_119.L_CORE 0.001353
K_14976 X_NUC_84.L_CORE X_NUC_120.L_CORE 0.001345
K_14977 X_NUC_84.L_CORE X_NUC_121.L_CORE 0.002335
K_14978 X_NUC_84.L_CORE X_NUC_122.L_CORE 0.002314
K_14979 X_NUC_84.L_CORE X_NUC_123.L_CORE 0.002323
K_14980 X_NUC_84.L_CORE X_NUC_124.L_CORE 0.002311
K_14981 X_NUC_84.L_CORE X_NUC_125.L_CORE 0.002123
K_14982 X_NUC_84.L_CORE X_NUC_126.L_CORE 0.002137
K_14983 X_NUC_84.L_CORE X_NUC_127.L_CORE 0.002130
K_14984 X_NUC_84.L_CORE X_NUC_128.L_CORE 0.002116
K_14985 X_NUC_84.L_CORE X_NUC_129.L_CORE 0.001393
K_14986 X_NUC_84.L_CORE X_NUC_130.L_CORE 0.001390
K_14987 X_NUC_84.L_CORE X_NUC_131.L_CORE 0.001394
K_14988 X_NUC_84.L_CORE X_NUC_132.L_CORE 0.001385
K_14989 X_NUC_84.L_CORE X_NUC_133.L_CORE 0.004029
K_14990 X_NUC_84.L_CORE X_NUC_134.L_CORE 0.004006
K_14991 X_NUC_84.L_CORE X_NUC_135.L_CORE 0.003977
K_14992 X_NUC_84.L_CORE X_NUC_136.L_CORE 0.003958
K_14993 X_NUC_84.L_CORE X_NUC_137.L_CORE 0.001517
K_14994 X_NUC_84.L_CORE X_NUC_138.L_CORE 0.001520
K_14995 X_NUC_84.L_CORE X_NUC_139.L_CORE 0.001520
K_14996 X_NUC_84.L_CORE X_NUC_140.L_CORE 0.001511
K_14997 X_NUC_84.L_CORE X_NUC_141.L_CORE 0.001748
K_14998 X_NUC_84.L_CORE X_NUC_142.L_CORE 0.001739
K_14999 X_NUC_84.L_CORE X_NUC_143.L_CORE 0.001744
K_15000 X_NUC_84.L_CORE X_NUC_144.L_CORE 0.001734
K_15001 X_NUC_84.L_CORE X_NUC_145.L_CORE 0.002662
K_15002 X_NUC_84.L_CORE X_NUC_146.L_CORE 0.002677
K_15003 X_NUC_84.L_CORE X_NUC_147.L_CORE 0.002660
K_15004 X_NUC_84.L_CORE X_NUC_148.L_CORE 0.002643
K_15005 X_NUC_84.L_CORE X_NUC_149.L_CORE 0.001419
K_15006 X_NUC_84.L_CORE X_NUC_150.L_CORE 0.001419
K_15007 X_NUC_84.L_CORE X_NUC_151.L_CORE 0.001420
K_15008 X_NUC_84.L_CORE X_NUC_152.L_CORE 0.001412
K_15009 X_NUC_84.L_CORE X_NUC_153.L_CORE 0.002398
K_15010 X_NUC_84.L_CORE X_NUC_154.L_CORE 0.002386
K_15011 X_NUC_84.L_CORE X_NUC_155.L_CORE 0.002383
K_15012 X_NUC_84.L_CORE X_NUC_156.L_CORE 0.002371
K_15013 X_NUC_84.L_CORE X_NUC_157.L_CORE 0.001795
K_15014 X_NUC_84.L_CORE X_NUC_158.L_CORE 0.001800
K_15015 X_NUC_84.L_CORE X_NUC_159.L_CORE 0.001796
K_15016 X_NUC_84.L_CORE X_NUC_160.L_CORE 0.001785
K_15017 X_NUC_84.L_CORE X_NUC_161.L_CORE 0.001602
K_15018 X_NUC_84.L_CORE X_NUC_162.L_CORE 0.001598
K_15019 X_NUC_84.L_CORE X_NUC_163.L_CORE 0.001600
K_15020 X_NUC_84.L_CORE X_NUC_164.L_CORE 0.001590
K_15021 X_NUC_84.L_CORE X_NUC_165.L_CORE 0.002254
K_15022 X_NUC_84.L_CORE X_NUC_166.L_CORE 0.002254
K_15023 X_NUC_84.L_CORE X_NUC_167.L_CORE 0.002246
K_15024 X_NUC_84.L_CORE X_NUC_168.L_CORE 0.002233
K_15025 X_NUC_84.L_CORE X_NUC_169.L_CORE 0.001677
K_15026 X_NUC_84.L_CORE X_NUC_170.L_CORE 0.001678
K_15027 X_NUC_84.L_CORE X_NUC_171.L_CORE 0.001676
K_15028 X_NUC_84.L_CORE X_NUC_172.L_CORE 0.001666
K_15029 X_NUC_84.L_CORE X_NUC_173.L_CORE 0.001703
K_15030 X_NUC_84.L_CORE X_NUC_174.L_CORE 0.001796
K_15031 X_NUC_84.L_CORE X_NUC_175.L_CORE 0.002194
K_15032 X_NUC_84.L_CORE X_NUC_176.L_CORE 0.001463
K_15033 X_NUC_84.L_CORE X_NUC_177.L_CORE 0.002438
K_15034 X_NUC_84.L_CORE X_NUC_178.L_CORE 0.001735
K_15035 X_NUC_84.L_CORE X_NUC_179.L_CORE 0.001525
K_15036 X_NUC_84.L_CORE X_NUC_180.L_CORE 0.003379
K_15037 X_NUC_84.L_CORE X_NUC_181.L_CORE 0.001395
K_15038 X_NUC_84.L_CORE X_NUC_182.L_CORE 0.002062
K_15039 X_NUC_84.L_CORE X_NUC_183.L_CORE 0.002234
K_15040 X_NUC_84.L_CORE X_NUC_184.L_CORE 0.001341
K_15041 X_NUC_84.L_CORE X_NUC_185.L_CORE 0.004316
K_15042 X_NUC_84.L_CORE X_NUC_186.L_CORE 0.001507
K_15043 X_NUC_84.L_CORE X_NUC_187.L_CORE 0.001608
K_15044 X_NUC_84.L_CORE X_NUC_188.L_CORE 0.003904
K_15045 X_NUC_84.L_CORE X_NUC_189.L_CORE 0.001285
K_15046 X_NUC_84.L_CORE X_NUC_190.L_CORE 0.002772
K_15047 X_NUC_84.L_CORE X_NUC_191.L_CORE 0.001866
K_15048 X_NUC_84.L_CORE X_NUC_192.L_CORE 0.001358
K_15049 X_NUC_84.L_CORE X_NUC_193.L_CORE 0.015563
K_15050 X_NUC_84.L_CORE X_NUC_194.L_CORE 0.001353
K_15051 X_NUC_84.L_CORE X_NUC_195.L_CORE 0.001861
K_15052 X_NUC_84.L_CORE X_NUC_196.L_CORE 0.002833
K_15053 X_NUC_84.L_CORE X_NUC_197.L_CORE 0.001261
K_15054 X_NUC_84.L_CORE X_NUC_198.L_CORE 0.004420
K_15055 X_NUC_84.L_CORE X_NUC_199.L_CORE 0.001581
K_15056 X_NUC_84.L_CORE X_NUC_200.L_CORE 0.001468
K_15057 X_NUC_84.L_CORE X_NUC_201.L_CORE 0.006287
K_15058 X_NUC_84.L_CORE X_NUC_202.L_CORE 0.001283
K_15059 X_NUC_84.L_CORE X_NUC_203.L_CORE 0.002295
K_15060 X_NUC_84.L_CORE X_NUC_204.L_CORE 0.002088
K_15061 X_NUC_84.L_CORE X_NUC_205.L_CORE 0.001310
K_15062 X_NUC_84.L_CORE X_NUC_206.L_CORE 0.005613
K_15063 X_NUC_84.L_CORE X_NUC_207.L_CORE 0.001428
K_15064 X_NUC_84.L_CORE X_NUC_208.L_CORE 0.001666
K_15065 X_NUC_84.L_CORE X_NUC_209.L_CORE 0.003030
K_15066 X_NUC_84.L_CORE X_NUC_210.L_CORE 0.001293
K_15067 X_NUC_84.L_CORE X_NUC_211.L_CORE 0.002709
K_15068 X_NUC_84.L_CORE X_NUC_212.L_CORE 0.001723
K_15069 X_NUC_84.L_CORE X_NUC_213.L_CORE 0.001436
K_15070 X_NUC_84.L_CORE X_NUC_214.L_CORE 0.003316
K_15071 X_NUC_84.L_CORE X_NUC_215.L_CORE 0.001397
K_15072 X_NUC_84.L_CORE X_NUC_216.L_CORE 0.001887
K_15073 X_NUC_84.L_CORE X_NUC_217.L_CORE 0.002087
K_15074 X_NUC_84.L_CORE X_NUC_218.L_CORE 0.001413
K_15075 X_NUC_84.L_CORE X_NUC_219.L_CORE 0.002340
K_15076 X_NUC_84.L_CORE X_NUC_220.L_CORE 0.001616
K_15077 X_NUC_84.L_CORE X_NUC_221.L_CORE 0.001651
K_15078 X_NUC_84.L_CORE X_NUC_222.L_CORE 0.001907
K_15079 X_NUC_85.L_CORE X_NUC_86.L_CORE 0.207973
K_15080 X_NUC_85.L_CORE X_NUC_87.L_CORE 0.207973
K_15081 X_NUC_85.L_CORE X_NUC_88.L_CORE 0.207973
K_15082 X_NUC_85.L_CORE X_NUC_89.L_CORE 0.001397
K_15083 X_NUC_85.L_CORE X_NUC_90.L_CORE 0.001389
K_15084 X_NUC_85.L_CORE X_NUC_91.L_CORE 0.001391
K_15085 X_NUC_85.L_CORE X_NUC_92.L_CORE 0.001395
K_15086 X_NUC_85.L_CORE X_NUC_93.L_CORE 0.001927
K_15087 X_NUC_85.L_CORE X_NUC_94.L_CORE 0.001930
K_15088 X_NUC_85.L_CORE X_NUC_95.L_CORE 0.001919
K_15089 X_NUC_85.L_CORE X_NUC_96.L_CORE 0.001937
K_15090 X_NUC_85.L_CORE X_NUC_97.L_CORE 0.002920
K_15091 X_NUC_85.L_CORE X_NUC_98.L_CORE 0.002881
K_15092 X_NUC_85.L_CORE X_NUC_99.L_CORE 0.002900
K_15093 X_NUC_85.L_CORE X_NUC_100.L_CORE 0.002892
K_15094 X_NUC_85.L_CORE X_NUC_101.L_CORE 0.001313
K_15095 X_NUC_85.L_CORE X_NUC_102.L_CORE 0.001308
K_15096 X_NUC_85.L_CORE X_NUC_103.L_CORE 0.001306
K_15097 X_NUC_85.L_CORE X_NUC_104.L_CORE 0.001313
K_15098 X_NUC_85.L_CORE X_NUC_105.L_CORE 0.004347
K_15099 X_NUC_85.L_CORE X_NUC_106.L_CORE 0.004394
K_15100 X_NUC_85.L_CORE X_NUC_107.L_CORE 0.004310
K_15101 X_NUC_85.L_CORE X_NUC_108.L_CORE 0.004380
K_15102 X_NUC_85.L_CORE X_NUC_109.L_CORE 0.001647
K_15103 X_NUC_85.L_CORE X_NUC_110.L_CORE 0.001635
K_15104 X_NUC_85.L_CORE X_NUC_111.L_CORE 0.001638
K_15105 X_NUC_85.L_CORE X_NUC_112.L_CORE 0.001641
K_15106 X_NUC_85.L_CORE X_NUC_113.L_CORE 0.001537
K_15107 X_NUC_85.L_CORE X_NUC_114.L_CORE 0.001535
K_15108 X_NUC_85.L_CORE X_NUC_115.L_CORE 0.001529
K_15109 X_NUC_85.L_CORE X_NUC_116.L_CORE 0.001540
K_15110 X_NUC_85.L_CORE X_NUC_117.L_CORE 0.005144
K_15111 X_NUC_85.L_CORE X_NUC_118.L_CORE 0.005061
K_15112 X_NUC_85.L_CORE X_NUC_119.L_CORE 0.005049
K_15113 X_NUC_85.L_CORE X_NUC_120.L_CORE 0.005027
K_15114 X_NUC_85.L_CORE X_NUC_121.L_CORE 0.001358
K_15115 X_NUC_85.L_CORE X_NUC_122.L_CORE 0.001351
K_15116 X_NUC_85.L_CORE X_NUC_123.L_CORE 0.001350
K_15117 X_NUC_85.L_CORE X_NUC_124.L_CORE 0.001356
K_15118 X_NUC_85.L_CORE X_NUC_125.L_CORE 0.002329
K_15119 X_NUC_85.L_CORE X_NUC_126.L_CORE 0.002335
K_15120 X_NUC_85.L_CORE X_NUC_127.L_CORE 0.002313
K_15121 X_NUC_85.L_CORE X_NUC_128.L_CORE 0.002336
K_15122 X_NUC_85.L_CORE X_NUC_129.L_CORE 0.002136
K_15123 X_NUC_85.L_CORE X_NUC_130.L_CORE 0.002117
K_15124 X_NUC_85.L_CORE X_NUC_131.L_CORE 0.002119
K_15125 X_NUC_85.L_CORE X_NUC_132.L_CORE 0.002121
K_15126 X_NUC_85.L_CORE X_NUC_133.L_CORE 0.001405
K_15127 X_NUC_85.L_CORE X_NUC_134.L_CORE 0.001401
K_15128 X_NUC_85.L_CORE X_NUC_135.L_CORE 0.001397
K_15129 X_NUC_85.L_CORE X_NUC_136.L_CORE 0.001405
K_15130 X_NUC_85.L_CORE X_NUC_137.L_CORE 0.003907
K_15131 X_NUC_85.L_CORE X_NUC_138.L_CORE 0.003907
K_15132 X_NUC_85.L_CORE X_NUC_139.L_CORE 0.003845
K_15133 X_NUC_85.L_CORE X_NUC_140.L_CORE 0.003875
K_15134 X_NUC_85.L_CORE X_NUC_141.L_CORE 0.001536
K_15135 X_NUC_85.L_CORE X_NUC_142.L_CORE 0.001527
K_15136 X_NUC_85.L_CORE X_NUC_143.L_CORE 0.001526
K_15137 X_NUC_85.L_CORE X_NUC_144.L_CORE 0.001531
K_15138 X_NUC_85.L_CORE X_NUC_145.L_CORE 0.001762
K_15139 X_NUC_85.L_CORE X_NUC_146.L_CORE 0.001761
K_15140 X_NUC_85.L_CORE X_NUC_147.L_CORE 0.001750
K_15141 X_NUC_85.L_CORE X_NUC_148.L_CORE 0.001763
K_15142 X_NUC_85.L_CORE X_NUC_149.L_CORE 0.002632
K_15143 X_NUC_85.L_CORE X_NUC_150.L_CORE 0.002611
K_15144 X_NUC_85.L_CORE X_NUC_151.L_CORE 0.002602
K_15145 X_NUC_85.L_CORE X_NUC_152.L_CORE 0.002606
K_15146 X_NUC_85.L_CORE X_NUC_153.L_CORE 0.001450
K_15147 X_NUC_85.L_CORE X_NUC_154.L_CORE 0.001445
K_15148 X_NUC_85.L_CORE X_NUC_155.L_CORE 0.001441
K_15149 X_NUC_85.L_CORE X_NUC_156.L_CORE 0.001448
K_15150 X_NUC_85.L_CORE X_NUC_157.L_CORE 0.002353
K_15151 X_NUC_85.L_CORE X_NUC_158.L_CORE 0.002351
K_15152 X_NUC_85.L_CORE X_NUC_159.L_CORE 0.002329
K_15153 X_NUC_85.L_CORE X_NUC_160.L_CORE 0.002347
K_15154 X_NUC_85.L_CORE X_NUC_161.L_CORE 0.001822
K_15155 X_NUC_85.L_CORE X_NUC_162.L_CORE 0.001811
K_15156 X_NUC_85.L_CORE X_NUC_163.L_CORE 0.001806
K_15157 X_NUC_85.L_CORE X_NUC_164.L_CORE 0.001812
K_15158 X_NUC_85.L_CORE X_NUC_165.L_CORE 0.001657
K_15159 X_NUC_85.L_CORE X_NUC_166.L_CORE 0.001652
K_15160 X_NUC_85.L_CORE X_NUC_167.L_CORE 0.001644
K_15161 X_NUC_85.L_CORE X_NUC_168.L_CORE 0.001654
K_15162 X_NUC_85.L_CORE X_NUC_169.L_CORE 0.002075
K_15163 X_NUC_85.L_CORE X_NUC_170.L_CORE 0.002067
K_15164 X_NUC_85.L_CORE X_NUC_171.L_CORE 0.002055
K_15165 X_NUC_85.L_CORE X_NUC_172.L_CORE 0.002064
K_15166 X_NUC_85.L_CORE X_NUC_173.L_CORE 0.001976
K_15167 X_NUC_85.L_CORE X_NUC_174.L_CORE 0.001602
K_15168 X_NUC_85.L_CORE X_NUC_175.L_CORE 0.001754
K_15169 X_NUC_85.L_CORE X_NUC_176.L_CORE 0.002213
K_15170 X_NUC_85.L_CORE X_NUC_177.L_CORE 0.001411
K_15171 X_NUC_85.L_CORE X_NUC_178.L_CORE 0.002456
K_15172 X_NUC_85.L_CORE X_NUC_179.L_CORE 0.001695
K_15173 X_NUC_85.L_CORE X_NUC_180.L_CORE 0.001491
K_15174 X_NUC_85.L_CORE X_NUC_181.L_CORE 0.003424
K_15175 X_NUC_85.L_CORE X_NUC_182.L_CORE 0.001364
K_15176 X_NUC_85.L_CORE X_NUC_183.L_CORE 0.002039
K_15177 X_NUC_85.L_CORE X_NUC_184.L_CORE 0.002198
K_15178 X_NUC_85.L_CORE X_NUC_185.L_CORE 0.001319
K_15179 X_NUC_85.L_CORE X_NUC_186.L_CORE 0.004353
K_15180 X_NUC_85.L_CORE X_NUC_187.L_CORE 0.001483
K_15181 X_NUC_85.L_CORE X_NUC_188.L_CORE 0.001590
K_15182 X_NUC_85.L_CORE X_NUC_189.L_CORE 0.003858
K_15183 X_NUC_85.L_CORE X_NUC_190.L_CORE 0.001269
K_15184 X_NUC_85.L_CORE X_NUC_191.L_CORE 0.002761
K_15185 X_NUC_85.L_CORE X_NUC_192.L_CORE 0.001843
K_15186 X_NUC_85.L_CORE X_NUC_193.L_CORE 0.001347
K_15187 X_NUC_85.L_CORE X_NUC_194.L_CORE 0.016208
K_15188 X_NUC_85.L_CORE X_NUC_195.L_CORE 0.001341
K_15189 X_NUC_85.L_CORE X_NUC_196.L_CORE 0.001854
K_15190 X_NUC_85.L_CORE X_NUC_197.L_CORE 0.002803
K_15191 X_NUC_85.L_CORE X_NUC_198.L_CORE 0.001255
K_15192 X_NUC_85.L_CORE X_NUC_199.L_CORE 0.004449
K_15193 X_NUC_85.L_CORE X_NUC_200.L_CORE 0.001572
K_15194 X_NUC_85.L_CORE X_NUC_201.L_CORE 0.001466
K_15195 X_NUC_85.L_CORE X_NUC_202.L_CORE 0.006208
K_15196 X_NUC_85.L_CORE X_NUC_203.L_CORE 0.001281
K_15197 X_NUC_85.L_CORE X_NUC_204.L_CORE 0.002302
K_15198 X_NUC_85.L_CORE X_NUC_205.L_CORE 0.002080
K_15199 X_NUC_85.L_CORE X_NUC_206.L_CORE 0.001313
K_15200 X_NUC_85.L_CORE X_NUC_207.L_CORE 0.005594
K_15201 X_NUC_85.L_CORE X_NUC_208.L_CORE 0.001430
K_15202 X_NUC_85.L_CORE X_NUC_209.L_CORE 0.001675
K_15203 X_NUC_85.L_CORE X_NUC_210.L_CORE 0.003009
K_15204 X_NUC_85.L_CORE X_NUC_211.L_CORE 0.001302
K_15205 X_NUC_85.L_CORE X_NUC_212.L_CORE 0.002713
K_15206 X_NUC_85.L_CORE X_NUC_213.L_CORE 0.001730
K_15207 X_NUC_85.L_CORE X_NUC_214.L_CORE 0.001452
K_15208 X_NUC_85.L_CORE X_NUC_215.L_CORE 0.003237
K_15209 X_NUC_85.L_CORE X_NUC_216.L_CORE 0.001416
K_15210 X_NUC_85.L_CORE X_NUC_217.L_CORE 0.001901
K_15211 X_NUC_85.L_CORE X_NUC_218.L_CORE 0.002078
K_15212 X_NUC_85.L_CORE X_NUC_219.L_CORE 0.001448
K_15213 X_NUC_85.L_CORE X_NUC_220.L_CORE 0.002264
K_15214 X_NUC_85.L_CORE X_NUC_221.L_CORE 0.001656
K_15215 X_NUC_85.L_CORE X_NUC_222.L_CORE 0.001707
K_15216 X_NUC_86.L_CORE X_NUC_87.L_CORE 0.207973
K_15217 X_NUC_86.L_CORE X_NUC_88.L_CORE 0.207973
K_15218 X_NUC_86.L_CORE X_NUC_89.L_CORE 0.001405
K_15219 X_NUC_86.L_CORE X_NUC_90.L_CORE 0.001397
K_15220 X_NUC_86.L_CORE X_NUC_91.L_CORE 0.001399
K_15221 X_NUC_86.L_CORE X_NUC_92.L_CORE 0.001404
K_15222 X_NUC_86.L_CORE X_NUC_93.L_CORE 0.001924
K_15223 X_NUC_86.L_CORE X_NUC_94.L_CORE 0.001927
K_15224 X_NUC_86.L_CORE X_NUC_95.L_CORE 0.001916
K_15225 X_NUC_86.L_CORE X_NUC_96.L_CORE 0.001933
K_15226 X_NUC_86.L_CORE X_NUC_97.L_CORE 0.002961
K_15227 X_NUC_86.L_CORE X_NUC_98.L_CORE 0.002920
K_15228 X_NUC_86.L_CORE X_NUC_99.L_CORE 0.002939
K_15229 X_NUC_86.L_CORE X_NUC_100.L_CORE 0.002932
K_15230 X_NUC_86.L_CORE X_NUC_101.L_CORE 0.001317
K_15231 X_NUC_86.L_CORE X_NUC_102.L_CORE 0.001313
K_15232 X_NUC_86.L_CORE X_NUC_103.L_CORE 0.001311
K_15233 X_NUC_86.L_CORE X_NUC_104.L_CORE 0.001318
K_15234 X_NUC_86.L_CORE X_NUC_105.L_CORE 0.004301
K_15235 X_NUC_86.L_CORE X_NUC_106.L_CORE 0.004347
K_15236 X_NUC_86.L_CORE X_NUC_107.L_CORE 0.004266
K_15237 X_NUC_86.L_CORE X_NUC_108.L_CORE 0.004333
K_15238 X_NUC_86.L_CORE X_NUC_109.L_CORE 0.001660
K_15239 X_NUC_86.L_CORE X_NUC_110.L_CORE 0.001647
K_15240 X_NUC_86.L_CORE X_NUC_111.L_CORE 0.001650
K_15241 X_NUC_86.L_CORE X_NUC_112.L_CORE 0.001654
K_15242 X_NUC_86.L_CORE X_NUC_113.L_CORE 0.001538
K_15243 X_NUC_86.L_CORE X_NUC_114.L_CORE 0.001537
K_15244 X_NUC_86.L_CORE X_NUC_115.L_CORE 0.001530
K_15245 X_NUC_86.L_CORE X_NUC_116.L_CORE 0.001541
K_15246 X_NUC_86.L_CORE X_NUC_117.L_CORE 0.005228
K_15247 X_NUC_86.L_CORE X_NUC_118.L_CORE 0.005144
K_15248 X_NUC_86.L_CORE X_NUC_119.L_CORE 0.005129
K_15249 X_NUC_86.L_CORE X_NUC_120.L_CORE 0.005107
K_15250 X_NUC_86.L_CORE X_NUC_121.L_CORE 0.001364
K_15251 X_NUC_86.L_CORE X_NUC_122.L_CORE 0.001358
K_15252 X_NUC_86.L_CORE X_NUC_123.L_CORE 0.001357
K_15253 X_NUC_86.L_CORE X_NUC_124.L_CORE 0.001362
K_15254 X_NUC_86.L_CORE X_NUC_125.L_CORE 0.002323
K_15255 X_NUC_86.L_CORE X_NUC_126.L_CORE 0.002329
K_15256 X_NUC_86.L_CORE X_NUC_127.L_CORE 0.002307
K_15257 X_NUC_86.L_CORE X_NUC_128.L_CORE 0.002330
K_15258 X_NUC_86.L_CORE X_NUC_129.L_CORE 0.002156
K_15259 X_NUC_86.L_CORE X_NUC_130.L_CORE 0.002136
K_15260 X_NUC_86.L_CORE X_NUC_131.L_CORE 0.002139
K_15261 X_NUC_86.L_CORE X_NUC_132.L_CORE 0.002140
K_15262 X_NUC_86.L_CORE X_NUC_133.L_CORE 0.001408
K_15263 X_NUC_86.L_CORE X_NUC_134.L_CORE 0.001405
K_15264 X_NUC_86.L_CORE X_NUC_135.L_CORE 0.001400
K_15265 X_NUC_86.L_CORE X_NUC_136.L_CORE 0.001409
K_15266 X_NUC_86.L_CORE X_NUC_137.L_CORE 0.003906
K_15267 X_NUC_86.L_CORE X_NUC_138.L_CORE 0.003907
K_15268 X_NUC_86.L_CORE X_NUC_139.L_CORE 0.003845
K_15269 X_NUC_86.L_CORE X_NUC_140.L_CORE 0.003875
K_15270 X_NUC_86.L_CORE X_NUC_141.L_CORE 0.001545
K_15271 X_NUC_86.L_CORE X_NUC_142.L_CORE 0.001536
K_15272 X_NUC_86.L_CORE X_NUC_143.L_CORE 0.001535
K_15273 X_NUC_86.L_CORE X_NUC_144.L_CORE 0.001540
K_15274 X_NUC_86.L_CORE X_NUC_145.L_CORE 0.001763
K_15275 X_NUC_86.L_CORE X_NUC_146.L_CORE 0.001762
K_15276 X_NUC_86.L_CORE X_NUC_147.L_CORE 0.001751
K_15277 X_NUC_86.L_CORE X_NUC_148.L_CORE 0.001764
K_15278 X_NUC_86.L_CORE X_NUC_149.L_CORE 0.002654
K_15279 X_NUC_86.L_CORE X_NUC_150.L_CORE 0.002632
K_15280 X_NUC_86.L_CORE X_NUC_151.L_CORE 0.002623
K_15281 X_NUC_86.L_CORE X_NUC_152.L_CORE 0.002627
K_15282 X_NUC_86.L_CORE X_NUC_153.L_CORE 0.001456
K_15283 X_NUC_86.L_CORE X_NUC_154.L_CORE 0.001450
K_15284 X_NUC_86.L_CORE X_NUC_155.L_CORE 0.001446
K_15285 X_NUC_86.L_CORE X_NUC_156.L_CORE 0.001454
K_15286 X_NUC_86.L_CORE X_NUC_157.L_CORE 0.002354
K_15287 X_NUC_86.L_CORE X_NUC_158.L_CORE 0.002353
K_15288 X_NUC_86.L_CORE X_NUC_159.L_CORE 0.002331
K_15289 X_NUC_86.L_CORE X_NUC_160.L_CORE 0.002348
K_15290 X_NUC_86.L_CORE X_NUC_161.L_CORE 0.001833
K_15291 X_NUC_86.L_CORE X_NUC_162.L_CORE 0.001822
K_15292 X_NUC_86.L_CORE X_NUC_163.L_CORE 0.001817
K_15293 X_NUC_86.L_CORE X_NUC_164.L_CORE 0.001823
K_15294 X_NUC_86.L_CORE X_NUC_165.L_CORE 0.001661
K_15295 X_NUC_86.L_CORE X_NUC_166.L_CORE 0.001657
K_15296 X_NUC_86.L_CORE X_NUC_167.L_CORE 0.001649
K_15297 X_NUC_86.L_CORE X_NUC_168.L_CORE 0.001658
K_15298 X_NUC_86.L_CORE X_NUC_169.L_CORE 0.002083
K_15299 X_NUC_86.L_CORE X_NUC_170.L_CORE 0.002075
K_15300 X_NUC_86.L_CORE X_NUC_171.L_CORE 0.002063
K_15301 X_NUC_86.L_CORE X_NUC_172.L_CORE 0.002073
K_15302 X_NUC_86.L_CORE X_NUC_173.L_CORE 0.001983
K_15303 X_NUC_86.L_CORE X_NUC_174.L_CORE 0.001610
K_15304 X_NUC_86.L_CORE X_NUC_175.L_CORE 0.001757
K_15305 X_NUC_86.L_CORE X_NUC_176.L_CORE 0.002226
K_15306 X_NUC_86.L_CORE X_NUC_177.L_CORE 0.001416
K_15307 X_NUC_86.L_CORE X_NUC_178.L_CORE 0.002454
K_15308 X_NUC_86.L_CORE X_NUC_179.L_CORE 0.001706
K_15309 X_NUC_86.L_CORE X_NUC_180.L_CORE 0.001493
K_15310 X_NUC_86.L_CORE X_NUC_181.L_CORE 0.003444
K_15311 X_NUC_86.L_CORE X_NUC_182.L_CORE 0.001371
K_15312 X_NUC_86.L_CORE X_NUC_183.L_CORE 0.002036
K_15313 X_NUC_86.L_CORE X_NUC_184.L_CORE 0.002219
K_15314 X_NUC_86.L_CORE X_NUC_185.L_CORE 0.001322
K_15315 X_NUC_86.L_CORE X_NUC_186.L_CORE 0.004323
K_15316 X_NUC_86.L_CORE X_NUC_187.L_CORE 0.001492
K_15317 X_NUC_86.L_CORE X_NUC_188.L_CORE 0.001590
K_15318 X_NUC_86.L_CORE X_NUC_189.L_CORE 0.003914
K_15319 X_NUC_86.L_CORE X_NUC_190.L_CORE 0.001275
K_15320 X_NUC_86.L_CORE X_NUC_191.L_CORE 0.002745
K_15321 X_NUC_86.L_CORE X_NUC_192.L_CORE 0.001859
K_15322 X_NUC_86.L_CORE X_NUC_193.L_CORE 0.001349
K_15323 X_NUC_86.L_CORE X_NUC_194.L_CORE 0.015888
K_15324 X_NUC_86.L_CORE X_NUC_195.L_CORE 0.001349
K_15325 X_NUC_86.L_CORE X_NUC_196.L_CORE 0.001850
K_15326 X_NUC_86.L_CORE X_NUC_197.L_CORE 0.002840
K_15327 X_NUC_86.L_CORE X_NUC_198.L_CORE 0.001259
K_15328 X_NUC_86.L_CORE X_NUC_199.L_CORE 0.004384
K_15329 X_NUC_86.L_CORE X_NUC_200.L_CORE 0.001583
K_15330 X_NUC_86.L_CORE X_NUC_201.L_CORE 0.001467
K_15331 X_NUC_86.L_CORE X_NUC_202.L_CORE 0.006341
K_15332 X_NUC_86.L_CORE X_NUC_203.L_CORE 0.001287
K_15333 X_NUC_86.L_CORE X_NUC_204.L_CORE 0.002293
K_15334 X_NUC_86.L_CORE X_NUC_205.L_CORE 0.002100
K_15335 X_NUC_86.L_CORE X_NUC_206.L_CORE 0.001316
K_15336 X_NUC_86.L_CORE X_NUC_207.L_CORE 0.005545
K_15337 X_NUC_86.L_CORE X_NUC_208.L_CORE 0.001438
K_15338 X_NUC_86.L_CORE X_NUC_209.L_CORE 0.001675
K_15339 X_NUC_86.L_CORE X_NUC_210.L_CORE 0.003043
K_15340 X_NUC_86.L_CORE X_NUC_211.L_CORE 0.001307
K_15341 X_NUC_86.L_CORE X_NUC_212.L_CORE 0.002703
K_15342 X_NUC_86.L_CORE X_NUC_213.L_CORE 0.001742
K_15343 X_NUC_86.L_CORE X_NUC_214.L_CORE 0.001454
K_15344 X_NUC_86.L_CORE X_NUC_215.L_CORE 0.003252
K_15345 X_NUC_86.L_CORE X_NUC_216.L_CORE 0.001423
K_15346 X_NUC_86.L_CORE X_NUC_217.L_CORE 0.001901
K_15347 X_NUC_86.L_CORE X_NUC_218.L_CORE 0.002093
K_15348 X_NUC_86.L_CORE X_NUC_219.L_CORE 0.001453
K_15349 X_NUC_86.L_CORE X_NUC_220.L_CORE 0.002269
K_15350 X_NUC_86.L_CORE X_NUC_221.L_CORE 0.001665
K_15351 X_NUC_86.L_CORE X_NUC_222.L_CORE 0.001712
K_15352 X_NUC_87.L_CORE X_NUC_88.L_CORE 0.207973
K_15353 X_NUC_87.L_CORE X_NUC_89.L_CORE 0.001404
K_15354 X_NUC_87.L_CORE X_NUC_90.L_CORE 0.001396
K_15355 X_NUC_87.L_CORE X_NUC_91.L_CORE 0.001397
K_15356 X_NUC_87.L_CORE X_NUC_92.L_CORE 0.001402
K_15357 X_NUC_87.L_CORE X_NUC_93.L_CORE 0.001935
K_15358 X_NUC_87.L_CORE X_NUC_94.L_CORE 0.001938
K_15359 X_NUC_87.L_CORE X_NUC_95.L_CORE 0.001927
K_15360 X_NUC_87.L_CORE X_NUC_96.L_CORE 0.001945
K_15361 X_NUC_87.L_CORE X_NUC_97.L_CORE 0.002941
K_15362 X_NUC_87.L_CORE X_NUC_98.L_CORE 0.002901
K_15363 X_NUC_87.L_CORE X_NUC_99.L_CORE 0.002920
K_15364 X_NUC_87.L_CORE X_NUC_100.L_CORE 0.002913
K_15365 X_NUC_87.L_CORE X_NUC_101.L_CORE 0.001319
K_15366 X_NUC_87.L_CORE X_NUC_102.L_CORE 0.001314
K_15367 X_NUC_87.L_CORE X_NUC_103.L_CORE 0.001313
K_15368 X_NUC_87.L_CORE X_NUC_104.L_CORE 0.001320
K_15369 X_NUC_87.L_CORE X_NUC_105.L_CORE 0.004384
K_15370 X_NUC_87.L_CORE X_NUC_106.L_CORE 0.004432
K_15371 X_NUC_87.L_CORE X_NUC_107.L_CORE 0.004347
K_15372 X_NUC_87.L_CORE X_NUC_108.L_CORE 0.004418
K_15373 X_NUC_87.L_CORE X_NUC_109.L_CORE 0.001657
K_15374 X_NUC_87.L_CORE X_NUC_110.L_CORE 0.001645
K_15375 X_NUC_87.L_CORE X_NUC_111.L_CORE 0.001647
K_15376 X_NUC_87.L_CORE X_NUC_112.L_CORE 0.001651
K_15377 X_NUC_87.L_CORE X_NUC_113.L_CORE 0.001544
K_15378 X_NUC_87.L_CORE X_NUC_114.L_CORE 0.001543
K_15379 X_NUC_87.L_CORE X_NUC_115.L_CORE 0.001537
K_15380 X_NUC_87.L_CORE X_NUC_116.L_CORE 0.001548
K_15381 X_NUC_87.L_CORE X_NUC_117.L_CORE 0.005241
K_15382 X_NUC_87.L_CORE X_NUC_118.L_CORE 0.005156
K_15383 X_NUC_87.L_CORE X_NUC_119.L_CORE 0.005144
K_15384 X_NUC_87.L_CORE X_NUC_120.L_CORE 0.005120
K_15385 X_NUC_87.L_CORE X_NUC_121.L_CORE 0.001365
K_15386 X_NUC_87.L_CORE X_NUC_122.L_CORE 0.001359
K_15387 X_NUC_87.L_CORE X_NUC_123.L_CORE 0.001358
K_15388 X_NUC_87.L_CORE X_NUC_124.L_CORE 0.001363
K_15389 X_NUC_87.L_CORE X_NUC_125.L_CORE 0.002346
K_15390 X_NUC_87.L_CORE X_NUC_126.L_CORE 0.002352
K_15391 X_NUC_87.L_CORE X_NUC_127.L_CORE 0.002329
K_15392 X_NUC_87.L_CORE X_NUC_128.L_CORE 0.002353
K_15393 X_NUC_87.L_CORE X_NUC_129.L_CORE 0.002154
K_15394 X_NUC_87.L_CORE X_NUC_130.L_CORE 0.002134
K_15395 X_NUC_87.L_CORE X_NUC_131.L_CORE 0.002136
K_15396 X_NUC_87.L_CORE X_NUC_132.L_CORE 0.002138
K_15397 X_NUC_87.L_CORE X_NUC_133.L_CORE 0.001413
K_15398 X_NUC_87.L_CORE X_NUC_134.L_CORE 0.001409
K_15399 X_NUC_87.L_CORE X_NUC_135.L_CORE 0.001405
K_15400 X_NUC_87.L_CORE X_NUC_136.L_CORE 0.001413
K_15401 X_NUC_87.L_CORE X_NUC_137.L_CORE 0.003970
K_15402 X_NUC_87.L_CORE X_NUC_138.L_CORE 0.003971
K_15403 X_NUC_87.L_CORE X_NUC_139.L_CORE 0.003907
K_15404 X_NUC_87.L_CORE X_NUC_140.L_CORE 0.003938
K_15405 X_NUC_87.L_CORE X_NUC_141.L_CORE 0.001547
K_15406 X_NUC_87.L_CORE X_NUC_142.L_CORE 0.001537
K_15407 X_NUC_87.L_CORE X_NUC_143.L_CORE 0.001536
K_15408 X_NUC_87.L_CORE X_NUC_144.L_CORE 0.001541
K_15409 X_NUC_87.L_CORE X_NUC_145.L_CORE 0.001774
K_15410 X_NUC_87.L_CORE X_NUC_146.L_CORE 0.001773
K_15411 X_NUC_87.L_CORE X_NUC_147.L_CORE 0.001762
K_15412 X_NUC_87.L_CORE X_NUC_148.L_CORE 0.001775
K_15413 X_NUC_87.L_CORE X_NUC_149.L_CORE 0.002663
K_15414 X_NUC_87.L_CORE X_NUC_150.L_CORE 0.002641
K_15415 X_NUC_87.L_CORE X_NUC_151.L_CORE 0.002632
K_15416 X_NUC_87.L_CORE X_NUC_152.L_CORE 0.002637
K_15417 X_NUC_87.L_CORE X_NUC_153.L_CORE 0.001460
K_15418 X_NUC_87.L_CORE X_NUC_154.L_CORE 0.001454
K_15419 X_NUC_87.L_CORE X_NUC_155.L_CORE 0.001450
K_15420 X_NUC_87.L_CORE X_NUC_156.L_CORE 0.001458
K_15421 X_NUC_87.L_CORE X_NUC_157.L_CORE 0.002377
K_15422 X_NUC_87.L_CORE X_NUC_158.L_CORE 0.002375
K_15423 X_NUC_87.L_CORE X_NUC_159.L_CORE 0.002353
K_15424 X_NUC_87.L_CORE X_NUC_160.L_CORE 0.002370
K_15425 X_NUC_87.L_CORE X_NUC_161.L_CORE 0.001837
K_15426 X_NUC_87.L_CORE X_NUC_162.L_CORE 0.001826
K_15427 X_NUC_87.L_CORE X_NUC_163.L_CORE 0.001822
K_15428 X_NUC_87.L_CORE X_NUC_164.L_CORE 0.001828
K_15429 X_NUC_87.L_CORE X_NUC_165.L_CORE 0.001669
K_15430 X_NUC_87.L_CORE X_NUC_166.L_CORE 0.001665
K_15431 X_NUC_87.L_CORE X_NUC_167.L_CORE 0.001657
K_15432 X_NUC_87.L_CORE X_NUC_168.L_CORE 0.001666
K_15433 X_NUC_87.L_CORE X_NUC_169.L_CORE 0.002096
K_15434 X_NUC_87.L_CORE X_NUC_170.L_CORE 0.002087
K_15435 X_NUC_87.L_CORE X_NUC_171.L_CORE 0.002075
K_15436 X_NUC_87.L_CORE X_NUC_172.L_CORE 0.002085
K_15437 X_NUC_87.L_CORE X_NUC_173.L_CORE 0.001973
K_15438 X_NUC_87.L_CORE X_NUC_174.L_CORE 0.001604
K_15439 X_NUC_87.L_CORE X_NUC_175.L_CORE 0.001754
K_15440 X_NUC_87.L_CORE X_NUC_176.L_CORE 0.002209
K_15441 X_NUC_87.L_CORE X_NUC_177.L_CORE 0.001414
K_15442 X_NUC_87.L_CORE X_NUC_178.L_CORE 0.002448
K_15443 X_NUC_87.L_CORE X_NUC_179.L_CORE 0.001697
K_15444 X_NUC_87.L_CORE X_NUC_180.L_CORE 0.001493
K_15445 X_NUC_87.L_CORE X_NUC_181.L_CORE 0.003399
K_15446 X_NUC_87.L_CORE X_NUC_182.L_CORE 0.001368
K_15447 X_NUC_87.L_CORE X_NUC_183.L_CORE 0.002039
K_15448 X_NUC_87.L_CORE X_NUC_184.L_CORE 0.002200
K_15449 X_NUC_87.L_CORE X_NUC_185.L_CORE 0.001322
K_15450 X_NUC_87.L_CORE X_NUC_186.L_CORE 0.004306
K_15451 X_NUC_87.L_CORE X_NUC_187.L_CORE 0.001487
K_15452 X_NUC_87.L_CORE X_NUC_188.L_CORE 0.001594
K_15453 X_NUC_87.L_CORE X_NUC_189.L_CORE 0.003846
K_15454 X_NUC_87.L_CORE X_NUC_190.L_CORE 0.001274
K_15455 X_NUC_87.L_CORE X_NUC_191.L_CORE 0.002761
K_15456 X_NUC_87.L_CORE X_NUC_192.L_CORE 0.001849
K_15457 X_NUC_87.L_CORE X_NUC_193.L_CORE 0.001352
K_15458 X_NUC_87.L_CORE X_NUC_194.L_CORE 0.015110
K_15459 X_NUC_87.L_CORE X_NUC_195.L_CORE 0.001347
K_15460 X_NUC_87.L_CORE X_NUC_196.L_CORE 0.001860
K_15461 X_NUC_87.L_CORE X_NUC_197.L_CORE 0.002815
K_15462 X_NUC_87.L_CORE X_NUC_198.L_CORE 0.001260
K_15463 X_NUC_87.L_CORE X_NUC_199.L_CORE 0.004458
K_15464 X_NUC_87.L_CORE X_NUC_200.L_CORE 0.001580
K_15465 X_NUC_87.L_CORE X_NUC_201.L_CORE 0.001472
K_15466 X_NUC_87.L_CORE X_NUC_202.L_CORE 0.006286
K_15467 X_NUC_87.L_CORE X_NUC_203.L_CORE 0.001287
K_15468 X_NUC_87.L_CORE X_NUC_204.L_CORE 0.002314
K_15469 X_NUC_87.L_CORE X_NUC_205.L_CORE 0.002094
K_15470 X_NUC_87.L_CORE X_NUC_206.L_CORE 0.001319
K_15471 X_NUC_87.L_CORE X_NUC_207.L_CORE 0.005689
K_15472 X_NUC_87.L_CORE X_NUC_208.L_CORE 0.001438
K_15473 X_NUC_87.L_CORE X_NUC_209.L_CORE 0.001685
K_15474 X_NUC_87.L_CORE X_NUC_210.L_CORE 0.003042
K_15475 X_NUC_87.L_CORE X_NUC_211.L_CORE 0.001309
K_15476 X_NUC_87.L_CORE X_NUC_212.L_CORE 0.002737
K_15477 X_NUC_87.L_CORE X_NUC_213.L_CORE 0.001742
K_15478 X_NUC_87.L_CORE X_NUC_214.L_CORE 0.001460
K_15479 X_NUC_87.L_CORE X_NUC_215.L_CORE 0.003283
K_15480 X_NUC_87.L_CORE X_NUC_216.L_CORE 0.001425
K_15481 X_NUC_87.L_CORE X_NUC_217.L_CORE 0.001915
K_15482 X_NUC_87.L_CORE X_NUC_218.L_CORE 0.002098
K_15483 X_NUC_87.L_CORE X_NUC_219.L_CORE 0.001458
K_15484 X_NUC_87.L_CORE X_NUC_220.L_CORE 0.002288
K_15485 X_NUC_87.L_CORE X_NUC_221.L_CORE 0.001670
K_15486 X_NUC_87.L_CORE X_NUC_222.L_CORE 0.001721
K_15487 X_NUC_88.L_CORE X_NUC_89.L_CORE 0.001399
K_15488 X_NUC_88.L_CORE X_NUC_90.L_CORE 0.001391
K_15489 X_NUC_88.L_CORE X_NUC_91.L_CORE 0.001392
K_15490 X_NUC_88.L_CORE X_NUC_92.L_CORE 0.001397
K_15491 X_NUC_88.L_CORE X_NUC_93.L_CORE 0.001918
K_15492 X_NUC_88.L_CORE X_NUC_94.L_CORE 0.001921
K_15493 X_NUC_88.L_CORE X_NUC_95.L_CORE 0.001910
K_15494 X_NUC_88.L_CORE X_NUC_96.L_CORE 0.001927
K_15495 X_NUC_88.L_CORE X_NUC_97.L_CORE 0.002949
K_15496 X_NUC_88.L_CORE X_NUC_98.L_CORE 0.002909
K_15497 X_NUC_88.L_CORE X_NUC_99.L_CORE 0.002928
K_15498 X_NUC_88.L_CORE X_NUC_100.L_CORE 0.002920
K_15499 X_NUC_88.L_CORE X_NUC_101.L_CORE 0.001312
K_15500 X_NUC_88.L_CORE X_NUC_102.L_CORE 0.001308
K_15501 X_NUC_88.L_CORE X_NUC_103.L_CORE 0.001306
K_15502 X_NUC_88.L_CORE X_NUC_104.L_CORE 0.001313
K_15503 X_NUC_88.L_CORE X_NUC_105.L_CORE 0.004314
K_15504 X_NUC_88.L_CORE X_NUC_106.L_CORE 0.004360
K_15505 X_NUC_88.L_CORE X_NUC_107.L_CORE 0.004279
K_15506 X_NUC_88.L_CORE X_NUC_108.L_CORE 0.004347
K_15507 X_NUC_88.L_CORE X_NUC_109.L_CORE 0.001653
K_15508 X_NUC_88.L_CORE X_NUC_110.L_CORE 0.001641
K_15509 X_NUC_88.L_CORE X_NUC_111.L_CORE 0.001644
K_15510 X_NUC_88.L_CORE X_NUC_112.L_CORE 0.001647
K_15511 X_NUC_88.L_CORE X_NUC_113.L_CORE 0.001533
K_15512 X_NUC_88.L_CORE X_NUC_114.L_CORE 0.001532
K_15513 X_NUC_88.L_CORE X_NUC_115.L_CORE 0.001526
K_15514 X_NUC_88.L_CORE X_NUC_116.L_CORE 0.001537
K_15515 X_NUC_88.L_CORE X_NUC_117.L_CORE 0.005266
K_15516 X_NUC_88.L_CORE X_NUC_118.L_CORE 0.005179
K_15517 X_NUC_88.L_CORE X_NUC_119.L_CORE 0.005165
K_15518 X_NUC_88.L_CORE X_NUC_120.L_CORE 0.005144
K_15519 X_NUC_88.L_CORE X_NUC_121.L_CORE 0.001359
K_15520 X_NUC_88.L_CORE X_NUC_122.L_CORE 0.001353
K_15521 X_NUC_88.L_CORE X_NUC_123.L_CORE 0.001352
K_15522 X_NUC_88.L_CORE X_NUC_124.L_CORE 0.001358
K_15523 X_NUC_88.L_CORE X_NUC_125.L_CORE 0.002323
K_15524 X_NUC_88.L_CORE X_NUC_126.L_CORE 0.002329
K_15525 X_NUC_88.L_CORE X_NUC_127.L_CORE 0.002307
K_15526 X_NUC_88.L_CORE X_NUC_128.L_CORE 0.002329
K_15527 X_NUC_88.L_CORE X_NUC_129.L_CORE 0.002152
K_15528 X_NUC_88.L_CORE X_NUC_130.L_CORE 0.002132
K_15529 X_NUC_88.L_CORE X_NUC_131.L_CORE 0.002135
K_15530 X_NUC_88.L_CORE X_NUC_132.L_CORE 0.002136
K_15531 X_NUC_88.L_CORE X_NUC_133.L_CORE 0.001404
K_15532 X_NUC_88.L_CORE X_NUC_134.L_CORE 0.001401
K_15533 X_NUC_88.L_CORE X_NUC_135.L_CORE 0.001397
K_15534 X_NUC_88.L_CORE X_NUC_136.L_CORE 0.001405
K_15535 X_NUC_88.L_CORE X_NUC_137.L_CORE 0.003938
K_15536 X_NUC_88.L_CORE X_NUC_138.L_CORE 0.003939
K_15537 X_NUC_88.L_CORE X_NUC_139.L_CORE 0.003876
K_15538 X_NUC_88.L_CORE X_NUC_140.L_CORE 0.003907
K_15539 X_NUC_88.L_CORE X_NUC_141.L_CORE 0.001541
K_15540 X_NUC_88.L_CORE X_NUC_142.L_CORE 0.001532
K_15541 X_NUC_88.L_CORE X_NUC_143.L_CORE 0.001531
K_15542 X_NUC_88.L_CORE X_NUC_144.L_CORE 0.001536
K_15543 X_NUC_88.L_CORE X_NUC_145.L_CORE 0.001761
K_15544 X_NUC_88.L_CORE X_NUC_146.L_CORE 0.001760
K_15545 X_NUC_88.L_CORE X_NUC_147.L_CORE 0.001749
K_15546 X_NUC_88.L_CORE X_NUC_148.L_CORE 0.001762
K_15547 X_NUC_88.L_CORE X_NUC_149.L_CORE 0.002659
K_15548 X_NUC_88.L_CORE X_NUC_150.L_CORE 0.002637
K_15549 X_NUC_88.L_CORE X_NUC_151.L_CORE 0.002628
K_15550 X_NUC_88.L_CORE X_NUC_152.L_CORE 0.002632
K_15551 X_NUC_88.L_CORE X_NUC_153.L_CORE 0.001453
K_15552 X_NUC_88.L_CORE X_NUC_154.L_CORE 0.001447
K_15553 X_NUC_88.L_CORE X_NUC_155.L_CORE 0.001443
K_15554 X_NUC_88.L_CORE X_NUC_156.L_CORE 0.001450
K_15555 X_NUC_88.L_CORE X_NUC_157.L_CORE 0.002359
K_15556 X_NUC_88.L_CORE X_NUC_158.L_CORE 0.002358
K_15557 X_NUC_88.L_CORE X_NUC_159.L_CORE 0.002336
K_15558 X_NUC_88.L_CORE X_NUC_160.L_CORE 0.002353
K_15559 X_NUC_88.L_CORE X_NUC_161.L_CORE 0.001831
K_15560 X_NUC_88.L_CORE X_NUC_162.L_CORE 0.001820
K_15561 X_NUC_88.L_CORE X_NUC_163.L_CORE 0.001816
K_15562 X_NUC_88.L_CORE X_NUC_164.L_CORE 0.001822
K_15563 X_NUC_88.L_CORE X_NUC_165.L_CORE 0.001660
K_15564 X_NUC_88.L_CORE X_NUC_166.L_CORE 0.001655
K_15565 X_NUC_88.L_CORE X_NUC_167.L_CORE 0.001647
K_15566 X_NUC_88.L_CORE X_NUC_168.L_CORE 0.001657
K_15567 X_NUC_88.L_CORE X_NUC_169.L_CORE 0.002085
K_15568 X_NUC_88.L_CORE X_NUC_170.L_CORE 0.002077
K_15569 X_NUC_88.L_CORE X_NUC_171.L_CORE 0.002065
K_15570 X_NUC_88.L_CORE X_NUC_172.L_CORE 0.002075
K_15571 X_NUC_88.L_CORE X_NUC_173.L_CORE 0.001964
K_15572 X_NUC_88.L_CORE X_NUC_174.L_CORE 0.001598
K_15573 X_NUC_88.L_CORE X_NUC_175.L_CORE 0.001743
K_15574 X_NUC_88.L_CORE X_NUC_176.L_CORE 0.002204
K_15575 X_NUC_88.L_CORE X_NUC_177.L_CORE 0.001407
K_15576 X_NUC_88.L_CORE X_NUC_178.L_CORE 0.002430
K_15577 X_NUC_88.L_CORE X_NUC_179.L_CORE 0.001693
K_15578 X_NUC_88.L_CORE X_NUC_180.L_CORE 0.001484
K_15579 X_NUC_88.L_CORE X_NUC_181.L_CORE 0.003395
K_15580 X_NUC_88.L_CORE X_NUC_182.L_CORE 0.001363
K_15581 X_NUC_88.L_CORE X_NUC_183.L_CORE 0.002022
K_15582 X_NUC_88.L_CORE X_NUC_184.L_CORE 0.002200
K_15583 X_NUC_88.L_CORE X_NUC_185.L_CORE 0.001315
K_15584 X_NUC_88.L_CORE X_NUC_186.L_CORE 0.004266
K_15585 X_NUC_88.L_CORE X_NUC_187.L_CORE 0.001484
K_15586 X_NUC_88.L_CORE X_NUC_188.L_CORE 0.001582
K_15587 X_NUC_88.L_CORE X_NUC_189.L_CORE 0.003869
K_15588 X_NUC_88.L_CORE X_NUC_190.L_CORE 0.001268
K_15589 X_NUC_88.L_CORE X_NUC_191.L_CORE 0.002730
K_15590 X_NUC_88.L_CORE X_NUC_192.L_CORE 0.001848
K_15591 X_NUC_88.L_CORE X_NUC_193.L_CORE 0.001343
K_15592 X_NUC_88.L_CORE X_NUC_194.L_CORE 0.015472
K_15593 X_NUC_88.L_CORE X_NUC_195.L_CORE 0.001342
K_15594 X_NUC_88.L_CORE X_NUC_196.L_CORE 0.001844
K_15595 X_NUC_88.L_CORE X_NUC_197.L_CORE 0.002826
K_15596 X_NUC_88.L_CORE X_NUC_198.L_CORE 0.001254
K_15597 X_NUC_88.L_CORE X_NUC_199.L_CORE 0.004390
K_15598 X_NUC_88.L_CORE X_NUC_200.L_CORE 0.001577
K_15599 X_NUC_88.L_CORE X_NUC_201.L_CORE 0.001462
K_15600 X_NUC_88.L_CORE X_NUC_202.L_CORE 0.006389
K_15601 X_NUC_88.L_CORE X_NUC_203.L_CORE 0.001282
K_15602 X_NUC_88.L_CORE X_NUC_204.L_CORE 0.002291
K_15603 X_NUC_88.L_CORE X_NUC_205.L_CORE 0.002094
K_15604 X_NUC_88.L_CORE X_NUC_206.L_CORE 0.001312
K_15605 X_NUC_88.L_CORE X_NUC_207.L_CORE 0.005639
K_15606 X_NUC_88.L_CORE X_NUC_208.L_CORE 0.001434
K_15607 X_NUC_88.L_CORE X_NUC_209.L_CORE 0.001672
K_15608 X_NUC_88.L_CORE X_NUC_210.L_CORE 0.003049
K_15609 X_NUC_88.L_CORE X_NUC_211.L_CORE 0.001303
K_15610 X_NUC_88.L_CORE X_NUC_212.L_CORE 0.002712
K_15611 X_NUC_88.L_CORE X_NUC_213.L_CORE 0.001739
K_15612 X_NUC_88.L_CORE X_NUC_214.L_CORE 0.001451
K_15613 X_NUC_88.L_CORE X_NUC_215.L_CORE 0.003275
K_15614 X_NUC_88.L_CORE X_NUC_216.L_CORE 0.001420
K_15615 X_NUC_88.L_CORE X_NUC_217.L_CORE 0.001902
K_15616 X_NUC_88.L_CORE X_NUC_218.L_CORE 0.002094
K_15617 X_NUC_88.L_CORE X_NUC_219.L_CORE 0.001450
K_15618 X_NUC_88.L_CORE X_NUC_220.L_CORE 0.002275
K_15619 X_NUC_88.L_CORE X_NUC_221.L_CORE 0.001664
K_15620 X_NUC_88.L_CORE X_NUC_222.L_CORE 0.001712
K_15621 X_NUC_89.L_CORE X_NUC_90.L_CORE 0.207973
K_15622 X_NUC_89.L_CORE X_NUC_91.L_CORE 0.207973
K_15623 X_NUC_89.L_CORE X_NUC_92.L_CORE 0.207973
K_15624 X_NUC_89.L_CORE X_NUC_93.L_CORE 0.001400
K_15625 X_NUC_89.L_CORE X_NUC_94.L_CORE 0.001410
K_15626 X_NUC_89.L_CORE X_NUC_95.L_CORE 0.001404
K_15627 X_NUC_89.L_CORE X_NUC_96.L_CORE 0.001406
K_15628 X_NUC_89.L_CORE X_NUC_97.L_CORE 0.001933
K_15629 X_NUC_89.L_CORE X_NUC_98.L_CORE 0.001943
K_15630 X_NUC_89.L_CORE X_NUC_99.L_CORE 0.001945
K_15631 X_NUC_89.L_CORE X_NUC_100.L_CORE 0.001930
K_15632 X_NUC_89.L_CORE X_NUC_101.L_CORE 0.002933
K_15633 X_NUC_89.L_CORE X_NUC_102.L_CORE 0.002958
K_15634 X_NUC_89.L_CORE X_NUC_103.L_CORE 0.002924
K_15635 X_NUC_89.L_CORE X_NUC_104.L_CORE 0.002957
K_15636 X_NUC_89.L_CORE X_NUC_105.L_CORE 0.001320
K_15637 X_NUC_89.L_CORE X_NUC_106.L_CORE 0.001328
K_15638 X_NUC_89.L_CORE X_NUC_107.L_CORE 0.001325
K_15639 X_NUC_89.L_CORE X_NUC_108.L_CORE 0.001322
K_15640 X_NUC_89.L_CORE X_NUC_109.L_CORE 0.004368
K_15641 X_NUC_89.L_CORE X_NUC_110.L_CORE 0.004382
K_15642 X_NUC_89.L_CORE X_NUC_111.L_CORE 0.004391
K_15643 X_NUC_89.L_CORE X_NUC_112.L_CORE 0.004309
K_15644 X_NUC_89.L_CORE X_NUC_113.L_CORE 0.001660
K_15645 X_NUC_89.L_CORE X_NUC_114.L_CORE 0.001672
K_15646 X_NUC_89.L_CORE X_NUC_115.L_CORE 0.001661
K_15647 X_NUC_89.L_CORE X_NUC_116.L_CORE 0.001667
K_15648 X_NUC_89.L_CORE X_NUC_117.L_CORE 0.001551
K_15649 X_NUC_89.L_CORE X_NUC_118.L_CORE 0.001559
K_15650 X_NUC_89.L_CORE X_NUC_119.L_CORE 0.001557
K_15651 X_NUC_89.L_CORE X_NUC_120.L_CORE 0.001550
K_15652 X_NUC_89.L_CORE X_NUC_121.L_CORE 0.005139
K_15653 X_NUC_89.L_CORE X_NUC_122.L_CORE 0.005188
K_15654 X_NUC_89.L_CORE X_NUC_123.L_CORE 0.005063
K_15655 X_NUC_89.L_CORE X_NUC_124.L_CORE 0.005131
K_15656 X_NUC_89.L_CORE X_NUC_125.L_CORE 0.001374
K_15657 X_NUC_89.L_CORE X_NUC_126.L_CORE 0.001383
K_15658 X_NUC_89.L_CORE X_NUC_127.L_CORE 0.001377
K_15659 X_NUC_89.L_CORE X_NUC_128.L_CORE 0.001377
K_15660 X_NUC_89.L_CORE X_NUC_129.L_CORE 0.002353
K_15661 X_NUC_89.L_CORE X_NUC_130.L_CORE 0.002365
K_15662 X_NUC_89.L_CORE X_NUC_131.L_CORE 0.002361
K_15663 X_NUC_89.L_CORE X_NUC_132.L_CORE 0.002340
K_15664 X_NUC_89.L_CORE X_NUC_133.L_CORE 0.002161
K_15665 X_NUC_89.L_CORE X_NUC_134.L_CORE 0.002177
K_15666 X_NUC_89.L_CORE X_NUC_135.L_CORE 0.002156
K_15667 X_NUC_89.L_CORE X_NUC_136.L_CORE 0.002168
K_15668 X_NUC_89.L_CORE X_NUC_137.L_CORE 0.001429
K_15669 X_NUC_89.L_CORE X_NUC_138.L_CORE 0.001438
K_15670 X_NUC_89.L_CORE X_NUC_139.L_CORE 0.001433
K_15671 X_NUC_89.L_CORE X_NUC_140.L_CORE 0.001429
K_15672 X_NUC_89.L_CORE X_NUC_141.L_CORE 0.003845
K_15673 X_NUC_89.L_CORE X_NUC_142.L_CORE 0.003869
K_15674 X_NUC_89.L_CORE X_NUC_143.L_CORE 0.003823
K_15675 X_NUC_89.L_CORE X_NUC_144.L_CORE 0.003802
K_15676 X_NUC_89.L_CORE X_NUC_145.L_CORE 0.001568
K_15677 X_NUC_89.L_CORE X_NUC_146.L_CORE 0.001579
K_15678 X_NUC_89.L_CORE X_NUC_147.L_CORE 0.001569
K_15679 X_NUC_89.L_CORE X_NUC_148.L_CORE 0.001571
K_15680 X_NUC_89.L_CORE X_NUC_149.L_CORE 0.001796
K_15681 X_NUC_89.L_CORE X_NUC_150.L_CORE 0.001806
K_15682 X_NUC_89.L_CORE X_NUC_151.L_CORE 0.001800
K_15683 X_NUC_89.L_CORE X_NUC_152.L_CORE 0.001791
K_15684 X_NUC_89.L_CORE X_NUC_153.L_CORE 0.002615
K_15685 X_NUC_89.L_CORE X_NUC_154.L_CORE 0.002635
K_15686 X_NUC_89.L_CORE X_NUC_155.L_CORE 0.002603
K_15687 X_NUC_89.L_CORE X_NUC_156.L_CORE 0.002613
K_15688 X_NUC_89.L_CORE X_NUC_157.L_CORE 0.001500
K_15689 X_NUC_89.L_CORE X_NUC_158.L_CORE 0.001510
K_15690 X_NUC_89.L_CORE X_NUC_159.L_CORE 0.001502
K_15691 X_NUC_89.L_CORE X_NUC_160.L_CORE 0.001500
K_15692 X_NUC_89.L_CORE X_NUC_161.L_CORE 0.002324
K_15693 X_NUC_89.L_CORE X_NUC_162.L_CORE 0.002338
K_15694 X_NUC_89.L_CORE X_NUC_163.L_CORE 0.002323
K_15695 X_NUC_89.L_CORE X_NUC_164.L_CORE 0.002312
K_15696 X_NUC_89.L_CORE X_NUC_165.L_CORE 0.001866
K_15697 X_NUC_89.L_CORE X_NUC_166.L_CORE 0.001879
K_15698 X_NUC_89.L_CORE X_NUC_167.L_CORE 0.001864
K_15699 X_NUC_89.L_CORE X_NUC_168.L_CORE 0.001866
K_15700 X_NUC_89.L_CORE X_NUC_169.L_CORE 0.001762
K_15701 X_NUC_89.L_CORE X_NUC_170.L_CORE 0.001773
K_15702 X_NUC_89.L_CORE X_NUC_171.L_CORE 0.001763
K_15703 X_NUC_89.L_CORE X_NUC_172.L_CORE 0.001759
K_15704 X_NUC_89.L_CORE X_NUC_173.L_CORE 0.001617
K_15705 X_NUC_89.L_CORE X_NUC_174.L_CORE 0.002116
K_15706 X_NUC_89.L_CORE X_NUC_175.L_CORE 0.001547
K_15707 X_NUC_89.L_CORE X_NUC_176.L_CORE 0.001723
K_15708 X_NUC_89.L_CORE X_NUC_177.L_CORE 0.002235
K_15709 X_NUC_89.L_CORE X_NUC_178.L_CORE 0.001379
K_15710 X_NUC_89.L_CORE X_NUC_179.L_CORE 0.002462
K_15711 X_NUC_89.L_CORE X_NUC_180.L_CORE 0.001677
K_15712 X_NUC_89.L_CORE X_NUC_181.L_CORE 0.001469
K_15713 X_NUC_89.L_CORE X_NUC_182.L_CORE 0.003460
K_15714 X_NUC_89.L_CORE X_NUC_183.L_CORE 0.001351
K_15715 X_NUC_89.L_CORE X_NUC_184.L_CORE 0.002019
K_15716 X_NUC_89.L_CORE X_NUC_185.L_CORE 0.002193
K_15717 X_NUC_89.L_CORE X_NUC_186.L_CORE 0.001309
K_15718 X_NUC_89.L_CORE X_NUC_187.L_CORE 0.004313
K_15719 X_NUC_89.L_CORE X_NUC_188.L_CORE 0.001479
K_15720 X_NUC_89.L_CORE X_NUC_189.L_CORE 0.001582
K_15721 X_NUC_89.L_CORE X_NUC_190.L_CORE 0.003866
K_15722 X_NUC_89.L_CORE X_NUC_191.L_CORE 0.001268
K_15723 X_NUC_89.L_CORE X_NUC_192.L_CORE 0.002741
K_15724 X_NUC_89.L_CORE X_NUC_193.L_CORE 0.001849
K_15725 X_NUC_89.L_CORE X_NUC_194.L_CORE 0.001348
K_15726 X_NUC_89.L_CORE X_NUC_195.L_CORE 0.015249
K_15727 X_NUC_89.L_CORE X_NUC_196.L_CORE 0.001347
K_15728 X_NUC_89.L_CORE X_NUC_197.L_CORE 0.001855
K_15729 X_NUC_89.L_CORE X_NUC_198.L_CORE 0.002832
K_15730 X_NUC_89.L_CORE X_NUC_199.L_CORE 0.001262
K_15731 X_NUC_89.L_CORE X_NUC_200.L_CORE 0.004430
K_15732 X_NUC_89.L_CORE X_NUC_201.L_CORE 0.001588
K_15733 X_NUC_89.L_CORE X_NUC_202.L_CORE 0.001476
K_15734 X_NUC_89.L_CORE X_NUC_203.L_CORE 0.006354
K_15735 X_NUC_89.L_CORE X_NUC_204.L_CORE 0.001295
K_15736 X_NUC_89.L_CORE X_NUC_205.L_CORE 0.002319
K_15737 X_NUC_89.L_CORE X_NUC_206.L_CORE 0.002114
K_15738 X_NUC_89.L_CORE X_NUC_207.L_CORE 0.001330
K_15739 X_NUC_89.L_CORE X_NUC_208.L_CORE 0.005613
K_15740 X_NUC_89.L_CORE X_NUC_209.L_CORE 0.001455
K_15741 X_NUC_89.L_CORE X_NUC_210.L_CORE 0.001699
K_15742 X_NUC_89.L_CORE X_NUC_211.L_CORE 0.003062
K_15743 X_NUC_89.L_CORE X_NUC_212.L_CORE 0.001328
K_15744 X_NUC_89.L_CORE X_NUC_213.L_CORE 0.002736
K_15745 X_NUC_89.L_CORE X_NUC_214.L_CORE 0.001769
K_15746 X_NUC_89.L_CORE X_NUC_215.L_CORE 0.001486
K_15747 X_NUC_89.L_CORE X_NUC_216.L_CORE 0.003214
K_15748 X_NUC_89.L_CORE X_NUC_217.L_CORE 0.001460
K_15749 X_NUC_89.L_CORE X_NUC_218.L_CORE 0.001935
K_15750 X_NUC_89.L_CORE X_NUC_219.L_CORE 0.002105
K_15751 X_NUC_89.L_CORE X_NUC_220.L_CORE 0.001513
K_15752 X_NUC_89.L_CORE X_NUC_221.L_CORE 0.002198
K_15753 X_NUC_89.L_CORE X_NUC_222.L_CORE 0.001744
K_15754 X_NUC_90.L_CORE X_NUC_91.L_CORE 0.207973
K_15755 X_NUC_90.L_CORE X_NUC_92.L_CORE 0.207973
K_15756 X_NUC_90.L_CORE X_NUC_93.L_CORE 0.001391
K_15757 X_NUC_90.L_CORE X_NUC_94.L_CORE 0.001400
K_15758 X_NUC_90.L_CORE X_NUC_95.L_CORE 0.001395
K_15759 X_NUC_90.L_CORE X_NUC_96.L_CORE 0.001396
K_15760 X_NUC_90.L_CORE X_NUC_97.L_CORE 0.001924
K_15761 X_NUC_90.L_CORE X_NUC_98.L_CORE 0.001933
K_15762 X_NUC_90.L_CORE X_NUC_99.L_CORE 0.001935
K_15763 X_NUC_90.L_CORE X_NUC_100.L_CORE 0.001920
K_15764 X_NUC_90.L_CORE X_NUC_101.L_CORE 0.002908
K_15765 X_NUC_90.L_CORE X_NUC_102.L_CORE 0.002933
K_15766 X_NUC_90.L_CORE X_NUC_103.L_CORE 0.002900
K_15767 X_NUC_90.L_CORE X_NUC_104.L_CORE 0.002932
K_15768 X_NUC_90.L_CORE X_NUC_105.L_CORE 0.001312
K_15769 X_NUC_90.L_CORE X_NUC_106.L_CORE 0.001320
K_15770 X_NUC_90.L_CORE X_NUC_107.L_CORE 0.001316
K_15771 X_NUC_90.L_CORE X_NUC_108.L_CORE 0.001314
K_15772 X_NUC_90.L_CORE X_NUC_109.L_CORE 0.004353
K_15773 X_NUC_90.L_CORE X_NUC_110.L_CORE 0.004368
K_15774 X_NUC_90.L_CORE X_NUC_111.L_CORE 0.004376
K_15775 X_NUC_90.L_CORE X_NUC_112.L_CORE 0.004295
K_15776 X_NUC_90.L_CORE X_NUC_113.L_CORE 0.001649
K_15777 X_NUC_90.L_CORE X_NUC_114.L_CORE 0.001660
K_15778 X_NUC_90.L_CORE X_NUC_115.L_CORE 0.001650
K_15779 X_NUC_90.L_CORE X_NUC_116.L_CORE 0.001656
K_15780 X_NUC_90.L_CORE X_NUC_117.L_CORE 0.001542
K_15781 X_NUC_90.L_CORE X_NUC_118.L_CORE 0.001551
K_15782 X_NUC_90.L_CORE X_NUC_119.L_CORE 0.001548
K_15783 X_NUC_90.L_CORE X_NUC_120.L_CORE 0.001541
K_15784 X_NUC_90.L_CORE X_NUC_121.L_CORE 0.005088
K_15785 X_NUC_90.L_CORE X_NUC_122.L_CORE 0.005139
K_15786 X_NUC_90.L_CORE X_NUC_123.L_CORE 0.005016
K_15787 X_NUC_90.L_CORE X_NUC_124.L_CORE 0.005082
K_15788 X_NUC_90.L_CORE X_NUC_125.L_CORE 0.001365
K_15789 X_NUC_90.L_CORE X_NUC_126.L_CORE 0.001374
K_15790 X_NUC_90.L_CORE X_NUC_127.L_CORE 0.001368
K_15791 X_NUC_90.L_CORE X_NUC_128.L_CORE 0.001368
K_15792 X_NUC_90.L_CORE X_NUC_129.L_CORE 0.002341
K_15793 X_NUC_90.L_CORE X_NUC_130.L_CORE 0.002353
K_15794 X_NUC_90.L_CORE X_NUC_131.L_CORE 0.002349
K_15795 X_NUC_90.L_CORE X_NUC_132.L_CORE 0.002329
K_15796 X_NUC_90.L_CORE X_NUC_133.L_CORE 0.002145
K_15797 X_NUC_90.L_CORE X_NUC_134.L_CORE 0.002161
K_15798 X_NUC_90.L_CORE X_NUC_135.L_CORE 0.002140
K_15799 X_NUC_90.L_CORE X_NUC_136.L_CORE 0.002152
K_15800 X_NUC_90.L_CORE X_NUC_137.L_CORE 0.001420
K_15801 X_NUC_90.L_CORE X_NUC_138.L_CORE 0.001429
K_15802 X_NUC_90.L_CORE X_NUC_139.L_CORE 0.001424
K_15803 X_NUC_90.L_CORE X_NUC_140.L_CORE 0.001421
K_15804 X_NUC_90.L_CORE X_NUC_141.L_CORE 0.003821
K_15805 X_NUC_90.L_CORE X_NUC_142.L_CORE 0.003845
K_15806 X_NUC_90.L_CORE X_NUC_143.L_CORE 0.003800
K_15807 X_NUC_90.L_CORE X_NUC_144.L_CORE 0.003779
K_15808 X_NUC_90.L_CORE X_NUC_145.L_CORE 0.001557
K_15809 X_NUC_90.L_CORE X_NUC_146.L_CORE 0.001568
K_15810 X_NUC_90.L_CORE X_NUC_147.L_CORE 0.001558
K_15811 X_NUC_90.L_CORE X_NUC_148.L_CORE 0.001560
K_15812 X_NUC_90.L_CORE X_NUC_149.L_CORE 0.001786
K_15813 X_NUC_90.L_CORE X_NUC_150.L_CORE 0.001796
K_15814 X_NUC_90.L_CORE X_NUC_151.L_CORE 0.001790
K_15815 X_NUC_90.L_CORE X_NUC_152.L_CORE 0.001781
K_15816 X_NUC_90.L_CORE X_NUC_153.L_CORE 0.002596
K_15817 X_NUC_90.L_CORE X_NUC_154.L_CORE 0.002615
K_15818 X_NUC_90.L_CORE X_NUC_155.L_CORE 0.002584
K_15819 X_NUC_90.L_CORE X_NUC_156.L_CORE 0.002593
K_15820 X_NUC_90.L_CORE X_NUC_157.L_CORE 0.001491
K_15821 X_NUC_90.L_CORE X_NUC_158.L_CORE 0.001500
K_15822 X_NUC_90.L_CORE X_NUC_159.L_CORE 0.001493
K_15823 X_NUC_90.L_CORE X_NUC_160.L_CORE 0.001491
K_15824 X_NUC_90.L_CORE X_NUC_161.L_CORE 0.002310
K_15825 X_NUC_90.L_CORE X_NUC_162.L_CORE 0.002324
K_15826 X_NUC_90.L_CORE X_NUC_163.L_CORE 0.002309
K_15827 X_NUC_90.L_CORE X_NUC_164.L_CORE 0.002299
K_15828 X_NUC_90.L_CORE X_NUC_165.L_CORE 0.001853
K_15829 X_NUC_90.L_CORE X_NUC_166.L_CORE 0.001866
K_15830 X_NUC_90.L_CORE X_NUC_167.L_CORE 0.001851
K_15831 X_NUC_90.L_CORE X_NUC_168.L_CORE 0.001853
K_15832 X_NUC_90.L_CORE X_NUC_169.L_CORE 0.001751
K_15833 X_NUC_90.L_CORE X_NUC_170.L_CORE 0.001762
K_15834 X_NUC_90.L_CORE X_NUC_171.L_CORE 0.001752
K_15835 X_NUC_90.L_CORE X_NUC_172.L_CORE 0.001748
K_15836 X_NUC_90.L_CORE X_NUC_173.L_CORE 0.001608
K_15837 X_NUC_90.L_CORE X_NUC_174.L_CORE 0.002106
K_15838 X_NUC_90.L_CORE X_NUC_175.L_CORE 0.001538
K_15839 X_NUC_90.L_CORE X_NUC_176.L_CORE 0.001715
K_15840 X_NUC_90.L_CORE X_NUC_177.L_CORE 0.002223
K_15841 X_NUC_90.L_CORE X_NUC_178.L_CORE 0.001371
K_15842 X_NUC_90.L_CORE X_NUC_179.L_CORE 0.002452
K_15843 X_NUC_90.L_CORE X_NUC_180.L_CORE 0.001666
K_15844 X_NUC_90.L_CORE X_NUC_181.L_CORE 0.001462
K_15845 X_NUC_90.L_CORE X_NUC_182.L_CORE 0.003445
K_15846 X_NUC_90.L_CORE X_NUC_183.L_CORE 0.001343
K_15847 X_NUC_90.L_CORE X_NUC_184.L_CORE 0.002010
K_15848 X_NUC_90.L_CORE X_NUC_185.L_CORE 0.002179
K_15849 X_NUC_90.L_CORE X_NUC_186.L_CORE 0.001302
K_15850 X_NUC_90.L_CORE X_NUC_187.L_CORE 0.004310
K_15851 X_NUC_90.L_CORE X_NUC_188.L_CORE 0.001470
K_15852 X_NUC_90.L_CORE X_NUC_189.L_CORE 0.001574
K_15853 X_NUC_90.L_CORE X_NUC_190.L_CORE 0.003842
K_15854 X_NUC_90.L_CORE X_NUC_191.L_CORE 0.001261
K_15855 X_NUC_90.L_CORE X_NUC_192.L_CORE 0.002733
K_15856 X_NUC_90.L_CORE X_NUC_193.L_CORE 0.001837
K_15857 X_NUC_90.L_CORE X_NUC_194.L_CORE 0.001341
K_15858 X_NUC_90.L_CORE X_NUC_195.L_CORE 0.015759
K_15859 X_NUC_90.L_CORE X_NUC_196.L_CORE 0.001339
K_15860 X_NUC_90.L_CORE X_NUC_197.L_CORE 0.001847
K_15861 X_NUC_90.L_CORE X_NUC_198.L_CORE 0.002812
K_15862 X_NUC_90.L_CORE X_NUC_199.L_CORE 0.001255
K_15863 X_NUC_90.L_CORE X_NUC_200.L_CORE 0.004432
K_15864 X_NUC_90.L_CORE X_NUC_201.L_CORE 0.001577
K_15865 X_NUC_90.L_CORE X_NUC_202.L_CORE 0.001469
K_15866 X_NUC_90.L_CORE X_NUC_203.L_CORE 0.006320
K_15867 X_NUC_90.L_CORE X_NUC_204.L_CORE 0.001287
K_15868 X_NUC_90.L_CORE X_NUC_205.L_CORE 0.002310
K_15869 X_NUC_90.L_CORE X_NUC_206.L_CORE 0.002100
K_15870 X_NUC_90.L_CORE X_NUC_207.L_CORE 0.001322
K_15871 X_NUC_90.L_CORE X_NUC_208.L_CORE 0.005611
K_15872 X_NUC_90.L_CORE X_NUC_209.L_CORE 0.001445
K_15873 X_NUC_90.L_CORE X_NUC_210.L_CORE 0.001691
K_15874 X_NUC_90.L_CORE X_NUC_211.L_CORE 0.003041
K_15875 X_NUC_90.L_CORE X_NUC_212.L_CORE 0.001320
K_15876 X_NUC_90.L_CORE X_NUC_213.L_CORE 0.002725
K_15877 X_NUC_90.L_CORE X_NUC_214.L_CORE 0.001758
K_15878 X_NUC_90.L_CORE X_NUC_215.L_CORE 0.001478
K_15879 X_NUC_90.L_CORE X_NUC_216.L_CORE 0.003196
K_15880 X_NUC_90.L_CORE X_NUC_217.L_CORE 0.001451
K_15881 X_NUC_90.L_CORE X_NUC_218.L_CORE 0.001925
K_15882 X_NUC_90.L_CORE X_NUC_219.L_CORE 0.002092
K_15883 X_NUC_90.L_CORE X_NUC_220.L_CORE 0.001504
K_15884 X_NUC_90.L_CORE X_NUC_221.L_CORE 0.002185
K_15885 X_NUC_90.L_CORE X_NUC_222.L_CORE 0.001734
K_15886 X_NUC_91.L_CORE X_NUC_92.L_CORE 0.207973
K_15887 X_NUC_91.L_CORE X_NUC_93.L_CORE 0.001397
K_15888 X_NUC_91.L_CORE X_NUC_94.L_CORE 0.001406
K_15889 X_NUC_91.L_CORE X_NUC_95.L_CORE 0.001400
K_15890 X_NUC_91.L_CORE X_NUC_96.L_CORE 0.001402
K_15891 X_NUC_91.L_CORE X_NUC_97.L_CORE 0.001922
K_15892 X_NUC_91.L_CORE X_NUC_98.L_CORE 0.001931
K_15893 X_NUC_91.L_CORE X_NUC_99.L_CORE 0.001933
K_15894 X_NUC_91.L_CORE X_NUC_100.L_CORE 0.001918
K_15895 X_NUC_91.L_CORE X_NUC_101.L_CORE 0.002941
K_15896 X_NUC_91.L_CORE X_NUC_102.L_CORE 0.002966
K_15897 X_NUC_91.L_CORE X_NUC_103.L_CORE 0.002933
K_15898 X_NUC_91.L_CORE X_NUC_104.L_CORE 0.002965
K_15899 X_NUC_91.L_CORE X_NUC_105.L_CORE 0.001315
K_15900 X_NUC_91.L_CORE X_NUC_106.L_CORE 0.001323
K_15901 X_NUC_91.L_CORE X_NUC_107.L_CORE 0.001320
K_15902 X_NUC_91.L_CORE X_NUC_108.L_CORE 0.001318
K_15903 X_NUC_91.L_CORE X_NUC_109.L_CORE 0.004344
K_15904 X_NUC_91.L_CORE X_NUC_110.L_CORE 0.004358
K_15905 X_NUC_91.L_CORE X_NUC_111.L_CORE 0.004368
K_15906 X_NUC_91.L_CORE X_NUC_112.L_CORE 0.004287
K_15907 X_NUC_91.L_CORE X_NUC_113.L_CORE 0.001659
K_15908 X_NUC_91.L_CORE X_NUC_114.L_CORE 0.001671
K_15909 X_NUC_91.L_CORE X_NUC_115.L_CORE 0.001660
K_15910 X_NUC_91.L_CORE X_NUC_116.L_CORE 0.001666
K_15911 X_NUC_91.L_CORE X_NUC_117.L_CORE 0.001544
K_15912 X_NUC_91.L_CORE X_NUC_118.L_CORE 0.001553
K_15913 X_NUC_91.L_CORE X_NUC_119.L_CORE 0.001551
K_15914 X_NUC_91.L_CORE X_NUC_120.L_CORE 0.001543
K_15915 X_NUC_91.L_CORE X_NUC_121.L_CORE 0.005215
K_15916 X_NUC_91.L_CORE X_NUC_122.L_CORE 0.005268
K_15917 X_NUC_91.L_CORE X_NUC_123.L_CORE 0.005139
K_15918 X_NUC_91.L_CORE X_NUC_124.L_CORE 0.005209
K_15919 X_NUC_91.L_CORE X_NUC_125.L_CORE 0.001371
K_15920 X_NUC_91.L_CORE X_NUC_126.L_CORE 0.001380
K_15921 X_NUC_91.L_CORE X_NUC_127.L_CORE 0.001374
K_15922 X_NUC_91.L_CORE X_NUC_128.L_CORE 0.001374
K_15923 X_NUC_91.L_CORE X_NUC_129.L_CORE 0.002344
K_15924 X_NUC_91.L_CORE X_NUC_130.L_CORE 0.002356
K_15925 X_NUC_91.L_CORE X_NUC_131.L_CORE 0.002353
K_15926 X_NUC_91.L_CORE X_NUC_132.L_CORE 0.002332
K_15927 X_NUC_91.L_CORE X_NUC_133.L_CORE 0.002165
K_15928 X_NUC_91.L_CORE X_NUC_134.L_CORE 0.002182
K_15929 X_NUC_91.L_CORE X_NUC_135.L_CORE 0.002161
K_15930 X_NUC_91.L_CORE X_NUC_136.L_CORE 0.002173
K_15931 X_NUC_91.L_CORE X_NUC_137.L_CORE 0.001425
K_15932 X_NUC_91.L_CORE X_NUC_138.L_CORE 0.001434
K_15933 X_NUC_91.L_CORE X_NUC_139.L_CORE 0.001429
K_15934 X_NUC_91.L_CORE X_NUC_140.L_CORE 0.001425
K_15935 X_NUC_91.L_CORE X_NUC_141.L_CORE 0.003867
K_15936 X_NUC_91.L_CORE X_NUC_142.L_CORE 0.003891
K_15937 X_NUC_91.L_CORE X_NUC_143.L_CORE 0.003845
K_15938 X_NUC_91.L_CORE X_NUC_144.L_CORE 0.003823
K_15939 X_NUC_91.L_CORE X_NUC_145.L_CORE 0.001567
K_15940 X_NUC_91.L_CORE X_NUC_146.L_CORE 0.001578
K_15941 X_NUC_91.L_CORE X_NUC_147.L_CORE 0.001568
K_15942 X_NUC_91.L_CORE X_NUC_148.L_CORE 0.001570
K_15943 X_NUC_91.L_CORE X_NUC_149.L_CORE 0.001792
K_15944 X_NUC_91.L_CORE X_NUC_150.L_CORE 0.001802
K_15945 X_NUC_91.L_CORE X_NUC_151.L_CORE 0.001796
K_15946 X_NUC_91.L_CORE X_NUC_152.L_CORE 0.001787
K_15947 X_NUC_91.L_CORE X_NUC_153.L_CORE 0.002628
K_15948 X_NUC_91.L_CORE X_NUC_154.L_CORE 0.002648
K_15949 X_NUC_91.L_CORE X_NUC_155.L_CORE 0.002615
K_15950 X_NUC_91.L_CORE X_NUC_156.L_CORE 0.002625
K_15951 X_NUC_91.L_CORE X_NUC_157.L_CORE 0.001498
K_15952 X_NUC_91.L_CORE X_NUC_158.L_CORE 0.001507
K_15953 X_NUC_91.L_CORE X_NUC_159.L_CORE 0.001500
K_15954 X_NUC_91.L_CORE X_NUC_160.L_CORE 0.001498
K_15955 X_NUC_91.L_CORE X_NUC_161.L_CORE 0.002326
K_15956 X_NUC_91.L_CORE X_NUC_162.L_CORE 0.002340
K_15957 X_NUC_91.L_CORE X_NUC_163.L_CORE 0.002324
K_15958 X_NUC_91.L_CORE X_NUC_164.L_CORE 0.002314
K_15959 X_NUC_91.L_CORE X_NUC_165.L_CORE 0.001868
K_15960 X_NUC_91.L_CORE X_NUC_166.L_CORE 0.001881
K_15961 X_NUC_91.L_CORE X_NUC_167.L_CORE 0.001866
K_15962 X_NUC_91.L_CORE X_NUC_168.L_CORE 0.001868
K_15963 X_NUC_91.L_CORE X_NUC_169.L_CORE 0.001761
K_15964 X_NUC_91.L_CORE X_NUC_170.L_CORE 0.001773
K_15965 X_NUC_91.L_CORE X_NUC_171.L_CORE 0.001762
K_15966 X_NUC_91.L_CORE X_NUC_172.L_CORE 0.001758
K_15967 X_NUC_91.L_CORE X_NUC_173.L_CORE 0.001606
K_15968 X_NUC_91.L_CORE X_NUC_174.L_CORE 0.002097
K_15969 X_NUC_91.L_CORE X_NUC_175.L_CORE 0.001538
K_15970 X_NUC_91.L_CORE X_NUC_176.L_CORE 0.001709
K_15971 X_NUC_91.L_CORE X_NUC_177.L_CORE 0.002219
K_15972 X_NUC_91.L_CORE X_NUC_178.L_CORE 0.001372
K_15973 X_NUC_91.L_CORE X_NUC_179.L_CORE 0.002434
K_15974 X_NUC_91.L_CORE X_NUC_180.L_CORE 0.001669
K_15975 X_NUC_91.L_CORE X_NUC_181.L_CORE 0.001460
K_15976 X_NUC_91.L_CORE X_NUC_182.L_CORE 0.003420
K_15977 X_NUC_91.L_CORE X_NUC_183.L_CORE 0.001345
K_15978 X_NUC_91.L_CORE X_NUC_184.L_CORE 0.002000
K_15979 X_NUC_91.L_CORE X_NUC_185.L_CORE 0.002185
K_15980 X_NUC_91.L_CORE X_NUC_186.L_CORE 0.001303
K_15981 X_NUC_91.L_CORE X_NUC_187.L_CORE 0.004236
K_15982 X_NUC_91.L_CORE X_NUC_188.L_CORE 0.001474
K_15983 X_NUC_91.L_CORE X_NUC_189.L_CORE 0.001572
K_15984 X_NUC_91.L_CORE X_NUC_190.L_CORE 0.003854
K_15985 X_NUC_91.L_CORE X_NUC_191.L_CORE 0.001263
K_15986 X_NUC_91.L_CORE X_NUC_192.L_CORE 0.002713
K_15987 X_NUC_91.L_CORE X_NUC_193.L_CORE 0.001846
K_15988 X_NUC_91.L_CORE X_NUC_194.L_CORE 0.001341
K_15989 X_NUC_91.L_CORE X_NUC_195.L_CORE 0.014837
K_15990 X_NUC_91.L_CORE X_NUC_196.L_CORE 0.001344
K_15991 X_NUC_91.L_CORE X_NUC_197.L_CORE 0.001844
K_15992 X_NUC_91.L_CORE X_NUC_198.L_CORE 0.002838
K_15993 X_NUC_91.L_CORE X_NUC_199.L_CORE 0.001258
K_15994 X_NUC_91.L_CORE X_NUC_200.L_CORE 0.004391
K_15995 X_NUC_91.L_CORE X_NUC_201.L_CORE 0.001586
K_15996 X_NUC_91.L_CORE X_NUC_202.L_CORE 0.001470
K_15997 X_NUC_91.L_CORE X_NUC_203.L_CORE 0.006489
K_15998 X_NUC_91.L_CORE X_NUC_204.L_CORE 0.001292
K_15999 X_NUC_91.L_CORE X_NUC_205.L_CORE 0.002307
K_16000 X_NUC_91.L_CORE X_NUC_206.L_CORE 0.002118
K_16001 X_NUC_91.L_CORE X_NUC_207.L_CORE 0.001325
K_16002 X_NUC_91.L_CORE X_NUC_208.L_CORE 0.005672
K_16003 X_NUC_91.L_CORE X_NUC_209.L_CORE 0.001453
K_16004 X_NUC_91.L_CORE X_NUC_210.L_CORE 0.001693
K_16005 X_NUC_91.L_CORE X_NUC_211.L_CORE 0.003086
K_16006 X_NUC_91.L_CORE X_NUC_212.L_CORE 0.001325
K_16007 X_NUC_91.L_CORE X_NUC_213.L_CORE 0.002735
K_16008 X_NUC_91.L_CORE X_NUC_214.L_CORE 0.001771
K_16009 X_NUC_91.L_CORE X_NUC_215.L_CORE 0.001482
K_16010 X_NUC_91.L_CORE X_NUC_216.L_CORE 0.003239
K_16011 X_NUC_91.L_CORE X_NUC_217.L_CORE 0.001459
K_16012 X_NUC_91.L_CORE X_NUC_218.L_CORE 0.001933
K_16013 X_NUC_91.L_CORE X_NUC_219.L_CORE 0.002112
K_16014 X_NUC_91.L_CORE X_NUC_220.L_CORE 0.001512
K_16015 X_NUC_91.L_CORE X_NUC_221.L_CORE 0.002202
K_16016 X_NUC_91.L_CORE X_NUC_222.L_CORE 0.001746
K_16017 X_NUC_92.L_CORE X_NUC_93.L_CORE 0.001395
K_16018 X_NUC_92.L_CORE X_NUC_94.L_CORE 0.001404
K_16019 X_NUC_92.L_CORE X_NUC_95.L_CORE 0.001398
K_16020 X_NUC_92.L_CORE X_NUC_96.L_CORE 0.001400
K_16021 X_NUC_92.L_CORE X_NUC_97.L_CORE 0.001937
K_16022 X_NUC_92.L_CORE X_NUC_98.L_CORE 0.001947
K_16023 X_NUC_92.L_CORE X_NUC_99.L_CORE 0.001949
K_16024 X_NUC_92.L_CORE X_NUC_100.L_CORE 0.001933
K_16025 X_NUC_92.L_CORE X_NUC_101.L_CORE 0.002909
K_16026 X_NUC_92.L_CORE X_NUC_102.L_CORE 0.002933
K_16027 X_NUC_92.L_CORE X_NUC_103.L_CORE 0.002901
K_16028 X_NUC_92.L_CORE X_NUC_104.L_CORE 0.002933
K_16029 X_NUC_92.L_CORE X_NUC_105.L_CORE 0.001318
K_16030 X_NUC_92.L_CORE X_NUC_106.L_CORE 0.001326
K_16031 X_NUC_92.L_CORE X_NUC_107.L_CORE 0.001322
K_16032 X_NUC_92.L_CORE X_NUC_108.L_CORE 0.001320
K_16033 X_NUC_92.L_CORE X_NUC_109.L_CORE 0.004428
K_16034 X_NUC_92.L_CORE X_NUC_110.L_CORE 0.004444
K_16035 X_NUC_92.L_CORE X_NUC_111.L_CORE 0.004453
K_16036 X_NUC_92.L_CORE X_NUC_112.L_CORE 0.004368
K_16037 X_NUC_92.L_CORE X_NUC_113.L_CORE 0.001653
K_16038 X_NUC_92.L_CORE X_NUC_114.L_CORE 0.001665
K_16039 X_NUC_92.L_CORE X_NUC_115.L_CORE 0.001654
K_16040 X_NUC_92.L_CORE X_NUC_116.L_CORE 0.001660
K_16041 X_NUC_92.L_CORE X_NUC_117.L_CORE 0.001551
K_16042 X_NUC_92.L_CORE X_NUC_118.L_CORE 0.001560
K_16043 X_NUC_92.L_CORE X_NUC_119.L_CORE 0.001558
K_16044 X_NUC_92.L_CORE X_NUC_120.L_CORE 0.001551
K_16045 X_NUC_92.L_CORE X_NUC_121.L_CORE 0.005143
K_16046 X_NUC_92.L_CORE X_NUC_122.L_CORE 0.005194
K_16047 X_NUC_92.L_CORE X_NUC_123.L_CORE 0.005068
K_16048 X_NUC_92.L_CORE X_NUC_124.L_CORE 0.005139
K_16049 X_NUC_92.L_CORE X_NUC_125.L_CORE 0.001371
K_16050 X_NUC_92.L_CORE X_NUC_126.L_CORE 0.001380
K_16051 X_NUC_92.L_CORE X_NUC_127.L_CORE 0.001374
K_16052 X_NUC_92.L_CORE X_NUC_128.L_CORE 0.001374
K_16053 X_NUC_92.L_CORE X_NUC_129.L_CORE 0.002365
K_16054 X_NUC_92.L_CORE X_NUC_130.L_CORE 0.002377
K_16055 X_NUC_92.L_CORE X_NUC_131.L_CORE 0.002374
K_16056 X_NUC_92.L_CORE X_NUC_132.L_CORE 0.002353
K_16057 X_NUC_92.L_CORE X_NUC_133.L_CORE 0.002153
K_16058 X_NUC_92.L_CORE X_NUC_134.L_CORE 0.002170
K_16059 X_NUC_92.L_CORE X_NUC_135.L_CORE 0.002149
K_16060 X_NUC_92.L_CORE X_NUC_136.L_CORE 0.002161
K_16061 X_NUC_92.L_CORE X_NUC_137.L_CORE 0.001429
K_16062 X_NUC_92.L_CORE X_NUC_138.L_CORE 0.001437
K_16063 X_NUC_92.L_CORE X_NUC_139.L_CORE 0.001433
K_16064 X_NUC_92.L_CORE X_NUC_140.L_CORE 0.001429
K_16065 X_NUC_92.L_CORE X_NUC_141.L_CORE 0.003889
K_16066 X_NUC_92.L_CORE X_NUC_142.L_CORE 0.003914
K_16067 X_NUC_92.L_CORE X_NUC_143.L_CORE 0.003866
K_16068 X_NUC_92.L_CORE X_NUC_144.L_CORE 0.003845
K_16069 X_NUC_92.L_CORE X_NUC_145.L_CORE 0.001565
K_16070 X_NUC_92.L_CORE X_NUC_146.L_CORE 0.001575
K_16071 X_NUC_92.L_CORE X_NUC_147.L_CORE 0.001566
K_16072 X_NUC_92.L_CORE X_NUC_148.L_CORE 0.001568
K_16073 X_NUC_92.L_CORE X_NUC_149.L_CORE 0.001801
K_16074 X_NUC_92.L_CORE X_NUC_150.L_CORE 0.001811
K_16075 X_NUC_92.L_CORE X_NUC_151.L_CORE 0.001805
K_16076 X_NUC_92.L_CORE X_NUC_152.L_CORE 0.001796
K_16077 X_NUC_92.L_CORE X_NUC_153.L_CORE 0.002618
K_16078 X_NUC_92.L_CORE X_NUC_154.L_CORE 0.002638
K_16079 X_NUC_92.L_CORE X_NUC_155.L_CORE 0.002606
K_16080 X_NUC_92.L_CORE X_NUC_156.L_CORE 0.002615
K_16081 X_NUC_92.L_CORE X_NUC_157.L_CORE 0.001499
K_16082 X_NUC_92.L_CORE X_NUC_158.L_CORE 0.001509
K_16083 X_NUC_92.L_CORE X_NUC_159.L_CORE 0.001501
K_16084 X_NUC_92.L_CORE X_NUC_160.L_CORE 0.001500
K_16085 X_NUC_92.L_CORE X_NUC_161.L_CORE 0.002336
K_16086 X_NUC_92.L_CORE X_NUC_162.L_CORE 0.002350
K_16087 X_NUC_92.L_CORE X_NUC_163.L_CORE 0.002335
K_16088 X_NUC_92.L_CORE X_NUC_164.L_CORE 0.002324
K_16089 X_NUC_92.L_CORE X_NUC_165.L_CORE 0.001866
K_16090 X_NUC_92.L_CORE X_NUC_166.L_CORE 0.001879
K_16091 X_NUC_92.L_CORE X_NUC_167.L_CORE 0.001864
K_16092 X_NUC_92.L_CORE X_NUC_168.L_CORE 0.001866
K_16093 X_NUC_92.L_CORE X_NUC_169.L_CORE 0.001765
K_16094 X_NUC_92.L_CORE X_NUC_170.L_CORE 0.001776
K_16095 X_NUC_92.L_CORE X_NUC_171.L_CORE 0.001766
K_16096 X_NUC_92.L_CORE X_NUC_172.L_CORE 0.001762
K_16097 X_NUC_92.L_CORE X_NUC_173.L_CORE 0.001608
K_16098 X_NUC_92.L_CORE X_NUC_174.L_CORE 0.002100
K_16099 X_NUC_92.L_CORE X_NUC_175.L_CORE 0.001537
K_16100 X_NUC_92.L_CORE X_NUC_176.L_CORE 0.001716
K_16101 X_NUC_92.L_CORE X_NUC_177.L_CORE 0.002212
K_16102 X_NUC_92.L_CORE X_NUC_178.L_CORE 0.001373
K_16103 X_NUC_92.L_CORE X_NUC_179.L_CORE 0.002448
K_16104 X_NUC_92.L_CORE X_NUC_180.L_CORE 0.001664
K_16105 X_NUC_92.L_CORE X_NUC_181.L_CORE 0.001465
K_16106 X_NUC_92.L_CORE X_NUC_182.L_CORE 0.003409
K_16107 X_NUC_92.L_CORE X_NUC_183.L_CORE 0.001344
K_16108 X_NUC_92.L_CORE X_NUC_184.L_CORE 0.002015
K_16109 X_NUC_92.L_CORE X_NUC_185.L_CORE 0.002171
K_16110 X_NUC_92.L_CORE X_NUC_186.L_CORE 0.001305
K_16111 X_NUC_92.L_CORE X_NUC_187.L_CORE 0.004285
K_16112 X_NUC_92.L_CORE X_NUC_188.L_CORE 0.001471
K_16113 X_NUC_92.L_CORE X_NUC_189.L_CORE 0.001580
K_16114 X_NUC_92.L_CORE X_NUC_190.L_CORE 0.003800
K_16115 X_NUC_92.L_CORE X_NUC_191.L_CORE 0.001264
K_16116 X_NUC_92.L_CORE X_NUC_192.L_CORE 0.002746
K_16117 X_NUC_92.L_CORE X_NUC_193.L_CORE 0.001836
K_16118 X_NUC_92.L_CORE X_NUC_194.L_CORE 0.001346
K_16119 X_NUC_92.L_CORE X_NUC_195.L_CORE 0.014757
K_16120 X_NUC_92.L_CORE X_NUC_196.L_CORE 0.001342
K_16121 X_NUC_92.L_CORE X_NUC_197.L_CORE 0.001858
K_16122 X_NUC_92.L_CORE X_NUC_198.L_CORE 0.002805
K_16123 X_NUC_92.L_CORE X_NUC_199.L_CORE 0.001260
K_16124 X_NUC_92.L_CORE X_NUC_200.L_CORE 0.004486
K_16125 X_NUC_92.L_CORE X_NUC_201.L_CORE 0.001580
K_16126 X_NUC_92.L_CORE X_NUC_202.L_CORE 0.001477
K_16127 X_NUC_92.L_CORE X_NUC_203.L_CORE 0.006317
K_16128 X_NUC_92.L_CORE X_NUC_204.L_CORE 0.001292
K_16129 X_NUC_92.L_CORE X_NUC_205.L_CORE 0.002331
K_16130 X_NUC_92.L_CORE X_NUC_206.L_CORE 0.002104
K_16131 X_NUC_92.L_CORE X_NUC_207.L_CORE 0.001329
K_16132 X_NUC_92.L_CORE X_NUC_208.L_CORE 0.005746
K_16133 X_NUC_92.L_CORE X_NUC_209.L_CORE 0.001450
K_16134 X_NUC_92.L_CORE X_NUC_210.L_CORE 0.001703
K_16135 X_NUC_92.L_CORE X_NUC_211.L_CORE 0.003058
K_16136 X_NUC_92.L_CORE X_NUC_212.L_CORE 0.001326
K_16137 X_NUC_92.L_CORE X_NUC_213.L_CORE 0.002760
K_16138 X_NUC_92.L_CORE X_NUC_214.L_CORE 0.001765
K_16139 X_NUC_92.L_CORE X_NUC_215.L_CORE 0.001487
K_16140 X_NUC_92.L_CORE X_NUC_216.L_CORE 0.003236
K_16141 X_NUC_92.L_CORE X_NUC_217.L_CORE 0.001458
K_16142 X_NUC_92.L_CORE X_NUC_218.L_CORE 0.001943
K_16143 X_NUC_92.L_CORE X_NUC_219.L_CORE 0.002106
K_16144 X_NUC_92.L_CORE X_NUC_220.L_CORE 0.001514
K_16145 X_NUC_92.L_CORE X_NUC_221.L_CORE 0.002208
K_16146 X_NUC_92.L_CORE X_NUC_222.L_CORE 0.001746
K_16147 X_NUC_93.L_CORE X_NUC_94.L_CORE 0.207973
K_16148 X_NUC_93.L_CORE X_NUC_95.L_CORE 0.207973
K_16149 X_NUC_93.L_CORE X_NUC_96.L_CORE 0.207973
K_16150 X_NUC_93.L_CORE X_NUC_97.L_CORE 0.001406
K_16151 X_NUC_93.L_CORE X_NUC_98.L_CORE 0.001401
K_16152 X_NUC_93.L_CORE X_NUC_99.L_CORE 0.001407
K_16153 X_NUC_93.L_CORE X_NUC_100.L_CORE 0.001400
K_16154 X_NUC_93.L_CORE X_NUC_101.L_CORE 0.001944
K_16155 X_NUC_93.L_CORE X_NUC_102.L_CORE 0.001927
K_16156 X_NUC_93.L_CORE X_NUC_103.L_CORE 0.001932
K_16157 X_NUC_93.L_CORE X_NUC_104.L_CORE 0.001937
K_16158 X_NUC_93.L_CORE X_NUC_105.L_CORE 0.002952
K_16159 X_NUC_93.L_CORE X_NUC_106.L_CORE 0.002955
K_16160 X_NUC_93.L_CORE X_NUC_107.L_CORE 0.002969
K_16161 X_NUC_93.L_CORE X_NUC_108.L_CORE 0.002928
K_16162 X_NUC_93.L_CORE X_NUC_109.L_CORE 0.001330
K_16163 X_NUC_93.L_CORE X_NUC_110.L_CORE 0.001323
K_16164 X_NUC_93.L_CORE X_NUC_111.L_CORE 0.001328
K_16165 X_NUC_93.L_CORE X_NUC_112.L_CORE 0.001324
K_16166 X_NUC_93.L_CORE X_NUC_113.L_CORE 0.004397
K_16167 X_NUC_93.L_CORE X_NUC_114.L_CORE 0.004328
K_16168 X_NUC_93.L_CORE X_NUC_115.L_CORE 0.004313
K_16169 X_NUC_93.L_CORE X_NUC_116.L_CORE 0.004361
K_16170 X_NUC_93.L_CORE X_NUC_117.L_CORE 0.001677
K_16171 X_NUC_93.L_CORE X_NUC_118.L_CORE 0.001672
K_16172 X_NUC_93.L_CORE X_NUC_119.L_CORE 0.001679
K_16173 X_NUC_93.L_CORE X_NUC_120.L_CORE 0.001667
K_16174 X_NUC_93.L_CORE X_NUC_121.L_CORE 0.001569
K_16175 X_NUC_93.L_CORE X_NUC_122.L_CORE 0.001557
K_16176 X_NUC_93.L_CORE X_NUC_123.L_CORE 0.001561
K_16177 X_NUC_93.L_CORE X_NUC_124.L_CORE 0.001561
K_16178 X_NUC_93.L_CORE X_NUC_125.L_CORE 0.005130
K_16179 X_NUC_93.L_CORE X_NUC_126.L_CORE 0.005135
K_16180 X_NUC_93.L_CORE X_NUC_127.L_CORE 0.005109
K_16181 X_NUC_93.L_CORE X_NUC_128.L_CORE 0.005027
K_16182 X_NUC_93.L_CORE X_NUC_129.L_CORE 0.001395
K_16183 X_NUC_93.L_CORE X_NUC_130.L_CORE 0.001388
K_16184 X_NUC_93.L_CORE X_NUC_131.L_CORE 0.001393
K_16185 X_NUC_93.L_CORE X_NUC_132.L_CORE 0.001387
K_16186 X_NUC_93.L_CORE X_NUC_133.L_CORE 0.002381
K_16187 X_NUC_93.L_CORE X_NUC_134.L_CORE 0.002358
K_16188 X_NUC_93.L_CORE X_NUC_135.L_CORE 0.002358
K_16189 X_NUC_93.L_CORE X_NUC_136.L_CORE 0.002365
K_16190 X_NUC_93.L_CORE X_NUC_137.L_CORE 0.002191
K_16191 X_NUC_93.L_CORE X_NUC_138.L_CORE 0.002186
K_16192 X_NUC_93.L_CORE X_NUC_139.L_CORE 0.002191
K_16193 X_NUC_93.L_CORE X_NUC_140.L_CORE 0.002171
K_16194 X_NUC_93.L_CORE X_NUC_141.L_CORE 0.001459
K_16195 X_NUC_93.L_CORE X_NUC_142.L_CORE 0.001450
K_16196 X_NUC_93.L_CORE X_NUC_143.L_CORE 0.001454
K_16197 X_NUC_93.L_CORE X_NUC_144.L_CORE 0.001450
K_16198 X_NUC_93.L_CORE X_NUC_145.L_CORE 0.003771
K_16199 X_NUC_93.L_CORE X_NUC_146.L_CORE 0.003738
K_16200 X_NUC_93.L_CORE X_NUC_147.L_CORE 0.003714
K_16201 X_NUC_93.L_CORE X_NUC_148.L_CORE 0.003711
K_16202 X_NUC_93.L_CORE X_NUC_149.L_CORE 0.001607
K_16203 X_NUC_93.L_CORE X_NUC_150.L_CORE 0.001600
K_16204 X_NUC_93.L_CORE X_NUC_151.L_CORE 0.001604
K_16205 X_NUC_93.L_CORE X_NUC_152.L_CORE 0.001595
K_16206 X_NUC_93.L_CORE X_NUC_153.L_CORE 0.001837
K_16207 X_NUC_93.L_CORE X_NUC_154.L_CORE 0.001823
K_16208 X_NUC_93.L_CORE X_NUC_155.L_CORE 0.001825
K_16209 X_NUC_93.L_CORE X_NUC_156.L_CORE 0.001824
K_16210 X_NUC_93.L_CORE X_NUC_157.L_CORE 0.002589
K_16211 X_NUC_93.L_CORE X_NUC_158.L_CORE 0.002579
K_16212 X_NUC_93.L_CORE X_NUC_159.L_CORE 0.002577
K_16213 X_NUC_93.L_CORE X_NUC_160.L_CORE 0.002558
K_16214 X_NUC_93.L_CORE X_NUC_161.L_CORE 0.001565
K_16215 X_NUC_93.L_CORE X_NUC_162.L_CORE 0.001557
K_16216 X_NUC_93.L_CORE X_NUC_163.L_CORE 0.001560
K_16217 X_NUC_93.L_CORE X_NUC_164.L_CORE 0.001554
K_16218 X_NUC_93.L_CORE X_NUC_165.L_CORE 0.002276
K_16219 X_NUC_93.L_CORE X_NUC_166.L_CORE 0.002260
K_16220 X_NUC_93.L_CORE X_NUC_167.L_CORE 0.002257
K_16221 X_NUC_93.L_CORE X_NUC_168.L_CORE 0.002253
K_16222 X_NUC_93.L_CORE X_NUC_169.L_CORE 0.001921
K_16223 X_NUC_93.L_CORE X_NUC_170.L_CORE 0.001911
K_16224 X_NUC_93.L_CORE X_NUC_171.L_CORE 0.001912
K_16225 X_NUC_93.L_CORE X_NUC_172.L_CORE 0.001903
K_16226 X_NUC_93.L_CORE X_NUC_173.L_CORE 0.001729
K_16227 X_NUC_93.L_CORE X_NUC_174.L_CORE 0.001513
K_16228 X_NUC_93.L_CORE X_NUC_175.L_CORE 0.002190
K_16229 X_NUC_93.L_CORE X_NUC_176.L_CORE 0.001493
K_16230 X_NUC_93.L_CORE X_NUC_177.L_CORE 0.001683
K_16231 X_NUC_93.L_CORE X_NUC_178.L_CORE 0.002231
K_16232 X_NUC_93.L_CORE X_NUC_179.L_CORE 0.001341
K_16233 X_NUC_93.L_CORE X_NUC_180.L_CORE 0.002447
K_16234 X_NUC_93.L_CORE X_NUC_181.L_CORE 0.001645
K_16235 X_NUC_93.L_CORE X_NUC_182.L_CORE 0.001439
K_16236 X_NUC_93.L_CORE X_NUC_183.L_CORE 0.003463
K_16237 X_NUC_93.L_CORE X_NUC_184.L_CORE 0.001327
K_16238 X_NUC_93.L_CORE X_NUC_185.L_CORE 0.001987
K_16239 X_NUC_93.L_CORE X_NUC_186.L_CORE 0.002167
K_16240 X_NUC_93.L_CORE X_NUC_187.L_CORE 0.001291
K_16241 X_NUC_93.L_CORE X_NUC_188.L_CORE 0.004266
K_16242 X_NUC_93.L_CORE X_NUC_189.L_CORE 0.001462
K_16243 X_NUC_93.L_CORE X_NUC_190.L_CORE 0.001563
K_16244 X_NUC_93.L_CORE X_NUC_191.L_CORE 0.003837
K_16245 X_NUC_93.L_CORE X_NUC_192.L_CORE 0.001257
K_16246 X_NUC_93.L_CORE X_NUC_193.L_CORE 0.002712
K_16247 X_NUC_93.L_CORE X_NUC_194.L_CORE 0.001838
K_16248 X_NUC_93.L_CORE X_NUC_195.L_CORE 0.001338
K_16249 X_NUC_93.L_CORE X_NUC_196.L_CORE 0.015179
K_16250 X_NUC_93.L_CORE X_NUC_197.L_CORE 0.001341
K_16251 X_NUC_93.L_CORE X_NUC_198.L_CORE 0.001846
K_16252 X_NUC_93.L_CORE X_NUC_199.L_CORE 0.002832
K_16253 X_NUC_93.L_CORE X_NUC_200.L_CORE 0.001259
K_16254 X_NUC_93.L_CORE X_NUC_201.L_CORE 0.004422
K_16255 X_NUC_93.L_CORE X_NUC_202.L_CORE 0.001589
K_16256 X_NUC_93.L_CORE X_NUC_203.L_CORE 0.001476
K_16257 X_NUC_93.L_CORE X_NUC_204.L_CORE 0.006452
K_16258 X_NUC_93.L_CORE X_NUC_205.L_CORE 0.001299
K_16259 X_NUC_93.L_CORE X_NUC_206.L_CORE 0.002324
K_16260 X_NUC_93.L_CORE X_NUC_207.L_CORE 0.002128
K_16261 X_NUC_93.L_CORE X_NUC_208.L_CORE 0.001337
K_16262 X_NUC_93.L_CORE X_NUC_209.L_CORE 0.005623
K_16263 X_NUC_93.L_CORE X_NUC_210.L_CORE 0.001467
K_16264 X_NUC_93.L_CORE X_NUC_211.L_CORE 0.001713
K_16265 X_NUC_93.L_CORE X_NUC_212.L_CORE 0.003081
K_16266 X_NUC_93.L_CORE X_NUC_213.L_CORE 0.001344
K_16267 X_NUC_93.L_CORE X_NUC_214.L_CORE 0.002742
K_16268 X_NUC_93.L_CORE X_NUC_215.L_CORE 0.001794
K_16269 X_NUC_93.L_CORE X_NUC_216.L_CORE 0.001511
K_16270 X_NUC_93.L_CORE X_NUC_217.L_CORE 0.003146
K_16271 X_NUC_93.L_CORE X_NUC_218.L_CORE 0.001496
K_16272 X_NUC_93.L_CORE X_NUC_219.L_CORE 0.001956
K_16273 X_NUC_93.L_CORE X_NUC_220.L_CORE 0.002104
K_16274 X_NUC_93.L_CORE X_NUC_221.L_CORE 0.001585
K_16275 X_NUC_93.L_CORE X_NUC_222.L_CORE 0.002060
K_16276 X_NUC_94.L_CORE X_NUC_95.L_CORE 0.207973
K_16277 X_NUC_94.L_CORE X_NUC_96.L_CORE 0.207973
K_16278 X_NUC_94.L_CORE X_NUC_97.L_CORE 0.001412
K_16279 X_NUC_94.L_CORE X_NUC_98.L_CORE 0.001406
K_16280 X_NUC_94.L_CORE X_NUC_99.L_CORE 0.001413
K_16281 X_NUC_94.L_CORE X_NUC_100.L_CORE 0.001405
K_16282 X_NUC_94.L_CORE X_NUC_101.L_CORE 0.001962
K_16283 X_NUC_94.L_CORE X_NUC_102.L_CORE 0.001944
K_16284 X_NUC_94.L_CORE X_NUC_103.L_CORE 0.001949
K_16285 X_NUC_94.L_CORE X_NUC_104.L_CORE 0.001954
K_16286 X_NUC_94.L_CORE X_NUC_105.L_CORE 0.002948
K_16287 X_NUC_94.L_CORE X_NUC_106.L_CORE 0.002952
K_16288 X_NUC_94.L_CORE X_NUC_107.L_CORE 0.002966
K_16289 X_NUC_94.L_CORE X_NUC_108.L_CORE 0.002925
K_16290 X_NUC_94.L_CORE X_NUC_109.L_CORE 0.001338
K_16291 X_NUC_94.L_CORE X_NUC_110.L_CORE 0.001330
K_16292 X_NUC_94.L_CORE X_NUC_111.L_CORE 0.001336
K_16293 X_NUC_94.L_CORE X_NUC_112.L_CORE 0.001332
K_16294 X_NUC_94.L_CORE X_NUC_113.L_CORE 0.004466
K_16295 X_NUC_94.L_CORE X_NUC_114.L_CORE 0.004397
K_16296 X_NUC_94.L_CORE X_NUC_115.L_CORE 0.004379
K_16297 X_NUC_94.L_CORE X_NUC_116.L_CORE 0.004430
K_16298 X_NUC_94.L_CORE X_NUC_117.L_CORE 0.001682
K_16299 X_NUC_94.L_CORE X_NUC_118.L_CORE 0.001677
K_16300 X_NUC_94.L_CORE X_NUC_119.L_CORE 0.001684
K_16301 X_NUC_94.L_CORE X_NUC_120.L_CORE 0.001672
K_16302 X_NUC_94.L_CORE X_NUC_121.L_CORE 0.001580
K_16303 X_NUC_94.L_CORE X_NUC_122.L_CORE 0.001569
K_16304 X_NUC_94.L_CORE X_NUC_123.L_CORE 0.001573
K_16305 X_NUC_94.L_CORE X_NUC_124.L_CORE 0.001572
K_16306 X_NUC_94.L_CORE X_NUC_125.L_CORE 0.005123
K_16307 X_NUC_94.L_CORE X_NUC_126.L_CORE 0.005130
K_16308 X_NUC_94.L_CORE X_NUC_127.L_CORE 0.005103
K_16309 X_NUC_94.L_CORE X_NUC_128.L_CORE 0.005021
K_16310 X_NUC_94.L_CORE X_NUC_129.L_CORE 0.001401
K_16311 X_NUC_94.L_CORE X_NUC_130.L_CORE 0.001395
K_16312 X_NUC_94.L_CORE X_NUC_131.L_CORE 0.001400
K_16313 X_NUC_94.L_CORE X_NUC_132.L_CORE 0.001393
K_16314 X_NUC_94.L_CORE X_NUC_133.L_CORE 0.002405
K_16315 X_NUC_94.L_CORE X_NUC_134.L_CORE 0.002381
K_16316 X_NUC_94.L_CORE X_NUC_135.L_CORE 0.002381
K_16317 X_NUC_94.L_CORE X_NUC_136.L_CORE 0.002388
K_16318 X_NUC_94.L_CORE X_NUC_137.L_CORE 0.002195
K_16319 X_NUC_94.L_CORE X_NUC_138.L_CORE 0.002191
K_16320 X_NUC_94.L_CORE X_NUC_139.L_CORE 0.002196
K_16321 X_NUC_94.L_CORE X_NUC_140.L_CORE 0.002176
K_16322 X_NUC_94.L_CORE X_NUC_141.L_CORE 0.001468
K_16323 X_NUC_94.L_CORE X_NUC_142.L_CORE 0.001459
K_16324 X_NUC_94.L_CORE X_NUC_143.L_CORE 0.001463
K_16325 X_NUC_94.L_CORE X_NUC_144.L_CORE 0.001459
K_16326 X_NUC_94.L_CORE X_NUC_145.L_CORE 0.003804
K_16327 X_NUC_94.L_CORE X_NUC_146.L_CORE 0.003771
K_16328 X_NUC_94.L_CORE X_NUC_147.L_CORE 0.003746
K_16329 X_NUC_94.L_CORE X_NUC_148.L_CORE 0.003743
K_16330 X_NUC_94.L_CORE X_NUC_149.L_CORE 0.001613
K_16331 X_NUC_94.L_CORE X_NUC_150.L_CORE 0.001607
K_16332 X_NUC_94.L_CORE X_NUC_151.L_CORE 0.001611
K_16333 X_NUC_94.L_CORE X_NUC_152.L_CORE 0.001602
K_16334 X_NUC_94.L_CORE X_NUC_153.L_CORE 0.001851
K_16335 X_NUC_94.L_CORE X_NUC_154.L_CORE 0.001837
K_16336 X_NUC_94.L_CORE X_NUC_155.L_CORE 0.001839
K_16337 X_NUC_94.L_CORE X_NUC_156.L_CORE 0.001838
K_16338 X_NUC_94.L_CORE X_NUC_157.L_CORE 0.002599
K_16339 X_NUC_94.L_CORE X_NUC_158.L_CORE 0.002589
K_16340 X_NUC_94.L_CORE X_NUC_159.L_CORE 0.002587
K_16341 X_NUC_94.L_CORE X_NUC_160.L_CORE 0.002567
K_16342 X_NUC_94.L_CORE X_NUC_161.L_CORE 0.001574
K_16343 X_NUC_94.L_CORE X_NUC_162.L_CORE 0.001565
K_16344 X_NUC_94.L_CORE X_NUC_163.L_CORE 0.001569
K_16345 X_NUC_94.L_CORE X_NUC_164.L_CORE 0.001563
K_16346 X_NUC_94.L_CORE X_NUC_165.L_CORE 0.002293
K_16347 X_NUC_94.L_CORE X_NUC_166.L_CORE 0.002276
K_16348 X_NUC_94.L_CORE X_NUC_167.L_CORE 0.002273
K_16349 X_NUC_94.L_CORE X_NUC_168.L_CORE 0.002269
K_16350 X_NUC_94.L_CORE X_NUC_169.L_CORE 0.001930
K_16351 X_NUC_94.L_CORE X_NUC_170.L_CORE 0.001921
K_16352 X_NUC_94.L_CORE X_NUC_171.L_CORE 0.001922
K_16353 X_NUC_94.L_CORE X_NUC_172.L_CORE 0.001913
K_16354 X_NUC_94.L_CORE X_NUC_173.L_CORE 0.001736
K_16355 X_NUC_94.L_CORE X_NUC_174.L_CORE 0.001521
K_16356 X_NUC_94.L_CORE X_NUC_175.L_CORE 0.002199
K_16357 X_NUC_94.L_CORE X_NUC_176.L_CORE 0.001498
K_16358 X_NUC_94.L_CORE X_NUC_177.L_CORE 0.001694
K_16359 X_NUC_94.L_CORE X_NUC_178.L_CORE 0.002234
K_16360 X_NUC_94.L_CORE X_NUC_179.L_CORE 0.001348
K_16361 X_NUC_94.L_CORE X_NUC_180.L_CORE 0.002464
K_16362 X_NUC_94.L_CORE X_NUC_181.L_CORE 0.001649
K_16363 X_NUC_94.L_CORE X_NUC_182.L_CORE 0.001448
K_16364 X_NUC_94.L_CORE X_NUC_183.L_CORE 0.003464
K_16365 X_NUC_94.L_CORE X_NUC_184.L_CORE 0.001333
K_16366 X_NUC_94.L_CORE X_NUC_185.L_CORE 0.002003
K_16367 X_NUC_94.L_CORE X_NUC_186.L_CORE 0.002167
K_16368 X_NUC_94.L_CORE X_NUC_187.L_CORE 0.001298
K_16369 X_NUC_94.L_CORE X_NUC_188.L_CORE 0.004300
K_16370 X_NUC_94.L_CORE X_NUC_189.L_CORE 0.001467
K_16371 X_NUC_94.L_CORE X_NUC_190.L_CORE 0.001575
K_16372 X_NUC_94.L_CORE X_NUC_191.L_CORE 0.003816
K_16373 X_NUC_94.L_CORE X_NUC_192.L_CORE 0.001263
K_16374 X_NUC_94.L_CORE X_NUC_193.L_CORE 0.002740
K_16375 X_NUC_94.L_CORE X_NUC_194.L_CORE 0.001840
K_16376 X_NUC_94.L_CORE X_NUC_195.L_CORE 0.001347
K_16377 X_NUC_94.L_CORE X_NUC_196.L_CORE 0.014750
K_16378 X_NUC_94.L_CORE X_NUC_197.L_CORE 0.001347
K_16379 X_NUC_94.L_CORE X_NUC_198.L_CORE 0.001862
K_16380 X_NUC_94.L_CORE X_NUC_199.L_CORE 0.002825
K_16381 X_NUC_94.L_CORE X_NUC_200.L_CORE 0.001266
K_16382 X_NUC_94.L_CORE X_NUC_201.L_CORE 0.004485
K_16383 X_NUC_94.L_CORE X_NUC_202.L_CORE 0.001593
K_16384 X_NUC_94.L_CORE X_NUC_203.L_CORE 0.001487
K_16385 X_NUC_94.L_CORE X_NUC_204.L_CORE 0.006366
K_16386 X_NUC_94.L_CORE X_NUC_205.L_CORE 0.001304
K_16387 X_NUC_94.L_CORE X_NUC_206.L_CORE 0.002347
K_16388 X_NUC_94.L_CORE X_NUC_207.L_CORE 0.002129
K_16389 X_NUC_94.L_CORE X_NUC_208.L_CORE 0.001345
K_16390 X_NUC_94.L_CORE X_NUC_209.L_CORE 0.005676
K_16391 X_NUC_94.L_CORE X_NUC_210.L_CORE 0.001472
K_16392 X_NUC_94.L_CORE X_NUC_211.L_CORE 0.001726
K_16393 X_NUC_94.L_CORE X_NUC_212.L_CORE 0.003079
K_16394 X_NUC_94.L_CORE X_NUC_213.L_CORE 0.001351
K_16395 X_NUC_94.L_CORE X_NUC_214.L_CORE 0.002767
K_16396 X_NUC_94.L_CORE X_NUC_215.L_CORE 0.001799
K_16397 X_NUC_94.L_CORE X_NUC_216.L_CORE 0.001521
K_16398 X_NUC_94.L_CORE X_NUC_217.L_CORE 0.003159
K_16399 X_NUC_94.L_CORE X_NUC_218.L_CORE 0.001502
K_16400 X_NUC_94.L_CORE X_NUC_219.L_CORE 0.001970
K_16401 X_NUC_94.L_CORE X_NUC_220.L_CORE 0.002111
K_16402 X_NUC_94.L_CORE X_NUC_221.L_CORE 0.001594
K_16403 X_NUC_94.L_CORE X_NUC_222.L_CORE 0.002072
K_16404 X_NUC_95.L_CORE X_NUC_96.L_CORE 0.207973
K_16405 X_NUC_95.L_CORE X_NUC_97.L_CORE 0.001406
K_16406 X_NUC_95.L_CORE X_NUC_98.L_CORE 0.001400
K_16407 X_NUC_95.L_CORE X_NUC_99.L_CORE 0.001406
K_16408 X_NUC_95.L_CORE X_NUC_100.L_CORE 0.001399
K_16409 X_NUC_95.L_CORE X_NUC_101.L_CORE 0.001956
K_16410 X_NUC_95.L_CORE X_NUC_102.L_CORE 0.001938
K_16411 X_NUC_95.L_CORE X_NUC_103.L_CORE 0.001944
K_16412 X_NUC_95.L_CORE X_NUC_104.L_CORE 0.001948
K_16413 X_NUC_95.L_CORE X_NUC_105.L_CORE 0.002934
K_16414 X_NUC_95.L_CORE X_NUC_106.L_CORE 0.002937
K_16415 X_NUC_95.L_CORE X_NUC_107.L_CORE 0.002952
K_16416 X_NUC_95.L_CORE X_NUC_108.L_CORE 0.002911
K_16417 X_NUC_95.L_CORE X_NUC_109.L_CORE 0.001333
K_16418 X_NUC_95.L_CORE X_NUC_110.L_CORE 0.001325
K_16419 X_NUC_95.L_CORE X_NUC_111.L_CORE 0.001330
K_16420 X_NUC_95.L_CORE X_NUC_112.L_CORE 0.001326
K_16421 X_NUC_95.L_CORE X_NUC_113.L_CORE 0.004484
K_16422 X_NUC_95.L_CORE X_NUC_114.L_CORE 0.004412
K_16423 X_NUC_95.L_CORE X_NUC_115.L_CORE 0.004397
K_16424 X_NUC_95.L_CORE X_NUC_116.L_CORE 0.004447
K_16425 X_NUC_95.L_CORE X_NUC_117.L_CORE 0.001675
K_16426 X_NUC_95.L_CORE X_NUC_118.L_CORE 0.001670
K_16427 X_NUC_95.L_CORE X_NUC_119.L_CORE 0.001677
K_16428 X_NUC_95.L_CORE X_NUC_120.L_CORE 0.001665
K_16429 X_NUC_95.L_CORE X_NUC_121.L_CORE 0.001576
K_16430 X_NUC_95.L_CORE X_NUC_122.L_CORE 0.001564
K_16431 X_NUC_95.L_CORE X_NUC_123.L_CORE 0.001569
K_16432 X_NUC_95.L_CORE X_NUC_124.L_CORE 0.001568
K_16433 X_NUC_95.L_CORE X_NUC_125.L_CORE 0.005149
K_16434 X_NUC_95.L_CORE X_NUC_126.L_CORE 0.005155
K_16435 X_NUC_95.L_CORE X_NUC_127.L_CORE 0.005130
K_16436 X_NUC_95.L_CORE X_NUC_128.L_CORE 0.005045
K_16437 X_NUC_95.L_CORE X_NUC_129.L_CORE 0.001396
K_16438 X_NUC_95.L_CORE X_NUC_130.L_CORE 0.001390
K_16439 X_NUC_95.L_CORE X_NUC_131.L_CORE 0.001395
K_16440 X_NUC_95.L_CORE X_NUC_132.L_CORE 0.001388
K_16441 X_NUC_95.L_CORE X_NUC_133.L_CORE 0.002405
K_16442 X_NUC_95.L_CORE X_NUC_134.L_CORE 0.002381
K_16443 X_NUC_95.L_CORE X_NUC_135.L_CORE 0.002381
K_16444 X_NUC_95.L_CORE X_NUC_136.L_CORE 0.002388
K_16445 X_NUC_95.L_CORE X_NUC_137.L_CORE 0.002190
K_16446 X_NUC_95.L_CORE X_NUC_138.L_CORE 0.002185
K_16447 X_NUC_95.L_CORE X_NUC_139.L_CORE 0.002191
K_16448 X_NUC_95.L_CORE X_NUC_140.L_CORE 0.002171
K_16449 X_NUC_95.L_CORE X_NUC_141.L_CORE 0.001464
K_16450 X_NUC_95.L_CORE X_NUC_142.L_CORE 0.001455
K_16451 X_NUC_95.L_CORE X_NUC_143.L_CORE 0.001459
K_16452 X_NUC_95.L_CORE X_NUC_144.L_CORE 0.001456
K_16453 X_NUC_95.L_CORE X_NUC_145.L_CORE 0.003829
K_16454 X_NUC_95.L_CORE X_NUC_146.L_CORE 0.003795
K_16455 X_NUC_95.L_CORE X_NUC_147.L_CORE 0.003771
K_16456 X_NUC_95.L_CORE X_NUC_148.L_CORE 0.003767
K_16457 X_NUC_95.L_CORE X_NUC_149.L_CORE 0.001609
K_16458 X_NUC_95.L_CORE X_NUC_150.L_CORE 0.001602
K_16459 X_NUC_95.L_CORE X_NUC_151.L_CORE 0.001607
K_16460 X_NUC_95.L_CORE X_NUC_152.L_CORE 0.001598
K_16461 X_NUC_95.L_CORE X_NUC_153.L_CORE 0.001849
K_16462 X_NUC_95.L_CORE X_NUC_154.L_CORE 0.001835
K_16463 X_NUC_95.L_CORE X_NUC_155.L_CORE 0.001837
K_16464 X_NUC_95.L_CORE X_NUC_156.L_CORE 0.001836
K_16465 X_NUC_95.L_CORE X_NUC_157.L_CORE 0.002601
K_16466 X_NUC_95.L_CORE X_NUC_158.L_CORE 0.002591
K_16467 X_NUC_95.L_CORE X_NUC_159.L_CORE 0.002589
K_16468 X_NUC_95.L_CORE X_NUC_160.L_CORE 0.002570
K_16469 X_NUC_95.L_CORE X_NUC_161.L_CORE 0.001571
K_16470 X_NUC_95.L_CORE X_NUC_162.L_CORE 0.001562
K_16471 X_NUC_95.L_CORE X_NUC_163.L_CORE 0.001565
K_16472 X_NUC_95.L_CORE X_NUC_164.L_CORE 0.001560
K_16473 X_NUC_95.L_CORE X_NUC_165.L_CORE 0.002295
K_16474 X_NUC_95.L_CORE X_NUC_166.L_CORE 0.002279
K_16475 X_NUC_95.L_CORE X_NUC_167.L_CORE 0.002276
K_16476 X_NUC_95.L_CORE X_NUC_168.L_CORE 0.002272
K_16477 X_NUC_95.L_CORE X_NUC_169.L_CORE 0.001929
K_16478 X_NUC_95.L_CORE X_NUC_170.L_CORE 0.001919
K_16479 X_NUC_95.L_CORE X_NUC_171.L_CORE 0.001921
K_16480 X_NUC_95.L_CORE X_NUC_172.L_CORE 0.001911
K_16481 X_NUC_95.L_CORE X_NUC_173.L_CORE 0.001722
K_16482 X_NUC_95.L_CORE X_NUC_174.L_CORE 0.001510
K_16483 X_NUC_95.L_CORE X_NUC_175.L_CORE 0.002177
K_16484 X_NUC_95.L_CORE X_NUC_176.L_CORE 0.001488
K_16485 X_NUC_95.L_CORE X_NUC_177.L_CORE 0.001682
K_16486 X_NUC_95.L_CORE X_NUC_178.L_CORE 0.002212
K_16487 X_NUC_95.L_CORE X_NUC_179.L_CORE 0.001340
K_16488 X_NUC_95.L_CORE X_NUC_180.L_CORE 0.002442
K_16489 X_NUC_95.L_CORE X_NUC_181.L_CORE 0.001637
K_16490 X_NUC_95.L_CORE X_NUC_182.L_CORE 0.001440
K_16491 X_NUC_95.L_CORE X_NUC_183.L_CORE 0.003416
K_16492 X_NUC_95.L_CORE X_NUC_184.L_CORE 0.001325
K_16493 X_NUC_95.L_CORE X_NUC_185.L_CORE 0.001991
K_16494 X_NUC_95.L_CORE X_NUC_186.L_CORE 0.002150
K_16495 X_NUC_95.L_CORE X_NUC_187.L_CORE 0.001291
K_16496 X_NUC_95.L_CORE X_NUC_188.L_CORE 0.004251
K_16497 X_NUC_95.L_CORE X_NUC_189.L_CORE 0.001458
K_16498 X_NUC_95.L_CORE X_NUC_190.L_CORE 0.001567
K_16499 X_NUC_95.L_CORE X_NUC_191.L_CORE 0.003773
K_16500 X_NUC_95.L_CORE X_NUC_192.L_CORE 0.001257
K_16501 X_NUC_95.L_CORE X_NUC_193.L_CORE 0.002728
K_16502 X_NUC_95.L_CORE X_NUC_194.L_CORE 0.001829
K_16503 X_NUC_95.L_CORE X_NUC_195.L_CORE 0.001341
K_16504 X_NUC_95.L_CORE X_NUC_196.L_CORE 0.014434
K_16505 X_NUC_95.L_CORE X_NUC_197.L_CORE 0.001340
K_16506 X_NUC_95.L_CORE X_NUC_198.L_CORE 0.001856
K_16507 X_NUC_95.L_CORE X_NUC_199.L_CORE 0.002809
K_16508 X_NUC_95.L_CORE X_NUC_200.L_CORE 0.001261
K_16509 X_NUC_95.L_CORE X_NUC_201.L_CORE 0.004496
K_16510 X_NUC_95.L_CORE X_NUC_202.L_CORE 0.001586
K_16511 X_NUC_95.L_CORE X_NUC_203.L_CORE 0.001482
K_16512 X_NUC_95.L_CORE X_NUC_204.L_CORE 0.006397
K_16513 X_NUC_95.L_CORE X_NUC_205.L_CORE 0.001299
K_16514 X_NUC_95.L_CORE X_NUC_206.L_CORE 0.002346
K_16515 X_NUC_95.L_CORE X_NUC_207.L_CORE 0.002122
K_16516 X_NUC_95.L_CORE X_NUC_208.L_CORE 0.001340
K_16517 X_NUC_95.L_CORE X_NUC_209.L_CORE 0.005772
K_16518 X_NUC_95.L_CORE X_NUC_210.L_CORE 0.001467
K_16519 X_NUC_95.L_CORE X_NUC_211.L_CORE 0.001723
K_16520 X_NUC_95.L_CORE X_NUC_212.L_CORE 0.003083
K_16521 X_NUC_95.L_CORE X_NUC_213.L_CORE 0.001348
K_16522 X_NUC_95.L_CORE X_NUC_214.L_CORE 0.002777
K_16523 X_NUC_95.L_CORE X_NUC_215.L_CORE 0.001795
K_16524 X_NUC_95.L_CORE X_NUC_216.L_CORE 0.001518
K_16525 X_NUC_95.L_CORE X_NUC_217.L_CORE 0.003176
K_16526 X_NUC_95.L_CORE X_NUC_218.L_CORE 0.001499
K_16527 X_NUC_95.L_CORE X_NUC_219.L_CORE 0.001971
K_16528 X_NUC_95.L_CORE X_NUC_220.L_CORE 0.002112
K_16529 X_NUC_95.L_CORE X_NUC_221.L_CORE 0.001592
K_16530 X_NUC_95.L_CORE X_NUC_222.L_CORE 0.002074
K_16531 X_NUC_96.L_CORE X_NUC_97.L_CORE 0.001413
K_16532 X_NUC_96.L_CORE X_NUC_98.L_CORE 0.001408
K_16533 X_NUC_96.L_CORE X_NUC_99.L_CORE 0.001414
K_16534 X_NUC_96.L_CORE X_NUC_100.L_CORE 0.001406
K_16535 X_NUC_96.L_CORE X_NUC_101.L_CORE 0.001951
K_16536 X_NUC_96.L_CORE X_NUC_102.L_CORE 0.001934
K_16537 X_NUC_96.L_CORE X_NUC_103.L_CORE 0.001939
K_16538 X_NUC_96.L_CORE X_NUC_104.L_CORE 0.001944
K_16539 X_NUC_96.L_CORE X_NUC_105.L_CORE 0.002975
K_16540 X_NUC_96.L_CORE X_NUC_106.L_CORE 0.002979
K_16541 X_NUC_96.L_CORE X_NUC_107.L_CORE 0.002993
K_16542 X_NUC_96.L_CORE X_NUC_108.L_CORE 0.002952
K_16543 X_NUC_96.L_CORE X_NUC_109.L_CORE 0.001337
K_16544 X_NUC_96.L_CORE X_NUC_110.L_CORE 0.001329
K_16545 X_NUC_96.L_CORE X_NUC_111.L_CORE 0.001334
K_16546 X_NUC_96.L_CORE X_NUC_112.L_CORE 0.001330
K_16547 X_NUC_96.L_CORE X_NUC_113.L_CORE 0.004431
K_16548 X_NUC_96.L_CORE X_NUC_114.L_CORE 0.004362
K_16549 X_NUC_96.L_CORE X_NUC_115.L_CORE 0.004346
K_16550 X_NUC_96.L_CORE X_NUC_116.L_CORE 0.004397
K_16551 X_NUC_96.L_CORE X_NUC_117.L_CORE 0.001688
K_16552 X_NUC_96.L_CORE X_NUC_118.L_CORE 0.001683
K_16553 X_NUC_96.L_CORE X_NUC_119.L_CORE 0.001690
K_16554 X_NUC_96.L_CORE X_NUC_120.L_CORE 0.001677
K_16555 X_NUC_96.L_CORE X_NUC_121.L_CORE 0.001576
K_16556 X_NUC_96.L_CORE X_NUC_122.L_CORE 0.001565
K_16557 X_NUC_96.L_CORE X_NUC_123.L_CORE 0.001569
K_16558 X_NUC_96.L_CORE X_NUC_124.L_CORE 0.001569
K_16559 X_NUC_96.L_CORE X_NUC_125.L_CORE 0.005238
K_16560 X_NUC_96.L_CORE X_NUC_126.L_CORE 0.005244
K_16561 X_NUC_96.L_CORE X_NUC_127.L_CORE 0.005217
K_16562 X_NUC_96.L_CORE X_NUC_128.L_CORE 0.005130
K_16563 X_NUC_96.L_CORE X_NUC_129.L_CORE 0.001403
K_16564 X_NUC_96.L_CORE X_NUC_130.L_CORE 0.001396
K_16565 X_NUC_96.L_CORE X_NUC_131.L_CORE 0.001401
K_16566 X_NUC_96.L_CORE X_NUC_132.L_CORE 0.001395
K_16567 X_NUC_96.L_CORE X_NUC_133.L_CORE 0.002398
K_16568 X_NUC_96.L_CORE X_NUC_134.L_CORE 0.002374
K_16569 X_NUC_96.L_CORE X_NUC_135.L_CORE 0.002374
K_16570 X_NUC_96.L_CORE X_NUC_136.L_CORE 0.002381
K_16571 X_NUC_96.L_CORE X_NUC_137.L_CORE 0.002210
K_16572 X_NUC_96.L_CORE X_NUC_138.L_CORE 0.002206
K_16573 X_NUC_96.L_CORE X_NUC_139.L_CORE 0.002211
K_16574 X_NUC_96.L_CORE X_NUC_140.L_CORE 0.002191
K_16575 X_NUC_96.L_CORE X_NUC_141.L_CORE 0.001467
K_16576 X_NUC_96.L_CORE X_NUC_142.L_CORE 0.001458
K_16577 X_NUC_96.L_CORE X_NUC_143.L_CORE 0.001462
K_16578 X_NUC_96.L_CORE X_NUC_144.L_CORE 0.001459
K_16579 X_NUC_96.L_CORE X_NUC_145.L_CORE 0.003832
K_16580 X_NUC_96.L_CORE X_NUC_146.L_CORE 0.003798
K_16581 X_NUC_96.L_CORE X_NUC_147.L_CORE 0.003773
K_16582 X_NUC_96.L_CORE X_NUC_148.L_CORE 0.003771
K_16583 X_NUC_96.L_CORE X_NUC_149.L_CORE 0.001618
K_16584 X_NUC_96.L_CORE X_NUC_150.L_CORE 0.001611
K_16585 X_NUC_96.L_CORE X_NUC_151.L_CORE 0.001616
K_16586 X_NUC_96.L_CORE X_NUC_152.L_CORE 0.001607
K_16587 X_NUC_96.L_CORE X_NUC_153.L_CORE 0.001850
K_16588 X_NUC_96.L_CORE X_NUC_154.L_CORE 0.001836
K_16589 X_NUC_96.L_CORE X_NUC_155.L_CORE 0.001838
K_16590 X_NUC_96.L_CORE X_NUC_156.L_CORE 0.001837
K_16591 X_NUC_96.L_CORE X_NUC_157.L_CORE 0.002621
K_16592 X_NUC_96.L_CORE X_NUC_158.L_CORE 0.002611
K_16593 X_NUC_96.L_CORE X_NUC_159.L_CORE 0.002609
K_16594 X_NUC_96.L_CORE X_NUC_160.L_CORE 0.002589
K_16595 X_NUC_96.L_CORE X_NUC_161.L_CORE 0.001577
K_16596 X_NUC_96.L_CORE X_NUC_162.L_CORE 0.001568
K_16597 X_NUC_96.L_CORE X_NUC_163.L_CORE 0.001571
K_16598 X_NUC_96.L_CORE X_NUC_164.L_CORE 0.001565
K_16599 X_NUC_96.L_CORE X_NUC_165.L_CORE 0.002299
K_16600 X_NUC_96.L_CORE X_NUC_166.L_CORE 0.002282
K_16601 X_NUC_96.L_CORE X_NUC_167.L_CORE 0.002280
K_16602 X_NUC_96.L_CORE X_NUC_168.L_CORE 0.002276
K_16603 X_NUC_96.L_CORE X_NUC_169.L_CORE 0.001939
K_16604 X_NUC_96.L_CORE X_NUC_170.L_CORE 0.001929
K_16605 X_NUC_96.L_CORE X_NUC_171.L_CORE 0.001930
K_16606 X_NUC_96.L_CORE X_NUC_172.L_CORE 0.001921
K_16607 X_NUC_96.L_CORE X_NUC_173.L_CORE 0.001728
K_16608 X_NUC_96.L_CORE X_NUC_174.L_CORE 0.001514
K_16609 X_NUC_96.L_CORE X_NUC_175.L_CORE 0.002182
K_16610 X_NUC_96.L_CORE X_NUC_176.L_CORE 0.001494
K_16611 X_NUC_96.L_CORE X_NUC_177.L_CORE 0.001682
K_16612 X_NUC_96.L_CORE X_NUC_178.L_CORE 0.002226
K_16613 X_NUC_96.L_CORE X_NUC_179.L_CORE 0.001344
K_16614 X_NUC_96.L_CORE X_NUC_180.L_CORE 0.002436
K_16615 X_NUC_96.L_CORE X_NUC_181.L_CORE 0.001648
K_16616 X_NUC_96.L_CORE X_NUC_182.L_CORE 0.001441
K_16617 X_NUC_96.L_CORE X_NUC_183.L_CORE 0.003434
K_16618 X_NUC_96.L_CORE X_NUC_184.L_CORE 0.001331
K_16619 X_NUC_96.L_CORE X_NUC_185.L_CORE 0.001986
K_16620 X_NUC_96.L_CORE X_NUC_186.L_CORE 0.002169
K_16621 X_NUC_96.L_CORE X_NUC_187.L_CORE 0.001294
K_16622 X_NUC_96.L_CORE X_NUC_188.L_CORE 0.004214
K_16623 X_NUC_96.L_CORE X_NUC_189.L_CORE 0.001467
K_16624 X_NUC_96.L_CORE X_NUC_190.L_CORE 0.001566
K_16625 X_NUC_96.L_CORE X_NUC_191.L_CORE 0.003827
K_16626 X_NUC_96.L_CORE X_NUC_192.L_CORE 0.001261
K_16627 X_NUC_96.L_CORE X_NUC_193.L_CORE 0.002709
K_16628 X_NUC_96.L_CORE X_NUC_194.L_CORE 0.001845
K_16629 X_NUC_96.L_CORE X_NUC_195.L_CORE 0.001343
K_16630 X_NUC_96.L_CORE X_NUC_196.L_CORE 0.014197
K_16631 X_NUC_96.L_CORE X_NUC_197.L_CORE 0.001347
K_16632 X_NUC_96.L_CORE X_NUC_198.L_CORE 0.001851
K_16633 X_NUC_96.L_CORE X_NUC_199.L_CORE 0.002846
K_16634 X_NUC_96.L_CORE X_NUC_200.L_CORE 0.001265
K_16635 X_NUC_96.L_CORE X_NUC_201.L_CORE 0.004425
K_16636 X_NUC_96.L_CORE X_NUC_202.L_CORE 0.001597
K_16637 X_NUC_96.L_CORE X_NUC_203.L_CORE 0.001482
K_16638 X_NUC_96.L_CORE X_NUC_204.L_CORE 0.006553
K_16639 X_NUC_96.L_CORE X_NUC_205.L_CORE 0.001305
K_16640 X_NUC_96.L_CORE X_NUC_206.L_CORE 0.002335
K_16641 X_NUC_96.L_CORE X_NUC_207.L_CORE 0.002143
K_16642 X_NUC_96.L_CORE X_NUC_208.L_CORE 0.001343
K_16643 X_NUC_96.L_CORE X_NUC_209.L_CORE 0.005722
K_16644 X_NUC_96.L_CORE X_NUC_210.L_CORE 0.001476
K_16645 X_NUC_96.L_CORE X_NUC_211.L_CORE 0.001722
K_16646 X_NUC_96.L_CORE X_NUC_212.L_CORE 0.003119
K_16647 X_NUC_96.L_CORE X_NUC_213.L_CORE 0.001352
K_16648 X_NUC_96.L_CORE X_NUC_214.L_CORE 0.002766
K_16649 X_NUC_96.L_CORE X_NUC_215.L_CORE 0.001808
K_16650 X_NUC_96.L_CORE X_NUC_216.L_CORE 0.001520
K_16651 X_NUC_96.L_CORE X_NUC_217.L_CORE 0.003191
K_16652 X_NUC_96.L_CORE X_NUC_218.L_CORE 0.001506
K_16653 X_NUC_96.L_CORE X_NUC_219.L_CORE 0.001971
K_16654 X_NUC_96.L_CORE X_NUC_220.L_CORE 0.002125
K_16655 X_NUC_96.L_CORE X_NUC_221.L_CORE 0.001597
K_16656 X_NUC_96.L_CORE X_NUC_222.L_CORE 0.002080
K_16657 X_NUC_97.L_CORE X_NUC_98.L_CORE 0.207973
K_16658 X_NUC_97.L_CORE X_NUC_99.L_CORE 0.207973
K_16659 X_NUC_97.L_CORE X_NUC_100.L_CORE 0.207973
K_16660 X_NUC_97.L_CORE X_NUC_101.L_CORE 0.001416
K_16661 X_NUC_97.L_CORE X_NUC_102.L_CORE 0.001415
K_16662 X_NUC_97.L_CORE X_NUC_103.L_CORE 0.001410
K_16663 X_NUC_97.L_CORE X_NUC_104.L_CORE 0.001420
K_16664 X_NUC_97.L_CORE X_NUC_105.L_CORE 0.001959
K_16665 X_NUC_97.L_CORE X_NUC_106.L_CORE 0.001975
K_16666 X_NUC_97.L_CORE X_NUC_107.L_CORE 0.001962
K_16667 X_NUC_97.L_CORE X_NUC_108.L_CORE 0.001971
K_16668 X_NUC_97.L_CORE X_NUC_109.L_CORE 0.002977
K_16669 X_NUC_97.L_CORE X_NUC_110.L_CORE 0.002947
K_16670 X_NUC_97.L_CORE X_NUC_111.L_CORE 0.002943
K_16671 X_NUC_97.L_CORE X_NUC_112.L_CORE 0.002971
K_16672 X_NUC_97.L_CORE X_NUC_113.L_CORE 0.001344
K_16673 X_NUC_97.L_CORE X_NUC_114.L_CORE 0.001347
K_16674 X_NUC_97.L_CORE X_NUC_115.L_CORE 0.001341
K_16675 X_NUC_97.L_CORE X_NUC_116.L_CORE 0.001349
K_16676 X_NUC_97.L_CORE X_NUC_117.L_CORE 0.004432
K_16677 X_NUC_97.L_CORE X_NUC_118.L_CORE 0.004520
K_16678 X_NUC_97.L_CORE X_NUC_119.L_CORE 0.004442
K_16679 X_NUC_97.L_CORE X_NUC_120.L_CORE 0.004454
K_16680 X_NUC_97.L_CORE X_NUC_121.L_CORE 0.001699
K_16681 X_NUC_97.L_CORE X_NUC_122.L_CORE 0.001694
K_16682 X_NUC_97.L_CORE X_NUC_123.L_CORE 0.001688
K_16683 X_NUC_97.L_CORE X_NUC_124.L_CORE 0.001701
K_16684 X_NUC_97.L_CORE X_NUC_125.L_CORE 0.001591
K_16685 X_NUC_97.L_CORE X_NUC_126.L_CORE 0.001600
K_16686 X_NUC_97.L_CORE X_NUC_127.L_CORE 0.001589
K_16687 X_NUC_97.L_CORE X_NUC_128.L_CORE 0.001598
K_16688 X_NUC_97.L_CORE X_NUC_129.L_CORE 0.005118
K_16689 X_NUC_97.L_CORE X_NUC_130.L_CORE 0.005059
K_16690 X_NUC_97.L_CORE X_NUC_131.L_CORE 0.004995
K_16691 X_NUC_97.L_CORE X_NUC_132.L_CORE 0.005055
K_16692 X_NUC_97.L_CORE X_NUC_133.L_CORE 0.001420
K_16693 X_NUC_97.L_CORE X_NUC_134.L_CORE 0.001421
K_16694 X_NUC_97.L_CORE X_NUC_135.L_CORE 0.001414
K_16695 X_NUC_97.L_CORE X_NUC_136.L_CORE 0.001423
K_16696 X_NUC_97.L_CORE X_NUC_137.L_CORE 0.002415
K_16697 X_NUC_97.L_CORE X_NUC_138.L_CORE 0.002438
K_16698 X_NUC_97.L_CORE X_NUC_139.L_CORE 0.002412
K_16699 X_NUC_97.L_CORE X_NUC_140.L_CORE 0.002423
K_16700 X_NUC_97.L_CORE X_NUC_141.L_CORE 0.002226
K_16701 X_NUC_97.L_CORE X_NUC_142.L_CORE 0.002216
K_16702 X_NUC_97.L_CORE X_NUC_143.L_CORE 0.002204
K_16703 X_NUC_97.L_CORE X_NUC_144.L_CORE 0.002223
K_16704 X_NUC_97.L_CORE X_NUC_145.L_CORE 0.001495
K_16705 X_NUC_97.L_CORE X_NUC_146.L_CORE 0.001500
K_16706 X_NUC_97.L_CORE X_NUC_147.L_CORE 0.001491
K_16707 X_NUC_97.L_CORE X_NUC_148.L_CORE 0.001500
K_16708 X_NUC_97.L_CORE X_NUC_149.L_CORE 0.003681
K_16709 X_NUC_97.L_CORE X_NUC_150.L_CORE 0.003702
K_16710 X_NUC_97.L_CORE X_NUC_151.L_CORE 0.003639
K_16711 X_NUC_97.L_CORE X_NUC_152.L_CORE 0.003665
K_16712 X_NUC_97.L_CORE X_NUC_153.L_CORE 0.001655
K_16713 X_NUC_97.L_CORE X_NUC_154.L_CORE 0.001653
K_16714 X_NUC_97.L_CORE X_NUC_155.L_CORE 0.001644
K_16715 X_NUC_97.L_CORE X_NUC_156.L_CORE 0.001656
K_16716 X_NUC_97.L_CORE X_NUC_157.L_CORE 0.001886
K_16717 X_NUC_97.L_CORE X_NUC_158.L_CORE 0.001896
K_16718 X_NUC_97.L_CORE X_NUC_159.L_CORE 0.001880
K_16719 X_NUC_97.L_CORE X_NUC_160.L_CORE 0.001891
K_16720 X_NUC_97.L_CORE X_NUC_161.L_CORE 0.002548
K_16721 X_NUC_97.L_CORE X_NUC_162.L_CORE 0.002544
K_16722 X_NUC_97.L_CORE X_NUC_163.L_CORE 0.002519
K_16723 X_NUC_97.L_CORE X_NUC_164.L_CORE 0.002540
K_16724 X_NUC_97.L_CORE X_NUC_165.L_CORE 0.001658
K_16725 X_NUC_97.L_CORE X_NUC_166.L_CORE 0.001661
K_16726 X_NUC_97.L_CORE X_NUC_167.L_CORE 0.001649
K_16727 X_NUC_97.L_CORE X_NUC_168.L_CORE 0.001660
K_16728 X_NUC_97.L_CORE X_NUC_169.L_CORE 0.002180
K_16729 X_NUC_97.L_CORE X_NUC_170.L_CORE 0.002187
K_16730 X_NUC_97.L_CORE X_NUC_171.L_CORE 0.002165
K_16731 X_NUC_97.L_CORE X_NUC_172.L_CORE 0.002180
K_16732 X_NUC_97.L_CORE X_NUC_173.L_CORE 0.001742
K_16733 X_NUC_97.L_CORE X_NUC_174.L_CORE 0.001725
K_16734 X_NUC_97.L_CORE X_NUC_175.L_CORE 0.001459
K_16735 X_NUC_97.L_CORE X_NUC_176.L_CORE 0.002256
K_16736 X_NUC_97.L_CORE X_NUC_177.L_CORE 0.001458
K_16737 X_NUC_97.L_CORE X_NUC_178.L_CORE 0.001666
K_16738 X_NUC_97.L_CORE X_NUC_179.L_CORE 0.002228
K_16739 X_NUC_97.L_CORE X_NUC_180.L_CORE 0.001321
K_16740 X_NUC_97.L_CORE X_NUC_181.L_CORE 0.002459
K_16741 X_NUC_97.L_CORE X_NUC_182.L_CORE 0.001625
K_16742 X_NUC_97.L_CORE X_NUC_183.L_CORE 0.001429
K_16743 X_NUC_97.L_CORE X_NUC_184.L_CORE 0.003460
K_16744 X_NUC_97.L_CORE X_NUC_185.L_CORE 0.001316
K_16745 X_NUC_97.L_CORE X_NUC_186.L_CORE 0.001987
K_16746 X_NUC_97.L_CORE X_NUC_187.L_CORE 0.002145
K_16747 X_NUC_97.L_CORE X_NUC_188.L_CORE 0.001287
K_16748 X_NUC_97.L_CORE X_NUC_189.L_CORE 0.004278
K_16749 X_NUC_97.L_CORE X_NUC_190.L_CORE 0.001456
K_16750 X_NUC_97.L_CORE X_NUC_191.L_CORE 0.001567
K_16751 X_NUC_97.L_CORE X_NUC_192.L_CORE 0.003777
K_16752 X_NUC_97.L_CORE X_NUC_193.L_CORE 0.001258
K_16753 X_NUC_97.L_CORE X_NUC_194.L_CORE 0.002736
K_16754 X_NUC_97.L_CORE X_NUC_195.L_CORE 0.001833
K_16755 X_NUC_97.L_CORE X_NUC_196.L_CORE 0.001346
K_16756 X_NUC_97.L_CORE X_NUC_197.L_CORE 0.014366
K_16757 X_NUC_97.L_CORE X_NUC_198.L_CORE 0.001347
K_16758 X_NUC_97.L_CORE X_NUC_199.L_CORE 0.001867
K_16759 X_NUC_97.L_CORE X_NUC_200.L_CORE 0.002824
K_16760 X_NUC_97.L_CORE X_NUC_201.L_CORE 0.001271
K_16761 X_NUC_97.L_CORE X_NUC_202.L_CORE 0.004532
K_16762 X_NUC_97.L_CORE X_NUC_203.L_CORE 0.001600
K_16763 X_NUC_97.L_CORE X_NUC_204.L_CORE 0.001497
K_16764 X_NUC_97.L_CORE X_NUC_205.L_CORE 0.006406
K_16765 X_NUC_97.L_CORE X_NUC_206.L_CORE 0.001315
K_16766 X_NUC_97.L_CORE X_NUC_207.L_CORE 0.002375
K_16767 X_NUC_97.L_CORE X_NUC_208.L_CORE 0.002148
K_16768 X_NUC_97.L_CORE X_NUC_209.L_CORE 0.001361
K_16769 X_NUC_97.L_CORE X_NUC_210.L_CORE 0.005718
K_16770 X_NUC_97.L_CORE X_NUC_211.L_CORE 0.001492
K_16771 X_NUC_97.L_CORE X_NUC_212.L_CORE 0.001754
K_16772 X_NUC_97.L_CORE X_NUC_213.L_CORE 0.003098
K_16773 X_NUC_97.L_CORE X_NUC_214.L_CORE 0.001378
K_16774 X_NUC_97.L_CORE X_NUC_215.L_CORE 0.002792
K_16775 X_NUC_97.L_CORE X_NUC_216.L_CORE 0.001832
K_16776 X_NUC_97.L_CORE X_NUC_217.L_CORE 0.001561
K_16777 X_NUC_97.L_CORE X_NUC_218.L_CORE 0.003086
K_16778 X_NUC_97.L_CORE X_NUC_219.L_CORE 0.001554
K_16779 X_NUC_97.L_CORE X_NUC_220.L_CORE 0.002004
K_16780 X_NUC_97.L_CORE X_NUC_221.L_CORE 0.002106
K_16781 X_NUC_97.L_CORE X_NUC_222.L_CORE 0.001725
K_16782 X_NUC_98.L_CORE X_NUC_99.L_CORE 0.207973
K_16783 X_NUC_98.L_CORE X_NUC_100.L_CORE 0.207973
K_16784 X_NUC_98.L_CORE X_NUC_101.L_CORE 0.001417
K_16785 X_NUC_98.L_CORE X_NUC_102.L_CORE 0.001416
K_16786 X_NUC_98.L_CORE X_NUC_103.L_CORE 0.001411
K_16787 X_NUC_98.L_CORE X_NUC_104.L_CORE 0.001421
K_16788 X_NUC_98.L_CORE X_NUC_105.L_CORE 0.001943
K_16789 X_NUC_98.L_CORE X_NUC_106.L_CORE 0.001959
K_16790 X_NUC_98.L_CORE X_NUC_107.L_CORE 0.001946
K_16791 X_NUC_98.L_CORE X_NUC_108.L_CORE 0.001954
K_16792 X_NUC_98.L_CORE X_NUC_109.L_CORE 0.003008
K_16793 X_NUC_98.L_CORE X_NUC_110.L_CORE 0.002977
K_16794 X_NUC_98.L_CORE X_NUC_111.L_CORE 0.002973
K_16795 X_NUC_98.L_CORE X_NUC_112.L_CORE 0.003002
K_16796 X_NUC_98.L_CORE X_NUC_113.L_CORE 0.001341
K_16797 X_NUC_98.L_CORE X_NUC_114.L_CORE 0.001344
K_16798 X_NUC_98.L_CORE X_NUC_115.L_CORE 0.001338
K_16799 X_NUC_98.L_CORE X_NUC_116.L_CORE 0.001346
K_16800 X_NUC_98.L_CORE X_NUC_117.L_CORE 0.004348
K_16801 X_NUC_98.L_CORE X_NUC_118.L_CORE 0.004432
K_16802 X_NUC_98.L_CORE X_NUC_119.L_CORE 0.004358
K_16803 X_NUC_98.L_CORE X_NUC_120.L_CORE 0.004369
K_16804 X_NUC_98.L_CORE X_NUC_121.L_CORE 0.001703
K_16805 X_NUC_98.L_CORE X_NUC_122.L_CORE 0.001699
K_16806 X_NUC_98.L_CORE X_NUC_123.L_CORE 0.001693
K_16807 X_NUC_98.L_CORE X_NUC_124.L_CORE 0.001706
K_16808 X_NUC_98.L_CORE X_NUC_125.L_CORE 0.001583
K_16809 X_NUC_98.L_CORE X_NUC_126.L_CORE 0.001591
K_16810 X_NUC_98.L_CORE X_NUC_127.L_CORE 0.001581
K_16811 X_NUC_98.L_CORE X_NUC_128.L_CORE 0.001589
K_16812 X_NUC_98.L_CORE X_NUC_129.L_CORE 0.005176
K_16813 X_NUC_98.L_CORE X_NUC_130.L_CORE 0.005118
K_16814 X_NUC_98.L_CORE X_NUC_131.L_CORE 0.005050
K_16815 X_NUC_98.L_CORE X_NUC_132.L_CORE 0.005112
K_16816 X_NUC_98.L_CORE X_NUC_133.L_CORE 0.001419
K_16817 X_NUC_98.L_CORE X_NUC_134.L_CORE 0.001420
K_16818 X_NUC_98.L_CORE X_NUC_135.L_CORE 0.001413
K_16819 X_NUC_98.L_CORE X_NUC_136.L_CORE 0.001423
K_16820 X_NUC_98.L_CORE X_NUC_137.L_CORE 0.002393
K_16821 X_NUC_98.L_CORE X_NUC_138.L_CORE 0.002415
K_16822 X_NUC_98.L_CORE X_NUC_139.L_CORE 0.002390
K_16823 X_NUC_98.L_CORE X_NUC_140.L_CORE 0.002401
K_16824 X_NUC_98.L_CORE X_NUC_141.L_CORE 0.002236
K_16825 X_NUC_98.L_CORE X_NUC_142.L_CORE 0.002226
K_16826 X_NUC_98.L_CORE X_NUC_143.L_CORE 0.002214
K_16827 X_NUC_98.L_CORE X_NUC_144.L_CORE 0.002233
K_16828 X_NUC_98.L_CORE X_NUC_145.L_CORE 0.001490
K_16829 X_NUC_98.L_CORE X_NUC_146.L_CORE 0.001495
K_16830 X_NUC_98.L_CORE X_NUC_147.L_CORE 0.001486
K_16831 X_NUC_98.L_CORE X_NUC_148.L_CORE 0.001495
K_16832 X_NUC_98.L_CORE X_NUC_149.L_CORE 0.003660
K_16833 X_NUC_98.L_CORE X_NUC_150.L_CORE 0.003681
K_16834 X_NUC_98.L_CORE X_NUC_151.L_CORE 0.003619
K_16835 X_NUC_98.L_CORE X_NUC_152.L_CORE 0.003645
K_16836 X_NUC_98.L_CORE X_NUC_153.L_CORE 0.001656
K_16837 X_NUC_98.L_CORE X_NUC_154.L_CORE 0.001655
K_16838 X_NUC_98.L_CORE X_NUC_155.L_CORE 0.001645
K_16839 X_NUC_98.L_CORE X_NUC_156.L_CORE 0.001657
K_16840 X_NUC_98.L_CORE X_NUC_157.L_CORE 0.001876
K_16841 X_NUC_98.L_CORE X_NUC_158.L_CORE 0.001886
K_16842 X_NUC_98.L_CORE X_NUC_159.L_CORE 0.001870
K_16843 X_NUC_98.L_CORE X_NUC_160.L_CORE 0.001881
K_16844 X_NUC_98.L_CORE X_NUC_161.L_CORE 0.002551
K_16845 X_NUC_98.L_CORE X_NUC_162.L_CORE 0.002548
K_16846 X_NUC_98.L_CORE X_NUC_163.L_CORE 0.002523
K_16847 X_NUC_98.L_CORE X_NUC_164.L_CORE 0.002544
K_16848 X_NUC_98.L_CORE X_NUC_165.L_CORE 0.001655
K_16849 X_NUC_98.L_CORE X_NUC_166.L_CORE 0.001658
K_16850 X_NUC_98.L_CORE X_NUC_167.L_CORE 0.001646
K_16851 X_NUC_98.L_CORE X_NUC_168.L_CORE 0.001657
K_16852 X_NUC_98.L_CORE X_NUC_169.L_CORE 0.002173
K_16853 X_NUC_98.L_CORE X_NUC_170.L_CORE 0.002180
K_16854 X_NUC_98.L_CORE X_NUC_171.L_CORE 0.002158
K_16855 X_NUC_98.L_CORE X_NUC_172.L_CORE 0.002173
K_16856 X_NUC_98.L_CORE X_NUC_173.L_CORE 0.001738
K_16857 X_NUC_98.L_CORE X_NUC_174.L_CORE 0.001726
K_16858 X_NUC_98.L_CORE X_NUC_175.L_CORE 0.001456
K_16859 X_NUC_98.L_CORE X_NUC_176.L_CORE 0.002253
K_16860 X_NUC_98.L_CORE X_NUC_177.L_CORE 0.001459
K_16861 X_NUC_98.L_CORE X_NUC_178.L_CORE 0.001658
K_16862 X_NUC_98.L_CORE X_NUC_179.L_CORE 0.002236
K_16863 X_NUC_98.L_CORE X_NUC_180.L_CORE 0.001318
K_16864 X_NUC_98.L_CORE X_NUC_181.L_CORE 0.002443
K_16865 X_NUC_98.L_CORE X_NUC_182.L_CORE 0.001629
K_16866 X_NUC_98.L_CORE X_NUC_183.L_CORE 0.001423
K_16867 X_NUC_98.L_CORE X_NUC_184.L_CORE 0.003472
K_16868 X_NUC_98.L_CORE X_NUC_185.L_CORE 0.001316
K_16869 X_NUC_98.L_CORE X_NUC_186.L_CORE 0.001972
K_16870 X_NUC_98.L_CORE X_NUC_187.L_CORE 0.002158
K_16871 X_NUC_98.L_CORE X_NUC_188.L_CORE 0.001284
K_16872 X_NUC_98.L_CORE X_NUC_189.L_CORE 0.004229
K_16873 X_NUC_98.L_CORE X_NUC_190.L_CORE 0.001459
K_16874 X_NUC_98.L_CORE X_NUC_191.L_CORE 0.001558
K_16875 X_NUC_98.L_CORE X_NUC_192.L_CORE 0.003830
K_16876 X_NUC_98.L_CORE X_NUC_193.L_CORE 0.001257
K_16877 X_NUC_98.L_CORE X_NUC_194.L_CORE 0.002702
K_16878 X_NUC_98.L_CORE X_NUC_195.L_CORE 0.001842
K_16879 X_NUC_98.L_CORE X_NUC_196.L_CORE 0.001341
K_16880 X_NUC_98.L_CORE X_NUC_197.L_CORE 0.014496
K_16881 X_NUC_98.L_CORE X_NUC_198.L_CORE 0.001348
K_16882 X_NUC_98.L_CORE X_NUC_199.L_CORE 0.001852
K_16883 X_NUC_98.L_CORE X_NUC_200.L_CORE 0.002855
K_16884 X_NUC_98.L_CORE X_NUC_201.L_CORE 0.001268
K_16885 X_NUC_98.L_CORE X_NUC_202.L_CORE 0.004436
K_16886 X_NUC_98.L_CORE X_NUC_203.L_CORE 0.001605
K_16887 X_NUC_98.L_CORE X_NUC_204.L_CORE 0.001489
K_16888 X_NUC_98.L_CORE X_NUC_205.L_CORE 0.006575
K_16889 X_NUC_98.L_CORE X_NUC_206.L_CORE 0.001314
K_16890 X_NUC_98.L_CORE X_NUC_207.L_CORE 0.002350
K_16891 X_NUC_98.L_CORE X_NUC_208.L_CORE 0.002161
K_16892 X_NUC_98.L_CORE X_NUC_209.L_CORE 0.001357
K_16893 X_NUC_98.L_CORE X_NUC_210.L_CORE 0.005645
K_16894 X_NUC_98.L_CORE X_NUC_211.L_CORE 0.001494
K_16895 X_NUC_98.L_CORE X_NUC_212.L_CORE 0.001742
K_16896 X_NUC_98.L_CORE X_NUC_213.L_CORE 0.003123
K_16897 X_NUC_98.L_CORE X_NUC_214.L_CORE 0.001376
K_16898 X_NUC_98.L_CORE X_NUC_215.L_CORE 0.002766
K_16899 X_NUC_98.L_CORE X_NUC_216.L_CORE 0.001837
K_16900 X_NUC_98.L_CORE X_NUC_217.L_CORE 0.001555
K_16901 X_NUC_98.L_CORE X_NUC_218.L_CORE 0.003085
K_16902 X_NUC_98.L_CORE X_NUC_219.L_CORE 0.001553
K_16903 X_NUC_98.L_CORE X_NUC_220.L_CORE 0.001994
K_16904 X_NUC_98.L_CORE X_NUC_221.L_CORE 0.002108
K_16905 X_NUC_98.L_CORE X_NUC_222.L_CORE 0.001721
K_16906 X_NUC_99.L_CORE X_NUC_100.L_CORE 0.207973
K_16907 X_NUC_99.L_CORE X_NUC_101.L_CORE 0.001421
K_16908 X_NUC_99.L_CORE X_NUC_102.L_CORE 0.001420
K_16909 X_NUC_99.L_CORE X_NUC_103.L_CORE 0.001416
K_16910 X_NUC_99.L_CORE X_NUC_104.L_CORE 0.001425
K_16911 X_NUC_99.L_CORE X_NUC_105.L_CORE 0.001956
K_16912 X_NUC_99.L_CORE X_NUC_106.L_CORE 0.001972
K_16913 X_NUC_99.L_CORE X_NUC_107.L_CORE 0.001959
K_16914 X_NUC_99.L_CORE X_NUC_108.L_CORE 0.001968
K_16915 X_NUC_99.L_CORE X_NUC_109.L_CORE 0.003012
K_16916 X_NUC_99.L_CORE X_NUC_110.L_CORE 0.002981
K_16917 X_NUC_99.L_CORE X_NUC_111.L_CORE 0.002977
K_16918 X_NUC_99.L_CORE X_NUC_112.L_CORE 0.003006
K_16919 X_NUC_99.L_CORE X_NUC_113.L_CORE 0.001347
K_16920 X_NUC_99.L_CORE X_NUC_114.L_CORE 0.001350
K_16921 X_NUC_99.L_CORE X_NUC_115.L_CORE 0.001344
K_16922 X_NUC_99.L_CORE X_NUC_116.L_CORE 0.001352
K_16923 X_NUC_99.L_CORE X_NUC_117.L_CORE 0.004420
K_16924 X_NUC_99.L_CORE X_NUC_118.L_CORE 0.004508
K_16925 X_NUC_99.L_CORE X_NUC_119.L_CORE 0.004432
K_16926 X_NUC_99.L_CORE X_NUC_120.L_CORE 0.004443
K_16927 X_NUC_99.L_CORE X_NUC_121.L_CORE 0.001709
K_16928 X_NUC_99.L_CORE X_NUC_122.L_CORE 0.001704
K_16929 X_NUC_99.L_CORE X_NUC_123.L_CORE 0.001699
K_16930 X_NUC_99.L_CORE X_NUC_124.L_CORE 0.001711
K_16931 X_NUC_99.L_CORE X_NUC_125.L_CORE 0.001593
K_16932 X_NUC_99.L_CORE X_NUC_126.L_CORE 0.001601
K_16933 X_NUC_99.L_CORE X_NUC_127.L_CORE 0.001591
K_16934 X_NUC_99.L_CORE X_NUC_128.L_CORE 0.001600
K_16935 X_NUC_99.L_CORE X_NUC_129.L_CORE 0.005247
K_16936 X_NUC_99.L_CORE X_NUC_130.L_CORE 0.005185
K_16937 X_NUC_99.L_CORE X_NUC_131.L_CORE 0.005118
K_16938 X_NUC_99.L_CORE X_NUC_132.L_CORE 0.005180
K_16939 X_NUC_99.L_CORE X_NUC_133.L_CORE 0.001426
K_16940 X_NUC_99.L_CORE X_NUC_134.L_CORE 0.001427
K_16941 X_NUC_99.L_CORE X_NUC_135.L_CORE 0.001420
K_16942 X_NUC_99.L_CORE X_NUC_136.L_CORE 0.001429
K_16943 X_NUC_99.L_CORE X_NUC_137.L_CORE 0.002418
K_16944 X_NUC_99.L_CORE X_NUC_138.L_CORE 0.002441
K_16945 X_NUC_99.L_CORE X_NUC_139.L_CORE 0.002415
K_16946 X_NUC_99.L_CORE X_NUC_140.L_CORE 0.002426
K_16947 X_NUC_99.L_CORE X_NUC_141.L_CORE 0.002248
K_16948 X_NUC_99.L_CORE X_NUC_142.L_CORE 0.002238
K_16949 X_NUC_99.L_CORE X_NUC_143.L_CORE 0.002226
K_16950 X_NUC_99.L_CORE X_NUC_144.L_CORE 0.002245
K_16951 X_NUC_99.L_CORE X_NUC_145.L_CORE 0.001500
K_16952 X_NUC_99.L_CORE X_NUC_146.L_CORE 0.001505
K_16953 X_NUC_99.L_CORE X_NUC_147.L_CORE 0.001495
K_16954 X_NUC_99.L_CORE X_NUC_148.L_CORE 0.001504
K_16955 X_NUC_99.L_CORE X_NUC_149.L_CORE 0.003724
K_16956 X_NUC_99.L_CORE X_NUC_150.L_CORE 0.003746
K_16957 X_NUC_99.L_CORE X_NUC_151.L_CORE 0.003681
K_16958 X_NUC_99.L_CORE X_NUC_152.L_CORE 0.003708
K_16959 X_NUC_99.L_CORE X_NUC_153.L_CORE 0.001665
K_16960 X_NUC_99.L_CORE X_NUC_154.L_CORE 0.001664
K_16961 X_NUC_99.L_CORE X_NUC_155.L_CORE 0.001655
K_16962 X_NUC_99.L_CORE X_NUC_156.L_CORE 0.001667
K_16963 X_NUC_99.L_CORE X_NUC_157.L_CORE 0.001893
K_16964 X_NUC_99.L_CORE X_NUC_158.L_CORE 0.001903
K_16965 X_NUC_99.L_CORE X_NUC_159.L_CORE 0.001886
K_16966 X_NUC_99.L_CORE X_NUC_160.L_CORE 0.001897
K_16967 X_NUC_99.L_CORE X_NUC_161.L_CORE 0.002577
K_16968 X_NUC_99.L_CORE X_NUC_162.L_CORE 0.002573
K_16969 X_NUC_99.L_CORE X_NUC_163.L_CORE 0.002548
K_16970 X_NUC_99.L_CORE X_NUC_164.L_CORE 0.002569
K_16971 X_NUC_99.L_CORE X_NUC_165.L_CORE 0.001667
K_16972 X_NUC_99.L_CORE X_NUC_166.L_CORE 0.001670
K_16973 X_NUC_99.L_CORE X_NUC_167.L_CORE 0.001658
K_16974 X_NUC_99.L_CORE X_NUC_168.L_CORE 0.001669
K_16975 X_NUC_99.L_CORE X_NUC_169.L_CORE 0.002195
K_16976 X_NUC_99.L_CORE X_NUC_170.L_CORE 0.002203
K_16977 X_NUC_99.L_CORE X_NUC_171.L_CORE 0.002180
K_16978 X_NUC_99.L_CORE X_NUC_172.L_CORE 0.002195
K_16979 X_NUC_99.L_CORE X_NUC_173.L_CORE 0.001736
K_16980 X_NUC_99.L_CORE X_NUC_174.L_CORE 0.001722
K_16981 X_NUC_99.L_CORE X_NUC_175.L_CORE 0.001457
K_16982 X_NUC_99.L_CORE X_NUC_176.L_CORE 0.002243
K_16983 X_NUC_99.L_CORE X_NUC_177.L_CORE 0.001458
K_16984 X_NUC_99.L_CORE X_NUC_178.L_CORE 0.001660
K_16985 X_NUC_99.L_CORE X_NUC_179.L_CORE 0.002225
K_16986 X_NUC_99.L_CORE X_NUC_180.L_CORE 0.001320
K_16987 X_NUC_99.L_CORE X_NUC_181.L_CORE 0.002438
K_16988 X_NUC_99.L_CORE X_NUC_182.L_CORE 0.001628
K_16989 X_NUC_99.L_CORE X_NUC_183.L_CORE 0.001426
K_16990 X_NUC_99.L_CORE X_NUC_184.L_CORE 0.003433
K_16991 X_NUC_99.L_CORE X_NUC_185.L_CORE 0.001318
K_16992 X_NUC_99.L_CORE X_NUC_186.L_CORE 0.001976
K_16993 X_NUC_99.L_CORE X_NUC_187.L_CORE 0.002151
K_16994 X_NUC_99.L_CORE X_NUC_188.L_CORE 0.001287
K_16995 X_NUC_99.L_CORE X_NUC_189.L_CORE 0.004199
K_16996 X_NUC_99.L_CORE X_NUC_190.L_CORE 0.001460
K_16997 X_NUC_99.L_CORE X_NUC_191.L_CORE 0.001564
K_16998 X_NUC_99.L_CORE X_NUC_192.L_CORE 0.003789
K_16999 X_NUC_99.L_CORE X_NUC_193.L_CORE 0.001260
K_17000 X_NUC_99.L_CORE X_NUC_194.L_CORE 0.002713
K_17001 X_NUC_99.L_CORE X_NUC_195.L_CORE 0.001842
K_17002 X_NUC_99.L_CORE X_NUC_196.L_CORE 0.001346
K_17003 X_NUC_99.L_CORE X_NUC_197.L_CORE 0.013631
K_17004 X_NUC_99.L_CORE X_NUC_198.L_CORE 0.001351
K_17005 X_NUC_99.L_CORE X_NUC_199.L_CORE 0.001863
K_17006 X_NUC_99.L_CORE X_NUC_200.L_CORE 0.002850
K_17007 X_NUC_99.L_CORE X_NUC_201.L_CORE 0.001273
K_17008 X_NUC_99.L_CORE X_NUC_202.L_CORE 0.004485
K_17009 X_NUC_99.L_CORE X_NUC_203.L_CORE 0.001608
K_17010 X_NUC_99.L_CORE X_NUC_204.L_CORE 0.001498
K_17011 X_NUC_99.L_CORE X_NUC_205.L_CORE 0.006586
K_17012 X_NUC_99.L_CORE X_NUC_206.L_CORE 0.001319
K_17013 X_NUC_99.L_CORE X_NUC_207.L_CORE 0.002370
K_17014 X_NUC_99.L_CORE X_NUC_208.L_CORE 0.002167
K_17015 X_NUC_99.L_CORE X_NUC_209.L_CORE 0.001364
K_17016 X_NUC_99.L_CORE X_NUC_210.L_CORE 0.005783
K_17017 X_NUC_99.L_CORE X_NUC_211.L_CORE 0.001500
K_17018 X_NUC_99.L_CORE X_NUC_212.L_CORE 0.001756
K_17019 X_NUC_99.L_CORE X_NUC_213.L_CORE 0.003145
K_17020 X_NUC_99.L_CORE X_NUC_214.L_CORE 0.001383
K_17021 X_NUC_99.L_CORE X_NUC_215.L_CORE 0.002802
K_17022 X_NUC_99.L_CORE X_NUC_216.L_CORE 0.001847
K_17023 X_NUC_99.L_CORE X_NUC_217.L_CORE 0.001566
K_17024 X_NUC_99.L_CORE X_NUC_218.L_CORE 0.003125
K_17025 X_NUC_99.L_CORE X_NUC_219.L_CORE 0.001563
K_17026 X_NUC_99.L_CORE X_NUC_220.L_CORE 0.002013
K_17027 X_NUC_99.L_CORE X_NUC_221.L_CORE 0.002125
K_17028 X_NUC_99.L_CORE X_NUC_222.L_CORE 0.001735
K_17029 X_NUC_100.L_CORE X_NUC_101.L_CORE 0.001412
K_17030 X_NUC_100.L_CORE X_NUC_102.L_CORE 0.001411
K_17031 X_NUC_100.L_CORE X_NUC_103.L_CORE 0.001406
K_17032 X_NUC_100.L_CORE X_NUC_104.L_CORE 0.001416
K_17033 X_NUC_100.L_CORE X_NUC_105.L_CORE 0.001948
K_17034 X_NUC_100.L_CORE X_NUC_106.L_CORE 0.001964
K_17035 X_NUC_100.L_CORE X_NUC_107.L_CORE 0.001950
K_17036 X_NUC_100.L_CORE X_NUC_108.L_CORE 0.001959
K_17037 X_NUC_100.L_CORE X_NUC_109.L_CORE 0.002983
K_17038 X_NUC_100.L_CORE X_NUC_110.L_CORE 0.002952
K_17039 X_NUC_100.L_CORE X_NUC_111.L_CORE 0.002948
K_17040 X_NUC_100.L_CORE X_NUC_112.L_CORE 0.002977
K_17041 X_NUC_100.L_CORE X_NUC_113.L_CORE 0.001339
K_17042 X_NUC_100.L_CORE X_NUC_114.L_CORE 0.001342
K_17043 X_NUC_100.L_CORE X_NUC_115.L_CORE 0.001336
K_17044 X_NUC_100.L_CORE X_NUC_116.L_CORE 0.001344
K_17045 X_NUC_100.L_CORE X_NUC_117.L_CORE 0.004409
K_17046 X_NUC_100.L_CORE X_NUC_118.L_CORE 0.004497
K_17047 X_NUC_100.L_CORE X_NUC_119.L_CORE 0.004420
K_17048 X_NUC_100.L_CORE X_NUC_120.L_CORE 0.004432
K_17049 X_NUC_100.L_CORE X_NUC_121.L_CORE 0.001696
K_17050 X_NUC_100.L_CORE X_NUC_122.L_CORE 0.001692
K_17051 X_NUC_100.L_CORE X_NUC_123.L_CORE 0.001686
K_17052 X_NUC_100.L_CORE X_NUC_124.L_CORE 0.001699
K_17053 X_NUC_100.L_CORE X_NUC_125.L_CORE 0.001584
K_17054 X_NUC_100.L_CORE X_NUC_126.L_CORE 0.001593
K_17055 X_NUC_100.L_CORE X_NUC_127.L_CORE 0.001583
K_17056 X_NUC_100.L_CORE X_NUC_128.L_CORE 0.001591
K_17057 X_NUC_100.L_CORE X_NUC_129.L_CORE 0.005180
K_17058 X_NUC_100.L_CORE X_NUC_130.L_CORE 0.005121
K_17059 X_NUC_100.L_CORE X_NUC_131.L_CORE 0.005055
K_17060 X_NUC_100.L_CORE X_NUC_132.L_CORE 0.005118
K_17061 X_NUC_100.L_CORE X_NUC_133.L_CORE 0.001416
K_17062 X_NUC_100.L_CORE X_NUC_134.L_CORE 0.001417
K_17063 X_NUC_100.L_CORE X_NUC_135.L_CORE 0.001411
K_17064 X_NUC_100.L_CORE X_NUC_136.L_CORE 0.001420
K_17065 X_NUC_100.L_CORE X_NUC_137.L_CORE 0.002406
K_17066 X_NUC_100.L_CORE X_NUC_138.L_CORE 0.002429
K_17067 X_NUC_100.L_CORE X_NUC_139.L_CORE 0.002403
K_17068 X_NUC_100.L_CORE X_NUC_140.L_CORE 0.002415
K_17069 X_NUC_100.L_CORE X_NUC_141.L_CORE 0.002229
K_17070 X_NUC_100.L_CORE X_NUC_142.L_CORE 0.002219
K_17071 X_NUC_100.L_CORE X_NUC_143.L_CORE 0.002207
K_17072 X_NUC_100.L_CORE X_NUC_144.L_CORE 0.002226
K_17073 X_NUC_100.L_CORE X_NUC_145.L_CORE 0.001491
K_17074 X_NUC_100.L_CORE X_NUC_146.L_CORE 0.001495
K_17075 X_NUC_100.L_CORE X_NUC_147.L_CORE 0.001486
K_17076 X_NUC_100.L_CORE X_NUC_148.L_CORE 0.001495
K_17077 X_NUC_100.L_CORE X_NUC_149.L_CORE 0.003697
K_17078 X_NUC_100.L_CORE X_NUC_150.L_CORE 0.003718
K_17079 X_NUC_100.L_CORE X_NUC_151.L_CORE 0.003655
K_17080 X_NUC_100.L_CORE X_NUC_152.L_CORE 0.003681
K_17081 X_NUC_100.L_CORE X_NUC_153.L_CORE 0.001653
K_17082 X_NUC_100.L_CORE X_NUC_154.L_CORE 0.001652
K_17083 X_NUC_100.L_CORE X_NUC_155.L_CORE 0.001643
K_17084 X_NUC_100.L_CORE X_NUC_156.L_CORE 0.001655
K_17085 X_NUC_100.L_CORE X_NUC_157.L_CORE 0.001882
K_17086 X_NUC_100.L_CORE X_NUC_158.L_CORE 0.001892
K_17087 X_NUC_100.L_CORE X_NUC_159.L_CORE 0.001875
K_17088 X_NUC_100.L_CORE X_NUC_160.L_CORE 0.001886
K_17089 X_NUC_100.L_CORE X_NUC_161.L_CORE 0.002555
K_17090 X_NUC_100.L_CORE X_NUC_162.L_CORE 0.002551
K_17091 X_NUC_100.L_CORE X_NUC_163.L_CORE 0.002527
K_17092 X_NUC_100.L_CORE X_NUC_164.L_CORE 0.002548
K_17093 X_NUC_100.L_CORE X_NUC_165.L_CORE 0.001656
K_17094 X_NUC_100.L_CORE X_NUC_166.L_CORE 0.001659
K_17095 X_NUC_100.L_CORE X_NUC_167.L_CORE 0.001647
K_17096 X_NUC_100.L_CORE X_NUC_168.L_CORE 0.001658
K_17097 X_NUC_100.L_CORE X_NUC_169.L_CORE 0.002181
K_17098 X_NUC_100.L_CORE X_NUC_170.L_CORE 0.002188
K_17099 X_NUC_100.L_CORE X_NUC_171.L_CORE 0.002166
K_17100 X_NUC_100.L_CORE X_NUC_172.L_CORE 0.002180
K_17101 X_NUC_100.L_CORE X_NUC_173.L_CORE 0.001728
K_17102 X_NUC_100.L_CORE X_NUC_174.L_CORE 0.001713
K_17103 X_NUC_100.L_CORE X_NUC_175.L_CORE 0.001449
K_17104 X_NUC_100.L_CORE X_NUC_176.L_CORE 0.002234
K_17105 X_NUC_100.L_CORE X_NUC_177.L_CORE 0.001450
K_17106 X_NUC_100.L_CORE X_NUC_178.L_CORE 0.001653
K_17107 X_NUC_100.L_CORE X_NUC_179.L_CORE 0.002213
K_17108 X_NUC_100.L_CORE X_NUC_180.L_CORE 0.001313
K_17109 X_NUC_100.L_CORE X_NUC_181.L_CORE 0.002432
K_17110 X_NUC_100.L_CORE X_NUC_182.L_CORE 0.001618
K_17111 X_NUC_100.L_CORE X_NUC_183.L_CORE 0.001420
K_17112 X_NUC_100.L_CORE X_NUC_184.L_CORE 0.003422
K_17113 X_NUC_100.L_CORE X_NUC_185.L_CORE 0.001311
K_17114 X_NUC_100.L_CORE X_NUC_186.L_CORE 0.001970
K_17115 X_NUC_100.L_CORE X_NUC_187.L_CORE 0.002137
K_17116 X_NUC_100.L_CORE X_NUC_188.L_CORE 0.001281
K_17117 X_NUC_100.L_CORE X_NUC_189.L_CORE 0.004207
K_17118 X_NUC_100.L_CORE X_NUC_190.L_CORE 0.001451
K_17119 X_NUC_100.L_CORE X_NUC_191.L_CORE 0.001557
K_17120 X_NUC_100.L_CORE X_NUC_192.L_CORE 0.003764
K_17121 X_NUC_100.L_CORE X_NUC_193.L_CORE 0.001253
K_17122 X_NUC_100.L_CORE X_NUC_194.L_CORE 0.002709
K_17123 X_NUC_100.L_CORE X_NUC_195.L_CORE 0.001829
K_17124 X_NUC_100.L_CORE X_NUC_196.L_CORE 0.001340
K_17125 X_NUC_100.L_CORE X_NUC_197.L_CORE 0.014053
K_17126 X_NUC_100.L_CORE X_NUC_198.L_CORE 0.001343
K_17127 X_NUC_100.L_CORE X_NUC_199.L_CORE 0.001856
K_17128 X_NUC_100.L_CORE X_NUC_200.L_CORE 0.002827
K_17129 X_NUC_100.L_CORE X_NUC_201.L_CORE 0.001266
K_17130 X_NUC_100.L_CORE X_NUC_202.L_CORE 0.004495
K_17131 X_NUC_100.L_CORE X_NUC_203.L_CORE 0.001597
K_17132 X_NUC_100.L_CORE X_NUC_204.L_CORE 0.001490
K_17133 X_NUC_100.L_CORE X_NUC_205.L_CORE 0.006526
K_17134 X_NUC_100.L_CORE X_NUC_206.L_CORE 0.001311
K_17135 X_NUC_100.L_CORE X_NUC_207.L_CORE 0.002363
K_17136 X_NUC_100.L_CORE X_NUC_208.L_CORE 0.002150
K_17137 X_NUC_100.L_CORE X_NUC_209.L_CORE 0.001356
K_17138 X_NUC_100.L_CORE X_NUC_210.L_CORE 0.005776
K_17139 X_NUC_100.L_CORE X_NUC_211.L_CORE 0.001490
K_17140 X_NUC_100.L_CORE X_NUC_212.L_CORE 0.001747
K_17141 X_NUC_100.L_CORE X_NUC_213.L_CORE 0.003118
K_17142 X_NUC_100.L_CORE X_NUC_214.L_CORE 0.001375
K_17143 X_NUC_100.L_CORE X_NUC_215.L_CORE 0.002791
K_17144 X_NUC_100.L_CORE X_NUC_216.L_CORE 0.001833
K_17145 X_NUC_100.L_CORE X_NUC_217.L_CORE 0.001557
K_17146 X_NUC_100.L_CORE X_NUC_218.L_CORE 0.003103
K_17147 X_NUC_100.L_CORE X_NUC_219.L_CORE 0.001552
K_17148 X_NUC_100.L_CORE X_NUC_220.L_CORE 0.002002
K_17149 X_NUC_100.L_CORE X_NUC_221.L_CORE 0.002110
K_17150 X_NUC_100.L_CORE X_NUC_222.L_CORE 0.001724
K_17151 X_NUC_101.L_CORE X_NUC_102.L_CORE 0.207973
K_17152 X_NUC_101.L_CORE X_NUC_103.L_CORE 0.207973
K_17153 X_NUC_101.L_CORE X_NUC_104.L_CORE 0.207973
K_17154 X_NUC_101.L_CORE X_NUC_105.L_CORE 0.001429
K_17155 X_NUC_101.L_CORE X_NUC_106.L_CORE 0.001436
K_17156 X_NUC_101.L_CORE X_NUC_107.L_CORE 0.001435
K_17157 X_NUC_101.L_CORE X_NUC_108.L_CORE 0.001429
K_17158 X_NUC_101.L_CORE X_NUC_109.L_CORE 0.001979
K_17159 X_NUC_101.L_CORE X_NUC_110.L_CORE 0.001973
K_17160 X_NUC_101.L_CORE X_NUC_111.L_CORE 0.001984
K_17161 X_NUC_101.L_CORE X_NUC_112.L_CORE 0.001966
K_17162 X_NUC_101.L_CORE X_NUC_113.L_CORE 0.003010
K_17163 X_NUC_101.L_CORE X_NUC_114.L_CORE 0.003054
K_17164 X_NUC_101.L_CORE X_NUC_115.L_CORE 0.003027
K_17165 X_NUC_101.L_CORE X_NUC_116.L_CORE 0.003026
K_17166 X_NUC_101.L_CORE X_NUC_117.L_CORE 0.001362
K_17167 X_NUC_101.L_CORE X_NUC_118.L_CORE 0.001365
K_17168 X_NUC_101.L_CORE X_NUC_119.L_CORE 0.001367
K_17169 X_NUC_101.L_CORE X_NUC_120.L_CORE 0.001359
K_17170 X_NUC_101.L_CORE X_NUC_121.L_CORE 0.004476
K_17171 X_NUC_101.L_CORE X_NUC_122.L_CORE 0.004421
K_17172 X_NUC_101.L_CORE X_NUC_123.L_CORE 0.004455
K_17173 X_NUC_101.L_CORE X_NUC_124.L_CORE 0.004388
K_17174 X_NUC_101.L_CORE X_NUC_125.L_CORE 0.001725
K_17175 X_NUC_101.L_CORE X_NUC_126.L_CORE 0.001738
K_17176 X_NUC_101.L_CORE X_NUC_127.L_CORE 0.001733
K_17177 X_NUC_101.L_CORE X_NUC_128.L_CORE 0.001726
K_17178 X_NUC_101.L_CORE X_NUC_129.L_CORE 0.001619
K_17179 X_NUC_101.L_CORE X_NUC_130.L_CORE 0.001618
K_17180 X_NUC_101.L_CORE X_NUC_131.L_CORE 0.001623
K_17181 X_NUC_101.L_CORE X_NUC_132.L_CORE 0.001611
K_17182 X_NUC_101.L_CORE X_NUC_133.L_CORE 0.005100
K_17183 X_NUC_101.L_CORE X_NUC_134.L_CORE 0.005185
K_17184 X_NUC_101.L_CORE X_NUC_135.L_CORE 0.005082
K_17185 X_NUC_101.L_CORE X_NUC_136.L_CORE 0.005070
K_17186 X_NUC_101.L_CORE X_NUC_137.L_CORE 0.001451
K_17187 X_NUC_101.L_CORE X_NUC_138.L_CORE 0.001457
K_17188 X_NUC_101.L_CORE X_NUC_139.L_CORE 0.001456
K_17189 X_NUC_101.L_CORE X_NUC_140.L_CORE 0.001448
K_17190 X_NUC_101.L_CORE X_NUC_141.L_CORE 0.002454
K_17191 X_NUC_101.L_CORE X_NUC_142.L_CORE 0.002446
K_17192 X_NUC_101.L_CORE X_NUC_143.L_CORE 0.002453
K_17193 X_NUC_101.L_CORE X_NUC_144.L_CORE 0.002429
K_17194 X_NUC_101.L_CORE X_NUC_145.L_CORE 0.002267
K_17195 X_NUC_101.L_CORE X_NUC_146.L_CORE 0.002288
K_17196 X_NUC_101.L_CORE X_NUC_147.L_CORE 0.002274
K_17197 X_NUC_101.L_CORE X_NUC_148.L_CORE 0.002266
K_17198 X_NUC_101.L_CORE X_NUC_149.L_CORE 0.001540
K_17199 X_NUC_101.L_CORE X_NUC_150.L_CORE 0.001543
K_17200 X_NUC_101.L_CORE X_NUC_151.L_CORE 0.001544
K_17201 X_NUC_101.L_CORE X_NUC_152.L_CORE 0.001534
K_17202 X_NUC_101.L_CORE X_NUC_153.L_CORE 0.003574
K_17203 X_NUC_101.L_CORE X_NUC_154.L_CORE 0.003579
K_17204 X_NUC_101.L_CORE X_NUC_155.L_CORE 0.003557
K_17205 X_NUC_101.L_CORE X_NUC_156.L_CORE 0.003524
K_17206 X_NUC_101.L_CORE X_NUC_157.L_CORE 0.001715
K_17207 X_NUC_101.L_CORE X_NUC_158.L_CORE 0.001724
K_17208 X_NUC_101.L_CORE X_NUC_159.L_CORE 0.001719
K_17209 X_NUC_101.L_CORE X_NUC_160.L_CORE 0.001710
K_17210 X_NUC_101.L_CORE X_NUC_161.L_CORE 0.001947
K_17211 X_NUC_101.L_CORE X_NUC_162.L_CORE 0.001947
K_17212 X_NUC_101.L_CORE X_NUC_163.L_CORE 0.001948
K_17213 X_NUC_101.L_CORE X_NUC_164.L_CORE 0.001933
K_17214 X_NUC_101.L_CORE X_NUC_165.L_CORE 0.002480
K_17215 X_NUC_101.L_CORE X_NUC_166.L_CORE 0.002495
K_17216 X_NUC_101.L_CORE X_NUC_167.L_CORE 0.002480
K_17217 X_NUC_101.L_CORE X_NUC_168.L_CORE 0.002465
K_17218 X_NUC_101.L_CORE X_NUC_169.L_CORE 0.001815
K_17219 X_NUC_101.L_CORE X_NUC_170.L_CORE 0.001821
K_17220 X_NUC_101.L_CORE X_NUC_171.L_CORE 0.001818
K_17221 X_NUC_101.L_CORE X_NUC_172.L_CORE 0.001806
K_17222 X_NUC_101.L_CORE X_NUC_173.L_CORE 0.001518
K_17223 X_NUC_101.L_CORE X_NUC_174.L_CORE 0.001767
K_17224 X_NUC_101.L_CORE X_NUC_175.L_CORE 0.001716
K_17225 X_NUC_101.L_CORE X_NUC_176.L_CORE 0.001415
K_17226 X_NUC_101.L_CORE X_NUC_177.L_CORE 0.002301
K_17227 X_NUC_101.L_CORE X_NUC_178.L_CORE 0.001432
K_17228 X_NUC_101.L_CORE X_NUC_179.L_CORE 0.001640
K_17229 X_NUC_101.L_CORE X_NUC_180.L_CORE 0.002236
K_17230 X_NUC_101.L_CORE X_NUC_181.L_CORE 0.001301
K_17231 X_NUC_101.L_CORE X_NUC_182.L_CORE 0.002440
K_17232 X_NUC_101.L_CORE X_NUC_183.L_CORE 0.001616
K_17233 X_NUC_101.L_CORE X_NUC_184.L_CORE 0.001412
K_17234 X_NUC_101.L_CORE X_NUC_185.L_CORE 0.003470
K_17235 X_NUC_101.L_CORE X_NUC_186.L_CORE 0.001309
K_17236 X_NUC_101.L_CORE X_NUC_187.L_CORE 0.001963
K_17237 X_NUC_101.L_CORE X_NUC_188.L_CORE 0.002149
K_17238 X_NUC_101.L_CORE X_NUC_189.L_CORE 0.001281
K_17239 X_NUC_101.L_CORE X_NUC_190.L_CORE 0.004199
K_17240 X_NUC_101.L_CORE X_NUC_191.L_CORE 0.001458
K_17241 X_NUC_101.L_CORE X_NUC_192.L_CORE 0.001558
K_17242 X_NUC_101.L_CORE X_NUC_193.L_CORE 0.003811
K_17243 X_NUC_101.L_CORE X_NUC_194.L_CORE 0.001260
K_17244 X_NUC_101.L_CORE X_NUC_195.L_CORE 0.002705
K_17245 X_NUC_101.L_CORE X_NUC_196.L_CORE 0.001848
K_17246 X_NUC_101.L_CORE X_NUC_197.L_CORE 0.001348
K_17247 X_NUC_101.L_CORE X_NUC_198.L_CORE 0.013801
K_17248 X_NUC_101.L_CORE X_NUC_199.L_CORE 0.001357
K_17249 X_NUC_101.L_CORE X_NUC_200.L_CORE 0.001866
K_17250 X_NUC_101.L_CORE X_NUC_201.L_CORE 0.002876
K_17251 X_NUC_101.L_CORE X_NUC_202.L_CORE 0.001280
K_17252 X_NUC_101.L_CORE X_NUC_203.L_CORE 0.004484
K_17253 X_NUC_101.L_CORE X_NUC_204.L_CORE 0.001623
K_17254 X_NUC_101.L_CORE X_NUC_205.L_CORE 0.001508
K_17255 X_NUC_101.L_CORE X_NUC_206.L_CORE 0.006667
K_17256 X_NUC_101.L_CORE X_NUC_207.L_CORE 0.001333
K_17257 X_NUC_101.L_CORE X_NUC_208.L_CORE 0.002387
K_17258 X_NUC_101.L_CORE X_NUC_209.L_CORE 0.002196
K_17259 X_NUC_101.L_CORE X_NUC_210.L_CORE 0.001382
K_17260 X_NUC_101.L_CORE X_NUC_211.L_CORE 0.005684
K_17261 X_NUC_101.L_CORE X_NUC_212.L_CORE 0.001525
K_17262 X_NUC_101.L_CORE X_NUC_213.L_CORE 0.001781
K_17263 X_NUC_101.L_CORE X_NUC_214.L_CORE 0.003161
K_17264 X_NUC_101.L_CORE X_NUC_215.L_CORE 0.001414
K_17265 X_NUC_101.L_CORE X_NUC_216.L_CORE 0.002799
K_17266 X_NUC_101.L_CORE X_NUC_217.L_CORE 0.001886
K_17267 X_NUC_101.L_CORE X_NUC_218.L_CORE 0.001609
K_17268 X_NUC_101.L_CORE X_NUC_219.L_CORE 0.003006
K_17269 X_NUC_101.L_CORE X_NUC_220.L_CORE 0.001628
K_17270 X_NUC_101.L_CORE X_NUC_221.L_CORE 0.002036
K_17271 X_NUC_101.L_CORE X_NUC_222.L_CORE 0.002083
K_17272 X_NUC_102.L_CORE X_NUC_103.L_CORE 0.207973
K_17273 X_NUC_102.L_CORE X_NUC_104.L_CORE 0.207973
K_17274 X_NUC_102.L_CORE X_NUC_105.L_CORE 0.001421
K_17275 X_NUC_102.L_CORE X_NUC_106.L_CORE 0.001429
K_17276 X_NUC_102.L_CORE X_NUC_107.L_CORE 0.001428
K_17277 X_NUC_102.L_CORE X_NUC_108.L_CORE 0.001421
K_17278 X_NUC_102.L_CORE X_NUC_109.L_CORE 0.001985
K_17279 X_NUC_102.L_CORE X_NUC_110.L_CORE 0.001979
K_17280 X_NUC_102.L_CORE X_NUC_111.L_CORE 0.001990
K_17281 X_NUC_102.L_CORE X_NUC_112.L_CORE 0.001972
K_17282 X_NUC_102.L_CORE X_NUC_113.L_CORE 0.002968
K_17283 X_NUC_102.L_CORE X_NUC_114.L_CORE 0.003010
K_17284 X_NUC_102.L_CORE X_NUC_115.L_CORE 0.002984
K_17285 X_NUC_102.L_CORE X_NUC_116.L_CORE 0.002983
K_17286 X_NUC_102.L_CORE X_NUC_117.L_CORE 0.001358
K_17287 X_NUC_102.L_CORE X_NUC_118.L_CORE 0.001362
K_17288 X_NUC_102.L_CORE X_NUC_119.L_CORE 0.001363
K_17289 X_NUC_102.L_CORE X_NUC_120.L_CORE 0.001355
K_17290 X_NUC_102.L_CORE X_NUC_121.L_CORE 0.004531
K_17291 X_NUC_102.L_CORE X_NUC_122.L_CORE 0.004476
K_17292 X_NUC_102.L_CORE X_NUC_123.L_CORE 0.004510
K_17293 X_NUC_102.L_CORE X_NUC_124.L_CORE 0.004441
K_17294 X_NUC_102.L_CORE X_NUC_125.L_CORE 0.001713
K_17295 X_NUC_102.L_CORE X_NUC_126.L_CORE 0.001725
K_17296 X_NUC_102.L_CORE X_NUC_127.L_CORE 0.001720
K_17297 X_NUC_102.L_CORE X_NUC_128.L_CORE 0.001714
K_17298 X_NUC_102.L_CORE X_NUC_129.L_CORE 0.001619
K_17299 X_NUC_102.L_CORE X_NUC_130.L_CORE 0.001619
K_17300 X_NUC_102.L_CORE X_NUC_131.L_CORE 0.001623
K_17301 X_NUC_102.L_CORE X_NUC_132.L_CORE 0.001611
K_17302 X_NUC_102.L_CORE X_NUC_133.L_CORE 0.005015
K_17303 X_NUC_102.L_CORE X_NUC_134.L_CORE 0.005100
K_17304 X_NUC_102.L_CORE X_NUC_135.L_CORE 0.005000
K_17305 X_NUC_102.L_CORE X_NUC_136.L_CORE 0.004989
K_17306 X_NUC_102.L_CORE X_NUC_137.L_CORE 0.001445
K_17307 X_NUC_102.L_CORE X_NUC_138.L_CORE 0.001451
K_17308 X_NUC_102.L_CORE X_NUC_139.L_CORE 0.001450
K_17309 X_NUC_102.L_CORE X_NUC_140.L_CORE 0.001442
K_17310 X_NUC_102.L_CORE X_NUC_141.L_CORE 0.002463
K_17311 X_NUC_102.L_CORE X_NUC_142.L_CORE 0.002454
K_17312 X_NUC_102.L_CORE X_NUC_143.L_CORE 0.002462
K_17313 X_NUC_102.L_CORE X_NUC_144.L_CORE 0.002437
K_17314 X_NUC_102.L_CORE X_NUC_145.L_CORE 0.002247
K_17315 X_NUC_102.L_CORE X_NUC_146.L_CORE 0.002267
K_17316 X_NUC_102.L_CORE X_NUC_147.L_CORE 0.002253
K_17317 X_NUC_102.L_CORE X_NUC_148.L_CORE 0.002245
K_17318 X_NUC_102.L_CORE X_NUC_149.L_CORE 0.001537
K_17319 X_NUC_102.L_CORE X_NUC_150.L_CORE 0.001540
K_17320 X_NUC_102.L_CORE X_NUC_151.L_CORE 0.001541
K_17321 X_NUC_102.L_CORE X_NUC_152.L_CORE 0.001531
K_17322 X_NUC_102.L_CORE X_NUC_153.L_CORE 0.003569
K_17323 X_NUC_102.L_CORE X_NUC_154.L_CORE 0.003574
K_17324 X_NUC_102.L_CORE X_NUC_155.L_CORE 0.003552
K_17325 X_NUC_102.L_CORE X_NUC_156.L_CORE 0.003519
K_17326 X_NUC_102.L_CORE X_NUC_157.L_CORE 0.001705
K_17327 X_NUC_102.L_CORE X_NUC_158.L_CORE 0.001715
K_17328 X_NUC_102.L_CORE X_NUC_159.L_CORE 0.001710
K_17329 X_NUC_102.L_CORE X_NUC_160.L_CORE 0.001701
K_17330 X_NUC_102.L_CORE X_NUC_161.L_CORE 0.001946
K_17331 X_NUC_102.L_CORE X_NUC_162.L_CORE 0.001947
K_17332 X_NUC_102.L_CORE X_NUC_163.L_CORE 0.001947
K_17333 X_NUC_102.L_CORE X_NUC_164.L_CORE 0.001932
K_17334 X_NUC_102.L_CORE X_NUC_165.L_CORE 0.002465
K_17335 X_NUC_102.L_CORE X_NUC_166.L_CORE 0.002480
K_17336 X_NUC_102.L_CORE X_NUC_167.L_CORE 0.002465
K_17337 X_NUC_102.L_CORE X_NUC_168.L_CORE 0.002451
K_17338 X_NUC_102.L_CORE X_NUC_169.L_CORE 0.001809
K_17339 X_NUC_102.L_CORE X_NUC_170.L_CORE 0.001815
K_17340 X_NUC_102.L_CORE X_NUC_171.L_CORE 0.001812
K_17341 X_NUC_102.L_CORE X_NUC_172.L_CORE 0.001800
K_17342 X_NUC_102.L_CORE X_NUC_173.L_CORE 0.001514
K_17343 X_NUC_102.L_CORE X_NUC_174.L_CORE 0.001766
K_17344 X_NUC_102.L_CORE X_NUC_175.L_CORE 0.001708
K_17345 X_NUC_102.L_CORE X_NUC_176.L_CORE 0.001413
K_17346 X_NUC_102.L_CORE X_NUC_177.L_CORE 0.002299
K_17347 X_NUC_102.L_CORE X_NUC_178.L_CORE 0.001426
K_17348 X_NUC_102.L_CORE X_NUC_179.L_CORE 0.001641
K_17349 X_NUC_102.L_CORE X_NUC_180.L_CORE 0.002222
K_17350 X_NUC_102.L_CORE X_NUC_181.L_CORE 0.001298
K_17351 X_NUC_102.L_CORE X_NUC_182.L_CORE 0.002449
K_17352 X_NUC_102.L_CORE X_NUC_183.L_CORE 0.001606
K_17353 X_NUC_102.L_CORE X_NUC_184.L_CORE 0.001412
K_17354 X_NUC_102.L_CORE X_NUC_185.L_CORE 0.003454
K_17355 X_NUC_102.L_CORE X_NUC_186.L_CORE 0.001304
K_17356 X_NUC_102.L_CORE X_NUC_187.L_CORE 0.001971
K_17357 X_NUC_102.L_CORE X_NUC_188.L_CORE 0.002130
K_17358 X_NUC_102.L_CORE X_NUC_189.L_CORE 0.001278
K_17359 X_NUC_102.L_CORE X_NUC_190.L_CORE 0.004242
K_17360 X_NUC_102.L_CORE X_NUC_191.L_CORE 0.001449
K_17361 X_NUC_102.L_CORE X_NUC_192.L_CORE 0.001561
K_17362 X_NUC_102.L_CORE X_NUC_193.L_CORE 0.003756
K_17363 X_NUC_102.L_CORE X_NUC_194.L_CORE 0.001256
K_17364 X_NUC_102.L_CORE X_NUC_195.L_CORE 0.002728
K_17365 X_NUC_102.L_CORE X_NUC_196.L_CORE 0.001832
K_17366 X_NUC_102.L_CORE X_NUC_197.L_CORE 0.001347
K_17367 X_NUC_102.L_CORE X_NUC_198.L_CORE 0.014022
K_17368 X_NUC_102.L_CORE X_NUC_199.L_CORE 0.001350
K_17369 X_NUC_102.L_CORE X_NUC_200.L_CORE 0.001873
K_17370 X_NUC_102.L_CORE X_NUC_201.L_CORE 0.002837
K_17371 X_NUC_102.L_CORE X_NUC_202.L_CORE 0.001277
K_17372 X_NUC_102.L_CORE X_NUC_203.L_CORE 0.004562
K_17373 X_NUC_102.L_CORE X_NUC_204.L_CORE 0.001611
K_17374 X_NUC_102.L_CORE X_NUC_205.L_CORE 0.001509
K_17375 X_NUC_102.L_CORE X_NUC_206.L_CORE 0.006497
K_17376 X_NUC_102.L_CORE X_NUC_207.L_CORE 0.001328
K_17377 X_NUC_102.L_CORE X_NUC_208.L_CORE 0.002401
K_17378 X_NUC_102.L_CORE X_NUC_209.L_CORE 0.002174
K_17379 X_NUC_102.L_CORE X_NUC_210.L_CORE 0.001380
K_17380 X_NUC_102.L_CORE X_NUC_211.L_CORE 0.005728
K_17381 X_NUC_102.L_CORE X_NUC_212.L_CORE 0.001517
K_17382 X_NUC_102.L_CORE X_NUC_213.L_CORE 0.001783
K_17383 X_NUC_102.L_CORE X_NUC_214.L_CORE 0.003125
K_17384 X_NUC_102.L_CORE X_NUC_215.L_CORE 0.001409
K_17385 X_NUC_102.L_CORE X_NUC_216.L_CORE 0.002809
K_17386 X_NUC_102.L_CORE X_NUC_217.L_CORE 0.001873
K_17387 X_NUC_102.L_CORE X_NUC_218.L_CORE 0.001608
K_17388 X_NUC_102.L_CORE X_NUC_219.L_CORE 0.002993
K_17389 X_NUC_102.L_CORE X_NUC_220.L_CORE 0.001621
K_17390 X_NUC_102.L_CORE X_NUC_221.L_CORE 0.002035
K_17391 X_NUC_102.L_CORE X_NUC_222.L_CORE 0.002074
K_17392 X_NUC_103.L_CORE X_NUC_104.L_CORE 0.207973
K_17393 X_NUC_103.L_CORE X_NUC_105.L_CORE 0.001422
K_17394 X_NUC_103.L_CORE X_NUC_106.L_CORE 0.001429
K_17395 X_NUC_103.L_CORE X_NUC_107.L_CORE 0.001429
K_17396 X_NUC_103.L_CORE X_NUC_108.L_CORE 0.001422
K_17397 X_NUC_103.L_CORE X_NUC_109.L_CORE 0.001974
K_17398 X_NUC_103.L_CORE X_NUC_110.L_CORE 0.001968
K_17399 X_NUC_103.L_CORE X_NUC_111.L_CORE 0.001979
K_17400 X_NUC_103.L_CORE X_NUC_112.L_CORE 0.001962
K_17401 X_NUC_103.L_CORE X_NUC_113.L_CORE 0.002993
K_17402 X_NUC_103.L_CORE X_NUC_114.L_CORE 0.003036
K_17403 X_NUC_103.L_CORE X_NUC_115.L_CORE 0.003010
K_17404 X_NUC_103.L_CORE X_NUC_116.L_CORE 0.003009
K_17405 X_NUC_103.L_CORE X_NUC_117.L_CORE 0.001356
K_17406 X_NUC_103.L_CORE X_NUC_118.L_CORE 0.001360
K_17407 X_NUC_103.L_CORE X_NUC_119.L_CORE 0.001362
K_17408 X_NUC_103.L_CORE X_NUC_120.L_CORE 0.001353
K_17409 X_NUC_103.L_CORE X_NUC_121.L_CORE 0.004495
K_17410 X_NUC_103.L_CORE X_NUC_122.L_CORE 0.004441
K_17411 X_NUC_103.L_CORE X_NUC_123.L_CORE 0.004476
K_17412 X_NUC_103.L_CORE X_NUC_124.L_CORE 0.004408
K_17413 X_NUC_103.L_CORE X_NUC_125.L_CORE 0.001717
K_17414 X_NUC_103.L_CORE X_NUC_126.L_CORE 0.001730
K_17415 X_NUC_103.L_CORE X_NUC_127.L_CORE 0.001725
K_17416 X_NUC_103.L_CORE X_NUC_128.L_CORE 0.001719
K_17417 X_NUC_103.L_CORE X_NUC_129.L_CORE 0.001614
K_17418 X_NUC_103.L_CORE X_NUC_130.L_CORE 0.001614
K_17419 X_NUC_103.L_CORE X_NUC_131.L_CORE 0.001619
K_17420 X_NUC_103.L_CORE X_NUC_132.L_CORE 0.001606
K_17421 X_NUC_103.L_CORE X_NUC_133.L_CORE 0.005114
K_17422 X_NUC_103.L_CORE X_NUC_134.L_CORE 0.005202
K_17423 X_NUC_103.L_CORE X_NUC_135.L_CORE 0.005100
K_17424 X_NUC_103.L_CORE X_NUC_136.L_CORE 0.005086
K_17425 X_NUC_103.L_CORE X_NUC_137.L_CORE 0.001445
K_17426 X_NUC_103.L_CORE X_NUC_138.L_CORE 0.001451
K_17427 X_NUC_103.L_CORE X_NUC_139.L_CORE 0.001451
K_17428 X_NUC_103.L_CORE X_NUC_140.L_CORE 0.001443
K_17429 X_NUC_103.L_CORE X_NUC_141.L_CORE 0.002455
K_17430 X_NUC_103.L_CORE X_NUC_142.L_CORE 0.002447
K_17431 X_NUC_103.L_CORE X_NUC_143.L_CORE 0.002454
K_17432 X_NUC_103.L_CORE X_NUC_144.L_CORE 0.002430
K_17433 X_NUC_103.L_CORE X_NUC_145.L_CORE 0.002261
K_17434 X_NUC_103.L_CORE X_NUC_146.L_CORE 0.002281
K_17435 X_NUC_103.L_CORE X_NUC_147.L_CORE 0.002267
K_17436 X_NUC_103.L_CORE X_NUC_148.L_CORE 0.002259
K_17437 X_NUC_103.L_CORE X_NUC_149.L_CORE 0.001536
K_17438 X_NUC_103.L_CORE X_NUC_150.L_CORE 0.001539
K_17439 X_NUC_103.L_CORE X_NUC_151.L_CORE 0.001540
K_17440 X_NUC_103.L_CORE X_NUC_152.L_CORE 0.001530
K_17441 X_NUC_103.L_CORE X_NUC_153.L_CORE 0.003590
K_17442 X_NUC_103.L_CORE X_NUC_154.L_CORE 0.003595
K_17443 X_NUC_103.L_CORE X_NUC_155.L_CORE 0.003574
K_17444 X_NUC_103.L_CORE X_NUC_156.L_CORE 0.003540
K_17445 X_NUC_103.L_CORE X_NUC_157.L_CORE 0.001710
K_17446 X_NUC_103.L_CORE X_NUC_158.L_CORE 0.001719
K_17447 X_NUC_103.L_CORE X_NUC_159.L_CORE 0.001715
K_17448 X_NUC_103.L_CORE X_NUC_160.L_CORE 0.001706
K_17449 X_NUC_103.L_CORE X_NUC_161.L_CORE 0.001945
K_17450 X_NUC_103.L_CORE X_NUC_162.L_CORE 0.001946
K_17451 X_NUC_103.L_CORE X_NUC_163.L_CORE 0.001947
K_17452 X_NUC_103.L_CORE X_NUC_164.L_CORE 0.001931
K_17453 X_NUC_103.L_CORE X_NUC_165.L_CORE 0.002480
K_17454 X_NUC_103.L_CORE X_NUC_166.L_CORE 0.002495
K_17455 X_NUC_103.L_CORE X_NUC_167.L_CORE 0.002480
K_17456 X_NUC_103.L_CORE X_NUC_168.L_CORE 0.002465
K_17457 X_NUC_103.L_CORE X_NUC_169.L_CORE 0.001813
K_17458 X_NUC_103.L_CORE X_NUC_170.L_CORE 0.001819
K_17459 X_NUC_103.L_CORE X_NUC_171.L_CORE 0.001815
K_17460 X_NUC_103.L_CORE X_NUC_172.L_CORE 0.001804
K_17461 X_NUC_103.L_CORE X_NUC_173.L_CORE 0.001507
K_17462 X_NUC_103.L_CORE X_NUC_174.L_CORE 0.001754
K_17463 X_NUC_103.L_CORE X_NUC_175.L_CORE 0.001702
K_17464 X_NUC_103.L_CORE X_NUC_176.L_CORE 0.001406
K_17465 X_NUC_103.L_CORE X_NUC_177.L_CORE 0.002279
K_17466 X_NUC_103.L_CORE X_NUC_178.L_CORE 0.001422
K_17467 X_NUC_103.L_CORE X_NUC_179.L_CORE 0.001630
K_17468 X_NUC_103.L_CORE X_NUC_180.L_CORE 0.002214
K_17469 X_NUC_103.L_CORE X_NUC_181.L_CORE 0.001294
K_17470 X_NUC_103.L_CORE X_NUC_182.L_CORE 0.002421
K_17471 X_NUC_103.L_CORE X_NUC_183.L_CORE 0.001604
K_17472 X_NUC_103.L_CORE X_NUC_184.L_CORE 0.001404
K_17473 X_NUC_103.L_CORE X_NUC_185.L_CORE 0.003425
K_17474 X_NUC_103.L_CORE X_NUC_186.L_CORE 0.001301
K_17475 X_NUC_103.L_CORE X_NUC_187.L_CORE 0.001953
K_17476 X_NUC_103.L_CORE X_NUC_188.L_CORE 0.002131
K_17477 X_NUC_103.L_CORE X_NUC_189.L_CORE 0.001274
K_17478 X_NUC_103.L_CORE X_NUC_190.L_CORE 0.004160
K_17479 X_NUC_103.L_CORE X_NUC_191.L_CORE 0.001449
K_17480 X_NUC_103.L_CORE X_NUC_192.L_CORE 0.001552
K_17481 X_NUC_103.L_CORE X_NUC_193.L_CORE 0.003766
K_17482 X_NUC_103.L_CORE X_NUC_194.L_CORE 0.001254
K_17483 X_NUC_103.L_CORE X_NUC_195.L_CORE 0.002696
K_17484 X_NUC_103.L_CORE X_NUC_196.L_CORE 0.001836
K_17485 X_NUC_103.L_CORE X_NUC_197.L_CORE 0.001342
K_17486 X_NUC_103.L_CORE X_NUC_198.L_CORE 0.013560
K_17487 X_NUC_103.L_CORE X_NUC_199.L_CORE 0.001350
K_17488 X_NUC_103.L_CORE X_NUC_200.L_CORE 0.001861
K_17489 X_NUC_103.L_CORE X_NUC_201.L_CORE 0.002857
K_17490 X_NUC_103.L_CORE X_NUC_202.L_CORE 0.001275
K_17491 X_NUC_103.L_CORE X_NUC_203.L_CORE 0.004500
K_17492 X_NUC_103.L_CORE X_NUC_204.L_CORE 0.001615
K_17493 X_NUC_103.L_CORE X_NUC_205.L_CORE 0.001504
K_17494 X_NUC_103.L_CORE X_NUC_206.L_CORE 0.006686
K_17495 X_NUC_103.L_CORE X_NUC_207.L_CORE 0.001328
K_17496 X_NUC_103.L_CORE X_NUC_208.L_CORE 0.002387
K_17497 X_NUC_103.L_CORE X_NUC_209.L_CORE 0.002188
K_17498 X_NUC_103.L_CORE X_NUC_210.L_CORE 0.001377
K_17499 X_NUC_103.L_CORE X_NUC_211.L_CORE 0.005774
K_17500 X_NUC_103.L_CORE X_NUC_212.L_CORE 0.001520
K_17501 X_NUC_103.L_CORE X_NUC_213.L_CORE 0.001779
K_17502 X_NUC_103.L_CORE X_NUC_214.L_CORE 0.003162
K_17503 X_NUC_103.L_CORE X_NUC_215.L_CORE 0.001410
K_17504 X_NUC_103.L_CORE X_NUC_216.L_CORE 0.002808
K_17505 X_NUC_103.L_CORE X_NUC_217.L_CORE 0.001882
K_17506 X_NUC_103.L_CORE X_NUC_218.L_CORE 0.001607
K_17507 X_NUC_103.L_CORE X_NUC_219.L_CORE 0.003017
K_17508 X_NUC_103.L_CORE X_NUC_220.L_CORE 0.001624
K_17509 X_NUC_103.L_CORE X_NUC_221.L_CORE 0.002037
K_17510 X_NUC_103.L_CORE X_NUC_222.L_CORE 0.002083
K_17511 X_NUC_104.L_CORE X_NUC_105.L_CORE 0.001428
K_17512 X_NUC_104.L_CORE X_NUC_106.L_CORE 0.001436
K_17513 X_NUC_104.L_CORE X_NUC_107.L_CORE 0.001435
K_17514 X_NUC_104.L_CORE X_NUC_108.L_CORE 0.001429
K_17515 X_NUC_104.L_CORE X_NUC_109.L_CORE 0.001992
K_17516 X_NUC_104.L_CORE X_NUC_110.L_CORE 0.001986
K_17517 X_NUC_104.L_CORE X_NUC_111.L_CORE 0.001997
K_17518 X_NUC_104.L_CORE X_NUC_112.L_CORE 0.001979
K_17519 X_NUC_104.L_CORE X_NUC_113.L_CORE 0.002994
K_17520 X_NUC_104.L_CORE X_NUC_114.L_CORE 0.003037
K_17521 X_NUC_104.L_CORE X_NUC_115.L_CORE 0.003011
K_17522 X_NUC_104.L_CORE X_NUC_116.L_CORE 0.003010
K_17523 X_NUC_104.L_CORE X_NUC_117.L_CORE 0.001365
K_17524 X_NUC_104.L_CORE X_NUC_118.L_CORE 0.001368
K_17525 X_NUC_104.L_CORE X_NUC_119.L_CORE 0.001370
K_17526 X_NUC_104.L_CORE X_NUC_120.L_CORE 0.001362
K_17527 X_NUC_104.L_CORE X_NUC_121.L_CORE 0.004567
K_17528 X_NUC_104.L_CORE X_NUC_122.L_CORE 0.004509
K_17529 X_NUC_104.L_CORE X_NUC_123.L_CORE 0.004545
K_17530 X_NUC_104.L_CORE X_NUC_124.L_CORE 0.004476
K_17531 X_NUC_104.L_CORE X_NUC_125.L_CORE 0.001724
K_17532 X_NUC_104.L_CORE X_NUC_126.L_CORE 0.001736
K_17533 X_NUC_104.L_CORE X_NUC_127.L_CORE 0.001732
K_17534 X_NUC_104.L_CORE X_NUC_128.L_CORE 0.001725
K_17535 X_NUC_104.L_CORE X_NUC_129.L_CORE 0.001627
K_17536 X_NUC_104.L_CORE X_NUC_130.L_CORE 0.001627
K_17537 X_NUC_104.L_CORE X_NUC_131.L_CORE 0.001631
K_17538 X_NUC_104.L_CORE X_NUC_132.L_CORE 0.001619
K_17539 X_NUC_104.L_CORE X_NUC_133.L_CORE 0.005126
K_17540 X_NUC_104.L_CORE X_NUC_134.L_CORE 0.005215
K_17541 X_NUC_104.L_CORE X_NUC_135.L_CORE 0.005110
K_17542 X_NUC_104.L_CORE X_NUC_136.L_CORE 0.005100
K_17543 X_NUC_104.L_CORE X_NUC_137.L_CORE 0.001453
K_17544 X_NUC_104.L_CORE X_NUC_138.L_CORE 0.001459
K_17545 X_NUC_104.L_CORE X_NUC_139.L_CORE 0.001459
K_17546 X_NUC_104.L_CORE X_NUC_140.L_CORE 0.001451
K_17547 X_NUC_104.L_CORE X_NUC_141.L_CORE 0.002480
K_17548 X_NUC_104.L_CORE X_NUC_142.L_CORE 0.002471
K_17549 X_NUC_104.L_CORE X_NUC_143.L_CORE 0.002479
K_17550 X_NUC_104.L_CORE X_NUC_144.L_CORE 0.002454
K_17551 X_NUC_104.L_CORE X_NUC_145.L_CORE 0.002269
K_17552 X_NUC_104.L_CORE X_NUC_146.L_CORE 0.002290
K_17553 X_NUC_104.L_CORE X_NUC_147.L_CORE 0.002275
K_17554 X_NUC_104.L_CORE X_NUC_148.L_CORE 0.002267
K_17555 X_NUC_104.L_CORE X_NUC_149.L_CORE 0.001547
K_17556 X_NUC_104.L_CORE X_NUC_150.L_CORE 0.001549
K_17557 X_NUC_104.L_CORE X_NUC_151.L_CORE 0.001551
K_17558 X_NUC_104.L_CORE X_NUC_152.L_CORE 0.001540
K_17559 X_NUC_104.L_CORE X_NUC_153.L_CORE 0.003625
K_17560 X_NUC_104.L_CORE X_NUC_154.L_CORE 0.003630
K_17561 X_NUC_104.L_CORE X_NUC_155.L_CORE 0.003608
K_17562 X_NUC_104.L_CORE X_NUC_156.L_CORE 0.003574
K_17563 X_NUC_104.L_CORE X_NUC_157.L_CORE 0.001719
K_17564 X_NUC_104.L_CORE X_NUC_158.L_CORE 0.001728
K_17565 X_NUC_104.L_CORE X_NUC_159.L_CORE 0.001723
K_17566 X_NUC_104.L_CORE X_NUC_160.L_CORE 0.001715
K_17567 X_NUC_104.L_CORE X_NUC_161.L_CORE 0.001961
K_17568 X_NUC_104.L_CORE X_NUC_162.L_CORE 0.001962
K_17569 X_NUC_104.L_CORE X_NUC_163.L_CORE 0.001962
K_17570 X_NUC_104.L_CORE X_NUC_164.L_CORE 0.001947
K_17571 X_NUC_104.L_CORE X_NUC_165.L_CORE 0.002495
K_17572 X_NUC_104.L_CORE X_NUC_166.L_CORE 0.002510
K_17573 X_NUC_104.L_CORE X_NUC_167.L_CORE 0.002494
K_17574 X_NUC_104.L_CORE X_NUC_168.L_CORE 0.002480
K_17575 X_NUC_104.L_CORE X_NUC_169.L_CORE 0.001824
K_17576 X_NUC_104.L_CORE X_NUC_170.L_CORE 0.001831
K_17577 X_NUC_104.L_CORE X_NUC_171.L_CORE 0.001827
K_17578 X_NUC_104.L_CORE X_NUC_172.L_CORE 0.001815
K_17579 X_NUC_104.L_CORE X_NUC_173.L_CORE 0.001514
K_17580 X_NUC_104.L_CORE X_NUC_174.L_CORE 0.001762
K_17581 X_NUC_104.L_CORE X_NUC_175.L_CORE 0.001707
K_17582 X_NUC_104.L_CORE X_NUC_176.L_CORE 0.001414
K_17583 X_NUC_104.L_CORE X_NUC_177.L_CORE 0.002287
K_17584 X_NUC_104.L_CORE X_NUC_178.L_CORE 0.001428
K_17585 X_NUC_104.L_CORE X_NUC_179.L_CORE 0.001640
K_17586 X_NUC_104.L_CORE X_NUC_180.L_CORE 0.002217
K_17587 X_NUC_104.L_CORE X_NUC_181.L_CORE 0.001300
K_17588 X_NUC_104.L_CORE X_NUC_182.L_CORE 0.002436
K_17589 X_NUC_104.L_CORE X_NUC_183.L_CORE 0.001608
K_17590 X_NUC_104.L_CORE X_NUC_184.L_CORE 0.001413
K_17591 X_NUC_104.L_CORE X_NUC_185.L_CORE 0.003422
K_17592 X_NUC_104.L_CORE X_NUC_186.L_CORE 0.001307
K_17593 X_NUC_104.L_CORE X_NUC_187.L_CORE 0.001968
K_17594 X_NUC_104.L_CORE X_NUC_188.L_CORE 0.002133
K_17595 X_NUC_104.L_CORE X_NUC_189.L_CORE 0.001282
K_17596 X_NUC_104.L_CORE X_NUC_190.L_CORE 0.004183
K_17597 X_NUC_104.L_CORE X_NUC_191.L_CORE 0.001454
K_17598 X_NUC_104.L_CORE X_NUC_192.L_CORE 0.001563
K_17599 X_NUC_104.L_CORE X_NUC_193.L_CORE 0.003747
K_17600 X_NUC_104.L_CORE X_NUC_194.L_CORE 0.001260
K_17601 X_NUC_104.L_CORE X_NUC_195.L_CORE 0.002721
K_17602 X_NUC_104.L_CORE X_NUC_196.L_CORE 0.001840
K_17603 X_NUC_104.L_CORE X_NUC_197.L_CORE 0.001351
K_17604 X_NUC_104.L_CORE X_NUC_198.L_CORE 0.013180
K_17605 X_NUC_104.L_CORE X_NUC_199.L_CORE 0.001356
K_17606 X_NUC_104.L_CORE X_NUC_200.L_CORE 0.001876
K_17607 X_NUC_104.L_CORE X_NUC_201.L_CORE 0.002853
K_17608 X_NUC_104.L_CORE X_NUC_202.L_CORE 0.001282
K_17609 X_NUC_104.L_CORE X_NUC_203.L_CORE 0.004558
K_17610 X_NUC_104.L_CORE X_NUC_204.L_CORE 0.001620
K_17611 X_NUC_104.L_CORE X_NUC_205.L_CORE 0.001515
K_17612 X_NUC_104.L_CORE X_NUC_206.L_CORE 0.006613
K_17613 X_NUC_104.L_CORE X_NUC_207.L_CORE 0.001335
K_17614 X_NUC_104.L_CORE X_NUC_208.L_CORE 0.002410
K_17615 X_NUC_104.L_CORE X_NUC_209.L_CORE 0.002191
K_17616 X_NUC_104.L_CORE X_NUC_210.L_CORE 0.001386
K_17617 X_NUC_104.L_CORE X_NUC_211.L_CORE 0.005836
K_17618 X_NUC_104.L_CORE X_NUC_212.L_CORE 0.001526
K_17619 X_NUC_104.L_CORE X_NUC_213.L_CORE 0.001793
K_17620 X_NUC_104.L_CORE X_NUC_214.L_CORE 0.003167
K_17621 X_NUC_104.L_CORE X_NUC_215.L_CORE 0.001418
K_17622 X_NUC_104.L_CORE X_NUC_216.L_CORE 0.002835
K_17623 X_NUC_104.L_CORE X_NUC_217.L_CORE 0.001889
K_17624 X_NUC_104.L_CORE X_NUC_218.L_CORE 0.001618
K_17625 X_NUC_104.L_CORE X_NUC_219.L_CORE 0.003035
K_17626 X_NUC_104.L_CORE X_NUC_220.L_CORE 0.001633
K_17627 X_NUC_104.L_CORE X_NUC_221.L_CORE 0.002052
K_17628 X_NUC_104.L_CORE X_NUC_222.L_CORE 0.002094
K_17629 X_NUC_105.L_CORE X_NUC_106.L_CORE 0.207973
K_17630 X_NUC_105.L_CORE X_NUC_107.L_CORE 0.207973
K_17631 X_NUC_105.L_CORE X_NUC_108.L_CORE 0.207973
K_17632 X_NUC_105.L_CORE X_NUC_109.L_CORE 0.001445
K_17633 X_NUC_105.L_CORE X_NUC_110.L_CORE 0.001435
K_17634 X_NUC_105.L_CORE X_NUC_111.L_CORE 0.001440
K_17635 X_NUC_105.L_CORE X_NUC_112.L_CORE 0.001440
K_17636 X_NUC_105.L_CORE X_NUC_113.L_CORE 0.002004
K_17637 X_NUC_105.L_CORE X_NUC_114.L_CORE 0.001997
K_17638 X_NUC_105.L_CORE X_NUC_115.L_CORE 0.001991
K_17639 X_NUC_105.L_CORE X_NUC_116.L_CORE 0.002008
K_17640 X_NUC_105.L_CORE X_NUC_117.L_CORE 0.003051
K_17641 X_NUC_105.L_CORE X_NUC_118.L_CORE 0.003018
K_17642 X_NUC_105.L_CORE X_NUC_119.L_CORE 0.003043
K_17643 X_NUC_105.L_CORE X_NUC_120.L_CORE 0.003015
K_17644 X_NUC_105.L_CORE X_NUC_121.L_CORE 0.001383
K_17645 X_NUC_105.L_CORE X_NUC_122.L_CORE 0.001375
K_17646 X_NUC_105.L_CORE X_NUC_123.L_CORE 0.001376
K_17647 X_NUC_105.L_CORE X_NUC_124.L_CORE 0.001380
K_17648 X_NUC_105.L_CORE X_NUC_125.L_CORE 0.004528
K_17649 X_NUC_105.L_CORE X_NUC_126.L_CORE 0.004519
K_17650 X_NUC_105.L_CORE X_NUC_127.L_CORE 0.004451
K_17651 X_NUC_105.L_CORE X_NUC_128.L_CORE 0.004539
K_17652 X_NUC_105.L_CORE X_NUC_129.L_CORE 0.001757
K_17653 X_NUC_105.L_CORE X_NUC_130.L_CORE 0.001743
K_17654 X_NUC_105.L_CORE X_NUC_131.L_CORE 0.001750
K_17655 X_NUC_105.L_CORE X_NUC_132.L_CORE 0.001746
K_17656 X_NUC_105.L_CORE X_NUC_133.L_CORE 0.001652
K_17657 X_NUC_105.L_CORE X_NUC_134.L_CORE 0.001644
K_17658 X_NUC_105.L_CORE X_NUC_135.L_CORE 0.001641
K_17659 X_NUC_105.L_CORE X_NUC_136.L_CORE 0.001651
K_17660 X_NUC_105.L_CORE X_NUC_137.L_CORE 0.005073
K_17661 X_NUC_105.L_CORE X_NUC_138.L_CORE 0.005000
K_17662 X_NUC_105.L_CORE X_NUC_139.L_CORE 0.004995
K_17663 X_NUC_105.L_CORE X_NUC_140.L_CORE 0.004954
K_17664 X_NUC_105.L_CORE X_NUC_141.L_CORE 0.001488
K_17665 X_NUC_105.L_CORE X_NUC_142.L_CORE 0.001478
K_17666 X_NUC_105.L_CORE X_NUC_143.L_CORE 0.001480
K_17667 X_NUC_105.L_CORE X_NUC_144.L_CORE 0.001482
K_17668 X_NUC_105.L_CORE X_NUC_145.L_CORE 0.002500
K_17669 X_NUC_105.L_CORE X_NUC_146.L_CORE 0.002488
K_17670 X_NUC_105.L_CORE X_NUC_147.L_CORE 0.002473
K_17671 X_NUC_105.L_CORE X_NUC_148.L_CORE 0.002497
K_17672 X_NUC_105.L_CORE X_NUC_149.L_CORE 0.002315
K_17673 X_NUC_105.L_CORE X_NUC_150.L_CORE 0.002294
K_17674 X_NUC_105.L_CORE X_NUC_151.L_CORE 0.002300
K_17675 X_NUC_105.L_CORE X_NUC_152.L_CORE 0.002292
K_17676 X_NUC_105.L_CORE X_NUC_153.L_CORE 0.001596
K_17677 X_NUC_105.L_CORE X_NUC_154.L_CORE 0.001586
K_17678 X_NUC_105.L_CORE X_NUC_155.L_CORE 0.001585
K_17679 X_NUC_105.L_CORE X_NUC_156.L_CORE 0.001591
K_17680 X_NUC_105.L_CORE X_NUC_157.L_CORE 0.003444
K_17681 X_NUC_105.L_CORE X_NUC_158.L_CORE 0.003416
K_17682 X_NUC_105.L_CORE X_NUC_159.L_CORE 0.003389
K_17683 X_NUC_105.L_CORE X_NUC_160.L_CORE 0.003408
K_17684 X_NUC_105.L_CORE X_NUC_161.L_CORE 0.001792
K_17685 X_NUC_105.L_CORE X_NUC_162.L_CORE 0.001778
K_17686 X_NUC_105.L_CORE X_NUC_163.L_CORE 0.001779
K_17687 X_NUC_105.L_CORE X_NUC_164.L_CORE 0.001780
K_17688 X_NUC_105.L_CORE X_NUC_165.L_CORE 0.002022
K_17689 X_NUC_105.L_CORE X_NUC_166.L_CORE 0.002009
K_17690 X_NUC_105.L_CORE X_NUC_167.L_CORE 0.002003
K_17691 X_NUC_105.L_CORE X_NUC_168.L_CORE 0.002013
K_17692 X_NUC_105.L_CORE X_NUC_169.L_CORE 0.002351
K_17693 X_NUC_105.L_CORE X_NUC_170.L_CORE 0.002332
K_17694 X_NUC_105.L_CORE X_NUC_171.L_CORE 0.002327
K_17695 X_NUC_105.L_CORE X_NUC_172.L_CORE 0.002331
K_17696 X_NUC_105.L_CORE X_NUC_173.L_CORE 0.001726
K_17697 X_NUC_105.L_CORE X_NUC_174.L_CORE 0.001428
K_17698 X_NUC_105.L_CORE X_NUC_175.L_CORE 0.001772
K_17699 X_NUC_105.L_CORE X_NUC_176.L_CORE 0.001693
K_17700 X_NUC_105.L_CORE X_NUC_177.L_CORE 0.001378
K_17701 X_NUC_105.L_CORE X_NUC_178.L_CORE 0.002330
K_17702 X_NUC_105.L_CORE X_NUC_179.L_CORE 0.001401
K_17703 X_NUC_105.L_CORE X_NUC_180.L_CORE 0.001619
K_17704 X_NUC_105.L_CORE X_NUC_181.L_CORE 0.002219
K_17705 X_NUC_105.L_CORE X_NUC_182.L_CORE 0.001280
K_17706 X_NUC_105.L_CORE X_NUC_183.L_CORE 0.002436
K_17707 X_NUC_105.L_CORE X_NUC_184.L_CORE 0.001593
K_17708 X_NUC_105.L_CORE X_NUC_185.L_CORE 0.001398
K_17709 X_NUC_105.L_CORE X_NUC_186.L_CORE 0.003448
K_17710 X_NUC_105.L_CORE X_NUC_187.L_CORE 0.001295
K_17711 X_NUC_105.L_CORE X_NUC_188.L_CORE 0.001955
K_17712 X_NUC_105.L_CORE X_NUC_189.L_CORE 0.002123
K_17713 X_NUC_105.L_CORE X_NUC_190.L_CORE 0.001273
K_17714 X_NUC_105.L_CORE X_NUC_191.L_CORE 0.004195
K_17715 X_NUC_105.L_CORE X_NUC_192.L_CORE 0.001447
K_17716 X_NUC_105.L_CORE X_NUC_193.L_CORE 0.001556
K_17717 X_NUC_105.L_CORE X_NUC_194.L_CORE 0.003753
K_17718 X_NUC_105.L_CORE X_NUC_195.L_CORE 0.001256
K_17719 X_NUC_105.L_CORE X_NUC_196.L_CORE 0.002718
K_17720 X_NUC_105.L_CORE X_NUC_197.L_CORE 0.001839
K_17721 X_NUC_105.L_CORE X_NUC_198.L_CORE 0.001350
K_17722 X_NUC_105.L_CORE X_NUC_199.L_CORE 0.013622
K_17723 X_NUC_105.L_CORE X_NUC_200.L_CORE 0.001358
K_17724 X_NUC_105.L_CORE X_NUC_201.L_CORE 0.001880
K_17725 X_NUC_105.L_CORE X_NUC_202.L_CORE 0.002866
K_17726 X_NUC_105.L_CORE X_NUC_203.L_CORE 0.001287
K_17727 X_NUC_105.L_CORE X_NUC_204.L_CORE 0.004580
K_17728 X_NUC_105.L_CORE X_NUC_205.L_CORE 0.001629
K_17729 X_NUC_105.L_CORE X_NUC_206.L_CORE 0.001524
K_17730 X_NUC_105.L_CORE X_NUC_207.L_CORE 0.006643
K_17731 X_NUC_105.L_CORE X_NUC_208.L_CORE 0.001346
K_17732 X_NUC_105.L_CORE X_NUC_209.L_CORE 0.002429
K_17733 X_NUC_105.L_CORE X_NUC_210.L_CORE 0.002213
K_17734 X_NUC_105.L_CORE X_NUC_211.L_CORE 0.001403
K_17735 X_NUC_105.L_CORE X_NUC_212.L_CORE 0.005715
K_17736 X_NUC_105.L_CORE X_NUC_213.L_CORE 0.001549
K_17737 X_NUC_105.L_CORE X_NUC_214.L_CORE 0.001818
K_17738 X_NUC_105.L_CORE X_NUC_215.L_CORE 0.003161
K_17739 X_NUC_105.L_CORE X_NUC_216.L_CORE 0.001449
K_17740 X_NUC_105.L_CORE X_NUC_217.L_CORE 0.002822
K_17741 X_NUC_105.L_CORE X_NUC_218.L_CORE 0.001925
K_17742 X_NUC_105.L_CORE X_NUC_219.L_CORE 0.001667
K_17743 X_NUC_105.L_CORE X_NUC_220.L_CORE 0.002877
K_17744 X_NUC_105.L_CORE X_NUC_221.L_CORE 0.001715
K_17745 X_NUC_105.L_CORE X_NUC_222.L_CORE 0.002059
K_17746 X_NUC_106.L_CORE X_NUC_107.L_CORE 0.207973
K_17747 X_NUC_106.L_CORE X_NUC_108.L_CORE 0.207973
K_17748 X_NUC_106.L_CORE X_NUC_109.L_CORE 0.001455
K_17749 X_NUC_106.L_CORE X_NUC_110.L_CORE 0.001445
K_17750 X_NUC_106.L_CORE X_NUC_111.L_CORE 0.001450
K_17751 X_NUC_106.L_CORE X_NUC_112.L_CORE 0.001450
K_17752 X_NUC_106.L_CORE X_NUC_113.L_CORE 0.002012
K_17753 X_NUC_106.L_CORE X_NUC_114.L_CORE 0.002004
K_17754 X_NUC_106.L_CORE X_NUC_115.L_CORE 0.001998
K_17755 X_NUC_106.L_CORE X_NUC_116.L_CORE 0.002016
K_17756 X_NUC_106.L_CORE X_NUC_117.L_CORE 0.003085
K_17757 X_NUC_106.L_CORE X_NUC_118.L_CORE 0.003051
K_17758 X_NUC_106.L_CORE X_NUC_119.L_CORE 0.003077
K_17759 X_NUC_106.L_CORE X_NUC_120.L_CORE 0.003048
K_17760 X_NUC_106.L_CORE X_NUC_121.L_CORE 0.001391
K_17761 X_NUC_106.L_CORE X_NUC_122.L_CORE 0.001383
K_17762 X_NUC_106.L_CORE X_NUC_123.L_CORE 0.001385
K_17763 X_NUC_106.L_CORE X_NUC_124.L_CORE 0.001388
K_17764 X_NUC_106.L_CORE X_NUC_125.L_CORE 0.004535
K_17765 X_NUC_106.L_CORE X_NUC_126.L_CORE 0.004528
K_17766 X_NUC_106.L_CORE X_NUC_127.L_CORE 0.004459
K_17767 X_NUC_106.L_CORE X_NUC_128.L_CORE 0.004548
K_17768 X_NUC_106.L_CORE X_NUC_129.L_CORE 0.001771
K_17769 X_NUC_106.L_CORE X_NUC_130.L_CORE 0.001757
K_17770 X_NUC_106.L_CORE X_NUC_131.L_CORE 0.001764
K_17771 X_NUC_106.L_CORE X_NUC_132.L_CORE 0.001760
K_17772 X_NUC_106.L_CORE X_NUC_133.L_CORE 0.001661
K_17773 X_NUC_106.L_CORE X_NUC_134.L_CORE 0.001652
K_17774 X_NUC_106.L_CORE X_NUC_135.L_CORE 0.001650
K_17775 X_NUC_106.L_CORE X_NUC_136.L_CORE 0.001659
K_17776 X_NUC_106.L_CORE X_NUC_137.L_CORE 0.005147
K_17777 X_NUC_106.L_CORE X_NUC_138.L_CORE 0.005073
K_17778 X_NUC_106.L_CORE X_NUC_139.L_CORE 0.005066
K_17779 X_NUC_106.L_CORE X_NUC_140.L_CORE 0.005024
K_17780 X_NUC_106.L_CORE X_NUC_141.L_CORE 0.001498
K_17781 X_NUC_106.L_CORE X_NUC_142.L_CORE 0.001488
K_17782 X_NUC_106.L_CORE X_NUC_143.L_CORE 0.001490
K_17783 X_NUC_106.L_CORE X_NUC_144.L_CORE 0.001492
K_17784 X_NUC_106.L_CORE X_NUC_145.L_CORE 0.002512
K_17785 X_NUC_106.L_CORE X_NUC_146.L_CORE 0.002500
K_17786 X_NUC_106.L_CORE X_NUC_147.L_CORE 0.002484
K_17787 X_NUC_106.L_CORE X_NUC_148.L_CORE 0.002508
K_17788 X_NUC_106.L_CORE X_NUC_149.L_CORE 0.002337
K_17789 X_NUC_106.L_CORE X_NUC_150.L_CORE 0.002315
K_17790 X_NUC_106.L_CORE X_NUC_151.L_CORE 0.002321
K_17791 X_NUC_106.L_CORE X_NUC_152.L_CORE 0.002314
K_17792 X_NUC_106.L_CORE X_NUC_153.L_CORE 0.001606
K_17793 X_NUC_106.L_CORE X_NUC_154.L_CORE 0.001596
K_17794 X_NUC_106.L_CORE X_NUC_155.L_CORE 0.001595
K_17795 X_NUC_106.L_CORE X_NUC_156.L_CORE 0.001601
K_17796 X_NUC_106.L_CORE X_NUC_157.L_CORE 0.003472
K_17797 X_NUC_106.L_CORE X_NUC_158.L_CORE 0.003444
K_17798 X_NUC_106.L_CORE X_NUC_159.L_CORE 0.003416
K_17799 X_NUC_106.L_CORE X_NUC_160.L_CORE 0.003435
K_17800 X_NUC_106.L_CORE X_NUC_161.L_CORE 0.001805
K_17801 X_NUC_106.L_CORE X_NUC_162.L_CORE 0.001792
K_17802 X_NUC_106.L_CORE X_NUC_163.L_CORE 0.001793
K_17803 X_NUC_106.L_CORE X_NUC_164.L_CORE 0.001794
K_17804 X_NUC_106.L_CORE X_NUC_165.L_CORE 0.002034
K_17805 X_NUC_106.L_CORE X_NUC_166.L_CORE 0.002022
K_17806 X_NUC_106.L_CORE X_NUC_167.L_CORE 0.002015
K_17807 X_NUC_106.L_CORE X_NUC_168.L_CORE 0.002026
K_17808 X_NUC_106.L_CORE X_NUC_169.L_CORE 0.002370
K_17809 X_NUC_106.L_CORE X_NUC_170.L_CORE 0.002351
K_17810 X_NUC_106.L_CORE X_NUC_171.L_CORE 0.002346
K_17811 X_NUC_106.L_CORE X_NUC_172.L_CORE 0.002350
K_17812 X_NUC_106.L_CORE X_NUC_173.L_CORE 0.001733
K_17813 X_NUC_106.L_CORE X_NUC_174.L_CORE 0.001435
K_17814 X_NUC_106.L_CORE X_NUC_175.L_CORE 0.001778
K_17815 X_NUC_106.L_CORE X_NUC_176.L_CORE 0.001702
K_17816 X_NUC_106.L_CORE X_NUC_177.L_CORE 0.001384
K_17817 X_NUC_106.L_CORE X_NUC_178.L_CORE 0.002336
K_17818 X_NUC_106.L_CORE X_NUC_179.L_CORE 0.001409
K_17819 X_NUC_106.L_CORE X_NUC_180.L_CORE 0.001625
K_17820 X_NUC_106.L_CORE X_NUC_181.L_CORE 0.002230
K_17821 X_NUC_106.L_CORE X_NUC_182.L_CORE 0.001287
K_17822 X_NUC_106.L_CORE X_NUC_183.L_CORE 0.002439
K_17823 X_NUC_106.L_CORE X_NUC_184.L_CORE 0.001603
K_17824 X_NUC_106.L_CORE X_NUC_185.L_CORE 0.001404
K_17825 X_NUC_106.L_CORE X_NUC_186.L_CORE 0.003456
K_17826 X_NUC_106.L_CORE X_NUC_187.L_CORE 0.001303
K_17827 X_NUC_106.L_CORE X_NUC_188.L_CORE 0.001960
K_17828 X_NUC_106.L_CORE X_NUC_189.L_CORE 0.002138
K_17829 X_NUC_106.L_CORE X_NUC_190.L_CORE 0.001279
K_17830 X_NUC_106.L_CORE X_NUC_191.L_CORE 0.004178
K_17831 X_NUC_106.L_CORE X_NUC_192.L_CORE 0.001457
K_17832 X_NUC_106.L_CORE X_NUC_193.L_CORE 0.001562
K_17833 X_NUC_106.L_CORE X_NUC_194.L_CORE 0.003779
K_17834 X_NUC_106.L_CORE X_NUC_195.L_CORE 0.001264
K_17835 X_NUC_106.L_CORE X_NUC_196.L_CORE 0.002718
K_17836 X_NUC_106.L_CORE X_NUC_197.L_CORE 0.001853
K_17837 X_NUC_106.L_CORE X_NUC_198.L_CORE 0.001357
K_17838 X_NUC_106.L_CORE X_NUC_199.L_CORE 0.013183
K_17839 X_NUC_106.L_CORE X_NUC_200.L_CORE 0.001366
K_17840 X_NUC_106.L_CORE X_NUC_201.L_CORE 0.001886
K_17841 X_NUC_106.L_CORE X_NUC_202.L_CORE 0.002892
K_17842 X_NUC_106.L_CORE X_NUC_203.L_CORE 0.001294
K_17843 X_NUC_106.L_CORE X_NUC_204.L_CORE 0.004561
K_17844 X_NUC_106.L_CORE X_NUC_205.L_CORE 0.001641
K_17845 X_NUC_106.L_CORE X_NUC_206.L_CORE 0.001531
K_17846 X_NUC_106.L_CORE X_NUC_207.L_CORE 0.006726
K_17847 X_NUC_106.L_CORE X_NUC_208.L_CORE 0.001355
K_17848 X_NUC_106.L_CORE X_NUC_209.L_CORE 0.002435
K_17849 X_NUC_106.L_CORE X_NUC_210.L_CORE 0.002232
K_17850 X_NUC_106.L_CORE X_NUC_211.L_CORE 0.001410
K_17851 X_NUC_106.L_CORE X_NUC_212.L_CORE 0.005730
K_17852 X_NUC_106.L_CORE X_NUC_213.L_CORE 0.001560
K_17853 X_NUC_106.L_CORE X_NUC_214.L_CORE 0.001827
K_17854 X_NUC_106.L_CORE X_NUC_215.L_CORE 0.003192
K_17855 X_NUC_106.L_CORE X_NUC_216.L_CORE 0.001458
K_17856 X_NUC_106.L_CORE X_NUC_217.L_CORE 0.002834
K_17857 X_NUC_106.L_CORE X_NUC_218.L_CORE 0.001940
K_17858 X_NUC_106.L_CORE X_NUC_219.L_CORE 0.001676
K_17859 X_NUC_106.L_CORE X_NUC_220.L_CORE 0.002899
K_17860 X_NUC_106.L_CORE X_NUC_221.L_CORE 0.001727
K_17861 X_NUC_106.L_CORE X_NUC_222.L_CORE 0.002072
K_17862 X_NUC_107.L_CORE X_NUC_108.L_CORE 0.207973
K_17863 X_NUC_107.L_CORE X_NUC_109.L_CORE 0.001450
K_17864 X_NUC_107.L_CORE X_NUC_110.L_CORE 0.001440
K_17865 X_NUC_107.L_CORE X_NUC_111.L_CORE 0.001445
K_17866 X_NUC_107.L_CORE X_NUC_112.L_CORE 0.001445
K_17867 X_NUC_107.L_CORE X_NUC_113.L_CORE 0.002018
K_17868 X_NUC_107.L_CORE X_NUC_114.L_CORE 0.002010
K_17869 X_NUC_107.L_CORE X_NUC_115.L_CORE 0.002004
K_17870 X_NUC_107.L_CORE X_NUC_116.L_CORE 0.002022
K_17871 X_NUC_107.L_CORE X_NUC_117.L_CORE 0.003058
K_17872 X_NUC_107.L_CORE X_NUC_118.L_CORE 0.003025
K_17873 X_NUC_107.L_CORE X_NUC_119.L_CORE 0.003051
K_17874 X_NUC_107.L_CORE X_NUC_120.L_CORE 0.003022
K_17875 X_NUC_107.L_CORE X_NUC_121.L_CORE 0.001390
K_17876 X_NUC_107.L_CORE X_NUC_122.L_CORE 0.001381
K_17877 X_NUC_107.L_CORE X_NUC_123.L_CORE 0.001383
K_17878 X_NUC_107.L_CORE X_NUC_124.L_CORE 0.001387
K_17879 X_NUC_107.L_CORE X_NUC_125.L_CORE 0.004606
K_17880 X_NUC_107.L_CORE X_NUC_126.L_CORE 0.004597
K_17881 X_NUC_107.L_CORE X_NUC_127.L_CORE 0.004528
K_17882 X_NUC_107.L_CORE X_NUC_128.L_CORE 0.004619
K_17883 X_NUC_107.L_CORE X_NUC_129.L_CORE 0.001764
K_17884 X_NUC_107.L_CORE X_NUC_130.L_CORE 0.001750
K_17885 X_NUC_107.L_CORE X_NUC_131.L_CORE 0.001757
K_17886 X_NUC_107.L_CORE X_NUC_132.L_CORE 0.001754
K_17887 X_NUC_107.L_CORE X_NUC_133.L_CORE 0.001663
K_17888 X_NUC_107.L_CORE X_NUC_134.L_CORE 0.001655
K_17889 X_NUC_107.L_CORE X_NUC_135.L_CORE 0.001652
K_17890 X_NUC_107.L_CORE X_NUC_136.L_CORE 0.001662
K_17891 X_NUC_107.L_CORE X_NUC_137.L_CORE 0.005152
K_17892 X_NUC_107.L_CORE X_NUC_138.L_CORE 0.005077
K_17893 X_NUC_107.L_CORE X_NUC_139.L_CORE 0.005073
K_17894 X_NUC_107.L_CORE X_NUC_140.L_CORE 0.005029
K_17895 X_NUC_107.L_CORE X_NUC_141.L_CORE 0.001496
K_17896 X_NUC_107.L_CORE X_NUC_142.L_CORE 0.001486
K_17897 X_NUC_107.L_CORE X_NUC_143.L_CORE 0.001488
K_17898 X_NUC_107.L_CORE X_NUC_144.L_CORE 0.001490
K_17899 X_NUC_107.L_CORE X_NUC_145.L_CORE 0.002528
K_17900 X_NUC_107.L_CORE X_NUC_146.L_CORE 0.002516
K_17901 X_NUC_107.L_CORE X_NUC_147.L_CORE 0.002500
K_17902 X_NUC_107.L_CORE X_NUC_148.L_CORE 0.002524
K_17903 X_NUC_107.L_CORE X_NUC_149.L_CORE 0.002331
K_17904 X_NUC_107.L_CORE X_NUC_150.L_CORE 0.002309
K_17905 X_NUC_107.L_CORE X_NUC_151.L_CORE 0.002315
K_17906 X_NUC_107.L_CORE X_NUC_152.L_CORE 0.002308
K_17907 X_NUC_107.L_CORE X_NUC_153.L_CORE 0.001607
K_17908 X_NUC_107.L_CORE X_NUC_154.L_CORE 0.001597
K_17909 X_NUC_107.L_CORE X_NUC_155.L_CORE 0.001596
K_17910 X_NUC_107.L_CORE X_NUC_156.L_CORE 0.001602
K_17911 X_NUC_107.L_CORE X_NUC_157.L_CORE 0.003501
K_17912 X_NUC_107.L_CORE X_NUC_158.L_CORE 0.003472
K_17913 X_NUC_107.L_CORE X_NUC_159.L_CORE 0.003444
K_17914 X_NUC_107.L_CORE X_NUC_160.L_CORE 0.003464
K_17915 X_NUC_107.L_CORE X_NUC_161.L_CORE 0.001804
K_17916 X_NUC_107.L_CORE X_NUC_162.L_CORE 0.001790
K_17917 X_NUC_107.L_CORE X_NUC_163.L_CORE 0.001792
K_17918 X_NUC_107.L_CORE X_NUC_164.L_CORE 0.001792
K_17919 X_NUC_107.L_CORE X_NUC_165.L_CORE 0.002041
K_17920 X_NUC_107.L_CORE X_NUC_166.L_CORE 0.002028
K_17921 X_NUC_107.L_CORE X_NUC_167.L_CORE 0.002022
K_17922 X_NUC_107.L_CORE X_NUC_168.L_CORE 0.002032
K_17923 X_NUC_107.L_CORE X_NUC_169.L_CORE 0.002375
K_17924 X_NUC_107.L_CORE X_NUC_170.L_CORE 0.002356
K_17925 X_NUC_107.L_CORE X_NUC_171.L_CORE 0.002351
K_17926 X_NUC_107.L_CORE X_NUC_172.L_CORE 0.002354
K_17927 X_NUC_107.L_CORE X_NUC_173.L_CORE 0.001722
K_17928 X_NUC_107.L_CORE X_NUC_174.L_CORE 0.001428
K_17929 X_NUC_107.L_CORE X_NUC_175.L_CORE 0.001770
K_17930 X_NUC_107.L_CORE X_NUC_176.L_CORE 0.001690
K_17931 X_NUC_107.L_CORE X_NUC_177.L_CORE 0.001379
K_17932 X_NUC_107.L_CORE X_NUC_178.L_CORE 0.002318
K_17933 X_NUC_107.L_CORE X_NUC_179.L_CORE 0.001402
K_17934 X_NUC_107.L_CORE X_NUC_180.L_CORE 0.001621
K_17935 X_NUC_107.L_CORE X_NUC_181.L_CORE 0.002207
K_17936 X_NUC_107.L_CORE X_NUC_182.L_CORE 0.001282
K_17937 X_NUC_107.L_CORE X_NUC_183.L_CORE 0.002430
K_17938 X_NUC_107.L_CORE X_NUC_184.L_CORE 0.001591
K_17939 X_NUC_107.L_CORE X_NUC_185.L_CORE 0.001401
K_17940 X_NUC_107.L_CORE X_NUC_186.L_CORE 0.003407
K_17941 X_NUC_107.L_CORE X_NUC_187.L_CORE 0.001297
K_17942 X_NUC_107.L_CORE X_NUC_188.L_CORE 0.001959
K_17943 X_NUC_107.L_CORE X_NUC_189.L_CORE 0.002117
K_17944 X_NUC_107.L_CORE X_NUC_190.L_CORE 0.001277
K_17945 X_NUC_107.L_CORE X_NUC_191.L_CORE 0.004160
K_17946 X_NUC_107.L_CORE X_NUC_192.L_CORE 0.001449
K_17947 X_NUC_107.L_CORE X_NUC_193.L_CORE 0.001562
K_17948 X_NUC_107.L_CORE X_NUC_194.L_CORE 0.003715
K_17949 X_NUC_107.L_CORE X_NUC_195.L_CORE 0.001260
K_17950 X_NUC_107.L_CORE X_NUC_196.L_CORE 0.002727
K_17951 X_NUC_107.L_CORE X_NUC_197.L_CORE 0.001840
K_17952 X_NUC_107.L_CORE X_NUC_198.L_CORE 0.001356
K_17953 X_NUC_107.L_CORE X_NUC_199.L_CORE 0.012828
K_17954 X_NUC_107.L_CORE X_NUC_200.L_CORE 0.001361
K_17955 X_NUC_107.L_CORE X_NUC_201.L_CORE 0.001890
K_17956 X_NUC_107.L_CORE X_NUC_202.L_CORE 0.002863
K_17957 X_NUC_107.L_CORE X_NUC_203.L_CORE 0.001292
K_17958 X_NUC_107.L_CORE X_NUC_204.L_CORE 0.004627
K_17959 X_NUC_107.L_CORE X_NUC_205.L_CORE 0.001634
K_17960 X_NUC_107.L_CORE X_NUC_206.L_CORE 0.001532
K_17961 X_NUC_107.L_CORE X_NUC_207.L_CORE 0.006668
K_17962 X_NUC_107.L_CORE X_NUC_208.L_CORE 0.001352
K_17963 X_NUC_107.L_CORE X_NUC_209.L_CORE 0.002450
K_17964 X_NUC_107.L_CORE X_NUC_210.L_CORE 0.002221
K_17965 X_NUC_107.L_CORE X_NUC_211.L_CORE 0.001411
K_17966 X_NUC_107.L_CORE X_NUC_212.L_CORE 0.005861
K_17967 X_NUC_107.L_CORE X_NUC_213.L_CORE 0.001556
K_17968 X_NUC_107.L_CORE X_NUC_214.L_CORE 0.001833
K_17969 X_NUC_107.L_CORE X_NUC_215.L_CORE 0.003188
K_17970 X_NUC_107.L_CORE X_NUC_216.L_CORE 0.001457
K_17971 X_NUC_107.L_CORE X_NUC_217.L_CORE 0.002859
K_17972 X_NUC_107.L_CORE X_NUC_218.L_CORE 0.001937
K_17973 X_NUC_107.L_CORE X_NUC_219.L_CORE 0.001680
K_17974 X_NUC_107.L_CORE X_NUC_220.L_CORE 0.002914
K_17975 X_NUC_107.L_CORE X_NUC_221.L_CORE 0.001728
K_17976 X_NUC_107.L_CORE X_NUC_222.L_CORE 0.002079
K_17977 X_NUC_108.L_CORE X_NUC_109.L_CORE 0.001450
K_17978 X_NUC_108.L_CORE X_NUC_110.L_CORE 0.001440
K_17979 X_NUC_108.L_CORE X_NUC_111.L_CORE 0.001445
K_17980 X_NUC_108.L_CORE X_NUC_112.L_CORE 0.001445
K_17981 X_NUC_108.L_CORE X_NUC_113.L_CORE 0.002000
K_17982 X_NUC_108.L_CORE X_NUC_114.L_CORE 0.001993
K_17983 X_NUC_108.L_CORE X_NUC_115.L_CORE 0.001987
K_17984 X_NUC_108.L_CORE X_NUC_116.L_CORE 0.002004
K_17985 X_NUC_108.L_CORE X_NUC_117.L_CORE 0.003088
K_17986 X_NUC_108.L_CORE X_NUC_118.L_CORE 0.003054
K_17987 X_NUC_108.L_CORE X_NUC_119.L_CORE 0.003080
K_17988 X_NUC_108.L_CORE X_NUC_120.L_CORE 0.003051
K_17989 X_NUC_108.L_CORE X_NUC_121.L_CORE 0.001386
K_17990 X_NUC_108.L_CORE X_NUC_122.L_CORE 0.001378
K_17991 X_NUC_108.L_CORE X_NUC_123.L_CORE 0.001379
K_17992 X_NUC_108.L_CORE X_NUC_124.L_CORE 0.001383
K_17993 X_NUC_108.L_CORE X_NUC_125.L_CORE 0.004514
K_17994 X_NUC_108.L_CORE X_NUC_126.L_CORE 0.004506
K_17995 X_NUC_108.L_CORE X_NUC_127.L_CORE 0.004440
K_17996 X_NUC_108.L_CORE X_NUC_128.L_CORE 0.004528
K_17997 X_NUC_108.L_CORE X_NUC_129.L_CORE 0.001768
K_17998 X_NUC_108.L_CORE X_NUC_130.L_CORE 0.001754
K_17999 X_NUC_108.L_CORE X_NUC_131.L_CORE 0.001761
K_18000 X_NUC_108.L_CORE X_NUC_132.L_CORE 0.001757
K_18001 X_NUC_108.L_CORE X_NUC_133.L_CORE 0.001653
K_18002 X_NUC_108.L_CORE X_NUC_134.L_CORE 0.001645
K_18003 X_NUC_108.L_CORE X_NUC_135.L_CORE 0.001642
K_18004 X_NUC_108.L_CORE X_NUC_136.L_CORE 0.001652
K_18005 X_NUC_108.L_CORE X_NUC_137.L_CORE 0.005198
K_18006 X_NUC_108.L_CORE X_NUC_138.L_CORE 0.005120
K_18007 X_NUC_108.L_CORE X_NUC_139.L_CORE 0.005115
K_18008 X_NUC_108.L_CORE X_NUC_140.L_CORE 0.005073
K_18009 X_NUC_108.L_CORE X_NUC_141.L_CORE 0.001494
K_18010 X_NUC_108.L_CORE X_NUC_142.L_CORE 0.001484
K_18011 X_NUC_108.L_CORE X_NUC_143.L_CORE 0.001486
K_18012 X_NUC_108.L_CORE X_NUC_144.L_CORE 0.001488
K_18013 X_NUC_108.L_CORE X_NUC_145.L_CORE 0.002503
K_18014 X_NUC_108.L_CORE X_NUC_146.L_CORE 0.002491
K_18015 X_NUC_108.L_CORE X_NUC_147.L_CORE 0.002476
K_18016 X_NUC_108.L_CORE X_NUC_148.L_CORE 0.002500
K_18017 X_NUC_108.L_CORE X_NUC_149.L_CORE 0.002338
K_18018 X_NUC_108.L_CORE X_NUC_150.L_CORE 0.002316
K_18019 X_NUC_108.L_CORE X_NUC_151.L_CORE 0.002323
K_18020 X_NUC_108.L_CORE X_NUC_152.L_CORE 0.002315
K_18021 X_NUC_108.L_CORE X_NUC_153.L_CORE 0.001601
K_18022 X_NUC_108.L_CORE X_NUC_154.L_CORE 0.001591
K_18023 X_NUC_108.L_CORE X_NUC_155.L_CORE 0.001590
K_18024 X_NUC_108.L_CORE X_NUC_156.L_CORE 0.001596
K_18025 X_NUC_108.L_CORE X_NUC_157.L_CORE 0.003481
K_18026 X_NUC_108.L_CORE X_NUC_158.L_CORE 0.003452
K_18027 X_NUC_108.L_CORE X_NUC_159.L_CORE 0.003424
K_18028 X_NUC_108.L_CORE X_NUC_160.L_CORE 0.003444
K_18029 X_NUC_108.L_CORE X_NUC_161.L_CORE 0.001803
K_18030 X_NUC_108.L_CORE X_NUC_162.L_CORE 0.001789
K_18031 X_NUC_108.L_CORE X_NUC_163.L_CORE 0.001791
K_18032 X_NUC_108.L_CORE X_NUC_164.L_CORE 0.001792
K_18033 X_NUC_108.L_CORE X_NUC_165.L_CORE 0.002030
K_18034 X_NUC_108.L_CORE X_NUC_166.L_CORE 0.002017
K_18035 X_NUC_108.L_CORE X_NUC_167.L_CORE 0.002011
K_18036 X_NUC_108.L_CORE X_NUC_168.L_CORE 0.002022
K_18037 X_NUC_108.L_CORE X_NUC_169.L_CORE 0.002372
K_18038 X_NUC_108.L_CORE X_NUC_170.L_CORE 0.002352
K_18039 X_NUC_108.L_CORE X_NUC_171.L_CORE 0.002347
K_18040 X_NUC_108.L_CORE X_NUC_172.L_CORE 0.002351
K_18041 X_NUC_108.L_CORE X_NUC_173.L_CORE 0.001720
K_18042 X_NUC_108.L_CORE X_NUC_174.L_CORE 0.001426
K_18043 X_NUC_108.L_CORE X_NUC_175.L_CORE 0.001763
K_18044 X_NUC_108.L_CORE X_NUC_176.L_CORE 0.001691
K_18045 X_NUC_108.L_CORE X_NUC_177.L_CORE 0.001375
K_18046 X_NUC_108.L_CORE X_NUC_178.L_CORE 0.002314
K_18047 X_NUC_108.L_CORE X_NUC_179.L_CORE 0.001402
K_18048 X_NUC_108.L_CORE X_NUC_180.L_CORE 0.001612
K_18049 X_NUC_108.L_CORE X_NUC_181.L_CORE 0.002215
K_18050 X_NUC_108.L_CORE X_NUC_182.L_CORE 0.001280
K_18051 X_NUC_108.L_CORE X_NUC_183.L_CORE 0.002413
K_18052 X_NUC_108.L_CORE X_NUC_184.L_CORE 0.001595
K_18053 X_NUC_108.L_CORE X_NUC_185.L_CORE 0.001395
K_18054 X_NUC_108.L_CORE X_NUC_186.L_CORE 0.003420
K_18055 X_NUC_108.L_CORE X_NUC_187.L_CORE 0.001296
K_18056 X_NUC_108.L_CORE X_NUC_188.L_CORE 0.001944
K_18057 X_NUC_108.L_CORE X_NUC_189.L_CORE 0.002129
K_18058 X_NUC_108.L_CORE X_NUC_190.L_CORE 0.001273
K_18059 X_NUC_108.L_CORE X_NUC_191.L_CORE 0.004116
K_18060 X_NUC_108.L_CORE X_NUC_192.L_CORE 0.001451
K_18061 X_NUC_108.L_CORE X_NUC_193.L_CORE 0.001552
K_18062 X_NUC_108.L_CORE X_NUC_194.L_CORE 0.003765
K_18063 X_NUC_108.L_CORE X_NUC_195.L_CORE 0.001258
K_18064 X_NUC_108.L_CORE X_NUC_196.L_CORE 0.002694
K_18065 X_NUC_108.L_CORE X_NUC_197.L_CORE 0.001848
K_18066 X_NUC_108.L_CORE X_NUC_198.L_CORE 0.001350
K_18067 X_NUC_108.L_CORE X_NUC_199.L_CORE 0.012972
K_18068 X_NUC_108.L_CORE X_NUC_200.L_CORE 0.001362
K_18069 X_NUC_108.L_CORE X_NUC_201.L_CORE 0.001874
K_18070 X_NUC_108.L_CORE X_NUC_202.L_CORE 0.002893
K_18071 X_NUC_108.L_CORE X_NUC_203.L_CORE 0.001289
K_18072 X_NUC_108.L_CORE X_NUC_204.L_CORE 0.004528
K_18073 X_NUC_108.L_CORE X_NUC_205.L_CORE 0.001638
K_18074 X_NUC_108.L_CORE X_NUC_206.L_CORE 0.001524
K_18075 X_NUC_108.L_CORE X_NUC_207.L_CORE 0.006844
K_18076 X_NUC_108.L_CORE X_NUC_208.L_CORE 0.001350
K_18077 X_NUC_108.L_CORE X_NUC_209.L_CORE 0.002423
K_18078 X_NUC_108.L_CORE X_NUC_210.L_CORE 0.002233
K_18079 X_NUC_108.L_CORE X_NUC_211.L_CORE 0.001405
K_18080 X_NUC_108.L_CORE X_NUC_212.L_CORE 0.005782
K_18081 X_NUC_108.L_CORE X_NUC_213.L_CORE 0.001557
K_18082 X_NUC_108.L_CORE X_NUC_214.L_CORE 0.001820
K_18083 X_NUC_108.L_CORE X_NUC_215.L_CORE 0.003209
K_18084 X_NUC_108.L_CORE X_NUC_216.L_CORE 0.001454
K_18085 X_NUC_108.L_CORE X_NUC_217.L_CORE 0.002833
K_18086 X_NUC_108.L_CORE X_NUC_218.L_CORE 0.001940
K_18087 X_NUC_108.L_CORE X_NUC_219.L_CORE 0.001672
K_18088 X_NUC_108.L_CORE X_NUC_220.L_CORE 0.002909
K_18089 X_NUC_108.L_CORE X_NUC_221.L_CORE 0.001725
K_18090 X_NUC_108.L_CORE X_NUC_222.L_CORE 0.002071
K_18091 X_NUC_109.L_CORE X_NUC_110.L_CORE 0.207973
K_18092 X_NUC_109.L_CORE X_NUC_111.L_CORE 0.207973
K_18093 X_NUC_109.L_CORE X_NUC_112.L_CORE 0.207973
K_18094 X_NUC_109.L_CORE X_NUC_113.L_CORE 0.001465
K_18095 X_NUC_109.L_CORE X_NUC_114.L_CORE 0.001473
K_18096 X_NUC_109.L_CORE X_NUC_115.L_CORE 0.001465
K_18097 X_NUC_109.L_CORE X_NUC_116.L_CORE 0.001473
K_18098 X_NUC_109.L_CORE X_NUC_117.L_CORE 0.002036
K_18099 X_NUC_109.L_CORE X_NUC_118.L_CORE 0.002054
K_18100 X_NUC_109.L_CORE X_NUC_119.L_CORE 0.002048
K_18101 X_NUC_109.L_CORE X_NUC_120.L_CORE 0.002039
K_18102 X_NUC_109.L_CORE X_NUC_121.L_CORE 0.003101
K_18103 X_NUC_109.L_CORE X_NUC_122.L_CORE 0.003106
K_18104 X_NUC_109.L_CORE X_NUC_123.L_CORE 0.003076
K_18105 X_NUC_109.L_CORE X_NUC_124.L_CORE 0.003121
K_18106 X_NUC_109.L_CORE X_NUC_125.L_CORE 0.001409
K_18107 X_NUC_109.L_CORE X_NUC_126.L_CORE 0.001418
K_18108 X_NUC_109.L_CORE X_NUC_127.L_CORE 0.001412
K_18109 X_NUC_109.L_CORE X_NUC_128.L_CORE 0.001414
K_18110 X_NUC_109.L_CORE X_NUC_129.L_CORE 0.004588
K_18111 X_NUC_109.L_CORE X_NUC_130.L_CORE 0.004659
K_18112 X_NUC_109.L_CORE X_NUC_131.L_CORE 0.004623
K_18113 X_NUC_109.L_CORE X_NUC_132.L_CORE 0.004563
K_18114 X_NUC_109.L_CORE X_NUC_133.L_CORE 0.001796
K_18115 X_NUC_109.L_CORE X_NUC_134.L_CORE 0.001804
K_18116 X_NUC_109.L_CORE X_NUC_135.L_CORE 0.001792
K_18117 X_NUC_109.L_CORE X_NUC_136.L_CORE 0.001804
K_18118 X_NUC_109.L_CORE X_NUC_137.L_CORE 0.001692
K_18119 X_NUC_109.L_CORE X_NUC_138.L_CORE 0.001706
K_18120 X_NUC_109.L_CORE X_NUC_139.L_CORE 0.001698
K_18121 X_NUC_109.L_CORE X_NUC_140.L_CORE 0.001696
K_18122 X_NUC_109.L_CORE X_NUC_141.L_CORE 0.005035
K_18123 X_NUC_109.L_CORE X_NUC_142.L_CORE 0.005065
K_18124 X_NUC_109.L_CORE X_NUC_143.L_CORE 0.004950
K_18125 X_NUC_109.L_CORE X_NUC_144.L_CORE 0.005027
K_18126 X_NUC_109.L_CORE X_NUC_145.L_CORE 0.001534
K_18127 X_NUC_109.L_CORE X_NUC_146.L_CORE 0.001543
K_18128 X_NUC_109.L_CORE X_NUC_147.L_CORE 0.001534
K_18129 X_NUC_109.L_CORE X_NUC_148.L_CORE 0.001539
K_18130 X_NUC_109.L_CORE X_NUC_149.L_CORE 0.002552
K_18131 X_NUC_109.L_CORE X_NUC_150.L_CORE 0.002579
K_18132 X_NUC_109.L_CORE X_NUC_151.L_CORE 0.002560
K_18133 X_NUC_109.L_CORE X_NUC_152.L_CORE 0.002550
K_18134 X_NUC_109.L_CORE X_NUC_153.L_CORE 0.002370
K_18135 X_NUC_109.L_CORE X_NUC_154.L_CORE 0.002383
K_18136 X_NUC_109.L_CORE X_NUC_155.L_CORE 0.002357
K_18137 X_NUC_109.L_CORE X_NUC_156.L_CORE 0.002378
K_18138 X_NUC_109.L_CORE X_NUC_157.L_CORE 0.001667
K_18139 X_NUC_109.L_CORE X_NUC_158.L_CORE 0.001679
K_18140 X_NUC_109.L_CORE X_NUC_159.L_CORE 0.001668
K_18141 X_NUC_109.L_CORE X_NUC_160.L_CORE 0.001670
K_18142 X_NUC_109.L_CORE X_NUC_161.L_CORE 0.003284
K_18143 X_NUC_109.L_CORE X_NUC_162.L_CORE 0.003317
K_18144 X_NUC_109.L_CORE X_NUC_163.L_CORE 0.003269
K_18145 X_NUC_109.L_CORE X_NUC_164.L_CORE 0.003275
K_18146 X_NUC_109.L_CORE X_NUC_165.L_CORE 0.001896
K_18147 X_NUC_109.L_CORE X_NUC_166.L_CORE 0.001908
K_18148 X_NUC_109.L_CORE X_NUC_167.L_CORE 0.001892
K_18149 X_NUC_109.L_CORE X_NUC_168.L_CORE 0.001901
K_18150 X_NUC_109.L_CORE X_NUC_169.L_CORE 0.002121
K_18151 X_NUC_109.L_CORE X_NUC_170.L_CORE 0.002138
K_18152 X_NUC_109.L_CORE X_NUC_171.L_CORE 0.002119
K_18153 X_NUC_109.L_CORE X_NUC_172.L_CORE 0.002122
K_18154 X_NUC_109.L_CORE X_NUC_173.L_CORE 0.001532
K_18155 X_NUC_109.L_CORE X_NUC_174.L_CORE 0.001809
K_18156 X_NUC_109.L_CORE X_NUC_175.L_CORE 0.001384
K_18157 X_NUC_109.L_CORE X_NUC_176.L_CORE 0.001781
K_18158 X_NUC_109.L_CORE X_NUC_177.L_CORE 0.001687
K_18159 X_NUC_109.L_CORE X_NUC_178.L_CORE 0.001359
K_18160 X_NUC_109.L_CORE X_NUC_179.L_CORE 0.002361
K_18161 X_NUC_109.L_CORE X_NUC_180.L_CORE 0.001389
K_18162 X_NUC_109.L_CORE X_NUC_181.L_CORE 0.001611
K_18163 X_NUC_109.L_CORE X_NUC_182.L_CORE 0.002219
K_18164 X_NUC_109.L_CORE X_NUC_183.L_CORE 0.001275
K_18165 X_NUC_109.L_CORE X_NUC_184.L_CORE 0.002435
K_18166 X_NUC_109.L_CORE X_NUC_185.L_CORE 0.001590
K_18167 X_NUC_109.L_CORE X_NUC_186.L_CORE 0.001397
K_18168 X_NUC_109.L_CORE X_NUC_187.L_CORE 0.003433
K_18169 X_NUC_109.L_CORE X_NUC_188.L_CORE 0.001297
K_18170 X_NUC_109.L_CORE X_NUC_189.L_CORE 0.001958
K_18171 X_NUC_109.L_CORE X_NUC_190.L_CORE 0.002125
K_18172 X_NUC_109.L_CORE X_NUC_191.L_CORE 0.001279
K_18173 X_NUC_109.L_CORE X_NUC_192.L_CORE 0.004157
K_18174 X_NUC_109.L_CORE X_NUC_193.L_CORE 0.001456
K_18175 X_NUC_109.L_CORE X_NUC_194.L_CORE 0.001567
K_18176 X_NUC_109.L_CORE X_NUC_195.L_CORE 0.003743
K_18177 X_NUC_109.L_CORE X_NUC_196.L_CORE 0.001268
K_18178 X_NUC_109.L_CORE X_NUC_197.L_CORE 0.002735
K_18179 X_NUC_109.L_CORE X_NUC_198.L_CORE 0.001857
K_18180 X_NUC_109.L_CORE X_NUC_199.L_CORE 0.001367
K_18181 X_NUC_109.L_CORE X_NUC_200.L_CORE 0.012686
K_18182 X_NUC_109.L_CORE X_NUC_201.L_CORE 0.001377
K_18183 X_NUC_109.L_CORE X_NUC_202.L_CORE 0.001908
K_18184 X_NUC_109.L_CORE X_NUC_203.L_CORE 0.002907
K_18185 X_NUC_109.L_CORE X_NUC_204.L_CORE 0.001309
K_18186 X_NUC_109.L_CORE X_NUC_205.L_CORE 0.004657
K_18187 X_NUC_109.L_CORE X_NUC_206.L_CORE 0.001661
K_18188 X_NUC_109.L_CORE X_NUC_207.L_CORE 0.001556
K_18189 X_NUC_109.L_CORE X_NUC_208.L_CORE 0.006775
K_18190 X_NUC_109.L_CORE X_NUC_209.L_CORE 0.001378
K_18191 X_NUC_109.L_CORE X_NUC_210.L_CORE 0.002488
K_18192 X_NUC_109.L_CORE X_NUC_211.L_CORE 0.002269
K_18193 X_NUC_109.L_CORE X_NUC_212.L_CORE 0.001442
K_18194 X_NUC_109.L_CORE X_NUC_213.L_CORE 0.005762
K_18195 X_NUC_109.L_CORE X_NUC_214.L_CORE 0.001598
K_18196 X_NUC_109.L_CORE X_NUC_215.L_CORE 0.001878
K_18197 X_NUC_109.L_CORE X_NUC_216.L_CORE 0.003216
K_18198 X_NUC_109.L_CORE X_NUC_217.L_CORE 0.001509
K_18199 X_NUC_109.L_CORE X_NUC_218.L_CORE 0.002862
K_18200 X_NUC_109.L_CORE X_NUC_219.L_CORE 0.002001
K_18201 X_NUC_109.L_CORE X_NUC_220.L_CORE 0.001759
K_18202 X_NUC_109.L_CORE X_NUC_221.L_CORE 0.002748
K_18203 X_NUC_109.L_CORE X_NUC_222.L_CORE 0.001885
K_18204 X_NUC_110.L_CORE X_NUC_111.L_CORE 0.207973
K_18205 X_NUC_110.L_CORE X_NUC_112.L_CORE 0.207973
K_18206 X_NUC_110.L_CORE X_NUC_113.L_CORE 0.001458
K_18207 X_NUC_110.L_CORE X_NUC_114.L_CORE 0.001465
K_18208 X_NUC_110.L_CORE X_NUC_115.L_CORE 0.001458
K_18209 X_NUC_110.L_CORE X_NUC_116.L_CORE 0.001465
K_18210 X_NUC_110.L_CORE X_NUC_117.L_CORE 0.002018
K_18211 X_NUC_110.L_CORE X_NUC_118.L_CORE 0.002036
K_18212 X_NUC_110.L_CORE X_NUC_119.L_CORE 0.002029
K_18213 X_NUC_110.L_CORE X_NUC_120.L_CORE 0.002021
K_18214 X_NUC_110.L_CORE X_NUC_121.L_CORE 0.003095
K_18215 X_NUC_110.L_CORE X_NUC_122.L_CORE 0.003101
K_18216 X_NUC_110.L_CORE X_NUC_123.L_CORE 0.003070
K_18217 X_NUC_110.L_CORE X_NUC_124.L_CORE 0.003115
K_18218 X_NUC_110.L_CORE X_NUC_125.L_CORE 0.001400
K_18219 X_NUC_110.L_CORE X_NUC_126.L_CORE 0.001409
K_18220 X_NUC_110.L_CORE X_NUC_127.L_CORE 0.001403
K_18221 X_NUC_110.L_CORE X_NUC_128.L_CORE 0.001405
K_18222 X_NUC_110.L_CORE X_NUC_129.L_CORE 0.004518
K_18223 X_NUC_110.L_CORE X_NUC_130.L_CORE 0.004588
K_18224 X_NUC_110.L_CORE X_NUC_131.L_CORE 0.004553
K_18225 X_NUC_110.L_CORE X_NUC_132.L_CORE 0.004495
K_18226 X_NUC_110.L_CORE X_NUC_133.L_CORE 0.001788
K_18227 X_NUC_110.L_CORE X_NUC_134.L_CORE 0.001796
K_18228 X_NUC_110.L_CORE X_NUC_135.L_CORE 0.001783
K_18229 X_NUC_110.L_CORE X_NUC_136.L_CORE 0.001796
K_18230 X_NUC_110.L_CORE X_NUC_137.L_CORE 0.001679
K_18231 X_NUC_110.L_CORE X_NUC_138.L_CORE 0.001692
K_18232 X_NUC_110.L_CORE X_NUC_139.L_CORE 0.001684
K_18233 X_NUC_110.L_CORE X_NUC_140.L_CORE 0.001683
K_18234 X_NUC_110.L_CORE X_NUC_141.L_CORE 0.005003
K_18235 X_NUC_110.L_CORE X_NUC_142.L_CORE 0.005035
K_18236 X_NUC_110.L_CORE X_NUC_143.L_CORE 0.004921
K_18237 X_NUC_110.L_CORE X_NUC_144.L_CORE 0.004996
K_18238 X_NUC_110.L_CORE X_NUC_145.L_CORE 0.001524
K_18239 X_NUC_110.L_CORE X_NUC_146.L_CORE 0.001534
K_18240 X_NUC_110.L_CORE X_NUC_147.L_CORE 0.001524
K_18241 X_NUC_110.L_CORE X_NUC_148.L_CORE 0.001530
K_18242 X_NUC_110.L_CORE X_NUC_149.L_CORE 0.002526
K_18243 X_NUC_110.L_CORE X_NUC_150.L_CORE 0.002552
K_18244 X_NUC_110.L_CORE X_NUC_151.L_CORE 0.002534
K_18245 X_NUC_110.L_CORE X_NUC_152.L_CORE 0.002525
K_18246 X_NUC_110.L_CORE X_NUC_153.L_CORE 0.002358
K_18247 X_NUC_110.L_CORE X_NUC_154.L_CORE 0.002370
K_18248 X_NUC_110.L_CORE X_NUC_155.L_CORE 0.002345
K_18249 X_NUC_110.L_CORE X_NUC_156.L_CORE 0.002366
K_18250 X_NUC_110.L_CORE X_NUC_157.L_CORE 0.001654
K_18251 X_NUC_110.L_CORE X_NUC_158.L_CORE 0.001667
K_18252 X_NUC_110.L_CORE X_NUC_159.L_CORE 0.001656
K_18253 X_NUC_110.L_CORE X_NUC_160.L_CORE 0.001658
K_18254 X_NUC_110.L_CORE X_NUC_161.L_CORE 0.003251
K_18255 X_NUC_110.L_CORE X_NUC_162.L_CORE 0.003284
K_18256 X_NUC_110.L_CORE X_NUC_163.L_CORE 0.003237
K_18257 X_NUC_110.L_CORE X_NUC_164.L_CORE 0.003243
K_18258 X_NUC_110.L_CORE X_NUC_165.L_CORE 0.001884
K_18259 X_NUC_110.L_CORE X_NUC_166.L_CORE 0.001896
K_18260 X_NUC_110.L_CORE X_NUC_167.L_CORE 0.001880
K_18261 X_NUC_110.L_CORE X_NUC_168.L_CORE 0.001889
K_18262 X_NUC_110.L_CORE X_NUC_169.L_CORE 0.002103
K_18263 X_NUC_110.L_CORE X_NUC_170.L_CORE 0.002121
K_18264 X_NUC_110.L_CORE X_NUC_171.L_CORE 0.002102
K_18265 X_NUC_110.L_CORE X_NUC_172.L_CORE 0.002105
K_18266 X_NUC_110.L_CORE X_NUC_173.L_CORE 0.001525
K_18267 X_NUC_110.L_CORE X_NUC_174.L_CORE 0.001803
K_18268 X_NUC_110.L_CORE X_NUC_175.L_CORE 0.001377
K_18269 X_NUC_110.L_CORE X_NUC_176.L_CORE 0.001773
K_18270 X_NUC_110.L_CORE X_NUC_177.L_CORE 0.001682
K_18271 X_NUC_110.L_CORE X_NUC_178.L_CORE 0.001352
K_18272 X_NUC_110.L_CORE X_NUC_179.L_CORE 0.002354
K_18273 X_NUC_110.L_CORE X_NUC_180.L_CORE 0.001384
K_18274 X_NUC_110.L_CORE X_NUC_181.L_CORE 0.001602
K_18275 X_NUC_110.L_CORE X_NUC_182.L_CORE 0.002217
K_18276 X_NUC_110.L_CORE X_NUC_183.L_CORE 0.001268
K_18277 X_NUC_110.L_CORE X_NUC_184.L_CORE 0.002423
K_18278 X_NUC_110.L_CORE X_NUC_185.L_CORE 0.001585
K_18279 X_NUC_110.L_CORE X_NUC_186.L_CORE 0.001389
K_18280 X_NUC_110.L_CORE X_NUC_187.L_CORE 0.003439
K_18281 X_NUC_110.L_CORE X_NUC_188.L_CORE 0.001291
K_18282 X_NUC_110.L_CORE X_NUC_189.L_CORE 0.001944
K_18283 X_NUC_110.L_CORE X_NUC_190.L_CORE 0.002123
K_18284 X_NUC_110.L_CORE X_NUC_191.L_CORE 0.001272
K_18285 X_NUC_110.L_CORE X_NUC_192.L_CORE 0.004143
K_18286 X_NUC_110.L_CORE X_NUC_193.L_CORE 0.001451
K_18287 X_NUC_110.L_CORE X_NUC_194.L_CORE 0.001557
K_18288 X_NUC_110.L_CORE X_NUC_195.L_CORE 0.003760
K_18289 X_NUC_110.L_CORE X_NUC_196.L_CORE 0.001262
K_18290 X_NUC_110.L_CORE X_NUC_197.L_CORE 0.002713
K_18291 X_NUC_110.L_CORE X_NUC_198.L_CORE 0.001853
K_18292 X_NUC_110.L_CORE X_NUC_199.L_CORE 0.001358
K_18293 X_NUC_110.L_CORE X_NUC_200.L_CORE 0.013103
K_18294 X_NUC_110.L_CORE X_NUC_201.L_CORE 0.001370
K_18295 X_NUC_110.L_CORE X_NUC_202.L_CORE 0.001892
K_18296 X_NUC_110.L_CORE X_NUC_203.L_CORE 0.002908
K_18297 X_NUC_110.L_CORE X_NUC_204.L_CORE 0.001301
K_18298 X_NUC_110.L_CORE X_NUC_205.L_CORE 0.004603
K_18299 X_NUC_110.L_CORE X_NUC_206.L_CORE 0.001654
K_18300 X_NUC_110.L_CORE X_NUC_207.L_CORE 0.001544
K_18301 X_NUC_110.L_CORE X_NUC_208.L_CORE 0.006828
K_18302 X_NUC_110.L_CORE X_NUC_209.L_CORE 0.001370
K_18303 X_NUC_110.L_CORE X_NUC_210.L_CORE 0.002465
K_18304 X_NUC_110.L_CORE X_NUC_211.L_CORE 0.002263
K_18305 X_NUC_110.L_CORE X_NUC_212.L_CORE 0.001433
K_18306 X_NUC_110.L_CORE X_NUC_213.L_CORE 0.005696
K_18307 X_NUC_110.L_CORE X_NUC_214.L_CORE 0.001590
K_18308 X_NUC_110.L_CORE X_NUC_215.L_CORE 0.001863
K_18309 X_NUC_110.L_CORE X_NUC_216.L_CORE 0.003204
K_18310 X_NUC_110.L_CORE X_NUC_217.L_CORE 0.001499
K_18311 X_NUC_110.L_CORE X_NUC_218.L_CORE 0.002835
K_18312 X_NUC_110.L_CORE X_NUC_219.L_CORE 0.001991
K_18313 X_NUC_110.L_CORE X_NUC_220.L_CORE 0.001746
K_18314 X_NUC_110.L_CORE X_NUC_221.L_CORE 0.002728
K_18315 X_NUC_110.L_CORE X_NUC_222.L_CORE 0.001873
K_18316 X_NUC_111.L_CORE X_NUC_112.L_CORE 0.207973
K_18317 X_NUC_111.L_CORE X_NUC_113.L_CORE 0.001465
K_18318 X_NUC_111.L_CORE X_NUC_114.L_CORE 0.001473
K_18319 X_NUC_111.L_CORE X_NUC_115.L_CORE 0.001465
K_18320 X_NUC_111.L_CORE X_NUC_116.L_CORE 0.001473
K_18321 X_NUC_111.L_CORE X_NUC_117.L_CORE 0.002023
K_18322 X_NUC_111.L_CORE X_NUC_118.L_CORE 0.002041
K_18323 X_NUC_111.L_CORE X_NUC_119.L_CORE 0.002036
K_18324 X_NUC_111.L_CORE X_NUC_120.L_CORE 0.002027
K_18325 X_NUC_111.L_CORE X_NUC_121.L_CORE 0.003126
K_18326 X_NUC_111.L_CORE X_NUC_122.L_CORE 0.003132
K_18327 X_NUC_111.L_CORE X_NUC_123.L_CORE 0.003101
K_18328 X_NUC_111.L_CORE X_NUC_124.L_CORE 0.003147
K_18329 X_NUC_111.L_CORE X_NUC_125.L_CORE 0.001407
K_18330 X_NUC_111.L_CORE X_NUC_126.L_CORE 0.001416
K_18331 X_NUC_111.L_CORE X_NUC_127.L_CORE 0.001409
K_18332 X_NUC_111.L_CORE X_NUC_128.L_CORE 0.001412
K_18333 X_NUC_111.L_CORE X_NUC_129.L_CORE 0.004552
K_18334 X_NUC_111.L_CORE X_NUC_130.L_CORE 0.004621
K_18335 X_NUC_111.L_CORE X_NUC_131.L_CORE 0.004588
K_18336 X_NUC_111.L_CORE X_NUC_132.L_CORE 0.004528
K_18337 X_NUC_111.L_CORE X_NUC_133.L_CORE 0.001800
K_18338 X_NUC_111.L_CORE X_NUC_134.L_CORE 0.001809
K_18339 X_NUC_111.L_CORE X_NUC_135.L_CORE 0.001796
K_18340 X_NUC_111.L_CORE X_NUC_136.L_CORE 0.001809
K_18341 X_NUC_111.L_CORE X_NUC_137.L_CORE 0.001687
K_18342 X_NUC_111.L_CORE X_NUC_138.L_CORE 0.001700
K_18343 X_NUC_111.L_CORE X_NUC_139.L_CORE 0.001692
K_18344 X_NUC_111.L_CORE X_NUC_140.L_CORE 0.001691
K_18345 X_NUC_111.L_CORE X_NUC_141.L_CORE 0.005122
K_18346 X_NUC_111.L_CORE X_NUC_142.L_CORE 0.005155
K_18347 X_NUC_111.L_CORE X_NUC_143.L_CORE 0.005035
K_18348 X_NUC_111.L_CORE X_NUC_144.L_CORE 0.005115
K_18349 X_NUC_111.L_CORE X_NUC_145.L_CORE 0.001534
K_18350 X_NUC_111.L_CORE X_NUC_146.L_CORE 0.001543
K_18351 X_NUC_111.L_CORE X_NUC_147.L_CORE 0.001534
K_18352 X_NUC_111.L_CORE X_NUC_148.L_CORE 0.001540
K_18353 X_NUC_111.L_CORE X_NUC_149.L_CORE 0.002544
K_18354 X_NUC_111.L_CORE X_NUC_150.L_CORE 0.002571
K_18355 X_NUC_111.L_CORE X_NUC_151.L_CORE 0.002552
K_18356 X_NUC_111.L_CORE X_NUC_152.L_CORE 0.002543
K_18357 X_NUC_111.L_CORE X_NUC_153.L_CORE 0.002383
K_18358 X_NUC_111.L_CORE X_NUC_154.L_CORE 0.002396
K_18359 X_NUC_111.L_CORE X_NUC_155.L_CORE 0.002370
K_18360 X_NUC_111.L_CORE X_NUC_156.L_CORE 0.002391
K_18361 X_NUC_111.L_CORE X_NUC_157.L_CORE 0.001665
K_18362 X_NUC_111.L_CORE X_NUC_158.L_CORE 0.001677
K_18363 X_NUC_111.L_CORE X_NUC_159.L_CORE 0.001667
K_18364 X_NUC_111.L_CORE X_NUC_160.L_CORE 0.001669
K_18365 X_NUC_111.L_CORE X_NUC_161.L_CORE 0.003298
K_18366 X_NUC_111.L_CORE X_NUC_162.L_CORE 0.003332
K_18367 X_NUC_111.L_CORE X_NUC_163.L_CORE 0.003284
K_18368 X_NUC_111.L_CORE X_NUC_164.L_CORE 0.003290
K_18369 X_NUC_111.L_CORE X_NUC_165.L_CORE 0.001900
K_18370 X_NUC_111.L_CORE X_NUC_166.L_CORE 0.001913
K_18371 X_NUC_111.L_CORE X_NUC_167.L_CORE 0.001896
K_18372 X_NUC_111.L_CORE X_NUC_168.L_CORE 0.001905
K_18373 X_NUC_111.L_CORE X_NUC_169.L_CORE 0.002122
K_18374 X_NUC_111.L_CORE X_NUC_170.L_CORE 0.002140
K_18375 X_NUC_111.L_CORE X_NUC_171.L_CORE 0.002121
K_18376 X_NUC_111.L_CORE X_NUC_172.L_CORE 0.002124
K_18377 X_NUC_111.L_CORE X_NUC_173.L_CORE 0.001523
K_18378 X_NUC_111.L_CORE X_NUC_174.L_CORE 0.001798
K_18379 X_NUC_111.L_CORE X_NUC_175.L_CORE 0.001378
K_18380 X_NUC_111.L_CORE X_NUC_176.L_CORE 0.001767
K_18381 X_NUC_111.L_CORE X_NUC_177.L_CORE 0.001681
K_18382 X_NUC_111.L_CORE X_NUC_178.L_CORE 0.001352
K_18383 X_NUC_111.L_CORE X_NUC_179.L_CORE 0.002339
K_18384 X_NUC_111.L_CORE X_NUC_180.L_CORE 0.001386
K_18385 X_NUC_111.L_CORE X_NUC_181.L_CORE 0.001600
K_18386 X_NUC_111.L_CORE X_NUC_182.L_CORE 0.002212
K_18387 X_NUC_111.L_CORE X_NUC_183.L_CORE 0.001270
K_18388 X_NUC_111.L_CORE X_NUC_184.L_CORE 0.002408
K_18389 X_NUC_111.L_CORE X_NUC_185.L_CORE 0.001588
K_18390 X_NUC_111.L_CORE X_NUC_186.L_CORE 0.001390
K_18391 X_NUC_111.L_CORE X_NUC_187.L_CORE 0.003405
K_18392 X_NUC_111.L_CORE X_NUC_188.L_CORE 0.001295
K_18393 X_NUC_111.L_CORE X_NUC_189.L_CORE 0.001940
K_18394 X_NUC_111.L_CORE X_NUC_190.L_CORE 0.002126
K_18395 X_NUC_111.L_CORE X_NUC_191.L_CORE 0.001275
K_18396 X_NUC_111.L_CORE X_NUC_192.L_CORE 0.004081
K_18397 X_NUC_111.L_CORE X_NUC_193.L_CORE 0.001455
K_18398 X_NUC_111.L_CORE X_NUC_194.L_CORE 0.001558
K_18399 X_NUC_111.L_CORE X_NUC_195.L_CORE 0.003752
K_18400 X_NUC_111.L_CORE X_NUC_196.L_CORE 0.001266
K_18401 X_NUC_111.L_CORE X_NUC_197.L_CORE 0.002704
K_18402 X_NUC_111.L_CORE X_NUC_198.L_CORE 0.001861
K_18403 X_NUC_111.L_CORE X_NUC_199.L_CORE 0.001362
K_18404 X_NUC_111.L_CORE X_NUC_200.L_CORE 0.012360
K_18405 X_NUC_111.L_CORE X_NUC_201.L_CORE 0.001376
K_18406 X_NUC_111.L_CORE X_NUC_202.L_CORE 0.001895
K_18407 X_NUC_111.L_CORE X_NUC_203.L_CORE 0.002927
K_18408 X_NUC_111.L_CORE X_NUC_204.L_CORE 0.001306
K_18409 X_NUC_111.L_CORE X_NUC_205.L_CORE 0.004592
K_18410 X_NUC_111.L_CORE X_NUC_206.L_CORE 0.001664
K_18411 X_NUC_111.L_CORE X_NUC_207.L_CORE 0.001550
K_18412 X_NUC_111.L_CORE X_NUC_208.L_CORE 0.006974
K_18413 X_NUC_111.L_CORE X_NUC_209.L_CORE 0.001377
K_18414 X_NUC_111.L_CORE X_NUC_210.L_CORE 0.002474
K_18415 X_NUC_111.L_CORE X_NUC_211.L_CORE 0.002282
K_18416 X_NUC_111.L_CORE X_NUC_212.L_CORE 0.001440
K_18417 X_NUC_111.L_CORE X_NUC_213.L_CORE 0.005805
K_18418 X_NUC_111.L_CORE X_NUC_214.L_CORE 0.001601
K_18419 X_NUC_111.L_CORE X_NUC_215.L_CORE 0.001873
K_18420 X_NUC_111.L_CORE X_NUC_216.L_CORE 0.003251
K_18421 X_NUC_111.L_CORE X_NUC_217.L_CORE 0.001509
K_18422 X_NUC_111.L_CORE X_NUC_218.L_CORE 0.002862
K_18423 X_NUC_111.L_CORE X_NUC_219.L_CORE 0.002009
K_18424 X_NUC_111.L_CORE X_NUC_220.L_CORE 0.001758
K_18425 X_NUC_111.L_CORE X_NUC_221.L_CORE 0.002763
K_18426 X_NUC_111.L_CORE X_NUC_222.L_CORE 0.001889
K_18427 X_NUC_112.L_CORE X_NUC_113.L_CORE 0.001458
K_18428 X_NUC_112.L_CORE X_NUC_114.L_CORE 0.001466
K_18429 X_NUC_112.L_CORE X_NUC_115.L_CORE 0.001458
K_18430 X_NUC_112.L_CORE X_NUC_116.L_CORE 0.001465
K_18431 X_NUC_112.L_CORE X_NUC_117.L_CORE 0.002031
K_18432 X_NUC_112.L_CORE X_NUC_118.L_CORE 0.002050
K_18433 X_NUC_112.L_CORE X_NUC_119.L_CORE 0.002044
K_18434 X_NUC_112.L_CORE X_NUC_120.L_CORE 0.002036
K_18435 X_NUC_112.L_CORE X_NUC_121.L_CORE 0.003081
K_18436 X_NUC_112.L_CORE X_NUC_122.L_CORE 0.003086
K_18437 X_NUC_112.L_CORE X_NUC_123.L_CORE 0.003056
K_18438 X_NUC_112.L_CORE X_NUC_124.L_CORE 0.003101
K_18439 X_NUC_112.L_CORE X_NUC_125.L_CORE 0.001404
K_18440 X_NUC_112.L_CORE X_NUC_126.L_CORE 0.001413
K_18441 X_NUC_112.L_CORE X_NUC_127.L_CORE 0.001406
K_18442 X_NUC_112.L_CORE X_NUC_128.L_CORE 0.001409
K_18443 X_NUC_112.L_CORE X_NUC_129.L_CORE 0.004611
K_18444 X_NUC_112.L_CORE X_NUC_130.L_CORE 0.004684
K_18445 X_NUC_112.L_CORE X_NUC_131.L_CORE 0.004648
K_18446 X_NUC_112.L_CORE X_NUC_132.L_CORE 0.004588
K_18447 X_NUC_112.L_CORE X_NUC_133.L_CORE 0.001788
K_18448 X_NUC_112.L_CORE X_NUC_134.L_CORE 0.001796
K_18449 X_NUC_112.L_CORE X_NUC_135.L_CORE 0.001783
K_18450 X_NUC_112.L_CORE X_NUC_136.L_CORE 0.001796
K_18451 X_NUC_112.L_CORE X_NUC_137.L_CORE 0.001688
K_18452 X_NUC_112.L_CORE X_NUC_138.L_CORE 0.001702
K_18453 X_NUC_112.L_CORE X_NUC_139.L_CORE 0.001694
K_18454 X_NUC_112.L_CORE X_NUC_140.L_CORE 0.001692
K_18455 X_NUC_112.L_CORE X_NUC_141.L_CORE 0.005041
K_18456 X_NUC_112.L_CORE X_NUC_142.L_CORE 0.005072
K_18457 X_NUC_112.L_CORE X_NUC_143.L_CORE 0.004957
K_18458 X_NUC_112.L_CORE X_NUC_144.L_CORE 0.005035
K_18459 X_NUC_112.L_CORE X_NUC_145.L_CORE 0.001528
K_18460 X_NUC_112.L_CORE X_NUC_146.L_CORE 0.001537
K_18461 X_NUC_112.L_CORE X_NUC_147.L_CORE 0.001528
K_18462 X_NUC_112.L_CORE X_NUC_148.L_CORE 0.001534
K_18463 X_NUC_112.L_CORE X_NUC_149.L_CORE 0.002554
K_18464 X_NUC_112.L_CORE X_NUC_150.L_CORE 0.002580
K_18465 X_NUC_112.L_CORE X_NUC_151.L_CORE 0.002561
K_18466 X_NUC_112.L_CORE X_NUC_152.L_CORE 0.002552
K_18467 X_NUC_112.L_CORE X_NUC_153.L_CORE 0.002363
K_18468 X_NUC_112.L_CORE X_NUC_154.L_CORE 0.002375
K_18469 X_NUC_112.L_CORE X_NUC_155.L_CORE 0.002350
K_18470 X_NUC_112.L_CORE X_NUC_156.L_CORE 0.002370
K_18471 X_NUC_112.L_CORE X_NUC_157.L_CORE 0.001663
K_18472 X_NUC_112.L_CORE X_NUC_158.L_CORE 0.001675
K_18473 X_NUC_112.L_CORE X_NUC_159.L_CORE 0.001664
K_18474 X_NUC_112.L_CORE X_NUC_160.L_CORE 0.001667
K_18475 X_NUC_112.L_CORE X_NUC_161.L_CORE 0.003292
K_18476 X_NUC_112.L_CORE X_NUC_162.L_CORE 0.003325
K_18477 X_NUC_112.L_CORE X_NUC_163.L_CORE 0.003277
K_18478 X_NUC_112.L_CORE X_NUC_164.L_CORE 0.003284
K_18479 X_NUC_112.L_CORE X_NUC_165.L_CORE 0.001891
K_18480 X_NUC_112.L_CORE X_NUC_166.L_CORE 0.001903
K_18481 X_NUC_112.L_CORE X_NUC_167.L_CORE 0.001887
K_18482 X_NUC_112.L_CORE X_NUC_168.L_CORE 0.001896
K_18483 X_NUC_112.L_CORE X_NUC_169.L_CORE 0.002119
K_18484 X_NUC_112.L_CORE X_NUC_170.L_CORE 0.002137
K_18485 X_NUC_112.L_CORE X_NUC_171.L_CORE 0.002117
K_18486 X_NUC_112.L_CORE X_NUC_172.L_CORE 0.002121
K_18487 X_NUC_112.L_CORE X_NUC_173.L_CORE 0.001521
K_18488 X_NUC_112.L_CORE X_NUC_174.L_CORE 0.001794
K_18489 X_NUC_112.L_CORE X_NUC_175.L_CORE 0.001375
K_18490 X_NUC_112.L_CORE X_NUC_176.L_CORE 0.001769
K_18491 X_NUC_112.L_CORE X_NUC_177.L_CORE 0.001674
K_18492 X_NUC_112.L_CORE X_NUC_178.L_CORE 0.001351
K_18493 X_NUC_112.L_CORE X_NUC_179.L_CORE 0.002339
K_18494 X_NUC_112.L_CORE X_NUC_180.L_CORE 0.001380
K_18495 X_NUC_112.L_CORE X_NUC_181.L_CORE 0.001603
K_18496 X_NUC_112.L_CORE X_NUC_182.L_CORE 0.002198
K_18497 X_NUC_112.L_CORE X_NUC_183.L_CORE 0.001268
K_18498 X_NUC_112.L_CORE X_NUC_184.L_CORE 0.002419
K_18499 X_NUC_112.L_CORE X_NUC_185.L_CORE 0.001579
K_18500 X_NUC_112.L_CORE X_NUC_186.L_CORE 0.001391
K_18501 X_NUC_112.L_CORE X_NUC_187.L_CORE 0.003390
K_18502 X_NUC_112.L_CORE X_NUC_188.L_CORE 0.001290
K_18503 X_NUC_112.L_CORE X_NUC_189.L_CORE 0.001949
K_18504 X_NUC_112.L_CORE X_NUC_190.L_CORE 0.002107
K_18505 X_NUC_112.L_CORE X_NUC_191.L_CORE 0.001273
K_18506 X_NUC_112.L_CORE X_NUC_192.L_CORE 0.004125
K_18507 X_NUC_112.L_CORE X_NUC_193.L_CORE 0.001447
K_18508 X_NUC_112.L_CORE X_NUC_194.L_CORE 0.001562
K_18509 X_NUC_112.L_CORE X_NUC_195.L_CORE 0.003699
K_18510 X_NUC_112.L_CORE X_NUC_196.L_CORE 0.001262
K_18511 X_NUC_112.L_CORE X_NUC_197.L_CORE 0.002729
K_18512 X_NUC_112.L_CORE X_NUC_198.L_CORE 0.001845
K_18513 X_NUC_112.L_CORE X_NUC_199.L_CORE 0.001362
K_18514 X_NUC_112.L_CORE X_NUC_200.L_CORE 0.012513
K_18515 X_NUC_112.L_CORE X_NUC_201.L_CORE 0.001370
K_18516 X_NUC_112.L_CORE X_NUC_202.L_CORE 0.001903
K_18517 X_NUC_112.L_CORE X_NUC_203.L_CORE 0.002886
K_18518 X_NUC_112.L_CORE X_NUC_204.L_CORE 0.001304
K_18519 X_NUC_112.L_CORE X_NUC_205.L_CORE 0.004680
K_18520 X_NUC_112.L_CORE X_NUC_206.L_CORE 0.001652
K_18521 X_NUC_112.L_CORE X_NUC_207.L_CORE 0.001552
K_18522 X_NUC_112.L_CORE X_NUC_208.L_CORE 0.006778
K_18523 X_NUC_112.L_CORE X_NUC_209.L_CORE 0.001372
K_18524 X_NUC_112.L_CORE X_NUC_210.L_CORE 0.002490
K_18525 X_NUC_112.L_CORE X_NUC_211.L_CORE 0.002259
K_18526 X_NUC_112.L_CORE X_NUC_212.L_CORE 0.001438
K_18527 X_NUC_112.L_CORE X_NUC_213.L_CORE 0.005848
K_18528 X_NUC_112.L_CORE X_NUC_214.L_CORE 0.001592
K_18529 X_NUC_112.L_CORE X_NUC_215.L_CORE 0.001876
K_18530 X_NUC_112.L_CORE X_NUC_216.L_CORE 0.003215
K_18531 X_NUC_112.L_CORE X_NUC_217.L_CORE 0.001505
K_18532 X_NUC_112.L_CORE X_NUC_218.L_CORE 0.002871
K_18533 X_NUC_112.L_CORE X_NUC_219.L_CORE 0.001996
K_18534 X_NUC_112.L_CORE X_NUC_220.L_CORE 0.001756
K_18535 X_NUC_112.L_CORE X_NUC_221.L_CORE 0.002752
K_18536 X_NUC_112.L_CORE X_NUC_222.L_CORE 0.001882
K_18537 X_NUC_113.L_CORE X_NUC_114.L_CORE 0.207973
K_18538 X_NUC_113.L_CORE X_NUC_115.L_CORE 0.207973
K_18539 X_NUC_113.L_CORE X_NUC_116.L_CORE 0.207973
K_18540 X_NUC_113.L_CORE X_NUC_117.L_CORE 0.001491
K_18541 X_NUC_113.L_CORE X_NUC_118.L_CORE 0.001490
K_18542 X_NUC_113.L_CORE X_NUC_119.L_CORE 0.001495
K_18543 X_NUC_113.L_CORE X_NUC_120.L_CORE 0.001485
K_18544 X_NUC_113.L_CORE X_NUC_121.L_CORE 0.002073
K_18545 X_NUC_113.L_CORE X_NUC_122.L_CORE 0.002054
K_18546 X_NUC_113.L_CORE X_NUC_123.L_CORE 0.002066
K_18547 X_NUC_113.L_CORE X_NUC_124.L_CORE 0.002059
K_18548 X_NUC_113.L_CORE X_NUC_125.L_CORE 0.003161
K_18549 X_NUC_113.L_CORE X_NUC_126.L_CORE 0.003188
K_18550 X_NUC_113.L_CORE X_NUC_127.L_CORE 0.003188
K_18551 X_NUC_113.L_CORE X_NUC_128.L_CORE 0.003149
K_18552 X_NUC_113.L_CORE X_NUC_129.L_CORE 0.001441
K_18553 X_NUC_113.L_CORE X_NUC_130.L_CORE 0.001436
K_18554 X_NUC_113.L_CORE X_NUC_131.L_CORE 0.001442
K_18555 X_NUC_113.L_CORE X_NUC_132.L_CORE 0.001433
K_18556 X_NUC_113.L_CORE X_NUC_133.L_CORE 0.004657
K_18557 X_NUC_113.L_CORE X_NUC_134.L_CORE 0.004564
K_18558 X_NUC_113.L_CORE X_NUC_135.L_CORE 0.004583
K_18559 X_NUC_113.L_CORE X_NUC_136.L_CORE 0.004577
K_18560 X_NUC_113.L_CORE X_NUC_137.L_CORE 0.001843
K_18561 X_NUC_113.L_CORE X_NUC_138.L_CORE 0.001845
K_18562 X_NUC_113.L_CORE X_NUC_139.L_CORE 0.001849
K_18563 X_NUC_113.L_CORE X_NUC_140.L_CORE 0.001834
K_18564 X_NUC_113.L_CORE X_NUC_141.L_CORE 0.001741
K_18565 X_NUC_113.L_CORE X_NUC_142.L_CORE 0.001730
K_18566 X_NUC_113.L_CORE X_NUC_143.L_CORE 0.001737
K_18567 X_NUC_113.L_CORE X_NUC_144.L_CORE 0.001729
K_18568 X_NUC_113.L_CORE X_NUC_145.L_CORE 0.004982
K_18569 X_NUC_113.L_CORE X_NUC_146.L_CORE 0.005005
K_18570 X_NUC_113.L_CORE X_NUC_147.L_CORE 0.004973
K_18571 X_NUC_113.L_CORE X_NUC_148.L_CORE 0.004895
K_18572 X_NUC_113.L_CORE X_NUC_149.L_CORE 0.001590
K_18573 X_NUC_113.L_CORE X_NUC_150.L_CORE 0.001586
K_18574 X_NUC_113.L_CORE X_NUC_151.L_CORE 0.001592
K_18575 X_NUC_113.L_CORE X_NUC_152.L_CORE 0.001580
K_18576 X_NUC_113.L_CORE X_NUC_153.L_CORE 0.002611
K_18577 X_NUC_113.L_CORE X_NUC_154.L_CORE 0.002585
K_18578 X_NUC_113.L_CORE X_NUC_155.L_CORE 0.002594
K_18579 X_NUC_113.L_CORE X_NUC_156.L_CORE 0.002581
K_18580 X_NUC_113.L_CORE X_NUC_157.L_CORE 0.002433
K_18581 X_NUC_113.L_CORE X_NUC_158.L_CORE 0.002437
K_18582 X_NUC_113.L_CORE X_NUC_159.L_CORE 0.002438
K_18583 X_NUC_113.L_CORE X_NUC_160.L_CORE 0.002413
K_18584 X_NUC_113.L_CORE X_NUC_161.L_CORE 0.001759
K_18585 X_NUC_113.L_CORE X_NUC_162.L_CORE 0.001752
K_18586 X_NUC_113.L_CORE X_NUC_163.L_CORE 0.001757
K_18587 X_NUC_113.L_CORE X_NUC_164.L_CORE 0.001746
K_18588 X_NUC_113.L_CORE X_NUC_165.L_CORE 0.003076
K_18589 X_NUC_113.L_CORE X_NUC_166.L_CORE 0.003059
K_18590 X_NUC_113.L_CORE X_NUC_167.L_CORE 0.003058
K_18591 X_NUC_113.L_CORE X_NUC_168.L_CORE 0.003032
K_18592 X_NUC_113.L_CORE X_NUC_169.L_CORE 0.002060
K_18593 X_NUC_113.L_CORE X_NUC_170.L_CORE 0.002056
K_18594 X_NUC_113.L_CORE X_NUC_171.L_CORE 0.002059
K_18595 X_NUC_113.L_CORE X_NUC_172.L_CORE 0.002042
K_18596 X_NUC_113.L_CORE X_NUC_173.L_CORE 0.001508
K_18597 X_NUC_113.L_CORE X_NUC_174.L_CORE 0.001481
K_18598 X_NUC_113.L_CORE X_NUC_175.L_CORE 0.001851
K_18599 X_NUC_113.L_CORE X_NUC_176.L_CORE 0.001343
K_18600 X_NUC_113.L_CORE X_NUC_177.L_CORE 0.001772
K_18601 X_NUC_113.L_CORE X_NUC_178.L_CORE 0.001674
K_18602 X_NUC_113.L_CORE X_NUC_179.L_CORE 0.001333
K_18603 X_NUC_113.L_CORE X_NUC_180.L_CORE 0.002372
K_18604 X_NUC_113.L_CORE X_NUC_181.L_CORE 0.001372
K_18605 X_NUC_113.L_CORE X_NUC_182.L_CORE 0.001590
K_18606 X_NUC_113.L_CORE X_NUC_183.L_CORE 0.002216
K_18607 X_NUC_113.L_CORE X_NUC_184.L_CORE 0.001261
K_18608 X_NUC_113.L_CORE X_NUC_185.L_CORE 0.002412
K_18609 X_NUC_113.L_CORE X_NUC_186.L_CORE 0.001582
K_18610 X_NUC_113.L_CORE X_NUC_187.L_CORE 0.001385
K_18611 X_NUC_113.L_CORE X_NUC_188.L_CORE 0.003421
K_18612 X_NUC_113.L_CORE X_NUC_189.L_CORE 0.001292
K_18613 X_NUC_113.L_CORE X_NUC_190.L_CORE 0.001940
K_18614 X_NUC_113.L_CORE X_NUC_191.L_CORE 0.002126
K_18615 X_NUC_113.L_CORE X_NUC_192.L_CORE 0.001275
K_18616 X_NUC_113.L_CORE X_NUC_193.L_CORE 0.004091
K_18617 X_NUC_113.L_CORE X_NUC_194.L_CORE 0.001458
K_18618 X_NUC_113.L_CORE X_NUC_195.L_CORE 0.001562
K_18619 X_NUC_113.L_CORE X_NUC_196.L_CORE 0.003764
K_18620 X_NUC_113.L_CORE X_NUC_197.L_CORE 0.001271
K_18621 X_NUC_113.L_CORE X_NUC_198.L_CORE 0.002717
K_18622 X_NUC_113.L_CORE X_NUC_199.L_CORE 0.001872
K_18623 X_NUC_113.L_CORE X_NUC_200.L_CORE 0.001371
K_18624 X_NUC_113.L_CORE X_NUC_201.L_CORE 0.012479
K_18625 X_NUC_113.L_CORE X_NUC_202.L_CORE 0.001388
K_18626 X_NUC_113.L_CORE X_NUC_203.L_CORE 0.001913
K_18627 X_NUC_113.L_CORE X_NUC_204.L_CORE 0.002957
K_18628 X_NUC_113.L_CORE X_NUC_205.L_CORE 0.001321
K_18629 X_NUC_113.L_CORE X_NUC_206.L_CORE 0.004649
K_18630 X_NUC_113.L_CORE X_NUC_207.L_CORE 0.001686
K_18631 X_NUC_113.L_CORE X_NUC_208.L_CORE 0.001572
K_18632 X_NUC_113.L_CORE X_NUC_209.L_CORE 0.007022
K_18633 X_NUC_113.L_CORE X_NUC_210.L_CORE 0.001401
K_18634 X_NUC_113.L_CORE X_NUC_211.L_CORE 0.002515
K_18635 X_NUC_113.L_CORE X_NUC_212.L_CORE 0.002323
K_18636 X_NUC_113.L_CORE X_NUC_213.L_CORE 0.001471
K_18637 X_NUC_113.L_CORE X_NUC_214.L_CORE 0.005684
K_18638 X_NUC_113.L_CORE X_NUC_215.L_CORE 0.001642
K_18639 X_NUC_113.L_CORE X_NUC_216.L_CORE 0.001920
K_18640 X_NUC_113.L_CORE X_NUC_217.L_CORE 0.003249
K_18641 X_NUC_113.L_CORE X_NUC_218.L_CORE 0.001565
K_18642 X_NUC_113.L_CORE X_NUC_219.L_CORE 0.002849
K_18643 X_NUC_113.L_CORE X_NUC_220.L_CORE 0.002072
K_18644 X_NUC_113.L_CORE X_NUC_221.L_CORE 0.001857
K_18645 X_NUC_113.L_CORE X_NUC_222.L_CORE 0.002501
K_18646 X_NUC_114.L_CORE X_NUC_115.L_CORE 0.207973
K_18647 X_NUC_114.L_CORE X_NUC_116.L_CORE 0.207973
K_18648 X_NUC_114.L_CORE X_NUC_117.L_CORE 0.001491
K_18649 X_NUC_114.L_CORE X_NUC_118.L_CORE 0.001491
K_18650 X_NUC_114.L_CORE X_NUC_119.L_CORE 0.001496
K_18651 X_NUC_114.L_CORE X_NUC_120.L_CORE 0.001485
K_18652 X_NUC_114.L_CORE X_NUC_121.L_CORE 0.002093
K_18653 X_NUC_114.L_CORE X_NUC_122.L_CORE 0.002073
K_18654 X_NUC_114.L_CORE X_NUC_123.L_CORE 0.002085
K_18655 X_NUC_114.L_CORE X_NUC_124.L_CORE 0.002079
K_18656 X_NUC_114.L_CORE X_NUC_125.L_CORE 0.003134
K_18657 X_NUC_114.L_CORE X_NUC_126.L_CORE 0.003161
K_18658 X_NUC_114.L_CORE X_NUC_127.L_CORE 0.003161
K_18659 X_NUC_114.L_CORE X_NUC_128.L_CORE 0.003123
K_18660 X_NUC_114.L_CORE X_NUC_129.L_CORE 0.001446
K_18661 X_NUC_114.L_CORE X_NUC_130.L_CORE 0.001441
K_18662 X_NUC_114.L_CORE X_NUC_131.L_CORE 0.001447
K_18663 X_NUC_114.L_CORE X_NUC_132.L_CORE 0.001438
K_18664 X_NUC_114.L_CORE X_NUC_133.L_CORE 0.004753
K_18665 X_NUC_114.L_CORE X_NUC_134.L_CORE 0.004657
K_18666 X_NUC_114.L_CORE X_NUC_135.L_CORE 0.004676
K_18667 X_NUC_114.L_CORE X_NUC_136.L_CORE 0.004670
K_18668 X_NUC_114.L_CORE X_NUC_137.L_CORE 0.001840
K_18669 X_NUC_114.L_CORE X_NUC_138.L_CORE 0.001843
K_18670 X_NUC_114.L_CORE X_NUC_139.L_CORE 0.001847
K_18671 X_NUC_114.L_CORE X_NUC_140.L_CORE 0.001831
K_18672 X_NUC_114.L_CORE X_NUC_141.L_CORE 0.001752
K_18673 X_NUC_114.L_CORE X_NUC_142.L_CORE 0.001741
K_18674 X_NUC_114.L_CORE X_NUC_143.L_CORE 0.001749
K_18675 X_NUC_114.L_CORE X_NUC_144.L_CORE 0.001740
K_18676 X_NUC_114.L_CORE X_NUC_145.L_CORE 0.004957
K_18677 X_NUC_114.L_CORE X_NUC_146.L_CORE 0.004982
K_18678 X_NUC_114.L_CORE X_NUC_147.L_CORE 0.004949
K_18679 X_NUC_114.L_CORE X_NUC_148.L_CORE 0.004872
K_18680 X_NUC_114.L_CORE X_NUC_149.L_CORE 0.001593
K_18681 X_NUC_114.L_CORE X_NUC_150.L_CORE 0.001590
K_18682 X_NUC_114.L_CORE X_NUC_151.L_CORE 0.001595
K_18683 X_NUC_114.L_CORE X_NUC_152.L_CORE 0.001583
K_18684 X_NUC_114.L_CORE X_NUC_153.L_CORE 0.002638
K_18685 X_NUC_114.L_CORE X_NUC_154.L_CORE 0.002611
K_18686 X_NUC_114.L_CORE X_NUC_155.L_CORE 0.002620
K_18687 X_NUC_114.L_CORE X_NUC_156.L_CORE 0.002607
K_18688 X_NUC_114.L_CORE X_NUC_157.L_CORE 0.002429
K_18689 X_NUC_114.L_CORE X_NUC_158.L_CORE 0.002433
K_18690 X_NUC_114.L_CORE X_NUC_159.L_CORE 0.002434
K_18691 X_NUC_114.L_CORE X_NUC_160.L_CORE 0.002410
K_18692 X_NUC_114.L_CORE X_NUC_161.L_CORE 0.001767
K_18693 X_NUC_114.L_CORE X_NUC_162.L_CORE 0.001759
K_18694 X_NUC_114.L_CORE X_NUC_163.L_CORE 0.001765
K_18695 X_NUC_114.L_CORE X_NUC_164.L_CORE 0.001754
K_18696 X_NUC_114.L_CORE X_NUC_165.L_CORE 0.003093
K_18697 X_NUC_114.L_CORE X_NUC_166.L_CORE 0.003076
K_18698 X_NUC_114.L_CORE X_NUC_167.L_CORE 0.003075
K_18699 X_NUC_114.L_CORE X_NUC_168.L_CORE 0.003049
K_18700 X_NUC_114.L_CORE X_NUC_169.L_CORE 0.002065
K_18701 X_NUC_114.L_CORE X_NUC_170.L_CORE 0.002060
K_18702 X_NUC_114.L_CORE X_NUC_171.L_CORE 0.002064
K_18703 X_NUC_114.L_CORE X_NUC_172.L_CORE 0.002047
K_18704 X_NUC_114.L_CORE X_NUC_173.L_CORE 0.001509
K_18705 X_NUC_114.L_CORE X_NUC_174.L_CORE 0.001485
K_18706 X_NUC_114.L_CORE X_NUC_175.L_CORE 0.001851
K_18707 X_NUC_114.L_CORE X_NUC_176.L_CORE 0.001345
K_18708 X_NUC_114.L_CORE X_NUC_177.L_CORE 0.001780
K_18709 X_NUC_114.L_CORE X_NUC_178.L_CORE 0.001672
K_18710 X_NUC_114.L_CORE X_NUC_179.L_CORE 0.001337
K_18711 X_NUC_114.L_CORE X_NUC_180.L_CORE 0.002376
K_18712 X_NUC_114.L_CORE X_NUC_181.L_CORE 0.001372
K_18713 X_NUC_114.L_CORE X_NUC_182.L_CORE 0.001599
K_18714 X_NUC_114.L_CORE X_NUC_183.L_CORE 0.002207
K_18715 X_NUC_114.L_CORE X_NUC_184.L_CORE 0.001264
K_18716 X_NUC_114.L_CORE X_NUC_185.L_CORE 0.002429
K_18717 X_NUC_114.L_CORE X_NUC_186.L_CORE 0.001579
K_18718 X_NUC_114.L_CORE X_NUC_187.L_CORE 0.001391
K_18719 X_NUC_114.L_CORE X_NUC_188.L_CORE 0.003406
K_18720 X_NUC_114.L_CORE X_NUC_189.L_CORE 0.001293
K_18721 X_NUC_114.L_CORE X_NUC_190.L_CORE 0.001955
K_18722 X_NUC_114.L_CORE X_NUC_191.L_CORE 0.002115
K_18723 X_NUC_114.L_CORE X_NUC_192.L_CORE 0.001280
K_18724 X_NUC_114.L_CORE X_NUC_193.L_CORE 0.004131
K_18725 X_NUC_114.L_CORE X_NUC_194.L_CORE 0.001457
K_18726 X_NUC_114.L_CORE X_NUC_195.L_CORE 0.001573
K_18727 X_NUC_114.L_CORE X_NUC_196.L_CORE 0.003715
K_18728 X_NUC_114.L_CORE X_NUC_197.L_CORE 0.001274
K_18729 X_NUC_114.L_CORE X_NUC_198.L_CORE 0.002751
K_18730 X_NUC_114.L_CORE X_NUC_199.L_CORE 0.001864
K_18731 X_NUC_114.L_CORE X_NUC_200.L_CORE 0.001377
K_18732 X_NUC_114.L_CORE X_NUC_201.L_CORE 0.012295
K_18733 X_NUC_114.L_CORE X_NUC_202.L_CORE 0.001388
K_18734 X_NUC_114.L_CORE X_NUC_203.L_CORE 0.001930
K_18735 X_NUC_114.L_CORE X_NUC_204.L_CORE 0.002928
K_18736 X_NUC_114.L_CORE X_NUC_205.L_CORE 0.001325
K_18737 X_NUC_114.L_CORE X_NUC_206.L_CORE 0.004751
K_18738 X_NUC_114.L_CORE X_NUC_207.L_CORE 0.001683
K_18739 X_NUC_114.L_CORE X_NUC_208.L_CORE 0.001582
K_18740 X_NUC_114.L_CORE X_NUC_209.L_CORE 0.006850
K_18741 X_NUC_114.L_CORE X_NUC_210.L_CORE 0.001403
K_18742 X_NUC_114.L_CORE X_NUC_211.L_CORE 0.002544
K_18743 X_NUC_114.L_CORE X_NUC_212.L_CORE 0.002312
K_18744 X_NUC_114.L_CORE X_NUC_213.L_CORE 0.001478
K_18745 X_NUC_114.L_CORE X_NUC_214.L_CORE 0.005761
K_18746 X_NUC_114.L_CORE X_NUC_215.L_CORE 0.001642
K_18747 X_NUC_114.L_CORE X_NUC_216.L_CORE 0.001934
K_18748 X_NUC_114.L_CORE X_NUC_217.L_CORE 0.003236
K_18749 X_NUC_114.L_CORE X_NUC_218.L_CORE 0.001569
K_18750 X_NUC_114.L_CORE X_NUC_219.L_CORE 0.002875
K_18751 X_NUC_114.L_CORE X_NUC_220.L_CORE 0.002072
K_18752 X_NUC_114.L_CORE X_NUC_221.L_CORE 0.001866
K_18753 X_NUC_114.L_CORE X_NUC_222.L_CORE 0.002509
K_18754 X_NUC_115.L_CORE X_NUC_116.L_CORE 0.207973
K_18755 X_NUC_115.L_CORE X_NUC_117.L_CORE 0.001486
K_18756 X_NUC_115.L_CORE X_NUC_118.L_CORE 0.001485
K_18757 X_NUC_115.L_CORE X_NUC_119.L_CORE 0.001491
K_18758 X_NUC_115.L_CORE X_NUC_120.L_CORE 0.001480
K_18759 X_NUC_115.L_CORE X_NUC_121.L_CORE 0.002081
K_18760 X_NUC_115.L_CORE X_NUC_122.L_CORE 0.002061
K_18761 X_NUC_115.L_CORE X_NUC_123.L_CORE 0.002073
K_18762 X_NUC_115.L_CORE X_NUC_124.L_CORE 0.002067
K_18763 X_NUC_115.L_CORE X_NUC_125.L_CORE 0.003134
K_18764 X_NUC_115.L_CORE X_NUC_126.L_CORE 0.003160
K_18765 X_NUC_115.L_CORE X_NUC_127.L_CORE 0.003161
K_18766 X_NUC_115.L_CORE X_NUC_128.L_CORE 0.003122
K_18767 X_NUC_115.L_CORE X_NUC_129.L_CORE 0.001440
K_18768 X_NUC_115.L_CORE X_NUC_130.L_CORE 0.001435
K_18769 X_NUC_115.L_CORE X_NUC_131.L_CORE 0.001441
K_18770 X_NUC_115.L_CORE X_NUC_132.L_CORE 0.001432
K_18771 X_NUC_115.L_CORE X_NUC_133.L_CORE 0.004733
K_18772 X_NUC_115.L_CORE X_NUC_134.L_CORE 0.004636
K_18773 X_NUC_115.L_CORE X_NUC_135.L_CORE 0.004657
K_18774 X_NUC_115.L_CORE X_NUC_136.L_CORE 0.004650
K_18775 X_NUC_115.L_CORE X_NUC_137.L_CORE 0.001836
K_18776 X_NUC_115.L_CORE X_NUC_138.L_CORE 0.001838
K_18777 X_NUC_115.L_CORE X_NUC_139.L_CORE 0.001843
K_18778 X_NUC_115.L_CORE X_NUC_140.L_CORE 0.001827
K_18779 X_NUC_115.L_CORE X_NUC_141.L_CORE 0.001744
K_18780 X_NUC_115.L_CORE X_NUC_142.L_CORE 0.001733
K_18781 X_NUC_115.L_CORE X_NUC_143.L_CORE 0.001741
K_18782 X_NUC_115.L_CORE X_NUC_144.L_CORE 0.001732
K_18783 X_NUC_115.L_CORE X_NUC_145.L_CORE 0.004989
K_18784 X_NUC_115.L_CORE X_NUC_146.L_CORE 0.005013
K_18785 X_NUC_115.L_CORE X_NUC_147.L_CORE 0.004982
K_18786 X_NUC_115.L_CORE X_NUC_148.L_CORE 0.004903
K_18787 X_NUC_115.L_CORE X_NUC_149.L_CORE 0.001588
K_18788 X_NUC_115.L_CORE X_NUC_150.L_CORE 0.001585
K_18789 X_NUC_115.L_CORE X_NUC_151.L_CORE 0.001590
K_18790 X_NUC_115.L_CORE X_NUC_152.L_CORE 0.001579
K_18791 X_NUC_115.L_CORE X_NUC_153.L_CORE 0.002629
K_18792 X_NUC_115.L_CORE X_NUC_154.L_CORE 0.002603
K_18793 X_NUC_115.L_CORE X_NUC_155.L_CORE 0.002611
K_18794 X_NUC_115.L_CORE X_NUC_156.L_CORE 0.002598
K_18795 X_NUC_115.L_CORE X_NUC_157.L_CORE 0.002428
K_18796 X_NUC_115.L_CORE X_NUC_158.L_CORE 0.002432
K_18797 X_NUC_115.L_CORE X_NUC_159.L_CORE 0.002433
K_18798 X_NUC_115.L_CORE X_NUC_160.L_CORE 0.002409
K_18799 X_NUC_115.L_CORE X_NUC_161.L_CORE 0.001762
K_18800 X_NUC_115.L_CORE X_NUC_162.L_CORE 0.001754
K_18801 X_NUC_115.L_CORE X_NUC_163.L_CORE 0.001759
K_18802 X_NUC_115.L_CORE X_NUC_164.L_CORE 0.001748
K_18803 X_NUC_115.L_CORE X_NUC_165.L_CORE 0.003094
K_18804 X_NUC_115.L_CORE X_NUC_166.L_CORE 0.003077
K_18805 X_NUC_115.L_CORE X_NUC_167.L_CORE 0.003076
K_18806 X_NUC_115.L_CORE X_NUC_168.L_CORE 0.003050
K_18807 X_NUC_115.L_CORE X_NUC_169.L_CORE 0.002062
K_18808 X_NUC_115.L_CORE X_NUC_170.L_CORE 0.002057
K_18809 X_NUC_115.L_CORE X_NUC_171.L_CORE 0.002060
K_18810 X_NUC_115.L_CORE X_NUC_172.L_CORE 0.002044
K_18811 X_NUC_115.L_CORE X_NUC_173.L_CORE 0.001499
K_18812 X_NUC_115.L_CORE X_NUC_174.L_CORE 0.001475
K_18813 X_NUC_115.L_CORE X_NUC_175.L_CORE 0.001837
K_18814 X_NUC_115.L_CORE X_NUC_176.L_CORE 0.001337
K_18815 X_NUC_115.L_CORE X_NUC_177.L_CORE 0.001765
K_18816 X_NUC_115.L_CORE X_NUC_178.L_CORE 0.001661
K_18817 X_NUC_115.L_CORE X_NUC_179.L_CORE 0.001329
K_18818 X_NUC_115.L_CORE X_NUC_180.L_CORE 0.002354
K_18819 X_NUC_115.L_CORE X_NUC_181.L_CORE 0.001365
K_18820 X_NUC_115.L_CORE X_NUC_182.L_CORE 0.001587
K_18821 X_NUC_115.L_CORE X_NUC_183.L_CORE 0.002193
K_18822 X_NUC_115.L_CORE X_NUC_184.L_CORE 0.001257
K_18823 X_NUC_115.L_CORE X_NUC_185.L_CORE 0.002405
K_18824 X_NUC_115.L_CORE X_NUC_186.L_CORE 0.001571
K_18825 X_NUC_115.L_CORE X_NUC_187.L_CORE 0.001383
K_18826 X_NUC_115.L_CORE X_NUC_188.L_CORE 0.003374
K_18827 X_NUC_115.L_CORE X_NUC_189.L_CORE 0.001287
K_18828 X_NUC_115.L_CORE X_NUC_190.L_CORE 0.001940
K_18829 X_NUC_115.L_CORE X_NUC_191.L_CORE 0.002106
K_18830 X_NUC_115.L_CORE X_NUC_192.L_CORE 0.001273
K_18831 X_NUC_115.L_CORE X_NUC_193.L_CORE 0.004077
K_18832 X_NUC_115.L_CORE X_NUC_194.L_CORE 0.001451
K_18833 X_NUC_115.L_CORE X_NUC_195.L_CORE 0.001563
K_18834 X_NUC_115.L_CORE X_NUC_196.L_CORE 0.003700
K_18835 X_NUC_115.L_CORE X_NUC_197.L_CORE 0.001268
K_18836 X_NUC_115.L_CORE X_NUC_198.L_CORE 0.002728
K_18837 X_NUC_115.L_CORE X_NUC_199.L_CORE 0.001859
K_18838 X_NUC_115.L_CORE X_NUC_200.L_CORE 0.001370
K_18839 X_NUC_115.L_CORE X_NUC_201.L_CORE 0.012156
K_18840 X_NUC_115.L_CORE X_NUC_202.L_CORE 0.001383
K_18841 X_NUC_115.L_CORE X_NUC_203.L_CORE 0.001919
K_18842 X_NUC_115.L_CORE X_NUC_204.L_CORE 0.002926
K_18843 X_NUC_115.L_CORE X_NUC_205.L_CORE 0.001320
K_18844 X_NUC_115.L_CORE X_NUC_206.L_CORE 0.004720
K_18845 X_NUC_115.L_CORE X_NUC_207.L_CORE 0.001678
K_18846 X_NUC_115.L_CORE X_NUC_208.L_CORE 0.001575
K_18847 X_NUC_115.L_CORE X_NUC_209.L_CORE 0.006953
K_18848 X_NUC_115.L_CORE X_NUC_210.L_CORE 0.001398
K_18849 X_NUC_115.L_CORE X_NUC_211.L_CORE 0.002532
K_18850 X_NUC_115.L_CORE X_NUC_212.L_CORE 0.002311
K_18851 X_NUC_115.L_CORE X_NUC_213.L_CORE 0.001472
K_18852 X_NUC_115.L_CORE X_NUC_214.L_CORE 0.005807
K_18853 X_NUC_115.L_CORE X_NUC_215.L_CORE 0.001638
K_18854 X_NUC_115.L_CORE X_NUC_216.L_CORE 0.001927
K_18855 X_NUC_115.L_CORE X_NUC_217.L_CORE 0.003247
K_18856 X_NUC_115.L_CORE X_NUC_218.L_CORE 0.001565
K_18857 X_NUC_115.L_CORE X_NUC_219.L_CORE 0.002873
K_18858 X_NUC_115.L_CORE X_NUC_220.L_CORE 0.002070
K_18859 X_NUC_115.L_CORE X_NUC_221.L_CORE 0.001861
K_18860 X_NUC_115.L_CORE X_NUC_222.L_CORE 0.002510
K_18861 X_NUC_116.L_CORE X_NUC_117.L_CORE 0.001496
K_18862 X_NUC_116.L_CORE X_NUC_118.L_CORE 0.001496
K_18863 X_NUC_116.L_CORE X_NUC_119.L_CORE 0.001501
K_18864 X_NUC_116.L_CORE X_NUC_120.L_CORE 0.001491
K_18865 X_NUC_116.L_CORE X_NUC_121.L_CORE 0.002088
K_18866 X_NUC_116.L_CORE X_NUC_122.L_CORE 0.002068
K_18867 X_NUC_116.L_CORE X_NUC_123.L_CORE 0.002080
K_18868 X_NUC_116.L_CORE X_NUC_124.L_CORE 0.002073
K_18869 X_NUC_116.L_CORE X_NUC_125.L_CORE 0.003172
K_18870 X_NUC_116.L_CORE X_NUC_126.L_CORE 0.003200
K_18871 X_NUC_116.L_CORE X_NUC_127.L_CORE 0.003200
K_18872 X_NUC_116.L_CORE X_NUC_128.L_CORE 0.003161
K_18873 X_NUC_116.L_CORE X_NUC_129.L_CORE 0.001448
K_18874 X_NUC_116.L_CORE X_NUC_130.L_CORE 0.001443
K_18875 X_NUC_116.L_CORE X_NUC_131.L_CORE 0.001449
K_18876 X_NUC_116.L_CORE X_NUC_132.L_CORE 0.001441
K_18877 X_NUC_116.L_CORE X_NUC_133.L_CORE 0.004739
K_18878 X_NUC_116.L_CORE X_NUC_134.L_CORE 0.004642
K_18879 X_NUC_116.L_CORE X_NUC_135.L_CORE 0.004662
K_18880 X_NUC_116.L_CORE X_NUC_136.L_CORE 0.004657
K_18881 X_NUC_116.L_CORE X_NUC_137.L_CORE 0.001852
K_18882 X_NUC_116.L_CORE X_NUC_138.L_CORE 0.001854
K_18883 X_NUC_116.L_CORE X_NUC_139.L_CORE 0.001858
K_18884 X_NUC_116.L_CORE X_NUC_140.L_CORE 0.001843
K_18885 X_NUC_116.L_CORE X_NUC_141.L_CORE 0.001753
K_18886 X_NUC_116.L_CORE X_NUC_142.L_CORE 0.001742
K_18887 X_NUC_116.L_CORE X_NUC_143.L_CORE 0.001749
K_18888 X_NUC_116.L_CORE X_NUC_144.L_CORE 0.001741
K_18889 X_NUC_116.L_CORE X_NUC_145.L_CORE 0.005071
K_18890 X_NUC_116.L_CORE X_NUC_146.L_CORE 0.005097
K_18891 X_NUC_116.L_CORE X_NUC_147.L_CORE 0.005063
K_18892 X_NUC_116.L_CORE X_NUC_148.L_CORE 0.004982
K_18893 X_NUC_116.L_CORE X_NUC_149.L_CORE 0.001599
K_18894 X_NUC_116.L_CORE X_NUC_150.L_CORE 0.001596
K_18895 X_NUC_116.L_CORE X_NUC_151.L_CORE 0.001601
K_18896 X_NUC_116.L_CORE X_NUC_152.L_CORE 0.001590
K_18897 X_NUC_116.L_CORE X_NUC_153.L_CORE 0.002642
K_18898 X_NUC_116.L_CORE X_NUC_154.L_CORE 0.002615
K_18899 X_NUC_116.L_CORE X_NUC_155.L_CORE 0.002624
K_18900 X_NUC_116.L_CORE X_NUC_156.L_CORE 0.002611
K_18901 X_NUC_116.L_CORE X_NUC_157.L_CORE 0.002453
K_18902 X_NUC_116.L_CORE X_NUC_158.L_CORE 0.002457
K_18903 X_NUC_116.L_CORE X_NUC_159.L_CORE 0.002458
K_18904 X_NUC_116.L_CORE X_NUC_160.L_CORE 0.002433
K_18905 X_NUC_116.L_CORE X_NUC_161.L_CORE 0.001773
K_18906 X_NUC_116.L_CORE X_NUC_162.L_CORE 0.001765
K_18907 X_NUC_116.L_CORE X_NUC_163.L_CORE 0.001771
K_18908 X_NUC_116.L_CORE X_NUC_164.L_CORE 0.001759
K_18909 X_NUC_116.L_CORE X_NUC_165.L_CORE 0.003122
K_18910 X_NUC_116.L_CORE X_NUC_166.L_CORE 0.003104
K_18911 X_NUC_116.L_CORE X_NUC_167.L_CORE 0.003103
K_18912 X_NUC_116.L_CORE X_NUC_168.L_CORE 0.003076
K_18913 X_NUC_116.L_CORE X_NUC_169.L_CORE 0.002079
K_18914 X_NUC_116.L_CORE X_NUC_170.L_CORE 0.002074
K_18915 X_NUC_116.L_CORE X_NUC_171.L_CORE 0.002077
K_18916 X_NUC_116.L_CORE X_NUC_172.L_CORE 0.002060
K_18917 X_NUC_116.L_CORE X_NUC_173.L_CORE 0.001505
K_18918 X_NUC_116.L_CORE X_NUC_174.L_CORE 0.001480
K_18919 X_NUC_116.L_CORE X_NUC_175.L_CORE 0.001844
K_18920 X_NUC_116.L_CORE X_NUC_176.L_CORE 0.001344
K_18921 X_NUC_116.L_CORE X_NUC_177.L_CORE 0.001769
K_18922 X_NUC_116.L_CORE X_NUC_178.L_CORE 0.001670
K_18923 X_NUC_116.L_CORE X_NUC_179.L_CORE 0.001334
K_18924 X_NUC_116.L_CORE X_NUC_180.L_CORE 0.002357
K_18925 X_NUC_116.L_CORE X_NUC_181.L_CORE 0.001372
K_18926 X_NUC_116.L_CORE X_NUC_182.L_CORE 0.001591
K_18927 X_NUC_116.L_CORE X_NUC_183.L_CORE 0.002204
K_18928 X_NUC_116.L_CORE X_NUC_184.L_CORE 0.001263
K_18929 X_NUC_116.L_CORE X_NUC_185.L_CORE 0.002404
K_18930 X_NUC_116.L_CORE X_NUC_186.L_CORE 0.001581
K_18931 X_NUC_116.L_CORE X_NUC_187.L_CORE 0.001388
K_18932 X_NUC_116.L_CORE X_NUC_188.L_CORE 0.003378
K_18933 X_NUC_116.L_CORE X_NUC_189.L_CORE 0.001294
K_18934 X_NUC_116.L_CORE X_NUC_190.L_CORE 0.001942
K_18935 X_NUC_116.L_CORE X_NUC_191.L_CORE 0.002121
K_18936 X_NUC_116.L_CORE X_NUC_192.L_CORE 0.001279
K_18937 X_NUC_116.L_CORE X_NUC_193.L_CORE 0.004052
K_18938 X_NUC_116.L_CORE X_NUC_194.L_CORE 0.001460
K_18939 X_NUC_116.L_CORE X_NUC_195.L_CORE 0.001568
K_18940 X_NUC_116.L_CORE X_NUC_196.L_CORE 0.003726
K_18941 X_NUC_116.L_CORE X_NUC_197.L_CORE 0.001275
K_18942 X_NUC_116.L_CORE X_NUC_198.L_CORE 0.002724
K_18943 X_NUC_116.L_CORE X_NUC_199.L_CORE 0.001873
K_18944 X_NUC_116.L_CORE X_NUC_200.L_CORE 0.001376
K_18945 X_NUC_116.L_CORE X_NUC_201.L_CORE 0.011801
K_18946 X_NUC_116.L_CORE X_NUC_202.L_CORE 0.001392
K_18947 X_NUC_116.L_CORE X_NUC_203.L_CORE 0.001923
K_18948 X_NUC_116.L_CORE X_NUC_204.L_CORE 0.002956
K_18949 X_NUC_116.L_CORE X_NUC_205.L_CORE 0.001327
K_18950 X_NUC_116.L_CORE X_NUC_206.L_CORE 0.004691
K_18951 X_NUC_116.L_CORE X_NUC_207.L_CORE 0.001692
K_18952 X_NUC_116.L_CORE X_NUC_208.L_CORE 0.001581
K_18953 X_NUC_116.L_CORE X_NUC_209.L_CORE 0.007068
K_18954 X_NUC_116.L_CORE X_NUC_210.L_CORE 0.001407
K_18955 X_NUC_116.L_CORE X_NUC_211.L_CORE 0.002537
K_18956 X_NUC_116.L_CORE X_NUC_212.L_CORE 0.002333
K_18957 X_NUC_116.L_CORE X_NUC_213.L_CORE 0.001480
K_18958 X_NUC_116.L_CORE X_NUC_214.L_CORE 0.005831
K_18959 X_NUC_116.L_CORE X_NUC_215.L_CORE 0.001650
K_18960 X_NUC_116.L_CORE X_NUC_216.L_CORE 0.001936
K_18961 X_NUC_116.L_CORE X_NUC_217.L_CORE 0.003284
K_18962 X_NUC_116.L_CORE X_NUC_218.L_CORE 0.001575
K_18963 X_NUC_116.L_CORE X_NUC_219.L_CORE 0.002888
K_18964 X_NUC_116.L_CORE X_NUC_220.L_CORE 0.002088
K_18965 X_NUC_116.L_CORE X_NUC_221.L_CORE 0.001873
K_18966 X_NUC_116.L_CORE X_NUC_222.L_CORE 0.002530
K_18967 X_NUC_117.L_CORE X_NUC_118.L_CORE 0.207973
K_18968 X_NUC_117.L_CORE X_NUC_119.L_CORE 0.207973
K_18969 X_NUC_117.L_CORE X_NUC_120.L_CORE 0.207973
K_18970 X_NUC_117.L_CORE X_NUC_121.L_CORE 0.001521
K_18971 X_NUC_117.L_CORE X_NUC_122.L_CORE 0.001514
K_18972 X_NUC_117.L_CORE X_NUC_123.L_CORE 0.001513
K_18973 X_NUC_117.L_CORE X_NUC_124.L_CORE 0.001521
K_18974 X_NUC_117.L_CORE X_NUC_125.L_CORE 0.002119
K_18975 X_NUC_117.L_CORE X_NUC_126.L_CORE 0.002129
K_18976 X_NUC_117.L_CORE X_NUC_127.L_CORE 0.002113
K_18977 X_NUC_117.L_CORE X_NUC_128.L_CORE 0.002132
K_18978 X_NUC_117.L_CORE X_NUC_129.L_CORE 0.003233
K_18979 X_NUC_117.L_CORE X_NUC_130.L_CORE 0.003185
K_18980 X_NUC_117.L_CORE X_NUC_131.L_CORE 0.003197
K_18981 X_NUC_117.L_CORE X_NUC_132.L_CORE 0.003208
K_18982 X_NUC_117.L_CORE X_NUC_133.L_CORE 0.001479
K_18983 X_NUC_117.L_CORE X_NUC_134.L_CORE 0.001476
K_18984 X_NUC_117.L_CORE X_NUC_135.L_CORE 0.001472
K_18985 X_NUC_117.L_CORE X_NUC_136.L_CORE 0.001482
K_18986 X_NUC_117.L_CORE X_NUC_137.L_CORE 0.004735
K_18987 X_NUC_117.L_CORE X_NUC_138.L_CORE 0.004800
K_18988 X_NUC_117.L_CORE X_NUC_139.L_CORE 0.004698
K_18989 X_NUC_117.L_CORE X_NUC_140.L_CORE 0.004771
K_18990 X_NUC_117.L_CORE X_NUC_141.L_CORE 0.001899
K_18991 X_NUC_117.L_CORE X_NUC_142.L_CORE 0.001886
K_18992 X_NUC_117.L_CORE X_NUC_143.L_CORE 0.001884
K_18993 X_NUC_117.L_CORE X_NUC_144.L_CORE 0.001895
K_18994 X_NUC_117.L_CORE X_NUC_145.L_CORE 0.001800
K_18995 X_NUC_117.L_CORE X_NUC_146.L_CORE 0.001802
K_18996 X_NUC_117.L_CORE X_NUC_147.L_CORE 0.001791
K_18997 X_NUC_117.L_CORE X_NUC_148.L_CORE 0.001806
K_18998 X_NUC_117.L_CORE X_NUC_149.L_CORE 0.004909
K_18999 X_NUC_117.L_CORE X_NUC_150.L_CORE 0.004841
K_19000 X_NUC_117.L_CORE X_NUC_151.L_CORE 0.004796
K_19001 X_NUC_117.L_CORE X_NUC_152.L_CORE 0.004842
K_19002 X_NUC_117.L_CORE X_NUC_153.L_CORE 0.001660
K_19003 X_NUC_117.L_CORE X_NUC_154.L_CORE 0.001654
K_19004 X_NUC_117.L_CORE X_NUC_155.L_CORE 0.001649
K_19005 X_NUC_117.L_CORE X_NUC_156.L_CORE 0.001660
K_19006 X_NUC_117.L_CORE X_NUC_157.L_CORE 0.002676
K_19007 X_NUC_117.L_CORE X_NUC_158.L_CORE 0.002686
K_19008 X_NUC_117.L_CORE X_NUC_159.L_CORE 0.002655
K_19009 X_NUC_117.L_CORE X_NUC_160.L_CORE 0.002684
K_19010 X_NUC_117.L_CORE X_NUC_161.L_CORE 0.002503
K_19011 X_NUC_117.L_CORE X_NUC_162.L_CORE 0.002484
K_19012 X_NUC_117.L_CORE X_NUC_163.L_CORE 0.002474
K_19013 X_NUC_117.L_CORE X_NUC_164.L_CORE 0.002492
K_19014 X_NUC_117.L_CORE X_NUC_165.L_CORE 0.001891
K_19015 X_NUC_117.L_CORE X_NUC_166.L_CORE 0.001888
K_19016 X_NUC_117.L_CORE X_NUC_167.L_CORE 0.001877
K_19017 X_NUC_117.L_CORE X_NUC_168.L_CORE 0.001892
K_19018 X_NUC_117.L_CORE X_NUC_169.L_CORE 0.002769
K_19019 X_NUC_117.L_CORE X_NUC_170.L_CORE 0.002762
K_19020 X_NUC_117.L_CORE X_NUC_171.L_CORE 0.002736
K_19021 X_NUC_117.L_CORE X_NUC_172.L_CORE 0.002762
K_19022 X_NUC_117.L_CORE X_NUC_173.L_CORE 0.001618
K_19023 X_NUC_117.L_CORE X_NUC_174.L_CORE 0.001468
K_19024 X_NUC_117.L_CORE X_NUC_175.L_CORE 0.001453
K_19025 X_NUC_117.L_CORE X_NUC_176.L_CORE 0.001879
K_19026 X_NUC_117.L_CORE X_NUC_177.L_CORE 0.001316
K_19027 X_NUC_117.L_CORE X_NUC_178.L_CORE 0.001775
K_19028 X_NUC_117.L_CORE X_NUC_179.L_CORE 0.001658
K_19029 X_NUC_117.L_CORE X_NUC_180.L_CORE 0.001320
K_19030 X_NUC_117.L_CORE X_NUC_181.L_CORE 0.002384
K_19031 X_NUC_117.L_CORE X_NUC_182.L_CORE 0.001358
K_19032 X_NUC_117.L_CORE X_NUC_183.L_CORE 0.001587
K_19033 X_NUC_117.L_CORE X_NUC_184.L_CORE 0.002197
K_19034 X_NUC_117.L_CORE X_NUC_185.L_CORE 0.001256
K_19035 X_NUC_117.L_CORE X_NUC_186.L_CORE 0.002418
K_19036 X_NUC_117.L_CORE X_NUC_187.L_CORE 0.001572
K_19037 X_NUC_117.L_CORE X_NUC_188.L_CORE 0.001387
K_19038 X_NUC_117.L_CORE X_NUC_189.L_CORE 0.003379
K_19039 X_NUC_117.L_CORE X_NUC_190.L_CORE 0.001291
K_19040 X_NUC_117.L_CORE X_NUC_191.L_CORE 0.001952
K_19041 X_NUC_117.L_CORE X_NUC_192.L_CORE 0.002111
K_19042 X_NUC_117.L_CORE X_NUC_193.L_CORE 0.001281
K_19043 X_NUC_117.L_CORE X_NUC_194.L_CORE 0.004093
K_19044 X_NUC_117.L_CORE X_NUC_195.L_CORE 0.001461
K_19045 X_NUC_117.L_CORE X_NUC_196.L_CORE 0.001578
K_19046 X_NUC_117.L_CORE X_NUC_197.L_CORE 0.003703
K_19047 X_NUC_117.L_CORE X_NUC_198.L_CORE 0.001281
K_19048 X_NUC_117.L_CORE X_NUC_199.L_CORE 0.002763
K_19049 X_NUC_117.L_CORE X_NUC_200.L_CORE 0.001877
K_19050 X_NUC_117.L_CORE X_NUC_201.L_CORE 0.001389
K_19051 X_NUC_117.L_CORE X_NUC_202.L_CORE 0.011948
K_19052 X_NUC_117.L_CORE X_NUC_203.L_CORE 0.001403
K_19053 X_NUC_117.L_CORE X_NUC_204.L_CORE 0.001953
K_19054 X_NUC_117.L_CORE X_NUC_205.L_CORE 0.002964
K_19055 X_NUC_117.L_CORE X_NUC_206.L_CORE 0.001344
K_19056 X_NUC_117.L_CORE X_NUC_207.L_CORE 0.004832
K_19057 X_NUC_117.L_CORE X_NUC_208.L_CORE 0.001711
K_19058 X_NUC_117.L_CORE X_NUC_209.L_CORE 0.001611
K_19059 X_NUC_117.L_CORE X_NUC_210.L_CORE 0.006982
K_19060 X_NUC_117.L_CORE X_NUC_211.L_CORE 0.001433
K_19061 X_NUC_117.L_CORE X_NUC_212.L_CORE 0.002601
K_19062 X_NUC_117.L_CORE X_NUC_213.L_CORE 0.002366
K_19063 X_NUC_117.L_CORE X_NUC_214.L_CORE 0.001518
K_19064 X_NUC_117.L_CORE X_NUC_215.L_CORE 0.005718
K_19065 X_NUC_117.L_CORE X_NUC_216.L_CORE 0.001694
K_19066 X_NUC_117.L_CORE X_NUC_217.L_CORE 0.001997
K_19067 X_NUC_117.L_CORE X_NUC_218.L_CORE 0.003253
K_19068 X_NUC_117.L_CORE X_NUC_219.L_CORE 0.001644
K_19069 X_NUC_117.L_CORE X_NUC_220.L_CORE 0.002864
K_19070 X_NUC_117.L_CORE X_NUC_221.L_CORE 0.002158
K_19071 X_NUC_117.L_CORE X_NUC_222.L_CORE 0.002032
K_19072 X_NUC_118.L_CORE X_NUC_119.L_CORE 0.207973
K_19073 X_NUC_118.L_CORE X_NUC_120.L_CORE 0.207973
K_19074 X_NUC_118.L_CORE X_NUC_121.L_CORE 0.001528
K_19075 X_NUC_118.L_CORE X_NUC_122.L_CORE 0.001521
K_19076 X_NUC_118.L_CORE X_NUC_123.L_CORE 0.001520
K_19077 X_NUC_118.L_CORE X_NUC_124.L_CORE 0.001528
K_19078 X_NUC_118.L_CORE X_NUC_125.L_CORE 0.002109
K_19079 X_NUC_118.L_CORE X_NUC_126.L_CORE 0.002119
K_19080 X_NUC_118.L_CORE X_NUC_127.L_CORE 0.002103
K_19081 X_NUC_118.L_CORE X_NUC_128.L_CORE 0.002122
K_19082 X_NUC_118.L_CORE X_NUC_129.L_CORE 0.003282
K_19083 X_NUC_118.L_CORE X_NUC_130.L_CORE 0.003233
K_19084 X_NUC_118.L_CORE X_NUC_131.L_CORE 0.003245
K_19085 X_NUC_118.L_CORE X_NUC_132.L_CORE 0.003256
K_19086 X_NUC_118.L_CORE X_NUC_133.L_CORE 0.001481
K_19087 X_NUC_118.L_CORE X_NUC_134.L_CORE 0.001479
K_19088 X_NUC_118.L_CORE X_NUC_135.L_CORE 0.001474
K_19089 X_NUC_118.L_CORE X_NUC_136.L_CORE 0.001484
K_19090 X_NUC_118.L_CORE X_NUC_137.L_CORE 0.004670
K_19091 X_NUC_118.L_CORE X_NUC_138.L_CORE 0.004735
K_19092 X_NUC_118.L_CORE X_NUC_139.L_CORE 0.004636
K_19093 X_NUC_118.L_CORE X_NUC_140.L_CORE 0.004706
K_19094 X_NUC_118.L_CORE X_NUC_141.L_CORE 0.001912
K_19095 X_NUC_118.L_CORE X_NUC_142.L_CORE 0.001899
K_19096 X_NUC_118.L_CORE X_NUC_143.L_CORE 0.001897
K_19097 X_NUC_118.L_CORE X_NUC_144.L_CORE 0.001908
K_19098 X_NUC_118.L_CORE X_NUC_145.L_CORE 0.001797
K_19099 X_NUC_118.L_CORE X_NUC_146.L_CORE 0.001800
K_19100 X_NUC_118.L_CORE X_NUC_147.L_CORE 0.001788
K_19101 X_NUC_118.L_CORE X_NUC_148.L_CORE 0.001803
K_19102 X_NUC_118.L_CORE X_NUC_149.L_CORE 0.004976
K_19103 X_NUC_118.L_CORE X_NUC_150.L_CORE 0.004909
K_19104 X_NUC_118.L_CORE X_NUC_151.L_CORE 0.004860
K_19105 X_NUC_118.L_CORE X_NUC_152.L_CORE 0.004907
K_19106 X_NUC_118.L_CORE X_NUC_153.L_CORE 0.001665
K_19107 X_NUC_118.L_CORE X_NUC_154.L_CORE 0.001660
K_19108 X_NUC_118.L_CORE X_NUC_155.L_CORE 0.001654
K_19109 X_NUC_118.L_CORE X_NUC_156.L_CORE 0.001666
K_19110 X_NUC_118.L_CORE X_NUC_157.L_CORE 0.002667
K_19111 X_NUC_118.L_CORE X_NUC_158.L_CORE 0.002676
K_19112 X_NUC_118.L_CORE X_NUC_159.L_CORE 0.002646
K_19113 X_NUC_118.L_CORE X_NUC_160.L_CORE 0.002674
K_19114 X_NUC_118.L_CORE X_NUC_161.L_CORE 0.002522
K_19115 X_NUC_118.L_CORE X_NUC_162.L_CORE 0.002503
K_19116 X_NUC_118.L_CORE X_NUC_163.L_CORE 0.002493
K_19117 X_NUC_118.L_CORE X_NUC_164.L_CORE 0.002511
K_19118 X_NUC_118.L_CORE X_NUC_165.L_CORE 0.001893
K_19119 X_NUC_118.L_CORE X_NUC_166.L_CORE 0.001891
K_19120 X_NUC_118.L_CORE X_NUC_167.L_CORE 0.001879
K_19121 X_NUC_118.L_CORE X_NUC_168.L_CORE 0.001895
K_19122 X_NUC_118.L_CORE X_NUC_169.L_CORE 0.002775
K_19123 X_NUC_118.L_CORE X_NUC_170.L_CORE 0.002769
K_19124 X_NUC_118.L_CORE X_NUC_171.L_CORE 0.002742
K_19125 X_NUC_118.L_CORE X_NUC_172.L_CORE 0.002769
K_19126 X_NUC_118.L_CORE X_NUC_173.L_CORE 0.001619
K_19127 X_NUC_118.L_CORE X_NUC_174.L_CORE 0.001471
K_19128 X_NUC_118.L_CORE X_NUC_175.L_CORE 0.001452
K_19129 X_NUC_118.L_CORE X_NUC_176.L_CORE 0.001883
K_19130 X_NUC_118.L_CORE X_NUC_177.L_CORE 0.001319
K_19131 X_NUC_118.L_CORE X_NUC_178.L_CORE 0.001771
K_19132 X_NUC_118.L_CORE X_NUC_179.L_CORE 0.001666
K_19133 X_NUC_118.L_CORE X_NUC_180.L_CORE 0.001320
K_19134 X_NUC_118.L_CORE X_NUC_181.L_CORE 0.002382
K_19135 X_NUC_118.L_CORE X_NUC_182.L_CORE 0.001363
K_19136 X_NUC_118.L_CORE X_NUC_183.L_CORE 0.001583
K_19137 X_NUC_118.L_CORE X_NUC_184.L_CORE 0.002211
K_19138 X_NUC_118.L_CORE X_NUC_185.L_CORE 0.001258
K_19139 X_NUC_118.L_CORE X_NUC_186.L_CORE 0.002404
K_19140 X_NUC_118.L_CORE X_NUC_187.L_CORE 0.001581
K_19141 X_NUC_118.L_CORE X_NUC_188.L_CORE 0.001385
K_19142 X_NUC_118.L_CORE X_NUC_189.L_CORE 0.003393
K_19143 X_NUC_118.L_CORE X_NUC_190.L_CORE 0.001295
K_19144 X_NUC_118.L_CORE X_NUC_191.L_CORE 0.001941
K_19145 X_NUC_118.L_CORE X_NUC_192.L_CORE 0.002130
K_19146 X_NUC_118.L_CORE X_NUC_193.L_CORE 0.001282
K_19147 X_NUC_118.L_CORE X_NUC_194.L_CORE 0.004046
K_19148 X_NUC_118.L_CORE X_NUC_195.L_CORE 0.001468
K_19149 X_NUC_118.L_CORE X_NUC_196.L_CORE 0.001574
K_19150 X_NUC_118.L_CORE X_NUC_197.L_CORE 0.003756
K_19151 X_NUC_118.L_CORE X_NUC_198.L_CORE 0.001284
K_19152 X_NUC_118.L_CORE X_NUC_199.L_CORE 0.002735
K_19153 X_NUC_118.L_CORE X_NUC_200.L_CORE 0.001893
K_19154 X_NUC_118.L_CORE X_NUC_201.L_CORE 0.001389
K_19155 X_NUC_118.L_CORE X_NUC_202.L_CORE 0.011825
K_19156 X_NUC_118.L_CORE X_NUC_203.L_CORE 0.001409
K_19157 X_NUC_118.L_CORE X_NUC_204.L_CORE 0.001943
K_19158 X_NUC_118.L_CORE X_NUC_205.L_CORE 0.003007
K_19159 X_NUC_118.L_CORE X_NUC_206.L_CORE 0.001346
K_19160 X_NUC_118.L_CORE X_NUC_207.L_CORE 0.004734
K_19161 X_NUC_118.L_CORE X_NUC_208.L_CORE 0.001722
K_19162 X_NUC_118.L_CORE X_NUC_209.L_CORE 0.001608
K_19163 X_NUC_118.L_CORE X_NUC_210.L_CORE 0.007194
K_19164 X_NUC_118.L_CORE X_NUC_211.L_CORE 0.001437
K_19165 X_NUC_118.L_CORE X_NUC_212.L_CORE 0.002582
K_19166 X_NUC_118.L_CORE X_NUC_213.L_CORE 0.002390
K_19167 X_NUC_118.L_CORE X_NUC_214.L_CORE 0.001519
K_19168 X_NUC_118.L_CORE X_NUC_215.L_CORE 0.005681
K_19169 X_NUC_118.L_CORE X_NUC_216.L_CORE 0.001703
K_19170 X_NUC_118.L_CORE X_NUC_217.L_CORE 0.001992
K_19171 X_NUC_118.L_CORE X_NUC_218.L_CORE 0.003286
K_19172 X_NUC_118.L_CORE X_NUC_219.L_CORE 0.001648
K_19173 X_NUC_118.L_CORE X_NUC_220.L_CORE 0.002857
K_19174 X_NUC_118.L_CORE X_NUC_221.L_CORE 0.002170
K_19175 X_NUC_118.L_CORE X_NUC_222.L_CORE 0.002035
K_19176 X_NUC_119.L_CORE X_NUC_120.L_CORE 0.207973
K_19177 X_NUC_119.L_CORE X_NUC_121.L_CORE 0.001529
K_19178 X_NUC_119.L_CORE X_NUC_122.L_CORE 0.001522
K_19179 X_NUC_119.L_CORE X_NUC_123.L_CORE 0.001521
K_19180 X_NUC_119.L_CORE X_NUC_124.L_CORE 0.001530
K_19181 X_NUC_119.L_CORE X_NUC_125.L_CORE 0.002124
K_19182 X_NUC_119.L_CORE X_NUC_126.L_CORE 0.002135
K_19183 X_NUC_119.L_CORE X_NUC_127.L_CORE 0.002119
K_19184 X_NUC_119.L_CORE X_NUC_128.L_CORE 0.002138
K_19185 X_NUC_119.L_CORE X_NUC_129.L_CORE 0.003269
K_19186 X_NUC_119.L_CORE X_NUC_130.L_CORE 0.003220
K_19187 X_NUC_119.L_CORE X_NUC_131.L_CORE 0.003233
K_19188 X_NUC_119.L_CORE X_NUC_132.L_CORE 0.003244
K_19189 X_NUC_119.L_CORE X_NUC_133.L_CORE 0.001486
K_19190 X_NUC_119.L_CORE X_NUC_134.L_CORE 0.001483
K_19191 X_NUC_119.L_CORE X_NUC_135.L_CORE 0.001479
K_19192 X_NUC_119.L_CORE X_NUC_136.L_CORE 0.001489
K_19193 X_NUC_119.L_CORE X_NUC_137.L_CORE 0.004770
K_19194 X_NUC_119.L_CORE X_NUC_138.L_CORE 0.004838
K_19195 X_NUC_119.L_CORE X_NUC_139.L_CORE 0.004735
K_19196 X_NUC_119.L_CORE X_NUC_140.L_CORE 0.004808
K_19197 X_NUC_119.L_CORE X_NUC_141.L_CORE 0.001913
K_19198 X_NUC_119.L_CORE X_NUC_142.L_CORE 0.001900
K_19199 X_NUC_119.L_CORE X_NUC_143.L_CORE 0.001899
K_19200 X_NUC_119.L_CORE X_NUC_144.L_CORE 0.001909
K_19201 X_NUC_119.L_CORE X_NUC_145.L_CORE 0.001808
K_19202 X_NUC_119.L_CORE X_NUC_146.L_CORE 0.001811
K_19203 X_NUC_119.L_CORE X_NUC_147.L_CORE 0.001800
K_19204 X_NUC_119.L_CORE X_NUC_148.L_CORE 0.001815
K_19205 X_NUC_119.L_CORE X_NUC_149.L_CORE 0.005026
K_19206 X_NUC_119.L_CORE X_NUC_150.L_CORE 0.004956
K_19207 X_NUC_119.L_CORE X_NUC_151.L_CORE 0.004909
K_19208 X_NUC_119.L_CORE X_NUC_152.L_CORE 0.004956
K_19209 X_NUC_119.L_CORE X_NUC_153.L_CORE 0.001671
K_19210 X_NUC_119.L_CORE X_NUC_154.L_CORE 0.001665
K_19211 X_NUC_119.L_CORE X_NUC_155.L_CORE 0.001660
K_19212 X_NUC_119.L_CORE X_NUC_156.L_CORE 0.001671
K_19213 X_NUC_119.L_CORE X_NUC_157.L_CORE 0.002698
K_19214 X_NUC_119.L_CORE X_NUC_158.L_CORE 0.002707
K_19215 X_NUC_119.L_CORE X_NUC_159.L_CORE 0.002676
K_19216 X_NUC_119.L_CORE X_NUC_160.L_CORE 0.002705
K_19217 X_NUC_119.L_CORE X_NUC_161.L_CORE 0.002532
K_19218 X_NUC_119.L_CORE X_NUC_162.L_CORE 0.002513
K_19219 X_NUC_119.L_CORE X_NUC_163.L_CORE 0.002503
K_19220 X_NUC_119.L_CORE X_NUC_164.L_CORE 0.002521
K_19221 X_NUC_119.L_CORE X_NUC_165.L_CORE 0.001905
K_19222 X_NUC_119.L_CORE X_NUC_166.L_CORE 0.001902
K_19223 X_NUC_119.L_CORE X_NUC_167.L_CORE 0.001891
K_19224 X_NUC_119.L_CORE X_NUC_168.L_CORE 0.001906
K_19225 X_NUC_119.L_CORE X_NUC_169.L_CORE 0.002803
K_19226 X_NUC_119.L_CORE X_NUC_170.L_CORE 0.002796
K_19227 X_NUC_119.L_CORE X_NUC_171.L_CORE 0.002769
K_19228 X_NUC_119.L_CORE X_NUC_172.L_CORE 0.002797
K_19229 X_NUC_119.L_CORE X_NUC_173.L_CORE 0.001614
K_19230 X_NUC_119.L_CORE X_NUC_174.L_CORE 0.001466
K_19231 X_NUC_119.L_CORE X_NUC_175.L_CORE 0.001450
K_19232 X_NUC_119.L_CORE X_NUC_176.L_CORE 0.001872
K_19233 X_NUC_119.L_CORE X_NUC_177.L_CORE 0.001317
K_19234 X_NUC_119.L_CORE X_NUC_178.L_CORE 0.001768
K_19235 X_NUC_119.L_CORE X_NUC_179.L_CORE 0.001657
K_19236 X_NUC_119.L_CORE X_NUC_180.L_CORE 0.001320
K_19237 X_NUC_119.L_CORE X_NUC_181.L_CORE 0.002366
K_19238 X_NUC_119.L_CORE X_NUC_182.L_CORE 0.001360
K_19239 X_NUC_119.L_CORE X_NUC_183.L_CORE 0.001584
K_19240 X_NUC_119.L_CORE X_NUC_184.L_CORE 0.002192
K_19241 X_NUC_119.L_CORE X_NUC_185.L_CORE 0.001258
K_19242 X_NUC_119.L_CORE X_NUC_186.L_CORE 0.002400
K_19243 X_NUC_119.L_CORE X_NUC_187.L_CORE 0.001574
K_19244 X_NUC_119.L_CORE X_NUC_188.L_CORE 0.001387
K_19245 X_NUC_119.L_CORE X_NUC_189.L_CORE 0.003345
K_19246 X_NUC_119.L_CORE X_NUC_190.L_CORE 0.001294
K_19247 X_NUC_119.L_CORE X_NUC_191.L_CORE 0.001946
K_19248 X_NUC_119.L_CORE X_NUC_192.L_CORE 0.002114
K_19249 X_NUC_119.L_CORE X_NUC_193.L_CORE 0.001284
K_19250 X_NUC_119.L_CORE X_NUC_194.L_CORE 0.004026
K_19251 X_NUC_119.L_CORE X_NUC_195.L_CORE 0.001466
K_19252 X_NUC_119.L_CORE X_NUC_196.L_CORE 0.001579
K_19253 X_NUC_119.L_CORE X_NUC_197.L_CORE 0.003696
K_19254 X_NUC_119.L_CORE X_NUC_198.L_CORE 0.001286
K_19255 X_NUC_119.L_CORE X_NUC_199.L_CORE 0.002750
K_19256 X_NUC_119.L_CORE X_NUC_200.L_CORE 0.001885
K_19257 X_NUC_119.L_CORE X_NUC_201.L_CORE 0.001393
K_19258 X_NUC_119.L_CORE X_NUC_202.L_CORE 0.011338
K_19259 X_NUC_119.L_CORE X_NUC_203.L_CORE 0.001409
K_19260 X_NUC_119.L_CORE X_NUC_204.L_CORE 0.001955
K_19261 X_NUC_119.L_CORE X_NUC_205.L_CORE 0.002984
K_19262 X_NUC_119.L_CORE X_NUC_206.L_CORE 0.001349
K_19263 X_NUC_119.L_CORE X_NUC_207.L_CORE 0.004812
K_19264 X_NUC_119.L_CORE X_NUC_208.L_CORE 0.001721
K_19265 X_NUC_119.L_CORE X_NUC_209.L_CORE 0.001616
K_19266 X_NUC_119.L_CORE X_NUC_210.L_CORE 0.007149
K_19267 X_NUC_119.L_CORE X_NUC_211.L_CORE 0.001440
K_19268 X_NUC_119.L_CORE X_NUC_212.L_CORE 0.002609
K_19269 X_NUC_119.L_CORE X_NUC_213.L_CORE 0.002388
K_19270 X_NUC_119.L_CORE X_NUC_214.L_CORE 0.001525
K_19271 X_NUC_119.L_CORE X_NUC_215.L_CORE 0.005834
K_19272 X_NUC_119.L_CORE X_NUC_216.L_CORE 0.001706
K_19273 X_NUC_119.L_CORE X_NUC_217.L_CORE 0.002008
K_19274 X_NUC_119.L_CORE X_NUC_218.L_CORE 0.003304
K_19275 X_NUC_119.L_CORE X_NUC_219.L_CORE 0.001655
K_19276 X_NUC_119.L_CORE X_NUC_220.L_CORE 0.002894
K_19277 X_NUC_119.L_CORE X_NUC_221.L_CORE 0.002180
K_19278 X_NUC_119.L_CORE X_NUC_222.L_CORE 0.002049
K_19279 X_NUC_120.L_CORE X_NUC_121.L_CORE 0.001520
K_19280 X_NUC_120.L_CORE X_NUC_122.L_CORE 0.001513
K_19281 X_NUC_120.L_CORE X_NUC_123.L_CORE 0.001512
K_19282 X_NUC_120.L_CORE X_NUC_124.L_CORE 0.001521
K_19283 X_NUC_120.L_CORE X_NUC_125.L_CORE 0.002105
K_19284 X_NUC_120.L_CORE X_NUC_126.L_CORE 0.002116
K_19285 X_NUC_120.L_CORE X_NUC_127.L_CORE 0.002100
K_19286 X_NUC_120.L_CORE X_NUC_128.L_CORE 0.002119
K_19287 X_NUC_120.L_CORE X_NUC_129.L_CORE 0.003257
K_19288 X_NUC_120.L_CORE X_NUC_130.L_CORE 0.003209
K_19289 X_NUC_120.L_CORE X_NUC_131.L_CORE 0.003221
K_19290 X_NUC_120.L_CORE X_NUC_132.L_CORE 0.003233
K_19291 X_NUC_120.L_CORE X_NUC_133.L_CORE 0.001475
K_19292 X_NUC_120.L_CORE X_NUC_134.L_CORE 0.001473
K_19293 X_NUC_120.L_CORE X_NUC_135.L_CORE 0.001468
K_19294 X_NUC_120.L_CORE X_NUC_136.L_CORE 0.001479
K_19295 X_NUC_120.L_CORE X_NUC_137.L_CORE 0.004697
K_19296 X_NUC_120.L_CORE X_NUC_138.L_CORE 0.004762
K_19297 X_NUC_120.L_CORE X_NUC_139.L_CORE 0.004662
K_19298 X_NUC_120.L_CORE X_NUC_140.L_CORE 0.004735
K_19299 X_NUC_120.L_CORE X_NUC_141.L_CORE 0.001902
K_19300 X_NUC_120.L_CORE X_NUC_142.L_CORE 0.001889
K_19301 X_NUC_120.L_CORE X_NUC_143.L_CORE 0.001888
K_19302 X_NUC_120.L_CORE X_NUC_144.L_CORE 0.001899
K_19303 X_NUC_120.L_CORE X_NUC_145.L_CORE 0.001793
K_19304 X_NUC_120.L_CORE X_NUC_146.L_CORE 0.001796
K_19305 X_NUC_120.L_CORE X_NUC_147.L_CORE 0.001785
K_19306 X_NUC_120.L_CORE X_NUC_148.L_CORE 0.001800
K_19307 X_NUC_120.L_CORE X_NUC_149.L_CORE 0.004976
K_19308 X_NUC_120.L_CORE X_NUC_150.L_CORE 0.004907
K_19309 X_NUC_120.L_CORE X_NUC_151.L_CORE 0.004860
K_19310 X_NUC_120.L_CORE X_NUC_152.L_CORE 0.004909
K_19311 X_NUC_120.L_CORE X_NUC_153.L_CORE 0.001659
K_19312 X_NUC_120.L_CORE X_NUC_154.L_CORE 0.001653
K_19313 X_NUC_120.L_CORE X_NUC_155.L_CORE 0.001648
K_19314 X_NUC_120.L_CORE X_NUC_156.L_CORE 0.001660
K_19315 X_NUC_120.L_CORE X_NUC_157.L_CORE 0.002669
K_19316 X_NUC_120.L_CORE X_NUC_158.L_CORE 0.002678
K_19317 X_NUC_120.L_CORE X_NUC_159.L_CORE 0.002648
K_19318 X_NUC_120.L_CORE X_NUC_160.L_CORE 0.002676
K_19319 X_NUC_120.L_CORE X_NUC_161.L_CORE 0.002514
K_19320 X_NUC_120.L_CORE X_NUC_162.L_CORE 0.002495
K_19321 X_NUC_120.L_CORE X_NUC_163.L_CORE 0.002485
K_19322 X_NUC_120.L_CORE X_NUC_164.L_CORE 0.002503
K_19323 X_NUC_120.L_CORE X_NUC_165.L_CORE 0.001889
K_19324 X_NUC_120.L_CORE X_NUC_166.L_CORE 0.001886
K_19325 X_NUC_120.L_CORE X_NUC_167.L_CORE 0.001875
K_19326 X_NUC_120.L_CORE X_NUC_168.L_CORE 0.001891
K_19327 X_NUC_120.L_CORE X_NUC_169.L_CORE 0.002775
K_19328 X_NUC_120.L_CORE X_NUC_170.L_CORE 0.002768
K_19329 X_NUC_120.L_CORE X_NUC_171.L_CORE 0.002742
K_19330 X_NUC_120.L_CORE X_NUC_172.L_CORE 0.002769
K_19331 X_NUC_120.L_CORE X_NUC_173.L_CORE 0.001608
K_19332 X_NUC_120.L_CORE X_NUC_174.L_CORE 0.001461
K_19333 X_NUC_120.L_CORE X_NUC_175.L_CORE 0.001444
K_19334 X_NUC_120.L_CORE X_NUC_176.L_CORE 0.001868
K_19335 X_NUC_120.L_CORE X_NUC_177.L_CORE 0.001311
K_19336 X_NUC_120.L_CORE X_NUC_178.L_CORE 0.001760
K_19337 X_NUC_120.L_CORE X_NUC_179.L_CORE 0.001653
K_19338 X_NUC_120.L_CORE X_NUC_180.L_CORE 0.001313
K_19339 X_NUC_120.L_CORE X_NUC_181.L_CORE 0.002362
K_19340 X_NUC_120.L_CORE X_NUC_182.L_CORE 0.001354
K_19341 X_NUC_120.L_CORE X_NUC_183.L_CORE 0.001576
K_19342 X_NUC_120.L_CORE X_NUC_184.L_CORE 0.002190
K_19343 X_NUC_120.L_CORE X_NUC_185.L_CORE 0.001251
K_19344 X_NUC_120.L_CORE X_NUC_186.L_CORE 0.002390
K_19345 X_NUC_120.L_CORE X_NUC_187.L_CORE 0.001569
K_19346 X_NUC_120.L_CORE X_NUC_188.L_CORE 0.001379
K_19347 X_NUC_120.L_CORE X_NUC_189.L_CORE 0.003353
K_19348 X_NUC_120.L_CORE X_NUC_190.L_CORE 0.001288
K_19349 X_NUC_120.L_CORE X_NUC_191.L_CORE 0.001934
K_19350 X_NUC_120.L_CORE X_NUC_192.L_CORE 0.002111
K_19351 X_NUC_120.L_CORE X_NUC_193.L_CORE 0.001276
K_19352 X_NUC_120.L_CORE X_NUC_194.L_CORE 0.004022
K_19353 X_NUC_120.L_CORE X_NUC_195.L_CORE 0.001460
K_19354 X_NUC_120.L_CORE X_NUC_196.L_CORE 0.001569
K_19355 X_NUC_120.L_CORE X_NUC_197.L_CORE 0.003710
K_19356 X_NUC_120.L_CORE X_NUC_198.L_CORE 0.001278
K_19357 X_NUC_120.L_CORE X_NUC_199.L_CORE 0.002731
K_19358 X_NUC_120.L_CORE X_NUC_200.L_CORE 0.001880
K_19359 X_NUC_120.L_CORE X_NUC_201.L_CORE 0.001384
K_19360 X_NUC_120.L_CORE X_NUC_202.L_CORE 0.011699
K_19361 X_NUC_120.L_CORE X_NUC_203.L_CORE 0.001402
K_19362 X_NUC_120.L_CORE X_NUC_204.L_CORE 0.001940
K_19363 X_NUC_120.L_CORE X_NUC_205.L_CORE 0.002982
K_19364 X_NUC_120.L_CORE X_NUC_206.L_CORE 0.001341
K_19365 X_NUC_120.L_CORE X_NUC_207.L_CORE 0.004763
K_19366 X_NUC_120.L_CORE X_NUC_208.L_CORE 0.001713
K_19367 X_NUC_120.L_CORE X_NUC_209.L_CORE 0.001604
K_19368 X_NUC_120.L_CORE X_NUC_210.L_CORE 0.007181
K_19369 X_NUC_120.L_CORE X_NUC_211.L_CORE 0.001431
K_19370 X_NUC_120.L_CORE X_NUC_212.L_CORE 0.002585
K_19371 X_NUC_120.L_CORE X_NUC_213.L_CORE 0.002378
K_19372 X_NUC_120.L_CORE X_NUC_214.L_CORE 0.001514
K_19373 X_NUC_120.L_CORE X_NUC_215.L_CORE 0.005756
K_19374 X_NUC_120.L_CORE X_NUC_216.L_CORE 0.001696
K_19375 X_NUC_120.L_CORE X_NUC_217.L_CORE 0.001991
K_19376 X_NUC_120.L_CORE X_NUC_218.L_CORE 0.003283
K_19377 X_NUC_120.L_CORE X_NUC_219.L_CORE 0.001644
K_19378 X_NUC_120.L_CORE X_NUC_220.L_CORE 0.002864
K_19379 X_NUC_120.L_CORE X_NUC_221.L_CORE 0.002165
K_19380 X_NUC_120.L_CORE X_NUC_222.L_CORE 0.002033
K_19381 X_NUC_121.L_CORE X_NUC_122.L_CORE 0.207973
K_19382 X_NUC_121.L_CORE X_NUC_123.L_CORE 0.207973
K_19383 X_NUC_121.L_CORE X_NUC_124.L_CORE 0.207973
K_19384 X_NUC_121.L_CORE X_NUC_125.L_CORE 0.001557
K_19385 X_NUC_121.L_CORE X_NUC_126.L_CORE 0.001569
K_19386 X_NUC_121.L_CORE X_NUC_127.L_CORE 0.001564
K_19387 X_NUC_121.L_CORE X_NUC_128.L_CORE 0.001562
K_19388 X_NUC_121.L_CORE X_NUC_129.L_CORE 0.002174
K_19389 X_NUC_121.L_CORE X_NUC_130.L_CORE 0.002179
K_19390 X_NUC_121.L_CORE X_NUC_131.L_CORE 0.002186
K_19391 X_NUC_121.L_CORE X_NUC_132.L_CORE 0.002164
K_19392 X_NUC_121.L_CORE X_NUC_133.L_CORE 0.003318
K_19393 X_NUC_121.L_CORE X_NUC_134.L_CORE 0.003365
K_19394 X_NUC_121.L_CORE X_NUC_135.L_CORE 0.003322
K_19395 X_NUC_121.L_CORE X_NUC_136.L_CORE 0.003347
K_19396 X_NUC_121.L_CORE X_NUC_137.L_CORE 0.001524
K_19397 X_NUC_121.L_CORE X_NUC_138.L_CORE 0.001533
K_19398 X_NUC_121.L_CORE X_NUC_139.L_CORE 0.001531
K_19399 X_NUC_121.L_CORE X_NUC_140.L_CORE 0.001525
K_19400 X_NUC_121.L_CORE X_NUC_141.L_CORE 0.004821
K_19401 X_NUC_121.L_CORE X_NUC_142.L_CORE 0.004825
K_19402 X_NUC_121.L_CORE X_NUC_143.L_CORE 0.004839
K_19403 X_NUC_121.L_CORE X_NUC_144.L_CORE 0.004740
K_19404 X_NUC_121.L_CORE X_NUC_145.L_CORE 0.001966
K_19405 X_NUC_121.L_CORE X_NUC_146.L_CORE 0.001985
K_19406 X_NUC_121.L_CORE X_NUC_147.L_CORE 0.001972
K_19407 X_NUC_121.L_CORE X_NUC_148.L_CORE 0.001973
K_19408 X_NUC_121.L_CORE X_NUC_149.L_CORE 0.001871
K_19409 X_NUC_121.L_CORE X_NUC_150.L_CORE 0.001880
K_19410 X_NUC_121.L_CORE X_NUC_151.L_CORE 0.001880
K_19411 X_NUC_121.L_CORE X_NUC_152.L_CORE 0.001866
K_19412 X_NUC_121.L_CORE X_NUC_153.L_CORE 0.004806
K_19413 X_NUC_121.L_CORE X_NUC_154.L_CORE 0.004888
K_19414 X_NUC_121.L_CORE X_NUC_155.L_CORE 0.004790
K_19415 X_NUC_121.L_CORE X_NUC_156.L_CORE 0.004793
K_19416 X_NUC_121.L_CORE X_NUC_157.L_CORE 0.001749
K_19417 X_NUC_121.L_CORE X_NUC_158.L_CORE 0.001762
K_19418 X_NUC_121.L_CORE X_NUC_159.L_CORE 0.001755
K_19419 X_NUC_121.L_CORE X_NUC_160.L_CORE 0.001750
K_19420 X_NUC_121.L_CORE X_NUC_161.L_CORE 0.002745
K_19421 X_NUC_121.L_CORE X_NUC_162.L_CORE 0.002760
K_19422 X_NUC_121.L_CORE X_NUC_163.L_CORE 0.002754
K_19423 X_NUC_121.L_CORE X_NUC_164.L_CORE 0.002726
K_19424 X_NUC_121.L_CORE X_NUC_165.L_CORE 0.002576
K_19425 X_NUC_121.L_CORE X_NUC_166.L_CORE 0.002604
K_19426 X_NUC_121.L_CORE X_NUC_167.L_CORE 0.002580
K_19427 X_NUC_121.L_CORE X_NUC_168.L_CORE 0.002577
K_19428 X_NUC_121.L_CORE X_NUC_169.L_CORE 0.002113
K_19429 X_NUC_121.L_CORE X_NUC_170.L_CORE 0.002128
K_19430 X_NUC_121.L_CORE X_NUC_171.L_CORE 0.002119
K_19431 X_NUC_121.L_CORE X_NUC_172.L_CORE 0.002108
K_19432 X_NUC_121.L_CORE X_NUC_173.L_CORE 0.001411
K_19433 X_NUC_121.L_CORE X_NUC_174.L_CORE 0.001679
K_19434 X_NUC_121.L_CORE X_NUC_175.L_CORE 0.001446
K_19435 X_NUC_121.L_CORE X_NUC_176.L_CORE 0.001432
K_19436 X_NUC_121.L_CORE X_NUC_177.L_CORE 0.001904
K_19437 X_NUC_121.L_CORE X_NUC_178.L_CORE 0.001300
K_19438 X_NUC_121.L_CORE X_NUC_179.L_CORE 0.001769
K_19439 X_NUC_121.L_CORE X_NUC_180.L_CORE 0.001658
K_19440 X_NUC_121.L_CORE X_NUC_181.L_CORE 0.001311
K_19441 X_NUC_121.L_CORE X_NUC_182.L_CORE 0.002385
K_19442 X_NUC_121.L_CORE X_NUC_183.L_CORE 0.001357
K_19443 X_NUC_121.L_CORE X_NUC_184.L_CORE 0.001580
K_19444 X_NUC_121.L_CORE X_NUC_185.L_CORE 0.002202
K_19445 X_NUC_121.L_CORE X_NUC_186.L_CORE 0.001257
K_19446 X_NUC_121.L_CORE X_NUC_187.L_CORE 0.002398
K_19447 X_NUC_121.L_CORE X_NUC_188.L_CORE 0.001580
K_19448 X_NUC_121.L_CORE X_NUC_189.L_CORE 0.001389
K_19449 X_NUC_121.L_CORE X_NUC_190.L_CORE 0.003354
K_19450 X_NUC_121.L_CORE X_NUC_191.L_CORE 0.001300
K_19451 X_NUC_121.L_CORE X_NUC_192.L_CORE 0.001948
K_19452 X_NUC_121.L_CORE X_NUC_193.L_CORE 0.002130
K_19453 X_NUC_121.L_CORE X_NUC_194.L_CORE 0.001292
K_19454 X_NUC_121.L_CORE X_NUC_195.L_CORE 0.004008
K_19455 X_NUC_121.L_CORE X_NUC_196.L_CORE 0.001480
K_19456 X_NUC_121.L_CORE X_NUC_197.L_CORE 0.001590
K_19457 X_NUC_121.L_CORE X_NUC_198.L_CORE 0.003734
K_19458 X_NUC_121.L_CORE X_NUC_199.L_CORE 0.001300
K_19459 X_NUC_121.L_CORE X_NUC_200.L_CORE 0.002763
K_19460 X_NUC_121.L_CORE X_NUC_201.L_CORE 0.001914
K_19461 X_NUC_121.L_CORE X_NUC_202.L_CORE 0.001410
K_19462 X_NUC_121.L_CORE X_NUC_203.L_CORE 0.011221
K_19463 X_NUC_121.L_CORE X_NUC_204.L_CORE 0.001433
K_19464 X_NUC_121.L_CORE X_NUC_205.L_CORE 0.001981
K_19465 X_NUC_121.L_CORE X_NUC_206.L_CORE 0.003053
K_19466 X_NUC_121.L_CORE X_NUC_207.L_CORE 0.001374
K_19467 X_NUC_121.L_CORE X_NUC_208.L_CORE 0.004859
K_19468 X_NUC_121.L_CORE X_NUC_209.L_CORE 0.001762
K_19469 X_NUC_121.L_CORE X_NUC_210.L_CORE 0.001651
K_19470 X_NUC_121.L_CORE X_NUC_211.L_CORE 0.007332
K_19471 X_NUC_121.L_CORE X_NUC_212.L_CORE 0.001479
K_19472 X_NUC_121.L_CORE X_NUC_213.L_CORE 0.002666
K_19473 X_NUC_121.L_CORE X_NUC_214.L_CORE 0.002462
K_19474 X_NUC_121.L_CORE X_NUC_215.L_CORE 0.001575
K_19475 X_NUC_121.L_CORE X_NUC_216.L_CORE 0.005671
K_19476 X_NUC_121.L_CORE X_NUC_217.L_CORE 0.001775
K_19477 X_NUC_121.L_CORE X_NUC_218.L_CORE 0.002081
K_19478 X_NUC_121.L_CORE X_NUC_219.L_CORE 0.003306
K_19479 X_NUC_121.L_CORE X_NUC_220.L_CORE 0.001757
K_19480 X_NUC_121.L_CORE X_NUC_221.L_CORE 0.002838
K_19481 X_NUC_121.L_CORE X_NUC_222.L_CORE 0.002291
K_19482 X_NUC_122.L_CORE X_NUC_123.L_CORE 0.207973
K_19483 X_NUC_122.L_CORE X_NUC_124.L_CORE 0.207973
K_19484 X_NUC_122.L_CORE X_NUC_125.L_CORE 0.001546
K_19485 X_NUC_122.L_CORE X_NUC_126.L_CORE 0.001557
K_19486 X_NUC_122.L_CORE X_NUC_127.L_CORE 0.001552
K_19487 X_NUC_122.L_CORE X_NUC_128.L_CORE 0.001550
K_19488 X_NUC_122.L_CORE X_NUC_129.L_CORE 0.002168
K_19489 X_NUC_122.L_CORE X_NUC_130.L_CORE 0.002174
K_19490 X_NUC_122.L_CORE X_NUC_131.L_CORE 0.002180
K_19491 X_NUC_122.L_CORE X_NUC_132.L_CORE 0.002159
K_19492 X_NUC_122.L_CORE X_NUC_133.L_CORE 0.003273
K_19493 X_NUC_122.L_CORE X_NUC_134.L_CORE 0.003318
K_19494 X_NUC_122.L_CORE X_NUC_135.L_CORE 0.003277
K_19495 X_NUC_122.L_CORE X_NUC_136.L_CORE 0.003301
K_19496 X_NUC_122.L_CORE X_NUC_137.L_CORE 0.001515
K_19497 X_NUC_122.L_CORE X_NUC_138.L_CORE 0.001524
K_19498 X_NUC_122.L_CORE X_NUC_139.L_CORE 0.001522
K_19499 X_NUC_122.L_CORE X_NUC_140.L_CORE 0.001516
K_19500 X_NUC_122.L_CORE X_NUC_141.L_CORE 0.004814
K_19501 X_NUC_122.L_CORE X_NUC_142.L_CORE 0.004821
K_19502 X_NUC_122.L_CORE X_NUC_143.L_CORE 0.004833
K_19503 X_NUC_122.L_CORE X_NUC_144.L_CORE 0.004735
K_19504 X_NUC_122.L_CORE X_NUC_145.L_CORE 0.001948
K_19505 X_NUC_122.L_CORE X_NUC_146.L_CORE 0.001966
K_19506 X_NUC_122.L_CORE X_NUC_147.L_CORE 0.001954
K_19507 X_NUC_122.L_CORE X_NUC_148.L_CORE 0.001955
K_19508 X_NUC_122.L_CORE X_NUC_149.L_CORE 0.001862
K_19509 X_NUC_122.L_CORE X_NUC_150.L_CORE 0.001871
K_19510 X_NUC_122.L_CORE X_NUC_151.L_CORE 0.001871
K_19511 X_NUC_122.L_CORE X_NUC_152.L_CORE 0.001857
K_19512 X_NUC_122.L_CORE X_NUC_153.L_CORE 0.004726
K_19513 X_NUC_122.L_CORE X_NUC_154.L_CORE 0.004806
K_19514 X_NUC_122.L_CORE X_NUC_155.L_CORE 0.004712
K_19515 X_NUC_122.L_CORE X_NUC_156.L_CORE 0.004715
K_19516 X_NUC_122.L_CORE X_NUC_157.L_CORE 0.001736
K_19517 X_NUC_122.L_CORE X_NUC_158.L_CORE 0.001749
K_19518 X_NUC_122.L_CORE X_NUC_159.L_CORE 0.001742
K_19519 X_NUC_122.L_CORE X_NUC_160.L_CORE 0.001737
K_19520 X_NUC_122.L_CORE X_NUC_161.L_CORE 0.002730
K_19521 X_NUC_122.L_CORE X_NUC_162.L_CORE 0.002745
K_19522 X_NUC_122.L_CORE X_NUC_163.L_CORE 0.002738
K_19523 X_NUC_122.L_CORE X_NUC_164.L_CORE 0.002711
K_19524 X_NUC_122.L_CORE X_NUC_165.L_CORE 0.002549
K_19525 X_NUC_122.L_CORE X_NUC_166.L_CORE 0.002576
K_19526 X_NUC_122.L_CORE X_NUC_167.L_CORE 0.002553
K_19527 X_NUC_122.L_CORE X_NUC_168.L_CORE 0.002550
K_19528 X_NUC_122.L_CORE X_NUC_169.L_CORE 0.002097
K_19529 X_NUC_122.L_CORE X_NUC_170.L_CORE 0.002113
K_19530 X_NUC_122.L_CORE X_NUC_171.L_CORE 0.002104
K_19531 X_NUC_122.L_CORE X_NUC_172.L_CORE 0.002093
K_19532 X_NUC_122.L_CORE X_NUC_173.L_CORE 0.001406
K_19533 X_NUC_122.L_CORE X_NUC_174.L_CORE 0.001675
K_19534 X_NUC_122.L_CORE X_NUC_175.L_CORE 0.001440
K_19535 X_NUC_122.L_CORE X_NUC_176.L_CORE 0.001428
K_19536 X_NUC_122.L_CORE X_NUC_177.L_CORE 0.001898
K_19537 X_NUC_122.L_CORE X_NUC_178.L_CORE 0.001294
K_19538 X_NUC_122.L_CORE X_NUC_179.L_CORE 0.001768
K_19539 X_NUC_122.L_CORE X_NUC_180.L_CORE 0.001649
K_19540 X_NUC_122.L_CORE X_NUC_181.L_CORE 0.001306
K_19541 X_NUC_122.L_CORE X_NUC_182.L_CORE 0.002385
K_19542 X_NUC_122.L_CORE X_NUC_183.L_CORE 0.001349
K_19543 X_NUC_122.L_CORE X_NUC_184.L_CORE 0.001577
K_19544 X_NUC_122.L_CORE X_NUC_185.L_CORE 0.002191
K_19545 X_NUC_122.L_CORE X_NUC_186.L_CORE 0.001251
K_19546 X_NUC_122.L_CORE X_NUC_187.L_CORE 0.002403
K_19547 X_NUC_122.L_CORE X_NUC_188.L_CORE 0.001570
K_19548 X_NUC_122.L_CORE X_NUC_189.L_CORE 0.001384
K_19549 X_NUC_122.L_CORE X_NUC_190.L_CORE 0.003352
K_19550 X_NUC_122.L_CORE X_NUC_191.L_CORE 0.001293
K_19551 X_NUC_122.L_CORE X_NUC_192.L_CORE 0.001948
K_19552 X_NUC_122.L_CORE X_NUC_193.L_CORE 0.002115
K_19553 X_NUC_122.L_CORE X_NUC_194.L_CORE 0.001286
K_19554 X_NUC_122.L_CORE X_NUC_195.L_CORE 0.004041
K_19555 X_NUC_122.L_CORE X_NUC_196.L_CORE 0.001470
K_19556 X_NUC_122.L_CORE X_NUC_197.L_CORE 0.001586
K_19557 X_NUC_122.L_CORE X_NUC_198.L_CORE 0.003707
K_19558 X_NUC_122.L_CORE X_NUC_199.L_CORE 0.001293
K_19559 X_NUC_122.L_CORE X_NUC_200.L_CORE 0.002771
K_19560 X_NUC_122.L_CORE X_NUC_201.L_CORE 0.001898
K_19561 X_NUC_122.L_CORE X_NUC_202.L_CORE 0.001405
K_19562 X_NUC_122.L_CORE X_NUC_203.L_CORE 0.011563
K_19563 X_NUC_122.L_CORE X_NUC_204.L_CORE 0.001423
K_19564 X_NUC_122.L_CORE X_NUC_205.L_CORE 0.001978
K_19565 X_NUC_122.L_CORE X_NUC_206.L_CORE 0.003019
K_19566 X_NUC_122.L_CORE X_NUC_207.L_CORE 0.001367
K_19567 X_NUC_122.L_CORE X_NUC_208.L_CORE 0.004900
K_19568 X_NUC_122.L_CORE X_NUC_209.L_CORE 0.001747
K_19569 X_NUC_122.L_CORE X_NUC_210.L_CORE 0.001645
K_19570 X_NUC_122.L_CORE X_NUC_211.L_CORE 0.007187
K_19571 X_NUC_122.L_CORE X_NUC_212.L_CORE 0.001469
K_19572 X_NUC_122.L_CORE X_NUC_213.L_CORE 0.002663
K_19573 X_NUC_122.L_CORE X_NUC_214.L_CORE 0.002436
K_19574 X_NUC_122.L_CORE X_NUC_215.L_CORE 0.001567
K_19575 X_NUC_122.L_CORE X_NUC_216.L_CORE 0.005640
K_19576 X_NUC_122.L_CORE X_NUC_217.L_CORE 0.001760
K_19577 X_NUC_122.L_CORE X_NUC_218.L_CORE 0.002072
K_19578 X_NUC_122.L_CORE X_NUC_219.L_CORE 0.003267
K_19579 X_NUC_122.L_CORE X_NUC_220.L_CORE 0.001745
K_19580 X_NUC_122.L_CORE X_NUC_221.L_CORE 0.002820
K_19581 X_NUC_122.L_CORE X_NUC_222.L_CORE 0.002271
K_19582 X_NUC_123.L_CORE X_NUC_124.L_CORE 0.207973
K_19583 X_NUC_123.L_CORE X_NUC_125.L_CORE 0.001551
K_19584 X_NUC_123.L_CORE X_NUC_126.L_CORE 0.001562
K_19585 X_NUC_123.L_CORE X_NUC_127.L_CORE 0.001557
K_19586 X_NUC_123.L_CORE X_NUC_128.L_CORE 0.001555
K_19587 X_NUC_123.L_CORE X_NUC_129.L_CORE 0.002161
K_19588 X_NUC_123.L_CORE X_NUC_130.L_CORE 0.002166
K_19589 X_NUC_123.L_CORE X_NUC_131.L_CORE 0.002174
K_19590 X_NUC_123.L_CORE X_NUC_132.L_CORE 0.002152
K_19591 X_NUC_123.L_CORE X_NUC_133.L_CORE 0.003314
K_19592 X_NUC_123.L_CORE X_NUC_134.L_CORE 0.003361
K_19593 X_NUC_123.L_CORE X_NUC_135.L_CORE 0.003318
K_19594 X_NUC_123.L_CORE X_NUC_136.L_CORE 0.003343
K_19595 X_NUC_123.L_CORE X_NUC_137.L_CORE 0.001517
K_19596 X_NUC_123.L_CORE X_NUC_138.L_CORE 0.001526
K_19597 X_NUC_123.L_CORE X_NUC_139.L_CORE 0.001524
K_19598 X_NUC_123.L_CORE X_NUC_140.L_CORE 0.001518
K_19599 X_NUC_123.L_CORE X_NUC_141.L_CORE 0.004801
K_19600 X_NUC_123.L_CORE X_NUC_142.L_CORE 0.004806
K_19601 X_NUC_123.L_CORE X_NUC_143.L_CORE 0.004821
K_19602 X_NUC_123.L_CORE X_NUC_144.L_CORE 0.004722
K_19603 X_NUC_123.L_CORE X_NUC_145.L_CORE 0.001960
K_19604 X_NUC_123.L_CORE X_NUC_146.L_CORE 0.001979
K_19605 X_NUC_123.L_CORE X_NUC_147.L_CORE 0.001966
K_19606 X_NUC_123.L_CORE X_NUC_148.L_CORE 0.001967
K_19607 X_NUC_123.L_CORE X_NUC_149.L_CORE 0.001863
K_19608 X_NUC_123.L_CORE X_NUC_150.L_CORE 0.001872
K_19609 X_NUC_123.L_CORE X_NUC_151.L_CORE 0.001871
K_19610 X_NUC_123.L_CORE X_NUC_152.L_CORE 0.001858
K_19611 X_NUC_123.L_CORE X_NUC_153.L_CORE 0.004820
K_19612 X_NUC_123.L_CORE X_NUC_154.L_CORE 0.004904
K_19613 X_NUC_123.L_CORE X_NUC_155.L_CORE 0.004806
K_19614 X_NUC_123.L_CORE X_NUC_156.L_CORE 0.004808
K_19615 X_NUC_123.L_CORE X_NUC_157.L_CORE 0.001742
K_19616 X_NUC_123.L_CORE X_NUC_158.L_CORE 0.001756
K_19617 X_NUC_123.L_CORE X_NUC_159.L_CORE 0.001749
K_19618 X_NUC_123.L_CORE X_NUC_160.L_CORE 0.001743
K_19619 X_NUC_123.L_CORE X_NUC_161.L_CORE 0.002736
K_19620 X_NUC_123.L_CORE X_NUC_162.L_CORE 0.002751
K_19621 X_NUC_123.L_CORE X_NUC_163.L_CORE 0.002745
K_19622 X_NUC_123.L_CORE X_NUC_164.L_CORE 0.002718
K_19623 X_NUC_123.L_CORE X_NUC_165.L_CORE 0.002572
K_19624 X_NUC_123.L_CORE X_NUC_166.L_CORE 0.002600
K_19625 X_NUC_123.L_CORE X_NUC_167.L_CORE 0.002576
K_19626 X_NUC_123.L_CORE X_NUC_168.L_CORE 0.002573
K_19627 X_NUC_123.L_CORE X_NUC_169.L_CORE 0.002106
K_19628 X_NUC_123.L_CORE X_NUC_170.L_CORE 0.002122
K_19629 X_NUC_123.L_CORE X_NUC_171.L_CORE 0.002113
K_19630 X_NUC_123.L_CORE X_NUC_172.L_CORE 0.002101
K_19631 X_NUC_123.L_CORE X_NUC_173.L_CORE 0.001402
K_19632 X_NUC_123.L_CORE X_NUC_174.L_CORE 0.001667
K_19633 X_NUC_123.L_CORE X_NUC_175.L_CORE 0.001437
K_19634 X_NUC_123.L_CORE X_NUC_176.L_CORE 0.001422
K_19635 X_NUC_123.L_CORE X_NUC_177.L_CORE 0.001890
K_19636 X_NUC_123.L_CORE X_NUC_178.L_CORE 0.001293
K_19637 X_NUC_123.L_CORE X_NUC_179.L_CORE 0.001756
K_19638 X_NUC_123.L_CORE X_NUC_180.L_CORE 0.001648
K_19639 X_NUC_123.L_CORE X_NUC_181.L_CORE 0.001303
K_19640 X_NUC_123.L_CORE X_NUC_182.L_CORE 0.002365
K_19641 X_NUC_123.L_CORE X_NUC_183.L_CORE 0.001349
K_19642 X_NUC_123.L_CORE X_NUC_184.L_CORE 0.001569
K_19643 X_NUC_123.L_CORE X_NUC_185.L_CORE 0.002188
K_19644 X_NUC_123.L_CORE X_NUC_186.L_CORE 0.001250
K_19645 X_NUC_123.L_CORE X_NUC_187.L_CORE 0.002377
K_19646 X_NUC_123.L_CORE X_NUC_188.L_CORE 0.001572
K_19647 X_NUC_123.L_CORE X_NUC_189.L_CORE 0.001380
K_19648 X_NUC_123.L_CORE X_NUC_190.L_CORE 0.003325
K_19649 X_NUC_123.L_CORE X_NUC_191.L_CORE 0.001294
K_19650 X_NUC_123.L_CORE X_NUC_192.L_CORE 0.001934
K_19651 X_NUC_123.L_CORE X_NUC_193.L_CORE 0.002120
K_19652 X_NUC_123.L_CORE X_NUC_194.L_CORE 0.001285
K_19653 X_NUC_123.L_CORE X_NUC_195.L_CORE 0.003965
K_19654 X_NUC_123.L_CORE X_NUC_196.L_CORE 0.001473
K_19655 X_NUC_123.L_CORE X_NUC_197.L_CORE 0.001580
K_19656 X_NUC_123.L_CORE X_NUC_198.L_CORE 0.003718
K_19657 X_NUC_123.L_CORE X_NUC_199.L_CORE 0.001293
K_19658 X_NUC_123.L_CORE X_NUC_200.L_CORE 0.002742
K_19659 X_NUC_123.L_CORE X_NUC_201.L_CORE 0.001907
K_19660 X_NUC_123.L_CORE X_NUC_202.L_CORE 0.001403
K_19661 X_NUC_123.L_CORE X_NUC_203.L_CORE 0.011146
K_19662 X_NUC_123.L_CORE X_NUC_204.L_CORE 0.001427
K_19663 X_NUC_123.L_CORE X_NUC_205.L_CORE 0.001969
K_19664 X_NUC_123.L_CORE X_NUC_206.L_CORE 0.003048
K_19665 X_NUC_123.L_CORE X_NUC_207.L_CORE 0.001368
K_19666 X_NUC_123.L_CORE X_NUC_208.L_CORE 0.004832
K_19667 X_NUC_123.L_CORE X_NUC_209.L_CORE 0.001756
K_19668 X_NUC_123.L_CORE X_NUC_210.L_CORE 0.001643
K_19669 X_NUC_123.L_CORE X_NUC_211.L_CORE 0.007432
K_19670 X_NUC_123.L_CORE X_NUC_212.L_CORE 0.001473
K_19671 X_NUC_123.L_CORE X_NUC_213.L_CORE 0.002654
K_19672 X_NUC_123.L_CORE X_NUC_214.L_CORE 0.002459
K_19673 X_NUC_123.L_CORE X_NUC_215.L_CORE 0.001569
K_19674 X_NUC_123.L_CORE X_NUC_216.L_CORE 0.005707
K_19675 X_NUC_123.L_CORE X_NUC_217.L_CORE 0.001770
K_19676 X_NUC_123.L_CORE X_NUC_218.L_CORE 0.002073
K_19677 X_NUC_123.L_CORE X_NUC_219.L_CORE 0.003313
K_19678 X_NUC_123.L_CORE X_NUC_220.L_CORE 0.001752
K_19679 X_NUC_123.L_CORE X_NUC_221.L_CORE 0.002835
K_19680 X_NUC_123.L_CORE X_NUC_222.L_CORE 0.002288
K_19681 X_NUC_124.L_CORE X_NUC_125.L_CORE 0.001553
K_19682 X_NUC_124.L_CORE X_NUC_126.L_CORE 0.001564
K_19683 X_NUC_124.L_CORE X_NUC_127.L_CORE 0.001559
K_19684 X_NUC_124.L_CORE X_NUC_128.L_CORE 0.001557
K_19685 X_NUC_124.L_CORE X_NUC_129.L_CORE 0.002183
K_19686 X_NUC_124.L_CORE X_NUC_130.L_CORE 0.002189
K_19687 X_NUC_124.L_CORE X_NUC_131.L_CORE 0.002196
K_19688 X_NUC_124.L_CORE X_NUC_132.L_CORE 0.002174
K_19689 X_NUC_124.L_CORE X_NUC_133.L_CORE 0.003290
K_19690 X_NUC_124.L_CORE X_NUC_134.L_CORE 0.003335
K_19691 X_NUC_124.L_CORE X_NUC_135.L_CORE 0.003294
K_19692 X_NUC_124.L_CORE X_NUC_136.L_CORE 0.003318
K_19693 X_NUC_124.L_CORE X_NUC_137.L_CORE 0.001524
K_19694 X_NUC_124.L_CORE X_NUC_138.L_CORE 0.001533
K_19695 X_NUC_124.L_CORE X_NUC_139.L_CORE 0.001531
K_19696 X_NUC_124.L_CORE X_NUC_140.L_CORE 0.001524
K_19697 X_NUC_124.L_CORE X_NUC_141.L_CORE 0.004903
K_19698 X_NUC_124.L_CORE X_NUC_142.L_CORE 0.004909
K_19699 X_NUC_124.L_CORE X_NUC_143.L_CORE 0.004924
K_19700 X_NUC_124.L_CORE X_NUC_144.L_CORE 0.004821
K_19701 X_NUC_124.L_CORE X_NUC_145.L_CORE 0.001960
K_19702 X_NUC_124.L_CORE X_NUC_146.L_CORE 0.001978
K_19703 X_NUC_124.L_CORE X_NUC_147.L_CORE 0.001966
K_19704 X_NUC_124.L_CORE X_NUC_148.L_CORE 0.001966
K_19705 X_NUC_124.L_CORE X_NUC_149.L_CORE 0.001876
K_19706 X_NUC_124.L_CORE X_NUC_150.L_CORE 0.001886
K_19707 X_NUC_124.L_CORE X_NUC_151.L_CORE 0.001885
K_19708 X_NUC_124.L_CORE X_NUC_152.L_CORE 0.001871
K_19709 X_NUC_124.L_CORE X_NUC_153.L_CORE 0.004817
K_19710 X_NUC_124.L_CORE X_NUC_154.L_CORE 0.004901
K_19711 X_NUC_124.L_CORE X_NUC_155.L_CORE 0.004802
K_19712 X_NUC_124.L_CORE X_NUC_156.L_CORE 0.004806
K_19713 X_NUC_124.L_CORE X_NUC_157.L_CORE 0.001748
K_19714 X_NUC_124.L_CORE X_NUC_158.L_CORE 0.001761
K_19715 X_NUC_124.L_CORE X_NUC_159.L_CORE 0.001754
K_19716 X_NUC_124.L_CORE X_NUC_160.L_CORE 0.001749
K_19717 X_NUC_124.L_CORE X_NUC_161.L_CORE 0.002764
K_19718 X_NUC_124.L_CORE X_NUC_162.L_CORE 0.002779
K_19719 X_NUC_124.L_CORE X_NUC_163.L_CORE 0.002773
K_19720 X_NUC_124.L_CORE X_NUC_164.L_CORE 0.002745
K_19721 X_NUC_124.L_CORE X_NUC_165.L_CORE 0.002575
K_19722 X_NUC_124.L_CORE X_NUC_166.L_CORE 0.002603
K_19723 X_NUC_124.L_CORE X_NUC_167.L_CORE 0.002579
K_19724 X_NUC_124.L_CORE X_NUC_168.L_CORE 0.002576
K_19725 X_NUC_124.L_CORE X_NUC_169.L_CORE 0.002117
K_19726 X_NUC_124.L_CORE X_NUC_170.L_CORE 0.002133
K_19727 X_NUC_124.L_CORE X_NUC_171.L_CORE 0.002124
K_19728 X_NUC_124.L_CORE X_NUC_172.L_CORE 0.002113
K_19729 X_NUC_124.L_CORE X_NUC_173.L_CORE 0.001405
K_19730 X_NUC_124.L_CORE X_NUC_174.L_CORE 0.001670
K_19731 X_NUC_124.L_CORE X_NUC_175.L_CORE 0.001438
K_19732 X_NUC_124.L_CORE X_NUC_176.L_CORE 0.001427
K_19733 X_NUC_124.L_CORE X_NUC_177.L_CORE 0.001889
K_19734 X_NUC_124.L_CORE X_NUC_178.L_CORE 0.001295
K_19735 X_NUC_124.L_CORE X_NUC_179.L_CORE 0.001764
K_19736 X_NUC_124.L_CORE X_NUC_180.L_CORE 0.001645
K_19737 X_NUC_124.L_CORE X_NUC_181.L_CORE 0.001307
K_19738 X_NUC_124.L_CORE X_NUC_182.L_CORE 0.002368
K_19739 X_NUC_124.L_CORE X_NUC_183.L_CORE 0.001350
K_19740 X_NUC_124.L_CORE X_NUC_184.L_CORE 0.001578
K_19741 X_NUC_124.L_CORE X_NUC_185.L_CORE 0.002179
K_19742 X_NUC_124.L_CORE X_NUC_186.L_CORE 0.001253
K_19743 X_NUC_124.L_CORE X_NUC_187.L_CORE 0.002393
K_19744 X_NUC_124.L_CORE X_NUC_188.L_CORE 0.001569
K_19745 X_NUC_124.L_CORE X_NUC_189.L_CORE 0.001387
K_19746 X_NUC_124.L_CORE X_NUC_190.L_CORE 0.003309
K_19747 X_NUC_124.L_CORE X_NUC_191.L_CORE 0.001296
K_19748 X_NUC_124.L_CORE X_NUC_192.L_CORE 0.001950
K_19749 X_NUC_124.L_CORE X_NUC_193.L_CORE 0.002109
K_19750 X_NUC_124.L_CORE X_NUC_194.L_CORE 0.001290
K_19751 X_NUC_124.L_CORE X_NUC_195.L_CORE 0.003996
K_19752 X_NUC_124.L_CORE X_NUC_196.L_CORE 0.001472
K_19753 X_NUC_124.L_CORE X_NUC_197.L_CORE 0.001591
K_19754 X_NUC_124.L_CORE X_NUC_198.L_CORE 0.003671
K_19755 X_NUC_124.L_CORE X_NUC_199.L_CORE 0.001297
K_19756 X_NUC_124.L_CORE X_NUC_200.L_CORE 0.002776
K_19757 X_NUC_124.L_CORE X_NUC_201.L_CORE 0.001900
K_19758 X_NUC_124.L_CORE X_NUC_202.L_CORE 0.001410
K_19759 X_NUC_124.L_CORE X_NUC_203.L_CORE 0.010964
K_19760 X_NUC_124.L_CORE X_NUC_204.L_CORE 0.001428
K_19761 X_NUC_124.L_CORE X_NUC_205.L_CORE 0.001988
K_19762 X_NUC_124.L_CORE X_NUC_206.L_CORE 0.003020
K_19763 X_NUC_124.L_CORE X_NUC_207.L_CORE 0.001373
K_19764 X_NUC_124.L_CORE X_NUC_208.L_CORE 0.004939
K_19765 X_NUC_124.L_CORE X_NUC_209.L_CORE 0.001754
K_19766 X_NUC_124.L_CORE X_NUC_210.L_CORE 0.001654
K_19767 X_NUC_124.L_CORE X_NUC_211.L_CORE 0.007255
K_19768 X_NUC_124.L_CORE X_NUC_212.L_CORE 0.001477
K_19769 X_NUC_124.L_CORE X_NUC_213.L_CORE 0.002687
K_19770 X_NUC_124.L_CORE X_NUC_214.L_CORE 0.002450
K_19771 X_NUC_124.L_CORE X_NUC_215.L_CORE 0.001577
K_19772 X_NUC_124.L_CORE X_NUC_216.L_CORE 0.005789
K_19773 X_NUC_124.L_CORE X_NUC_217.L_CORE 0.001772
K_19774 X_NUC_124.L_CORE X_NUC_218.L_CORE 0.002090
K_19775 X_NUC_124.L_CORE X_NUC_219.L_CORE 0.003308
K_19776 X_NUC_124.L_CORE X_NUC_220.L_CORE 0.001758
K_19777 X_NUC_124.L_CORE X_NUC_221.L_CORE 0.002859
K_19778 X_NUC_124.L_CORE X_NUC_222.L_CORE 0.002294
K_19779 X_NUC_125.L_CORE X_NUC_126.L_CORE 0.207973
K_19780 X_NUC_125.L_CORE X_NUC_127.L_CORE 0.207973
K_19781 X_NUC_125.L_CORE X_NUC_128.L_CORE 0.207973
K_19782 X_NUC_125.L_CORE X_NUC_129.L_CORE 0.001601
K_19783 X_NUC_125.L_CORE X_NUC_130.L_CORE 0.001591
K_19784 X_NUC_125.L_CORE X_NUC_131.L_CORE 0.001599
K_19785 X_NUC_125.L_CORE X_NUC_132.L_CORE 0.001592
K_19786 X_NUC_125.L_CORE X_NUC_133.L_CORE 0.002239
K_19787 X_NUC_125.L_CORE X_NUC_134.L_CORE 0.002219
K_19788 X_NUC_125.L_CORE X_NUC_135.L_CORE 0.002221
K_19789 X_NUC_125.L_CORE X_NUC_136.L_CORE 0.002234
K_19790 X_NUC_125.L_CORE X_NUC_137.L_CORE 0.003421
K_19791 X_NUC_125.L_CORE X_NUC_138.L_CORE 0.003401
K_19792 X_NUC_125.L_CORE X_NUC_139.L_CORE 0.003429
K_19793 X_NUC_125.L_CORE X_NUC_140.L_CORE 0.003378
K_19794 X_NUC_125.L_CORE X_NUC_141.L_CORE 0.001580
K_19795 X_NUC_125.L_CORE X_NUC_142.L_CORE 0.001568
K_19796 X_NUC_125.L_CORE X_NUC_143.L_CORE 0.001574
K_19797 X_NUC_125.L_CORE X_NUC_144.L_CORE 0.001572
K_19798 X_NUC_125.L_CORE X_NUC_145.L_CORE 0.004914
K_19799 X_NUC_125.L_CORE X_NUC_146.L_CORE 0.004837
K_19800 X_NUC_125.L_CORE X_NUC_147.L_CORE 0.004807
K_19801 X_NUC_125.L_CORE X_NUC_148.L_CORE 0.004873
K_19802 X_NUC_125.L_CORE X_NUC_149.L_CORE 0.002049
K_19803 X_NUC_125.L_CORE X_NUC_150.L_CORE 0.002035
K_19804 X_NUC_125.L_CORE X_NUC_151.L_CORE 0.002046
K_19805 X_NUC_125.L_CORE X_NUC_152.L_CORE 0.002032
K_19806 X_NUC_125.L_CORE X_NUC_153.L_CORE 0.001961
K_19807 X_NUC_125.L_CORE X_NUC_154.L_CORE 0.001943
K_19808 X_NUC_125.L_CORE X_NUC_155.L_CORE 0.001947
K_19809 X_NUC_125.L_CORE X_NUC_156.L_CORE 0.001951
K_19810 X_NUC_125.L_CORE X_NUC_157.L_CORE 0.004664
K_19811 X_NUC_125.L_CORE X_NUC_158.L_CORE 0.004604
K_19812 X_NUC_125.L_CORE X_NUC_159.L_CORE 0.004609
K_19813 X_NUC_125.L_CORE X_NUC_160.L_CORE 0.004562
K_19814 X_NUC_125.L_CORE X_NUC_161.L_CORE 0.001868
K_19815 X_NUC_125.L_CORE X_NUC_162.L_CORE 0.001853
K_19816 X_NUC_125.L_CORE X_NUC_163.L_CORE 0.001859
K_19817 X_NUC_125.L_CORE X_NUC_164.L_CORE 0.001854
K_19818 X_NUC_125.L_CORE X_NUC_165.L_CORE 0.002809
K_19819 X_NUC_125.L_CORE X_NUC_166.L_CORE 0.002777
K_19820 X_NUC_125.L_CORE X_NUC_167.L_CORE 0.002776
K_19821 X_NUC_125.L_CORE X_NUC_168.L_CORE 0.002783
K_19822 X_NUC_125.L_CORE X_NUC_169.L_CORE 0.002633
K_19823 X_NUC_125.L_CORE X_NUC_170.L_CORE 0.002608
K_19824 X_NUC_125.L_CORE X_NUC_171.L_CORE 0.002615
K_19825 X_NUC_125.L_CORE X_NUC_172.L_CORE 0.002602
K_19826 X_NUC_125.L_CORE X_NUC_173.L_CORE 0.001519
K_19827 X_NUC_125.L_CORE X_NUC_174.L_CORE 0.001346
K_19828 X_NUC_125.L_CORE X_NUC_175.L_CORE 0.001707
K_19829 X_NUC_125.L_CORE X_NUC_176.L_CORE 0.001421
K_19830 X_NUC_125.L_CORE X_NUC_177.L_CORE 0.001409
K_19831 X_NUC_125.L_CORE X_NUC_178.L_CORE 0.001912
K_19832 X_NUC_125.L_CORE X_NUC_179.L_CORE 0.001280
K_19833 X_NUC_125.L_CORE X_NUC_180.L_CORE 0.001761
K_19834 X_NUC_125.L_CORE X_NUC_181.L_CORE 0.001644
K_19835 X_NUC_125.L_CORE X_NUC_182.L_CORE 0.001297
K_19836 X_NUC_125.L_CORE X_NUC_183.L_CORE 0.002381
K_19837 X_NUC_125.L_CORE X_NUC_184.L_CORE 0.001345
K_19838 X_NUC_125.L_CORE X_NUC_185.L_CORE 0.001570
K_19839 X_NUC_125.L_CORE X_NUC_186.L_CORE 0.002188
K_19840 X_NUC_125.L_CORE X_NUC_187.L_CORE 0.001251
K_19841 X_NUC_125.L_CORE X_NUC_188.L_CORE 0.002386
K_19842 X_NUC_125.L_CORE X_NUC_189.L_CORE 0.001573
K_19843 X_NUC_125.L_CORE X_NUC_190.L_CORE 0.001386
K_19844 X_NUC_125.L_CORE X_NUC_191.L_CORE 0.003320
K_19845 X_NUC_125.L_CORE X_NUC_192.L_CORE 0.001300
K_19846 X_NUC_125.L_CORE X_NUC_193.L_CORE 0.001948
K_19847 X_NUC_125.L_CORE X_NUC_194.L_CORE 0.002125
K_19848 X_NUC_125.L_CORE X_NUC_195.L_CORE 0.001295
K_19849 X_NUC_125.L_CORE X_NUC_196.L_CORE 0.003978
K_19850 X_NUC_125.L_CORE X_NUC_197.L_CORE 0.001485
K_19851 X_NUC_125.L_CORE X_NUC_198.L_CORE 0.001598
K_19852 X_NUC_125.L_CORE X_NUC_199.L_CORE 0.003719
K_19853 X_NUC_125.L_CORE X_NUC_200.L_CORE 0.001309
K_19854 X_NUC_125.L_CORE X_NUC_201.L_CORE 0.002782
K_19855 X_NUC_125.L_CORE X_NUC_202.L_CORE 0.001927
K_19856 X_NUC_125.L_CORE X_NUC_203.L_CORE 0.001425
K_19857 X_NUC_125.L_CORE X_NUC_204.L_CORE 0.011078
K_19858 X_NUC_125.L_CORE X_NUC_205.L_CORE 0.001450
K_19859 X_NUC_125.L_CORE X_NUC_206.L_CORE 0.002010
K_19860 X_NUC_125.L_CORE X_NUC_207.L_CORE 0.003092
K_19861 X_NUC_125.L_CORE X_NUC_208.L_CORE 0.001397
K_19862 X_NUC_125.L_CORE X_NUC_209.L_CORE 0.004973
K_19863 X_NUC_125.L_CORE X_NUC_210.L_CORE 0.001795
K_19864 X_NUC_125.L_CORE X_NUC_211.L_CORE 0.001686
K_19865 X_NUC_125.L_CORE X_NUC_212.L_CORE 0.007459
K_19866 X_NUC_125.L_CORE X_NUC_213.L_CORE 0.001516
K_19867 X_NUC_125.L_CORE X_NUC_214.L_CORE 0.002737
K_19868 X_NUC_125.L_CORE X_NUC_215.L_CORE 0.002526
K_19869 X_NUC_125.L_CORE X_NUC_216.L_CORE 0.001628
K_19870 X_NUC_125.L_CORE X_NUC_217.L_CORE 0.005545
K_19871 X_NUC_125.L_CORE X_NUC_218.L_CORE 0.001846
K_19872 X_NUC_125.L_CORE X_NUC_219.L_CORE 0.002166
K_19873 X_NUC_125.L_CORE X_NUC_220.L_CORE 0.003268
K_19874 X_NUC_125.L_CORE X_NUC_221.L_CORE 0.001892
K_19875 X_NUC_125.L_CORE X_NUC_222.L_CORE 0.002705
K_19876 X_NUC_126.L_CORE X_NUC_127.L_CORE 0.207973
K_19877 X_NUC_126.L_CORE X_NUC_128.L_CORE 0.207973
K_19878 X_NUC_126.L_CORE X_NUC_129.L_CORE 0.001611
K_19879 X_NUC_126.L_CORE X_NUC_130.L_CORE 0.001601
K_19880 X_NUC_126.L_CORE X_NUC_131.L_CORE 0.001609
K_19881 X_NUC_126.L_CORE X_NUC_132.L_CORE 0.001602
K_19882 X_NUC_126.L_CORE X_NUC_133.L_CORE 0.002259
K_19883 X_NUC_126.L_CORE X_NUC_134.L_CORE 0.002239
K_19884 X_NUC_126.L_CORE X_NUC_135.L_CORE 0.002241
K_19885 X_NUC_126.L_CORE X_NUC_136.L_CORE 0.002254
K_19886 X_NUC_126.L_CORE X_NUC_137.L_CORE 0.003439
K_19887 X_NUC_126.L_CORE X_NUC_138.L_CORE 0.003421
K_19888 X_NUC_126.L_CORE X_NUC_139.L_CORE 0.003449
K_19889 X_NUC_126.L_CORE X_NUC_140.L_CORE 0.003397
K_19890 X_NUC_126.L_CORE X_NUC_141.L_CORE 0.001592
K_19891 X_NUC_126.L_CORE X_NUC_142.L_CORE 0.001580
K_19892 X_NUC_126.L_CORE X_NUC_143.L_CORE 0.001585
K_19893 X_NUC_126.L_CORE X_NUC_144.L_CORE 0.001584
K_19894 X_NUC_126.L_CORE X_NUC_145.L_CORE 0.004993
K_19895 X_NUC_126.L_CORE X_NUC_146.L_CORE 0.004914
K_19896 X_NUC_126.L_CORE X_NUC_147.L_CORE 0.004882
K_19897 X_NUC_126.L_CORE X_NUC_148.L_CORE 0.004951
K_19898 X_NUC_126.L_CORE X_NUC_149.L_CORE 0.002063
K_19899 X_NUC_126.L_CORE X_NUC_150.L_CORE 0.002049
K_19900 X_NUC_126.L_CORE X_NUC_151.L_CORE 0.002060
K_19901 X_NUC_126.L_CORE X_NUC_152.L_CORE 0.002046
K_19902 X_NUC_126.L_CORE X_NUC_153.L_CORE 0.001978
K_19903 X_NUC_126.L_CORE X_NUC_154.L_CORE 0.001961
K_19904 X_NUC_126.L_CORE X_NUC_155.L_CORE 0.001964
K_19905 X_NUC_126.L_CORE X_NUC_156.L_CORE 0.001968
K_19906 X_NUC_126.L_CORE X_NUC_157.L_CORE 0.004725
K_19907 X_NUC_126.L_CORE X_NUC_158.L_CORE 0.004664
K_19908 X_NUC_126.L_CORE X_NUC_159.L_CORE 0.004668
K_19909 X_NUC_126.L_CORE X_NUC_160.L_CORE 0.004620
K_19910 X_NUC_126.L_CORE X_NUC_161.L_CORE 0.001883
K_19911 X_NUC_126.L_CORE X_NUC_162.L_CORE 0.001868
K_19912 X_NUC_126.L_CORE X_NUC_163.L_CORE 0.001874
K_19913 X_NUC_126.L_CORE X_NUC_164.L_CORE 0.001869
K_19914 X_NUC_126.L_CORE X_NUC_165.L_CORE 0.002841
K_19915 X_NUC_126.L_CORE X_NUC_166.L_CORE 0.002809
K_19916 X_NUC_126.L_CORE X_NUC_167.L_CORE 0.002808
K_19917 X_NUC_126.L_CORE X_NUC_168.L_CORE 0.002815
K_19918 X_NUC_126.L_CORE X_NUC_169.L_CORE 0.002659
K_19919 X_NUC_126.L_CORE X_NUC_170.L_CORE 0.002633
K_19920 X_NUC_126.L_CORE X_NUC_171.L_CORE 0.002640
K_19921 X_NUC_126.L_CORE X_NUC_172.L_CORE 0.002627
K_19922 X_NUC_126.L_CORE X_NUC_173.L_CORE 0.001523
K_19923 X_NUC_126.L_CORE X_NUC_174.L_CORE 0.001352
K_19924 X_NUC_126.L_CORE X_NUC_175.L_CORE 0.001712
K_19925 X_NUC_126.L_CORE X_NUC_176.L_CORE 0.001426
K_19926 X_NUC_126.L_CORE X_NUC_177.L_CORE 0.001415
K_19927 X_NUC_126.L_CORE X_NUC_178.L_CORE 0.001915
K_19928 X_NUC_126.L_CORE X_NUC_179.L_CORE 0.001285
K_19929 X_NUC_126.L_CORE X_NUC_180.L_CORE 0.001767
K_19930 X_NUC_126.L_CORE X_NUC_181.L_CORE 0.001648
K_19931 X_NUC_126.L_CORE X_NUC_182.L_CORE 0.001304
K_19932 X_NUC_126.L_CORE X_NUC_183.L_CORE 0.002382
K_19933 X_NUC_126.L_CORE X_NUC_184.L_CORE 0.001351
K_19934 X_NUC_126.L_CORE X_NUC_185.L_CORE 0.001578
K_19935 X_NUC_126.L_CORE X_NUC_186.L_CORE 0.002189
K_19936 X_NUC_126.L_CORE X_NUC_187.L_CORE 0.001257
K_19937 X_NUC_126.L_CORE X_NUC_188.L_CORE 0.002393
K_19938 X_NUC_126.L_CORE X_NUC_189.L_CORE 0.001579
K_19939 X_NUC_126.L_CORE X_NUC_190.L_CORE 0.001394
K_19940 X_NUC_126.L_CORE X_NUC_191.L_CORE 0.003308
K_19941 X_NUC_126.L_CORE X_NUC_192.L_CORE 0.001306
K_19942 X_NUC_126.L_CORE X_NUC_193.L_CORE 0.001958
K_19943 X_NUC_126.L_CORE X_NUC_194.L_CORE 0.002129
K_19944 X_NUC_126.L_CORE X_NUC_195.L_CORE 0.001303
K_19945 X_NUC_126.L_CORE X_NUC_196.L_CORE 0.003973
K_19946 X_NUC_126.L_CORE X_NUC_197.L_CORE 0.001491
K_19947 X_NUC_126.L_CORE X_NUC_198.L_CORE 0.001608
K_19948 X_NUC_126.L_CORE X_NUC_199.L_CORE 0.003706
K_19949 X_NUC_126.L_CORE X_NUC_200.L_CORE 0.001317
K_19950 X_NUC_126.L_CORE X_NUC_201.L_CORE 0.002799
K_19951 X_NUC_126.L_CORE X_NUC_202.L_CORE 0.001935
K_19952 X_NUC_126.L_CORE X_NUC_203.L_CORE 0.001434
K_19953 X_NUC_126.L_CORE X_NUC_204.L_CORE 0.010712
K_19954 X_NUC_126.L_CORE X_NUC_205.L_CORE 0.001458
K_19955 X_NUC_126.L_CORE X_NUC_206.L_CORE 0.002025
K_19956 X_NUC_126.L_CORE X_NUC_207.L_CORE 0.003098
K_19957 X_NUC_126.L_CORE X_NUC_208.L_CORE 0.001406
K_19958 X_NUC_126.L_CORE X_NUC_209.L_CORE 0.005015
K_19959 X_NUC_126.L_CORE X_NUC_210.L_CORE 0.001804
K_19960 X_NUC_126.L_CORE X_NUC_211.L_CORE 0.001699
K_19961 X_NUC_126.L_CORE X_NUC_212.L_CORE 0.007454
K_19962 X_NUC_126.L_CORE X_NUC_213.L_CORE 0.001526
K_19963 X_NUC_126.L_CORE X_NUC_214.L_CORE 0.002764
K_19964 X_NUC_126.L_CORE X_NUC_215.L_CORE 0.002540
K_19965 X_NUC_126.L_CORE X_NUC_216.L_CORE 0.001641
K_19966 X_NUC_126.L_CORE X_NUC_217.L_CORE 0.005626
K_19967 X_NUC_126.L_CORE X_NUC_218.L_CORE 0.001859
K_19968 X_NUC_126.L_CORE X_NUC_219.L_CORE 0.002186
K_19969 X_NUC_126.L_CORE X_NUC_220.L_CORE 0.003298
K_19970 X_NUC_126.L_CORE X_NUC_221.L_CORE 0.001908
K_19971 X_NUC_126.L_CORE X_NUC_222.L_CORE 0.002733
K_19972 X_NUC_127.L_CORE X_NUC_128.L_CORE 0.207973
K_19973 X_NUC_127.L_CORE X_NUC_129.L_CORE 0.001603
K_19974 X_NUC_127.L_CORE X_NUC_130.L_CORE 0.001593
K_19975 X_NUC_127.L_CORE X_NUC_131.L_CORE 0.001601
K_19976 X_NUC_127.L_CORE X_NUC_132.L_CORE 0.001594
K_19977 X_NUC_127.L_CORE X_NUC_133.L_CORE 0.002257
K_19978 X_NUC_127.L_CORE X_NUC_134.L_CORE 0.002237
K_19979 X_NUC_127.L_CORE X_NUC_135.L_CORE 0.002239
K_19980 X_NUC_127.L_CORE X_NUC_136.L_CORE 0.002252
K_19981 X_NUC_127.L_CORE X_NUC_137.L_CORE 0.003411
K_19982 X_NUC_127.L_CORE X_NUC_138.L_CORE 0.003392
K_19983 X_NUC_127.L_CORE X_NUC_139.L_CORE 0.003421
K_19984 X_NUC_127.L_CORE X_NUC_140.L_CORE 0.003369
K_19985 X_NUC_127.L_CORE X_NUC_141.L_CORE 0.001586
K_19986 X_NUC_127.L_CORE X_NUC_142.L_CORE 0.001574
K_19987 X_NUC_127.L_CORE X_NUC_143.L_CORE 0.001580
K_19988 X_NUC_127.L_CORE X_NUC_144.L_CORE 0.001578
K_19989 X_NUC_127.L_CORE X_NUC_145.L_CORE 0.005026
K_19990 X_NUC_127.L_CORE X_NUC_146.L_CORE 0.004945
K_19991 X_NUC_127.L_CORE X_NUC_147.L_CORE 0.004914
K_19992 X_NUC_127.L_CORE X_NUC_148.L_CORE 0.004984
K_19993 X_NUC_127.L_CORE X_NUC_149.L_CORE 0.002053
K_19994 X_NUC_127.L_CORE X_NUC_150.L_CORE 0.002038
K_19995 X_NUC_127.L_CORE X_NUC_151.L_CORE 0.002049
K_19996 X_NUC_127.L_CORE X_NUC_152.L_CORE 0.002036
K_19997 X_NUC_127.L_CORE X_NUC_153.L_CORE 0.001975
K_19998 X_NUC_127.L_CORE X_NUC_154.L_CORE 0.001957
K_19999 X_NUC_127.L_CORE X_NUC_155.L_CORE 0.001961
K_20000 X_NUC_127.L_CORE X_NUC_156.L_CORE 0.001964
K_20001 X_NUC_127.L_CORE X_NUC_157.L_CORE 0.004719
K_20002 X_NUC_127.L_CORE X_NUC_158.L_CORE 0.004657
K_20003 X_NUC_127.L_CORE X_NUC_159.L_CORE 0.004664
K_20004 X_NUC_127.L_CORE X_NUC_160.L_CORE 0.004615
K_20005 X_NUC_127.L_CORE X_NUC_161.L_CORE 0.001876
K_20006 X_NUC_127.L_CORE X_NUC_162.L_CORE 0.001861
K_20007 X_NUC_127.L_CORE X_NUC_163.L_CORE 0.001868
K_20008 X_NUC_127.L_CORE X_NUC_164.L_CORE 0.001862
K_20009 X_NUC_127.L_CORE X_NUC_165.L_CORE 0.002842
K_20010 X_NUC_127.L_CORE X_NUC_166.L_CORE 0.002810
K_20011 X_NUC_127.L_CORE X_NUC_167.L_CORE 0.002809
K_20012 X_NUC_127.L_CORE X_NUC_168.L_CORE 0.002816
K_20013 X_NUC_127.L_CORE X_NUC_169.L_CORE 0.002652
K_20014 X_NUC_127.L_CORE X_NUC_170.L_CORE 0.002626
K_20015 X_NUC_127.L_CORE X_NUC_171.L_CORE 0.002633
K_20016 X_NUC_127.L_CORE X_NUC_172.L_CORE 0.002621
K_20017 X_NUC_127.L_CORE X_NUC_173.L_CORE 0.001513
K_20018 X_NUC_127.L_CORE X_NUC_174.L_CORE 0.001344
K_20019 X_NUC_127.L_CORE X_NUC_175.L_CORE 0.001701
K_20020 X_NUC_127.L_CORE X_NUC_176.L_CORE 0.001416
K_20021 X_NUC_127.L_CORE X_NUC_177.L_CORE 0.001408
K_20022 X_NUC_127.L_CORE X_NUC_178.L_CORE 0.001900
K_20023 X_NUC_127.L_CORE X_NUC_179.L_CORE 0.001278
K_20024 X_NUC_127.L_CORE X_NUC_180.L_CORE 0.001758
K_20025 X_NUC_127.L_CORE X_NUC_181.L_CORE 0.001635
K_20026 X_NUC_127.L_CORE X_NUC_182.L_CORE 0.001297
K_20027 X_NUC_127.L_CORE X_NUC_183.L_CORE 0.002364
K_20028 X_NUC_127.L_CORE X_NUC_184.L_CORE 0.001343
K_20029 X_NUC_127.L_CORE X_NUC_185.L_CORE 0.001572
K_20030 X_NUC_127.L_CORE X_NUC_186.L_CORE 0.002168
K_20031 X_NUC_127.L_CORE X_NUC_187.L_CORE 0.001251
K_20032 X_NUC_127.L_CORE X_NUC_188.L_CORE 0.002381
K_20033 X_NUC_127.L_CORE X_NUC_189.L_CORE 0.001567
K_20034 X_NUC_127.L_CORE X_NUC_190.L_CORE 0.001389
K_20035 X_NUC_127.L_CORE X_NUC_191.L_CORE 0.003273
K_20036 X_NUC_127.L_CORE X_NUC_192.L_CORE 0.001299
K_20037 X_NUC_127.L_CORE X_NUC_193.L_CORE 0.001952
K_20038 X_NUC_127.L_CORE X_NUC_194.L_CORE 0.002110
K_20039 X_NUC_127.L_CORE X_NUC_195.L_CORE 0.001297
K_20040 X_NUC_127.L_CORE X_NUC_196.L_CORE 0.003955
K_20041 X_NUC_127.L_CORE X_NUC_197.L_CORE 0.001482
K_20042 X_NUC_127.L_CORE X_NUC_198.L_CORE 0.001604
K_20043 X_NUC_127.L_CORE X_NUC_199.L_CORE 0.003660
K_20044 X_NUC_127.L_CORE X_NUC_200.L_CORE 0.001310
K_20045 X_NUC_127.L_CORE X_NUC_201.L_CORE 0.002797
K_20046 X_NUC_127.L_CORE X_NUC_202.L_CORE 0.001921
K_20047 X_NUC_127.L_CORE X_NUC_203.L_CORE 0.001430
K_20048 X_NUC_127.L_CORE X_NUC_204.L_CORE 0.010629
K_20049 X_NUC_127.L_CORE X_NUC_205.L_CORE 0.001450
K_20050 X_NUC_127.L_CORE X_NUC_206.L_CORE 0.002022
K_20051 X_NUC_127.L_CORE X_NUC_207.L_CORE 0.003070
K_20052 X_NUC_127.L_CORE X_NUC_208.L_CORE 0.001401
K_20053 X_NUC_127.L_CORE X_NUC_209.L_CORE 0.005056
K_20054 X_NUC_127.L_CORE X_NUC_210.L_CORE 0.001794
K_20055 X_NUC_127.L_CORE X_NUC_211.L_CORE 0.001696
K_20056 X_NUC_127.L_CORE X_NUC_212.L_CORE 0.007426
K_20057 X_NUC_127.L_CORE X_NUC_213.L_CORE 0.001520
K_20058 X_NUC_127.L_CORE X_NUC_214.L_CORE 0.002769
K_20059 X_NUC_127.L_CORE X_NUC_215.L_CORE 0.002526
K_20060 X_NUC_127.L_CORE X_NUC_216.L_CORE 0.001637
K_20061 X_NUC_127.L_CORE X_NUC_217.L_CORE 0.005689
K_20062 X_NUC_127.L_CORE X_NUC_218.L_CORE 0.001852
K_20063 X_NUC_127.L_CORE X_NUC_219.L_CORE 0.002186
K_20064 X_NUC_127.L_CORE X_NUC_220.L_CORE 0.003293
K_20065 X_NUC_127.L_CORE X_NUC_221.L_CORE 0.001903
K_20066 X_NUC_127.L_CORE X_NUC_222.L_CORE 0.002735
K_20067 X_NUC_128.L_CORE X_NUC_129.L_CORE 0.001610
K_20068 X_NUC_128.L_CORE X_NUC_130.L_CORE 0.001599
K_20069 X_NUC_128.L_CORE X_NUC_131.L_CORE 0.001608
K_20070 X_NUC_128.L_CORE X_NUC_132.L_CORE 0.001601
K_20071 X_NUC_128.L_CORE X_NUC_133.L_CORE 0.002244
K_20072 X_NUC_128.L_CORE X_NUC_134.L_CORE 0.002224
K_20073 X_NUC_128.L_CORE X_NUC_135.L_CORE 0.002226
K_20074 X_NUC_128.L_CORE X_NUC_136.L_CORE 0.002239
K_20075 X_NUC_128.L_CORE X_NUC_137.L_CORE 0.003464
K_20076 X_NUC_128.L_CORE X_NUC_138.L_CORE 0.003444
K_20077 X_NUC_128.L_CORE X_NUC_139.L_CORE 0.003473
K_20078 X_NUC_128.L_CORE X_NUC_140.L_CORE 0.003421
K_20079 X_NUC_128.L_CORE X_NUC_141.L_CORE 0.001587
K_20080 X_NUC_128.L_CORE X_NUC_142.L_CORE 0.001575
K_20081 X_NUC_128.L_CORE X_NUC_143.L_CORE 0.001581
K_20082 X_NUC_128.L_CORE X_NUC_144.L_CORE 0.001580
K_20083 X_NUC_128.L_CORE X_NUC_145.L_CORE 0.004954
K_20084 X_NUC_128.L_CORE X_NUC_146.L_CORE 0.004876
K_20085 X_NUC_128.L_CORE X_NUC_147.L_CORE 0.004845
K_20086 X_NUC_128.L_CORE X_NUC_148.L_CORE 0.004914
K_20087 X_NUC_128.L_CORE X_NUC_149.L_CORE 0.002066
K_20088 X_NUC_128.L_CORE X_NUC_150.L_CORE 0.002052
K_20089 X_NUC_128.L_CORE X_NUC_151.L_CORE 0.002063
K_20090 X_NUC_128.L_CORE X_NUC_152.L_CORE 0.002049
K_20091 X_NUC_128.L_CORE X_NUC_153.L_CORE 0.001971
K_20092 X_NUC_128.L_CORE X_NUC_154.L_CORE 0.001953
K_20093 X_NUC_128.L_CORE X_NUC_155.L_CORE 0.001957
K_20094 X_NUC_128.L_CORE X_NUC_156.L_CORE 0.001961
K_20095 X_NUC_128.L_CORE X_NUC_157.L_CORE 0.004771
K_20096 X_NUC_128.L_CORE X_NUC_158.L_CORE 0.004707
K_20097 X_NUC_128.L_CORE X_NUC_159.L_CORE 0.004713
K_20098 X_NUC_128.L_CORE X_NUC_160.L_CORE 0.004664
K_20099 X_NUC_128.L_CORE X_NUC_161.L_CORE 0.001882
K_20100 X_NUC_128.L_CORE X_NUC_162.L_CORE 0.001866
K_20101 X_NUC_128.L_CORE X_NUC_163.L_CORE 0.001873
K_20102 X_NUC_128.L_CORE X_NUC_164.L_CORE 0.001868
K_20103 X_NUC_128.L_CORE X_NUC_165.L_CORE 0.002835
K_20104 X_NUC_128.L_CORE X_NUC_166.L_CORE 0.002803
K_20105 X_NUC_128.L_CORE X_NUC_167.L_CORE 0.002802
K_20106 X_NUC_128.L_CORE X_NUC_168.L_CORE 0.002809
K_20107 X_NUC_128.L_CORE X_NUC_169.L_CORE 0.002665
K_20108 X_NUC_128.L_CORE X_NUC_170.L_CORE 0.002639
K_20109 X_NUC_128.L_CORE X_NUC_171.L_CORE 0.002646
K_20110 X_NUC_128.L_CORE X_NUC_172.L_CORE 0.002633
K_20111 X_NUC_128.L_CORE X_NUC_173.L_CORE 0.001515
K_20112 X_NUC_128.L_CORE X_NUC_174.L_CORE 0.001344
K_20113 X_NUC_128.L_CORE X_NUC_175.L_CORE 0.001700
K_20114 X_NUC_128.L_CORE X_NUC_176.L_CORE 0.001420
K_20115 X_NUC_128.L_CORE X_NUC_177.L_CORE 0.001406
K_20116 X_NUC_128.L_CORE X_NUC_178.L_CORE 0.001904
K_20117 X_NUC_128.L_CORE X_NUC_179.L_CORE 0.001280
K_20118 X_NUC_128.L_CORE X_NUC_180.L_CORE 0.001753
K_20119 X_NUC_128.L_CORE X_NUC_181.L_CORE 0.001643
K_20120 X_NUC_128.L_CORE X_NUC_182.L_CORE 0.001297
K_20121 X_NUC_128.L_CORE X_NUC_183.L_CORE 0.002361
K_20122 X_NUC_128.L_CORE X_NUC_184.L_CORE 0.001347
K_20123 X_NUC_128.L_CORE X_NUC_185.L_CORE 0.001567
K_20124 X_NUC_128.L_CORE X_NUC_186.L_CORE 0.002182
K_20125 X_NUC_128.L_CORE X_NUC_187.L_CORE 0.001252
K_20126 X_NUC_128.L_CORE X_NUC_188.L_CORE 0.002367
K_20127 X_NUC_128.L_CORE X_NUC_189.L_CORE 0.001576
K_20128 X_NUC_128.L_CORE X_NUC_190.L_CORE 0.001386
K_20129 X_NUC_128.L_CORE X_NUC_191.L_CORE 0.003285
K_20130 X_NUC_128.L_CORE X_NUC_192.L_CORE 0.001303
K_20131 X_NUC_128.L_CORE X_NUC_193.L_CORE 0.001941
K_20132 X_NUC_128.L_CORE X_NUC_194.L_CORE 0.002129
K_20133 X_NUC_128.L_CORE X_NUC_195.L_CORE 0.001297
K_20134 X_NUC_128.L_CORE X_NUC_196.L_CORE 0.003911
K_20135 X_NUC_128.L_CORE X_NUC_197.L_CORE 0.001490
K_20136 X_NUC_128.L_CORE X_NUC_198.L_CORE 0.001598
K_20137 X_NUC_128.L_CORE X_NUC_199.L_CORE 0.003712
K_20138 X_NUC_128.L_CORE X_NUC_200.L_CORE 0.001313
K_20139 X_NUC_128.L_CORE X_NUC_201.L_CORE 0.002766
K_20140 X_NUC_128.L_CORE X_NUC_202.L_CORE 0.001937
K_20141 X_NUC_128.L_CORE X_NUC_203.L_CORE 0.001428
K_20142 X_NUC_128.L_CORE X_NUC_204.L_CORE 0.010556
K_20143 X_NUC_128.L_CORE X_NUC_205.L_CORE 0.001456
K_20144 X_NUC_128.L_CORE X_NUC_206.L_CORE 0.002010
K_20145 X_NUC_128.L_CORE X_NUC_207.L_CORE 0.003116
K_20146 X_NUC_128.L_CORE X_NUC_208.L_CORE 0.001402
K_20147 X_NUC_128.L_CORE X_NUC_209.L_CORE 0.004944
K_20148 X_NUC_128.L_CORE X_NUC_210.L_CORE 0.001806
K_20149 X_NUC_128.L_CORE X_NUC_211.L_CORE 0.001691
K_20150 X_NUC_128.L_CORE X_NUC_212.L_CORE 0.007670
K_20151 X_NUC_128.L_CORE X_NUC_213.L_CORE 0.001524
K_20152 X_NUC_128.L_CORE X_NUC_214.L_CORE 0.002745
K_20153 X_NUC_128.L_CORE X_NUC_215.L_CORE 0.002552
K_20154 X_NUC_128.L_CORE X_NUC_216.L_CORE 0.001636
K_20155 X_NUC_128.L_CORE X_NUC_217.L_CORE 0.005657
K_20156 X_NUC_128.L_CORE X_NUC_218.L_CORE 0.001861
K_20157 X_NUC_128.L_CORE X_NUC_219.L_CORE 0.002180
K_20158 X_NUC_128.L_CORE X_NUC_220.L_CORE 0.003320
K_20159 X_NUC_128.L_CORE X_NUC_221.L_CORE 0.001907
K_20160 X_NUC_128.L_CORE X_NUC_222.L_CORE 0.002735
K_20161 X_NUC_129.L_CORE X_NUC_130.L_CORE 0.207973
K_20162 X_NUC_129.L_CORE X_NUC_131.L_CORE 0.207973
K_20163 X_NUC_129.L_CORE X_NUC_132.L_CORE 0.207973
K_20164 X_NUC_129.L_CORE X_NUC_133.L_CORE 0.001653
K_20165 X_NUC_129.L_CORE X_NUC_134.L_CORE 0.001657
K_20166 X_NUC_129.L_CORE X_NUC_135.L_CORE 0.001648
K_20167 X_NUC_129.L_CORE X_NUC_136.L_CORE 0.001661
K_20168 X_NUC_129.L_CORE X_NUC_137.L_CORE 0.002318
K_20169 X_NUC_129.L_CORE X_NUC_138.L_CORE 0.002344
K_20170 X_NUC_129.L_CORE X_NUC_139.L_CORE 0.002327
K_20171 X_NUC_129.L_CORE X_NUC_140.L_CORE 0.002332
K_20172 X_NUC_129.L_CORE X_NUC_141.L_CORE 0.003543
K_20173 X_NUC_129.L_CORE X_NUC_142.L_CORE 0.003521
K_20174 X_NUC_129.L_CORE X_NUC_143.L_CORE 0.003497
K_20175 X_NUC_129.L_CORE X_NUC_144.L_CORE 0.003551
K_20176 X_NUC_129.L_CORE X_NUC_145.L_CORE 0.001647
K_20177 X_NUC_129.L_CORE X_NUC_146.L_CORE 0.001656
K_20178 X_NUC_129.L_CORE X_NUC_147.L_CORE 0.001645
K_20179 X_NUC_129.L_CORE X_NUC_148.L_CORE 0.001655
K_20180 X_NUC_129.L_CORE X_NUC_149.L_CORE 0.005011
K_20181 X_NUC_129.L_CORE X_NUC_150.L_CORE 0.005121
K_20182 X_NUC_129.L_CORE X_NUC_151.L_CORE 0.005022
K_20183 X_NUC_129.L_CORE X_NUC_152.L_CORE 0.005030
K_20184 X_NUC_129.L_CORE X_NUC_153.L_CORE 0.002152
K_20185 X_NUC_129.L_CORE X_NUC_154.L_CORE 0.002154
K_20186 X_NUC_129.L_CORE X_NUC_155.L_CORE 0.002139
K_20187 X_NUC_129.L_CORE X_NUC_156.L_CORE 0.002160
K_20188 X_NUC_129.L_CORE X_NUC_157.L_CORE 0.002074
K_20189 X_NUC_129.L_CORE X_NUC_158.L_CORE 0.002091
K_20190 X_NUC_129.L_CORE X_NUC_159.L_CORE 0.002073
K_20191 X_NUC_129.L_CORE X_NUC_160.L_CORE 0.002084
K_20192 X_NUC_129.L_CORE X_NUC_161.L_CORE 0.004464
K_20193 X_NUC_129.L_CORE X_NUC_162.L_CORE 0.004481
K_20194 X_NUC_129.L_CORE X_NUC_163.L_CORE 0.004395
K_20195 X_NUC_129.L_CORE X_NUC_164.L_CORE 0.004465
K_20196 X_NUC_129.L_CORE X_NUC_165.L_CORE 0.002039
K_20197 X_NUC_129.L_CORE X_NUC_166.L_CORE 0.002048
K_20198 X_NUC_129.L_CORE X_NUC_167.L_CORE 0.002030
K_20199 X_NUC_129.L_CORE X_NUC_168.L_CORE 0.002047
K_20200 X_NUC_129.L_CORE X_NUC_169.L_CORE 0.002834
K_20201 X_NUC_129.L_CORE X_NUC_170.L_CORE 0.002859
K_20202 X_NUC_129.L_CORE X_NUC_171.L_CORE 0.002822
K_20203 X_NUC_129.L_CORE X_NUC_172.L_CORE 0.002843
K_20204 X_NUC_129.L_CORE X_NUC_173.L_CORE 0.001464
K_20205 X_NUC_129.L_CORE X_NUC_174.L_CORE 0.001543
K_20206 X_NUC_129.L_CORE X_NUC_175.L_CORE 0.001315
K_20207 X_NUC_129.L_CORE X_NUC_176.L_CORE 0.001732
K_20208 X_NUC_129.L_CORE X_NUC_177.L_CORE 0.001409
K_20209 X_NUC_129.L_CORE X_NUC_178.L_CORE 0.001402
K_20210 X_NUC_129.L_CORE X_NUC_179.L_CORE 0.001919
K_20211 X_NUC_129.L_CORE X_NUC_180.L_CORE 0.001273
K_20212 X_NUC_129.L_CORE X_NUC_181.L_CORE 0.001763
K_20213 X_NUC_129.L_CORE X_NUC_182.L_CORE 0.001639
K_20214 X_NUC_129.L_CORE X_NUC_183.L_CORE 0.001299
K_20215 X_NUC_129.L_CORE X_NUC_184.L_CORE 0.002373
K_20216 X_NUC_129.L_CORE X_NUC_185.L_CORE 0.001347
K_20217 X_NUC_129.L_CORE X_NUC_186.L_CORE 0.001577
K_20218 X_NUC_129.L_CORE X_NUC_187.L_CORE 0.002175
K_20219 X_NUC_129.L_CORE X_NUC_188.L_CORE 0.001259
K_20220 X_NUC_129.L_CORE X_NUC_189.L_CORE 0.002385
K_20221 X_NUC_129.L_CORE X_NUC_190.L_CORE 0.001579
K_20222 X_NUC_129.L_CORE X_NUC_191.L_CORE 0.001400
K_20223 X_NUC_129.L_CORE X_NUC_192.L_CORE 0.003260
K_20224 X_NUC_129.L_CORE X_NUC_193.L_CORE 0.001314
K_20225 X_NUC_129.L_CORE X_NUC_194.L_CORE 0.001968
K_20226 X_NUC_129.L_CORE X_NUC_195.L_CORE 0.002129
K_20227 X_NUC_129.L_CORE X_NUC_196.L_CORE 0.001315
K_20228 X_NUC_129.L_CORE X_NUC_197.L_CORE 0.003934
K_20229 X_NUC_129.L_CORE X_NUC_198.L_CORE 0.001505
K_20230 X_NUC_129.L_CORE X_NUC_199.L_CORE 0.001628
K_20231 X_NUC_129.L_CORE X_NUC_200.L_CORE 0.003681
K_20232 X_NUC_129.L_CORE X_NUC_201.L_CORE 0.001335
K_20233 X_NUC_129.L_CORE X_NUC_202.L_CORE 0.002835
K_20234 X_NUC_129.L_CORE X_NUC_203.L_CORE 0.001959
K_20235 X_NUC_129.L_CORE X_NUC_204.L_CORE 0.001461
K_20236 X_NUC_129.L_CORE X_NUC_205.L_CORE 0.010291
K_20237 X_NUC_129.L_CORE X_NUC_206.L_CORE 0.001486
K_20238 X_NUC_129.L_CORE X_NUC_207.L_CORE 0.002072
K_20239 X_NUC_129.L_CORE X_NUC_208.L_CORE 0.003151
K_20240 X_NUC_129.L_CORE X_NUC_209.L_CORE 0.001441
K_20241 X_NUC_129.L_CORE X_NUC_210.L_CORE 0.005185
K_20242 X_NUC_129.L_CORE X_NUC_211.L_CORE 0.001852
K_20243 X_NUC_129.L_CORE X_NUC_212.L_CORE 0.001753
K_20244 X_NUC_129.L_CORE X_NUC_213.L_CORE 0.007602
K_20245 X_NUC_129.L_CORE X_NUC_214.L_CORE 0.001579
K_20246 X_NUC_129.L_CORE X_NUC_215.L_CORE 0.002872
K_20247 X_NUC_129.L_CORE X_NUC_216.L_CORE 0.002631
K_20248 X_NUC_129.L_CORE X_NUC_217.L_CORE 0.001718
K_20249 X_NUC_129.L_CORE X_NUC_218.L_CORE 0.005517
K_20250 X_NUC_129.L_CORE X_NUC_219.L_CORE 0.001963
K_20251 X_NUC_129.L_CORE X_NUC_220.L_CORE 0.002312
K_20252 X_NUC_129.L_CORE X_NUC_221.L_CORE 0.003240
K_20253 X_NUC_129.L_CORE X_NUC_222.L_CORE 0.002163
K_20254 X_NUC_130.L_CORE X_NUC_131.L_CORE 0.207973
K_20255 X_NUC_130.L_CORE X_NUC_132.L_CORE 0.207973
K_20256 X_NUC_130.L_CORE X_NUC_133.L_CORE 0.001650
K_20257 X_NUC_130.L_CORE X_NUC_134.L_CORE 0.001653
K_20258 X_NUC_130.L_CORE X_NUC_135.L_CORE 0.001645
K_20259 X_NUC_130.L_CORE X_NUC_136.L_CORE 0.001658
K_20260 X_NUC_130.L_CORE X_NUC_137.L_CORE 0.002293
K_20261 X_NUC_130.L_CORE X_NUC_138.L_CORE 0.002318
K_20262 X_NUC_130.L_CORE X_NUC_139.L_CORE 0.002302
K_20263 X_NUC_130.L_CORE X_NUC_140.L_CORE 0.002306
K_20264 X_NUC_130.L_CORE X_NUC_141.L_CORE 0.003564
K_20265 X_NUC_130.L_CORE X_NUC_142.L_CORE 0.003543
K_20266 X_NUC_130.L_CORE X_NUC_143.L_CORE 0.003518
K_20267 X_NUC_130.L_CORE X_NUC_144.L_CORE 0.003573
K_20268 X_NUC_130.L_CORE X_NUC_145.L_CORE 0.001639
K_20269 X_NUC_130.L_CORE X_NUC_146.L_CORE 0.001647
K_20270 X_NUC_130.L_CORE X_NUC_147.L_CORE 0.001637
K_20271 X_NUC_130.L_CORE X_NUC_148.L_CORE 0.001647
K_20272 X_NUC_130.L_CORE X_NUC_149.L_CORE 0.004906
K_20273 X_NUC_130.L_CORE X_NUC_150.L_CORE 0.005011
K_20274 X_NUC_130.L_CORE X_NUC_151.L_CORE 0.004917
K_20275 X_NUC_130.L_CORE X_NUC_152.L_CORE 0.004924
K_20276 X_NUC_130.L_CORE X_NUC_153.L_CORE 0.002150
K_20277 X_NUC_130.L_CORE X_NUC_154.L_CORE 0.002152
K_20278 X_NUC_130.L_CORE X_NUC_155.L_CORE 0.002137
K_20279 X_NUC_130.L_CORE X_NUC_156.L_CORE 0.002158
K_20280 X_NUC_130.L_CORE X_NUC_157.L_CORE 0.002057
K_20281 X_NUC_130.L_CORE X_NUC_158.L_CORE 0.002074
K_20282 X_NUC_130.L_CORE X_NUC_159.L_CORE 0.002057
K_20283 X_NUC_130.L_CORE X_NUC_160.L_CORE 0.002067
K_20284 X_NUC_130.L_CORE X_NUC_161.L_CORE 0.004445
K_20285 X_NUC_130.L_CORE X_NUC_162.L_CORE 0.004464
K_20286 X_NUC_130.L_CORE X_NUC_163.L_CORE 0.004377
K_20287 X_NUC_130.L_CORE X_NUC_164.L_CORE 0.004446
K_20288 X_NUC_130.L_CORE X_NUC_165.L_CORE 0.002030
K_20289 X_NUC_130.L_CORE X_NUC_166.L_CORE 0.002039
K_20290 X_NUC_130.L_CORE X_NUC_167.L_CORE 0.002022
K_20291 X_NUC_130.L_CORE X_NUC_168.L_CORE 0.002038
K_20292 X_NUC_130.L_CORE X_NUC_169.L_CORE 0.002809
K_20293 X_NUC_130.L_CORE X_NUC_170.L_CORE 0.002834
K_20294 X_NUC_130.L_CORE X_NUC_171.L_CORE 0.002797
K_20295 X_NUC_130.L_CORE X_NUC_172.L_CORE 0.002818
K_20296 X_NUC_130.L_CORE X_NUC_173.L_CORE 0.001460
K_20297 X_NUC_130.L_CORE X_NUC_174.L_CORE 0.001542
K_20298 X_NUC_130.L_CORE X_NUC_175.L_CORE 0.001312
K_20299 X_NUC_130.L_CORE X_NUC_176.L_CORE 0.001728
K_20300 X_NUC_130.L_CORE X_NUC_177.L_CORE 0.001408
K_20301 X_NUC_130.L_CORE X_NUC_178.L_CORE 0.001396
K_20302 X_NUC_130.L_CORE X_NUC_179.L_CORE 0.001921
K_20303 X_NUC_130.L_CORE X_NUC_180.L_CORE 0.001271
K_20304 X_NUC_130.L_CORE X_NUC_181.L_CORE 0.001755
K_20305 X_NUC_130.L_CORE X_NUC_182.L_CORE 0.001641
K_20306 X_NUC_130.L_CORE X_NUC_183.L_CORE 0.001293
K_20307 X_NUC_130.L_CORE X_NUC_184.L_CORE 0.002371
K_20308 X_NUC_130.L_CORE X_NUC_185.L_CORE 0.001346
K_20309 X_NUC_130.L_CORE X_NUC_186.L_CORE 0.001568
K_20310 X_NUC_130.L_CORE X_NUC_187.L_CORE 0.002184
K_20311 X_NUC_130.L_CORE X_NUC_188.L_CORE 0.001255
K_20312 X_NUC_130.L_CORE X_NUC_189.L_CORE 0.002370
K_20313 X_NUC_130.L_CORE X_NUC_190.L_CORE 0.001581
K_20314 X_NUC_130.L_CORE X_NUC_191.L_CORE 0.001393
K_20315 X_NUC_130.L_CORE X_NUC_192.L_CORE 0.003278
K_20316 X_NUC_130.L_CORE X_NUC_193.L_CORE 0.001311
K_20317 X_NUC_130.L_CORE X_NUC_194.L_CORE 0.001952
K_20318 X_NUC_130.L_CORE X_NUC_195.L_CORE 0.002140
K_20319 X_NUC_130.L_CORE X_NUC_196.L_CORE 0.001309
K_20320 X_NUC_130.L_CORE X_NUC_197.L_CORE 0.003911
K_20321 X_NUC_130.L_CORE X_NUC_198.L_CORE 0.001505
K_20322 X_NUC_130.L_CORE X_NUC_199.L_CORE 0.001616
K_20323 X_NUC_130.L_CORE X_NUC_200.L_CORE 0.003728
K_20324 X_NUC_130.L_CORE X_NUC_201.L_CORE 0.001331
K_20325 X_NUC_130.L_CORE X_NUC_202.L_CORE 0.002802
K_20326 X_NUC_130.L_CORE X_NUC_203.L_CORE 0.001965
K_20327 X_NUC_130.L_CORE X_NUC_204.L_CORE 0.001452
K_20328 X_NUC_130.L_CORE X_NUC_205.L_CORE 0.010495
K_20329 X_NUC_130.L_CORE X_NUC_206.L_CORE 0.001484
K_20330 X_NUC_130.L_CORE X_NUC_207.L_CORE 0.002052
K_20331 X_NUC_130.L_CORE X_NUC_208.L_CORE 0.003180
K_20332 X_NUC_130.L_CORE X_NUC_209.L_CORE 0.001435
K_20333 X_NUC_130.L_CORE X_NUC_210.L_CORE 0.005072
K_20334 X_NUC_130.L_CORE X_NUC_211.L_CORE 0.001853
K_20335 X_NUC_130.L_CORE X_NUC_212.L_CORE 0.001740
K_20336 X_NUC_130.L_CORE X_NUC_213.L_CORE 0.007770
K_20337 X_NUC_130.L_CORE X_NUC_214.L_CORE 0.001574
K_20338 X_NUC_130.L_CORE X_NUC_215.L_CORE 0.002834
K_20339 X_NUC_130.L_CORE X_NUC_216.L_CORE 0.002637
K_20340 X_NUC_130.L_CORE X_NUC_217.L_CORE 0.001708
K_20341 X_NUC_130.L_CORE X_NUC_218.L_CORE 0.005439
K_20342 X_NUC_130.L_CORE X_NUC_219.L_CORE 0.001959
K_20343 X_NUC_130.L_CORE X_NUC_220.L_CORE 0.002292
K_20344 X_NUC_130.L_CORE X_NUC_221.L_CORE 0.003231
K_20345 X_NUC_130.L_CORE X_NUC_222.L_CORE 0.002152
K_20346 X_NUC_131.L_CORE X_NUC_132.L_CORE 0.207973
K_20347 X_NUC_131.L_CORE X_NUC_133.L_CORE 0.001658
K_20348 X_NUC_131.L_CORE X_NUC_134.L_CORE 0.001662
K_20349 X_NUC_131.L_CORE X_NUC_135.L_CORE 0.001653
K_20350 X_NUC_131.L_CORE X_NUC_136.L_CORE 0.001666
K_20351 X_NUC_131.L_CORE X_NUC_137.L_CORE 0.002309
K_20352 X_NUC_131.L_CORE X_NUC_138.L_CORE 0.002335
K_20353 X_NUC_131.L_CORE X_NUC_139.L_CORE 0.002318
K_20354 X_NUC_131.L_CORE X_NUC_140.L_CORE 0.002322
K_20355 X_NUC_131.L_CORE X_NUC_141.L_CORE 0.003590
K_20356 X_NUC_131.L_CORE X_NUC_142.L_CORE 0.003568
K_20357 X_NUC_131.L_CORE X_NUC_143.L_CORE 0.003543
K_20358 X_NUC_131.L_CORE X_NUC_144.L_CORE 0.003599
K_20359 X_NUC_131.L_CORE X_NUC_145.L_CORE 0.001649
K_20360 X_NUC_131.L_CORE X_NUC_146.L_CORE 0.001658
K_20361 X_NUC_131.L_CORE X_NUC_147.L_CORE 0.001647
K_20362 X_NUC_131.L_CORE X_NUC_148.L_CORE 0.001657
K_20363 X_NUC_131.L_CORE X_NUC_149.L_CORE 0.004998
K_20364 X_NUC_131.L_CORE X_NUC_150.L_CORE 0.005109
K_20365 X_NUC_131.L_CORE X_NUC_151.L_CORE 0.005011
K_20366 X_NUC_131.L_CORE X_NUC_152.L_CORE 0.005018
K_20367 X_NUC_131.L_CORE X_NUC_153.L_CORE 0.002166
K_20368 X_NUC_131.L_CORE X_NUC_154.L_CORE 0.002168
K_20369 X_NUC_131.L_CORE X_NUC_155.L_CORE 0.002152
K_20370 X_NUC_131.L_CORE X_NUC_156.L_CORE 0.002174
K_20371 X_NUC_131.L_CORE X_NUC_157.L_CORE 0.002074
K_20372 X_NUC_131.L_CORE X_NUC_158.L_CORE 0.002092
K_20373 X_NUC_131.L_CORE X_NUC_159.L_CORE 0.002074
K_20374 X_NUC_131.L_CORE X_NUC_160.L_CORE 0.002084
K_20375 X_NUC_131.L_CORE X_NUC_161.L_CORE 0.004534
K_20376 X_NUC_131.L_CORE X_NUC_162.L_CORE 0.004554
K_20377 X_NUC_131.L_CORE X_NUC_163.L_CORE 0.004464
K_20378 X_NUC_131.L_CORE X_NUC_164.L_CORE 0.004536
K_20379 X_NUC_131.L_CORE X_NUC_165.L_CORE 0.002047
K_20380 X_NUC_131.L_CORE X_NUC_166.L_CORE 0.002057
K_20381 X_NUC_131.L_CORE X_NUC_167.L_CORE 0.002039
K_20382 X_NUC_131.L_CORE X_NUC_168.L_CORE 0.002056
K_20383 X_NUC_131.L_CORE X_NUC_169.L_CORE 0.002846
K_20384 X_NUC_131.L_CORE X_NUC_170.L_CORE 0.002872
K_20385 X_NUC_131.L_CORE X_NUC_171.L_CORE 0.002834
K_20386 X_NUC_131.L_CORE X_NUC_172.L_CORE 0.002855
K_20387 X_NUC_131.L_CORE X_NUC_173.L_CORE 0.001457
K_20388 X_NUC_131.L_CORE X_NUC_174.L_CORE 0.001538
K_20389 X_NUC_131.L_CORE X_NUC_175.L_CORE 0.001311
K_20390 X_NUC_131.L_CORE X_NUC_176.L_CORE 0.001721
K_20391 X_NUC_131.L_CORE X_NUC_177.L_CORE 0.001406
K_20392 X_NUC_131.L_CORE X_NUC_178.L_CORE 0.001396
K_20393 X_NUC_131.L_CORE X_NUC_179.L_CORE 0.001910
K_20394 X_NUC_131.L_CORE X_NUC_180.L_CORE 0.001271
K_20395 X_NUC_131.L_CORE X_NUC_181.L_CORE 0.001750
K_20396 X_NUC_131.L_CORE X_NUC_182.L_CORE 0.001637
K_20397 X_NUC_131.L_CORE X_NUC_183.L_CORE 0.001295
K_20398 X_NUC_131.L_CORE X_NUC_184.L_CORE 0.002352
K_20399 X_NUC_131.L_CORE X_NUC_185.L_CORE 0.001347
K_20400 X_NUC_131.L_CORE X_NUC_186.L_CORE 0.001568
K_20401 X_NUC_131.L_CORE X_NUC_187.L_CORE 0.002171
K_20402 X_NUC_131.L_CORE X_NUC_188.L_CORE 0.001257
K_20403 X_NUC_131.L_CORE X_NUC_189.L_CORE 0.002359
K_20404 X_NUC_131.L_CORE X_NUC_190.L_CORE 0.001580
K_20405 X_NUC_131.L_CORE X_NUC_191.L_CORE 0.001396
K_20406 X_NUC_131.L_CORE X_NUC_192.L_CORE 0.003235
K_20407 X_NUC_131.L_CORE X_NUC_193.L_CORE 0.001314
K_20408 X_NUC_131.L_CORE X_NUC_194.L_CORE 0.001953
K_20409 X_NUC_131.L_CORE X_NUC_195.L_CORE 0.002135
K_20410 X_NUC_131.L_CORE X_NUC_196.L_CORE 0.001313
K_20411 X_NUC_131.L_CORE X_NUC_197.L_CORE 0.003863
K_20412 X_NUC_131.L_CORE X_NUC_198.L_CORE 0.001508
K_20413 X_NUC_131.L_CORE X_NUC_199.L_CORE 0.001621
K_20414 X_NUC_131.L_CORE X_NUC_200.L_CORE 0.003692
K_20415 X_NUC_131.L_CORE X_NUC_201.L_CORE 0.001335
K_20416 X_NUC_131.L_CORE X_NUC_202.L_CORE 0.002803
K_20417 X_NUC_131.L_CORE X_NUC_203.L_CORE 0.001968
K_20418 X_NUC_131.L_CORE X_NUC_204.L_CORE 0.001458
K_20419 X_NUC_131.L_CORE X_NUC_205.L_CORE 0.009996
K_20420 X_NUC_131.L_CORE X_NUC_206.L_CORE 0.001489
K_20421 X_NUC_131.L_CORE X_NUC_207.L_CORE 0.002061
K_20422 X_NUC_131.L_CORE X_NUC_208.L_CORE 0.003182
K_20423 X_NUC_131.L_CORE X_NUC_209.L_CORE 0.001442
K_20424 X_NUC_131.L_CORE X_NUC_210.L_CORE 0.005104
K_20425 X_NUC_131.L_CORE X_NUC_211.L_CORE 0.001862
K_20426 X_NUC_131.L_CORE X_NUC_212.L_CORE 0.001750
K_20427 X_NUC_131.L_CORE X_NUC_213.L_CORE 0.007877
K_20428 X_NUC_131.L_CORE X_NUC_214.L_CORE 0.001583
K_20429 X_NUC_131.L_CORE X_NUC_215.L_CORE 0.002861
K_20430 X_NUC_131.L_CORE X_NUC_216.L_CORE 0.002657
K_20431 X_NUC_131.L_CORE X_NUC_217.L_CORE 0.001719
K_20432 X_NUC_131.L_CORE X_NUC_218.L_CORE 0.005581
K_20433 X_NUC_131.L_CORE X_NUC_219.L_CORE 0.001973
K_20434 X_NUC_131.L_CORE X_NUC_220.L_CORE 0.002315
K_20435 X_NUC_131.L_CORE X_NUC_221.L_CORE 0.003278
K_20436 X_NUC_131.L_CORE X_NUC_222.L_CORE 0.002173
K_20437 X_NUC_132.L_CORE X_NUC_133.L_CORE 0.001646
K_20438 X_NUC_132.L_CORE X_NUC_134.L_CORE 0.001649
K_20439 X_NUC_132.L_CORE X_NUC_135.L_CORE 0.001641
K_20440 X_NUC_132.L_CORE X_NUC_136.L_CORE 0.001653
K_20441 X_NUC_132.L_CORE X_NUC_137.L_CORE 0.002305
K_20442 X_NUC_132.L_CORE X_NUC_138.L_CORE 0.002330
K_20443 X_NUC_132.L_CORE X_NUC_139.L_CORE 0.002314
K_20444 X_NUC_132.L_CORE X_NUC_140.L_CORE 0.002318
K_20445 X_NUC_132.L_CORE X_NUC_141.L_CORE 0.003534
K_20446 X_NUC_132.L_CORE X_NUC_142.L_CORE 0.003513
K_20447 X_NUC_132.L_CORE X_NUC_143.L_CORE 0.003489
K_20448 X_NUC_132.L_CORE X_NUC_144.L_CORE 0.003543
K_20449 X_NUC_132.L_CORE X_NUC_145.L_CORE 0.001639
K_20450 X_NUC_132.L_CORE X_NUC_146.L_CORE 0.001648
K_20451 X_NUC_132.L_CORE X_NUC_147.L_CORE 0.001638
K_20452 X_NUC_132.L_CORE X_NUC_148.L_CORE 0.001647
K_20453 X_NUC_132.L_CORE X_NUC_149.L_CORE 0.004990
K_20454 X_NUC_132.L_CORE X_NUC_150.L_CORE 0.005100
K_20455 X_NUC_132.L_CORE X_NUC_151.L_CORE 0.005002
K_20456 X_NUC_132.L_CORE X_NUC_152.L_CORE 0.005011
K_20457 X_NUC_132.L_CORE X_NUC_153.L_CORE 0.002144
K_20458 X_NUC_132.L_CORE X_NUC_154.L_CORE 0.002146
K_20459 X_NUC_132.L_CORE X_NUC_155.L_CORE 0.002131
K_20460 X_NUC_132.L_CORE X_NUC_156.L_CORE 0.002152
K_20461 X_NUC_132.L_CORE X_NUC_157.L_CORE 0.002064
K_20462 X_NUC_132.L_CORE X_NUC_158.L_CORE 0.002081
K_20463 X_NUC_132.L_CORE X_NUC_159.L_CORE 0.002064
K_20464 X_NUC_132.L_CORE X_NUC_160.L_CORE 0.002074
K_20465 X_NUC_132.L_CORE X_NUC_161.L_CORE 0.004461
K_20466 X_NUC_132.L_CORE X_NUC_162.L_CORE 0.004480
K_20467 X_NUC_132.L_CORE X_NUC_163.L_CORE 0.004393
K_20468 X_NUC_132.L_CORE X_NUC_164.L_CORE 0.004464
K_20469 X_NUC_132.L_CORE X_NUC_165.L_CORE 0.002031
K_20470 X_NUC_132.L_CORE X_NUC_166.L_CORE 0.002040
K_20471 X_NUC_132.L_CORE X_NUC_167.L_CORE 0.002022
K_20472 X_NUC_132.L_CORE X_NUC_168.L_CORE 0.002039
K_20473 X_NUC_132.L_CORE X_NUC_169.L_CORE 0.002824
K_20474 X_NUC_132.L_CORE X_NUC_170.L_CORE 0.002849
K_20475 X_NUC_132.L_CORE X_NUC_171.L_CORE 0.002812
K_20476 X_NUC_132.L_CORE X_NUC_172.L_CORE 0.002834
K_20477 X_NUC_132.L_CORE X_NUC_173.L_CORE 0.001454
K_20478 X_NUC_132.L_CORE X_NUC_174.L_CORE 0.001533
K_20479 X_NUC_132.L_CORE X_NUC_175.L_CORE 0.001307
K_20480 X_NUC_132.L_CORE X_NUC_176.L_CORE 0.001720
K_20481 X_NUC_132.L_CORE X_NUC_177.L_CORE 0.001400
K_20482 X_NUC_132.L_CORE X_NUC_178.L_CORE 0.001393
K_20483 X_NUC_132.L_CORE X_NUC_179.L_CORE 0.001906
K_20484 X_NUC_132.L_CORE X_NUC_180.L_CORE 0.001266
K_20485 X_NUC_132.L_CORE X_NUC_181.L_CORE 0.001751
K_20486 X_NUC_132.L_CORE X_NUC_182.L_CORE 0.001629
K_20487 X_NUC_132.L_CORE X_NUC_183.L_CORE 0.001291
K_20488 X_NUC_132.L_CORE X_NUC_184.L_CORE 0.002355
K_20489 X_NUC_132.L_CORE X_NUC_185.L_CORE 0.001340
K_20490 X_NUC_132.L_CORE X_NUC_186.L_CORE 0.001567
K_20491 X_NUC_132.L_CORE X_NUC_187.L_CORE 0.002161
K_20492 X_NUC_132.L_CORE X_NUC_188.L_CORE 0.001252
K_20493 X_NUC_132.L_CORE X_NUC_189.L_CORE 0.002366
K_20494 X_NUC_132.L_CORE X_NUC_190.L_CORE 0.001570
K_20495 X_NUC_132.L_CORE X_NUC_191.L_CORE 0.001392
K_20496 X_NUC_132.L_CORE X_NUC_192.L_CORE 0.003236
K_20497 X_NUC_132.L_CORE X_NUC_193.L_CORE 0.001307
K_20498 X_NUC_132.L_CORE X_NUC_194.L_CORE 0.001955
K_20499 X_NUC_132.L_CORE X_NUC_195.L_CORE 0.002119
K_20500 X_NUC_132.L_CORE X_NUC_196.L_CORE 0.001308
K_20501 X_NUC_132.L_CORE X_NUC_197.L_CORE 0.003899
K_20502 X_NUC_132.L_CORE X_NUC_198.L_CORE 0.001497
K_20503 X_NUC_132.L_CORE X_NUC_199.L_CORE 0.001619
K_20504 X_NUC_132.L_CORE X_NUC_200.L_CORE 0.003664
K_20505 X_NUC_132.L_CORE X_NUC_201.L_CORE 0.001328
K_20506 X_NUC_132.L_CORE X_NUC_202.L_CORE 0.002815
K_20507 X_NUC_132.L_CORE X_NUC_203.L_CORE 0.001950
K_20508 X_NUC_132.L_CORE X_NUC_204.L_CORE 0.001453
K_20509 X_NUC_132.L_CORE X_NUC_205.L_CORE 0.010264
K_20510 X_NUC_132.L_CORE X_NUC_206.L_CORE 0.001479
K_20511 X_NUC_132.L_CORE X_NUC_207.L_CORE 0.002060
K_20512 X_NUC_132.L_CORE X_NUC_208.L_CORE 0.003144
K_20513 X_NUC_132.L_CORE X_NUC_209.L_CORE 0.001434
K_20514 X_NUC_132.L_CORE X_NUC_210.L_CORE 0.005162
K_20515 X_NUC_132.L_CORE X_NUC_211.L_CORE 0.001845
K_20516 X_NUC_132.L_CORE X_NUC_212.L_CORE 0.001745
K_20517 X_NUC_132.L_CORE X_NUC_213.L_CORE 0.007686
K_20518 X_NUC_132.L_CORE X_NUC_214.L_CORE 0.001573
K_20519 X_NUC_132.L_CORE X_NUC_215.L_CORE 0.002860
K_20520 X_NUC_132.L_CORE X_NUC_216.L_CORE 0.002625
K_20521 X_NUC_132.L_CORE X_NUC_217.L_CORE 0.001710
K_20522 X_NUC_132.L_CORE X_NUC_218.L_CORE 0.005539
K_20523 X_NUC_132.L_CORE X_NUC_219.L_CORE 0.001956
K_20524 X_NUC_132.L_CORE X_NUC_220.L_CORE 0.002304
K_20525 X_NUC_132.L_CORE X_NUC_221.L_CORE 0.003239
K_20526 X_NUC_132.L_CORE X_NUC_222.L_CORE 0.002156
K_20527 X_NUC_133.L_CORE X_NUC_134.L_CORE 0.207973
K_20528 X_NUC_133.L_CORE X_NUC_135.L_CORE 0.207973
K_20529 X_NUC_133.L_CORE X_NUC_136.L_CORE 0.207973
K_20530 X_NUC_133.L_CORE X_NUC_137.L_CORE 0.001717
K_20531 X_NUC_133.L_CORE X_NUC_138.L_CORE 0.001724
K_20532 X_NUC_133.L_CORE X_NUC_139.L_CORE 0.001726
K_20533 X_NUC_133.L_CORE X_NUC_140.L_CORE 0.001714
K_20534 X_NUC_133.L_CORE X_NUC_141.L_CORE 0.002415
K_20535 X_NUC_133.L_CORE X_NUC_142.L_CORE 0.002398
K_20536 X_NUC_133.L_CORE X_NUC_143.L_CORE 0.002415
K_20537 X_NUC_133.L_CORE X_NUC_144.L_CORE 0.002393
K_20538 X_NUC_133.L_CORE X_NUC_145.L_CORE 0.003691
K_20539 X_NUC_133.L_CORE X_NUC_146.L_CORE 0.003748
K_20540 X_NUC_133.L_CORE X_NUC_147.L_CORE 0.003725
K_20541 X_NUC_133.L_CORE X_NUC_148.L_CORE 0.003694
K_20542 X_NUC_133.L_CORE X_NUC_149.L_CORE 0.001732
K_20543 X_NUC_133.L_CORE X_NUC_150.L_CORE 0.001732
K_20544 X_NUC_133.L_CORE X_NUC_151.L_CORE 0.001738
K_20545 X_NUC_133.L_CORE X_NUC_152.L_CORE 0.001724
K_20546 X_NUC_133.L_CORE X_NUC_153.L_CORE 0.005105
K_20547 X_NUC_133.L_CORE X_NUC_154.L_CORE 0.005035
K_20548 X_NUC_133.L_CORE X_NUC_155.L_CORE 0.005072
K_20549 X_NUC_133.L_CORE X_NUC_156.L_CORE 0.004989
K_20550 X_NUC_133.L_CORE X_NUC_157.L_CORE 0.002283
K_20551 X_NUC_133.L_CORE X_NUC_158.L_CORE 0.002297
K_20552 X_NUC_133.L_CORE X_NUC_159.L_CORE 0.002295
K_20553 X_NUC_133.L_CORE X_NUC_160.L_CORE 0.002276
K_20554 X_NUC_133.L_CORE X_NUC_161.L_CORE 0.002224
K_20555 X_NUC_133.L_CORE X_NUC_162.L_CORE 0.002218
K_20556 X_NUC_133.L_CORE X_NUC_163.L_CORE 0.002227
K_20557 X_NUC_133.L_CORE X_NUC_164.L_CORE 0.002205
K_20558 X_NUC_133.L_CORE X_NUC_165.L_CORE 0.004172
K_20559 X_NUC_133.L_CORE X_NUC_166.L_CORE 0.004196
K_20560 X_NUC_133.L_CORE X_NUC_167.L_CORE 0.004180
K_20561 X_NUC_133.L_CORE X_NUC_168.L_CORE 0.004118
K_20562 X_NUC_133.L_CORE X_NUC_169.L_CORE 0.002340
K_20563 X_NUC_133.L_CORE X_NUC_170.L_CORE 0.002345
K_20564 X_NUC_133.L_CORE X_NUC_171.L_CORE 0.002347
K_20565 X_NUC_133.L_CORE X_NUC_172.L_CORE 0.002323
K_20566 X_NUC_133.L_CORE X_NUC_173.L_CORE 0.001370
K_20567 X_NUC_133.L_CORE X_NUC_174.L_CORE 0.001459
K_20568 X_NUC_133.L_CORE X_NUC_175.L_CORE 0.001554
K_20569 X_NUC_133.L_CORE X_NUC_176.L_CORE 0.001290
K_20570 X_NUC_133.L_CORE X_NUC_177.L_CORE 0.001741
K_20571 X_NUC_133.L_CORE X_NUC_178.L_CORE 0.001399
K_20572 X_NUC_133.L_CORE X_NUC_179.L_CORE 0.001388
K_20573 X_NUC_133.L_CORE X_NUC_180.L_CORE 0.001924
K_20574 X_NUC_133.L_CORE X_NUC_181.L_CORE 0.001267
K_20575 X_NUC_133.L_CORE X_NUC_182.L_CORE 0.001751
K_20576 X_NUC_133.L_CORE X_NUC_183.L_CORE 0.001640
K_20577 X_NUC_133.L_CORE X_NUC_184.L_CORE 0.001294
K_20578 X_NUC_133.L_CORE X_NUC_185.L_CORE 0.002355
K_20579 X_NUC_133.L_CORE X_NUC_186.L_CORE 0.001350
K_20580 X_NUC_133.L_CORE X_NUC_187.L_CORE 0.001571
K_20581 X_NUC_133.L_CORE X_NUC_188.L_CORE 0.002176
K_20582 X_NUC_133.L_CORE X_NUC_189.L_CORE 0.001263
K_20583 X_NUC_133.L_CORE X_NUC_190.L_CORE 0.002357
K_20584 X_NUC_133.L_CORE X_NUC_191.L_CORE 0.001591
K_20585 X_NUC_133.L_CORE X_NUC_192.L_CORE 0.001404
K_20586 X_NUC_133.L_CORE X_NUC_193.L_CORE 0.003224
K_20587 X_NUC_133.L_CORE X_NUC_194.L_CORE 0.001326
K_20588 X_NUC_133.L_CORE X_NUC_195.L_CORE 0.001963
K_20589 X_NUC_133.L_CORE X_NUC_196.L_CORE 0.002154
K_20590 X_NUC_133.L_CORE X_NUC_197.L_CORE 0.001328
K_20591 X_NUC_133.L_CORE X_NUC_198.L_CORE 0.003843
K_20592 X_NUC_133.L_CORE X_NUC_199.L_CORE 0.001529
K_20593 X_NUC_133.L_CORE X_NUC_200.L_CORE 0.001642
K_20594 X_NUC_133.L_CORE X_NUC_201.L_CORE 0.003722
K_20595 X_NUC_133.L_CORE X_NUC_202.L_CORE 0.001358
K_20596 X_NUC_133.L_CORE X_NUC_203.L_CORE 0.002834
K_20597 X_NUC_133.L_CORE X_NUC_204.L_CORE 0.002006
K_20598 X_NUC_133.L_CORE X_NUC_205.L_CORE 0.001487
K_20599 X_NUC_133.L_CORE X_NUC_206.L_CORE 0.009869
K_20600 X_NUC_133.L_CORE X_NUC_207.L_CORE 0.001524
K_20601 X_NUC_133.L_CORE X_NUC_208.L_CORE 0.002107
K_20602 X_NUC_133.L_CORE X_NUC_209.L_CORE 0.003273
K_20603 X_NUC_133.L_CORE X_NUC_210.L_CORE 0.001481
K_20604 X_NUC_133.L_CORE X_NUC_211.L_CORE 0.005221
K_20605 X_NUC_133.L_CORE X_NUC_212.L_CORE 0.001923
K_20606 X_NUC_133.L_CORE X_NUC_213.L_CORE 0.001808
K_20607 X_NUC_133.L_CORE X_NUC_214.L_CORE 0.008085
K_20608 X_NUC_133.L_CORE X_NUC_215.L_CORE 0.001647
K_20609 X_NUC_133.L_CORE X_NUC_216.L_CORE 0.002963
K_20610 X_NUC_133.L_CORE X_NUC_217.L_CORE 0.002770
K_20611 X_NUC_133.L_CORE X_NUC_218.L_CORE 0.001810
K_20612 X_NUC_133.L_CORE X_NUC_219.L_CORE 0.005309
K_20613 X_NUC_133.L_CORE X_NUC_220.L_CORE 0.002107
K_20614 X_NUC_133.L_CORE X_NUC_221.L_CORE 0.002462
K_20615 X_NUC_133.L_CORE X_NUC_222.L_CORE 0.003082
K_20616 X_NUC_134.L_CORE X_NUC_135.L_CORE 0.207973
K_20617 X_NUC_134.L_CORE X_NUC_136.L_CORE 0.207973
K_20618 X_NUC_134.L_CORE X_NUC_137.L_CORE 0.001710
K_20619 X_NUC_134.L_CORE X_NUC_138.L_CORE 0.001717
K_20620 X_NUC_134.L_CORE X_NUC_139.L_CORE 0.001720
K_20621 X_NUC_134.L_CORE X_NUC_140.L_CORE 0.001707
K_20622 X_NUC_134.L_CORE X_NUC_141.L_CORE 0.002432
K_20623 X_NUC_134.L_CORE X_NUC_142.L_CORE 0.002415
K_20624 X_NUC_134.L_CORE X_NUC_143.L_CORE 0.002432
K_20625 X_NUC_134.L_CORE X_NUC_144.L_CORE 0.002410
K_20626 X_NUC_134.L_CORE X_NUC_145.L_CORE 0.003634
K_20627 X_NUC_134.L_CORE X_NUC_146.L_CORE 0.003691
K_20628 X_NUC_134.L_CORE X_NUC_147.L_CORE 0.003667
K_20629 X_NUC_134.L_CORE X_NUC_148.L_CORE 0.003639
K_20630 X_NUC_134.L_CORE X_NUC_149.L_CORE 0.001731
K_20631 X_NUC_134.L_CORE X_NUC_150.L_CORE 0.001732
K_20632 X_NUC_134.L_CORE X_NUC_151.L_CORE 0.001737
K_20633 X_NUC_134.L_CORE X_NUC_152.L_CORE 0.001723
K_20634 X_NUC_134.L_CORE X_NUC_153.L_CORE 0.005176
K_20635 X_NUC_134.L_CORE X_NUC_154.L_CORE 0.005105
K_20636 X_NUC_134.L_CORE X_NUC_155.L_CORE 0.005142
K_20637 X_NUC_134.L_CORE X_NUC_156.L_CORE 0.005056
K_20638 X_NUC_134.L_CORE X_NUC_157.L_CORE 0.002269
K_20639 X_NUC_134.L_CORE X_NUC_158.L_CORE 0.002283
K_20640 X_NUC_134.L_CORE X_NUC_159.L_CORE 0.002281
K_20641 X_NUC_134.L_CORE X_NUC_160.L_CORE 0.002262
K_20642 X_NUC_134.L_CORE X_NUC_161.L_CORE 0.002229
K_20643 X_NUC_134.L_CORE X_NUC_162.L_CORE 0.002224
K_20644 X_NUC_134.L_CORE X_NUC_163.L_CORE 0.002233
K_20645 X_NUC_134.L_CORE X_NUC_164.L_CORE 0.002211
K_20646 X_NUC_134.L_CORE X_NUC_165.L_CORE 0.004146
K_20647 X_NUC_134.L_CORE X_NUC_166.L_CORE 0.004172
K_20648 X_NUC_134.L_CORE X_NUC_167.L_CORE 0.004155
K_20649 X_NUC_134.L_CORE X_NUC_168.L_CORE 0.004094
K_20650 X_NUC_134.L_CORE X_NUC_169.L_CORE 0.002335
K_20651 X_NUC_134.L_CORE X_NUC_170.L_CORE 0.002340
K_20652 X_NUC_134.L_CORE X_NUC_171.L_CORE 0.002342
K_20653 X_NUC_134.L_CORE X_NUC_172.L_CORE 0.002318
K_20654 X_NUC_134.L_CORE X_NUC_173.L_CORE 0.001369
K_20655 X_NUC_134.L_CORE X_NUC_174.L_CORE 0.001461
K_20656 X_NUC_134.L_CORE X_NUC_175.L_CORE 0.001551
K_20657 X_NUC_134.L_CORE X_NUC_176.L_CORE 0.001290
K_20658 X_NUC_134.L_CORE X_NUC_177.L_CORE 0.001744
K_20659 X_NUC_134.L_CORE X_NUC_178.L_CORE 0.001395
K_20660 X_NUC_134.L_CORE X_NUC_179.L_CORE 0.001391
K_20661 X_NUC_134.L_CORE X_NUC_180.L_CORE 0.001919
K_20662 X_NUC_134.L_CORE X_NUC_181.L_CORE 0.001265
K_20663 X_NUC_134.L_CORE X_NUC_182.L_CORE 0.001758
K_20664 X_NUC_134.L_CORE X_NUC_183.L_CORE 0.001632
K_20665 X_NUC_134.L_CORE X_NUC_184.L_CORE 0.001295
K_20666 X_NUC_134.L_CORE X_NUC_185.L_CORE 0.002358
K_20667 X_NUC_134.L_CORE X_NUC_186.L_CORE 0.001346
K_20668 X_NUC_134.L_CORE X_NUC_187.L_CORE 0.001577
K_20669 X_NUC_134.L_CORE X_NUC_188.L_CORE 0.002163
K_20670 X_NUC_134.L_CORE X_NUC_189.L_CORE 0.001263
K_20671 X_NUC_134.L_CORE X_NUC_190.L_CORE 0.002373
K_20672 X_NUC_134.L_CORE X_NUC_191.L_CORE 0.001582
K_20673 X_NUC_134.L_CORE X_NUC_192.L_CORE 0.001408
K_20674 X_NUC_134.L_CORE X_NUC_193.L_CORE 0.003212
K_20675 X_NUC_134.L_CORE X_NUC_194.L_CORE 0.001323
K_20676 X_NUC_134.L_CORE X_NUC_195.L_CORE 0.001977
K_20677 X_NUC_134.L_CORE X_NUC_196.L_CORE 0.002135
K_20678 X_NUC_134.L_CORE X_NUC_197.L_CORE 0.001329
K_20679 X_NUC_134.L_CORE X_NUC_198.L_CORE 0.003885
K_20680 X_NUC_134.L_CORE X_NUC_199.L_CORE 0.001522
K_20681 X_NUC_134.L_CORE X_NUC_200.L_CORE 0.001649
K_20682 X_NUC_134.L_CORE X_NUC_201.L_CORE 0.003670
K_20683 X_NUC_134.L_CORE X_NUC_202.L_CORE 0.001356
K_20684 X_NUC_134.L_CORE X_NUC_203.L_CORE 0.002868
K_20685 X_NUC_134.L_CORE X_NUC_204.L_CORE 0.001990
K_20686 X_NUC_134.L_CORE X_NUC_205.L_CORE 0.001489
K_20687 X_NUC_134.L_CORE X_NUC_206.L_CORE 0.009911
K_20688 X_NUC_134.L_CORE X_NUC_207.L_CORE 0.001519
K_20689 X_NUC_134.L_CORE X_NUC_208.L_CORE 0.002122
K_20690 X_NUC_134.L_CORE X_NUC_209.L_CORE 0.003223
K_20691 X_NUC_134.L_CORE X_NUC_210.L_CORE 0.001481
K_20692 X_NUC_134.L_CORE X_NUC_211.L_CORE 0.005351
K_20693 X_NUC_134.L_CORE X_NUC_212.L_CORE 0.001910
K_20694 X_NUC_134.L_CORE X_NUC_213.L_CORE 0.001814
K_20695 X_NUC_134.L_CORE X_NUC_214.L_CORE 0.007820
K_20696 X_NUC_134.L_CORE X_NUC_215.L_CORE 0.001643
K_20697 X_NUC_134.L_CORE X_NUC_216.L_CORE 0.002991
K_20698 X_NUC_134.L_CORE X_NUC_217.L_CORE 0.002742
K_20699 X_NUC_134.L_CORE X_NUC_218.L_CORE 0.001812
K_20700 X_NUC_134.L_CORE X_NUC_219.L_CORE 0.005331
K_20701 X_NUC_134.L_CORE X_NUC_220.L_CORE 0.002098
K_20702 X_NUC_134.L_CORE X_NUC_221.L_CORE 0.002469
K_20703 X_NUC_134.L_CORE X_NUC_222.L_CORE 0.003070
K_20704 X_NUC_135.L_CORE X_NUC_136.L_CORE 0.207973
K_20705 X_NUC_135.L_CORE X_NUC_137.L_CORE 0.001708
K_20706 X_NUC_135.L_CORE X_NUC_138.L_CORE 0.001714
K_20707 X_NUC_135.L_CORE X_NUC_139.L_CORE 0.001717
K_20708 X_NUC_135.L_CORE X_NUC_140.L_CORE 0.001705
K_20709 X_NUC_135.L_CORE X_NUC_141.L_CORE 0.002414
K_20710 X_NUC_135.L_CORE X_NUC_142.L_CORE 0.002397
K_20711 X_NUC_135.L_CORE X_NUC_143.L_CORE 0.002415
K_20712 X_NUC_135.L_CORE X_NUC_144.L_CORE 0.002393
K_20713 X_NUC_135.L_CORE X_NUC_145.L_CORE 0.003656
K_20714 X_NUC_135.L_CORE X_NUC_146.L_CORE 0.003713
K_20715 X_NUC_135.L_CORE X_NUC_147.L_CORE 0.003691
K_20716 X_NUC_135.L_CORE X_NUC_148.L_CORE 0.003661
K_20717 X_NUC_135.L_CORE X_NUC_149.L_CORE 0.001726
K_20718 X_NUC_135.L_CORE X_NUC_150.L_CORE 0.001726
K_20719 X_NUC_135.L_CORE X_NUC_151.L_CORE 0.001732
K_20720 X_NUC_135.L_CORE X_NUC_152.L_CORE 0.001718
K_20721 X_NUC_135.L_CORE X_NUC_153.L_CORE 0.005136
K_20722 X_NUC_135.L_CORE X_NUC_154.L_CORE 0.005066
K_20723 X_NUC_135.L_CORE X_NUC_155.L_CORE 0.005105
K_20724 X_NUC_135.L_CORE X_NUC_156.L_CORE 0.005020
K_20725 X_NUC_135.L_CORE X_NUC_157.L_CORE 0.002270
K_20726 X_NUC_135.L_CORE X_NUC_158.L_CORE 0.002284
K_20727 X_NUC_135.L_CORE X_NUC_159.L_CORE 0.002283
K_20728 X_NUC_135.L_CORE X_NUC_160.L_CORE 0.002263
K_20729 X_NUC_135.L_CORE X_NUC_161.L_CORE 0.002220
K_20730 X_NUC_135.L_CORE X_NUC_162.L_CORE 0.002214
K_20731 X_NUC_135.L_CORE X_NUC_163.L_CORE 0.002224
K_20732 X_NUC_135.L_CORE X_NUC_164.L_CORE 0.002202
K_20733 X_NUC_135.L_CORE X_NUC_165.L_CORE 0.004163
K_20734 X_NUC_135.L_CORE X_NUC_166.L_CORE 0.004188
K_20735 X_NUC_135.L_CORE X_NUC_167.L_CORE 0.004172
K_20736 X_NUC_135.L_CORE X_NUC_168.L_CORE 0.004110
K_20737 X_NUC_135.L_CORE X_NUC_169.L_CORE 0.002332
K_20738 X_NUC_135.L_CORE X_NUC_170.L_CORE 0.002337
K_20739 X_NUC_135.L_CORE X_NUC_171.L_CORE 0.002340
K_20740 X_NUC_135.L_CORE X_NUC_172.L_CORE 0.002316
K_20741 X_NUC_135.L_CORE X_NUC_173.L_CORE 0.001362
K_20742 X_NUC_135.L_CORE X_NUC_174.L_CORE 0.001451
K_20743 X_NUC_135.L_CORE X_NUC_175.L_CORE 0.001543
K_20744 X_NUC_135.L_CORE X_NUC_176.L_CORE 0.001283
K_20745 X_NUC_135.L_CORE X_NUC_177.L_CORE 0.001731
K_20746 X_NUC_135.L_CORE X_NUC_178.L_CORE 0.001390
K_20747 X_NUC_135.L_CORE X_NUC_179.L_CORE 0.001382
K_20748 X_NUC_135.L_CORE X_NUC_180.L_CORE 0.001909
K_20749 X_NUC_135.L_CORE X_NUC_181.L_CORE 0.001260
K_20750 X_NUC_135.L_CORE X_NUC_182.L_CORE 0.001743
K_20751 X_NUC_135.L_CORE X_NUC_183.L_CORE 0.001627
K_20752 X_NUC_135.L_CORE X_NUC_184.L_CORE 0.001288
K_20753 X_NUC_135.L_CORE X_NUC_185.L_CORE 0.002339
K_20754 X_NUC_135.L_CORE X_NUC_186.L_CORE 0.001342
K_20755 X_NUC_135.L_CORE X_NUC_187.L_CORE 0.001565
K_20756 X_NUC_135.L_CORE X_NUC_188.L_CORE 0.002157
K_20757 X_NUC_135.L_CORE X_NUC_189.L_CORE 0.001257
K_20758 X_NUC_135.L_CORE X_NUC_190.L_CORE 0.002348
K_20759 X_NUC_135.L_CORE X_NUC_191.L_CORE 0.001579
K_20760 X_NUC_135.L_CORE X_NUC_192.L_CORE 0.001399
K_20761 X_NUC_135.L_CORE X_NUC_193.L_CORE 0.003193
K_20762 X_NUC_135.L_CORE X_NUC_194.L_CORE 0.001319
K_20763 X_NUC_135.L_CORE X_NUC_195.L_CORE 0.001959
K_20764 X_NUC_135.L_CORE X_NUC_196.L_CORE 0.002134
K_20765 X_NUC_135.L_CORE X_NUC_197.L_CORE 0.001323
K_20766 X_NUC_135.L_CORE X_NUC_198.L_CORE 0.003831
K_20767 X_NUC_135.L_CORE X_NUC_199.L_CORE 0.001519
K_20768 X_NUC_135.L_CORE X_NUC_200.L_CORE 0.001638
K_20769 X_NUC_135.L_CORE X_NUC_201.L_CORE 0.003675
K_20770 X_NUC_135.L_CORE X_NUC_202.L_CORE 0.001352
K_20771 X_NUC_135.L_CORE X_NUC_203.L_CORE 0.002835
K_20772 X_NUC_135.L_CORE X_NUC_204.L_CORE 0.001991
K_20773 X_NUC_135.L_CORE X_NUC_205.L_CORE 0.001482
K_20774 X_NUC_135.L_CORE X_NUC_206.L_CORE 0.009814
K_20775 X_NUC_135.L_CORE X_NUC_207.L_CORE 0.001516
K_20776 X_NUC_135.L_CORE X_NUC_208.L_CORE 0.002106
K_20777 X_NUC_135.L_CORE X_NUC_209.L_CORE 0.003240
K_20778 X_NUC_135.L_CORE X_NUC_210.L_CORE 0.001476
K_20779 X_NUC_135.L_CORE X_NUC_211.L_CORE 0.005273
K_20780 X_NUC_135.L_CORE X_NUC_212.L_CORE 0.001911
K_20781 X_NUC_135.L_CORE X_NUC_213.L_CORE 0.001805
K_20782 X_NUC_135.L_CORE X_NUC_214.L_CORE 0.008037
K_20783 X_NUC_135.L_CORE X_NUC_215.L_CORE 0.001640
K_20784 X_NUC_135.L_CORE X_NUC_216.L_CORE 0.002970
K_20785 X_NUC_135.L_CORE X_NUC_217.L_CORE 0.002753
K_20786 X_NUC_135.L_CORE X_NUC_218.L_CORE 0.001806
K_20787 X_NUC_135.L_CORE X_NUC_219.L_CORE 0.005351
K_20788 X_NUC_135.L_CORE X_NUC_220.L_CORE 0.002099
K_20789 X_NUC_135.L_CORE X_NUC_221.L_CORE 0.002462
K_20790 X_NUC_135.L_CORE X_NUC_222.L_CORE 0.003078
K_20791 X_NUC_136.L_CORE X_NUC_137.L_CORE 0.001720
K_20792 X_NUC_136.L_CORE X_NUC_138.L_CORE 0.001727
K_20793 X_NUC_136.L_CORE X_NUC_139.L_CORE 0.001730
K_20794 X_NUC_136.L_CORE X_NUC_140.L_CORE 0.001717
K_20795 X_NUC_136.L_CORE X_NUC_141.L_CORE 0.002436
K_20796 X_NUC_136.L_CORE X_NUC_142.L_CORE 0.002419
K_20797 X_NUC_136.L_CORE X_NUC_143.L_CORE 0.002437
K_20798 X_NUC_136.L_CORE X_NUC_144.L_CORE 0.002415
K_20799 X_NUC_136.L_CORE X_NUC_145.L_CORE 0.003685
K_20800 X_NUC_136.L_CORE X_NUC_146.L_CORE 0.003744
K_20801 X_NUC_136.L_CORE X_NUC_147.L_CORE 0.003720
K_20802 X_NUC_136.L_CORE X_NUC_148.L_CORE 0.003691
K_20803 X_NUC_136.L_CORE X_NUC_149.L_CORE 0.001740
K_20804 X_NUC_136.L_CORE X_NUC_150.L_CORE 0.001741
K_20805 X_NUC_136.L_CORE X_NUC_151.L_CORE 0.001746
K_20806 X_NUC_136.L_CORE X_NUC_152.L_CORE 0.001732
K_20807 X_NUC_136.L_CORE X_NUC_153.L_CORE 0.005227
K_20808 X_NUC_136.L_CORE X_NUC_154.L_CORE 0.005153
K_20809 X_NUC_136.L_CORE X_NUC_155.L_CORE 0.005193
K_20810 X_NUC_136.L_CORE X_NUC_156.L_CORE 0.005105
K_20811 X_NUC_136.L_CORE X_NUC_157.L_CORE 0.002290
K_20812 X_NUC_136.L_CORE X_NUC_158.L_CORE 0.002304
K_20813 X_NUC_136.L_CORE X_NUC_159.L_CORE 0.002303
K_20814 X_NUC_136.L_CORE X_NUC_160.L_CORE 0.002283
K_20815 X_NUC_136.L_CORE X_NUC_161.L_CORE 0.002242
K_20816 X_NUC_136.L_CORE X_NUC_162.L_CORE 0.002236
K_20817 X_NUC_136.L_CORE X_NUC_163.L_CORE 0.002246
K_20818 X_NUC_136.L_CORE X_NUC_164.L_CORE 0.002224
K_20819 X_NUC_136.L_CORE X_NUC_165.L_CORE 0.004226
K_20820 X_NUC_136.L_CORE X_NUC_166.L_CORE 0.004252
K_20821 X_NUC_136.L_CORE X_NUC_167.L_CORE 0.004235
K_20822 X_NUC_136.L_CORE X_NUC_168.L_CORE 0.004172
K_20823 X_NUC_136.L_CORE X_NUC_169.L_CORE 0.002356
K_20824 X_NUC_136.L_CORE X_NUC_170.L_CORE 0.002361
K_20825 X_NUC_136.L_CORE X_NUC_171.L_CORE 0.002364
K_20826 X_NUC_136.L_CORE X_NUC_172.L_CORE 0.002340
K_20827 X_NUC_136.L_CORE X_NUC_173.L_CORE 0.001367
K_20828 X_NUC_136.L_CORE X_NUC_174.L_CORE 0.001456
K_20829 X_NUC_136.L_CORE X_NUC_175.L_CORE 0.001547
K_20830 X_NUC_136.L_CORE X_NUC_176.L_CORE 0.001289
K_20831 X_NUC_136.L_CORE X_NUC_177.L_CORE 0.001734
K_20832 X_NUC_136.L_CORE X_NUC_178.L_CORE 0.001395
K_20833 X_NUC_136.L_CORE X_NUC_179.L_CORE 0.001388
K_20834 X_NUC_136.L_CORE X_NUC_180.L_CORE 0.001910
K_20835 X_NUC_136.L_CORE X_NUC_181.L_CORE 0.001265
K_20836 X_NUC_136.L_CORE X_NUC_182.L_CORE 0.001748
K_20837 X_NUC_136.L_CORE X_NUC_183.L_CORE 0.001631
K_20838 X_NUC_136.L_CORE X_NUC_184.L_CORE 0.001295
K_20839 X_NUC_136.L_CORE X_NUC_185.L_CORE 0.002337
K_20840 X_NUC_136.L_CORE X_NUC_186.L_CORE 0.001348
K_20841 X_NUC_136.L_CORE X_NUC_187.L_CORE 0.001572
K_20842 X_NUC_136.L_CORE X_NUC_188.L_CORE 0.002157
K_20843 X_NUC_136.L_CORE X_NUC_189.L_CORE 0.001264
K_20844 X_NUC_136.L_CORE X_NUC_190.L_CORE 0.002351
K_20845 X_NUC_136.L_CORE X_NUC_191.L_CORE 0.001585
K_20846 X_NUC_136.L_CORE X_NUC_192.L_CORE 0.001407
K_20847 X_NUC_136.L_CORE X_NUC_193.L_CORE 0.003179
K_20848 X_NUC_136.L_CORE X_NUC_194.L_CORE 0.001326
K_20849 X_NUC_136.L_CORE X_NUC_195.L_CORE 0.001968
K_20850 X_NUC_136.L_CORE X_NUC_196.L_CORE 0.002139
K_20851 X_NUC_136.L_CORE X_NUC_197.L_CORE 0.001331
K_20852 X_NUC_136.L_CORE X_NUC_198.L_CORE 0.003817
K_20853 X_NUC_136.L_CORE X_NUC_199.L_CORE 0.001527
K_20854 X_NUC_136.L_CORE X_NUC_200.L_CORE 0.001648
K_20855 X_NUC_136.L_CORE X_NUC_201.L_CORE 0.003662
K_20856 X_NUC_136.L_CORE X_NUC_202.L_CORE 0.001360
K_20857 X_NUC_136.L_CORE X_NUC_203.L_CORE 0.002847
K_20858 X_NUC_136.L_CORE X_NUC_204.L_CORE 0.001999
K_20859 X_NUC_136.L_CORE X_NUC_205.L_CORE 0.001492
K_20860 X_NUC_136.L_CORE X_NUC_206.L_CORE 0.009508
K_20861 X_NUC_136.L_CORE X_NUC_207.L_CORE 0.001526
K_20862 X_NUC_136.L_CORE X_NUC_208.L_CORE 0.002121
K_20863 X_NUC_136.L_CORE X_NUC_209.L_CORE 0.003250
K_20864 X_NUC_136.L_CORE X_NUC_210.L_CORE 0.001486
K_20865 X_NUC_136.L_CORE X_NUC_211.L_CORE 0.005307
K_20866 X_NUC_136.L_CORE X_NUC_212.L_CORE 0.001923
K_20867 X_NUC_136.L_CORE X_NUC_213.L_CORE 0.001819
K_20868 X_NUC_136.L_CORE X_NUC_214.L_CORE 0.008068
K_20869 X_NUC_136.L_CORE X_NUC_215.L_CORE 0.001652
K_20870 X_NUC_136.L_CORE X_NUC_216.L_CORE 0.003000
K_20871 X_NUC_136.L_CORE X_NUC_217.L_CORE 0.002775
K_20872 X_NUC_136.L_CORE X_NUC_218.L_CORE 0.001821
K_20873 X_NUC_136.L_CORE X_NUC_219.L_CORE 0.005439
K_20874 X_NUC_136.L_CORE X_NUC_220.L_CORE 0.002117
K_20875 X_NUC_136.L_CORE X_NUC_221.L_CORE 0.002487
K_20876 X_NUC_136.L_CORE X_NUC_222.L_CORE 0.003113
K_20877 X_NUC_137.L_CORE X_NUC_138.L_CORE 0.207973
K_20878 X_NUC_137.L_CORE X_NUC_139.L_CORE 0.207973
K_20879 X_NUC_137.L_CORE X_NUC_140.L_CORE 0.207973
K_20880 X_NUC_137.L_CORE X_NUC_141.L_CORE 0.001795
K_20881 X_NUC_137.L_CORE X_NUC_142.L_CORE 0.001781
K_20882 X_NUC_137.L_CORE X_NUC_143.L_CORE 0.001785
K_20883 X_NUC_137.L_CORE X_NUC_144.L_CORE 0.001790
K_20884 X_NUC_137.L_CORE X_NUC_145.L_CORE 0.002533
K_20885 X_NUC_137.L_CORE X_NUC_146.L_CORE 0.002530
K_20886 X_NUC_137.L_CORE X_NUC_147.L_CORE 0.002515
K_20887 X_NUC_137.L_CORE X_NUC_148.L_CORE 0.002545
K_20888 X_NUC_137.L_CORE X_NUC_149.L_CORE 0.003870
K_20889 X_NUC_137.L_CORE X_NUC_150.L_CORE 0.003803
K_20890 X_NUC_137.L_CORE X_NUC_151.L_CORE 0.003834
K_20891 X_NUC_137.L_CORE X_NUC_152.L_CORE 0.003818
K_20892 X_NUC_137.L_CORE X_NUC_153.L_CORE 0.001839
K_20893 X_NUC_137.L_CORE X_NUC_154.L_CORE 0.001828
K_20894 X_NUC_137.L_CORE X_NUC_155.L_CORE 0.001827
K_20895 X_NUC_137.L_CORE X_NUC_156.L_CORE 0.001838
K_20896 X_NUC_137.L_CORE X_NUC_157.L_CORE 0.005182
K_20897 X_NUC_137.L_CORE X_NUC_158.L_CORE 0.005164
K_20898 X_NUC_137.L_CORE X_NUC_159.L_CORE 0.005076
K_20899 X_NUC_137.L_CORE X_NUC_160.L_CORE 0.005186
K_20900 X_NUC_137.L_CORE X_NUC_161.L_CORE 0.002455
K_20901 X_NUC_137.L_CORE X_NUC_162.L_CORE 0.002428
K_20902 X_NUC_137.L_CORE X_NUC_163.L_CORE 0.002433
K_20903 X_NUC_137.L_CORE X_NUC_164.L_CORE 0.002440
K_20904 X_NUC_137.L_CORE X_NUC_165.L_CORE 0.002434
K_20905 X_NUC_137.L_CORE X_NUC_166.L_CORE 0.002420
K_20906 X_NUC_137.L_CORE X_NUC_167.L_CORE 0.002409
K_20907 X_NUC_137.L_CORE X_NUC_168.L_CORE 0.002432
K_20908 X_NUC_137.L_CORE X_NUC_169.L_CORE 0.003690
K_20909 X_NUC_137.L_CORE X_NUC_170.L_CORE 0.003644
K_20910 X_NUC_137.L_CORE X_NUC_171.L_CORE 0.003628
K_20911 X_NUC_137.L_CORE X_NUC_172.L_CORE 0.003657
K_20912 X_NUC_137.L_CORE X_NUC_173.L_CORE 0.001480
K_20913 X_NUC_137.L_CORE X_NUC_174.L_CORE 0.001326
K_20914 X_NUC_137.L_CORE X_NUC_175.L_CORE 0.001455
K_20915 X_NUC_137.L_CORE X_NUC_176.L_CORE 0.001554
K_20916 X_NUC_137.L_CORE X_NUC_177.L_CORE 0.001273
K_20917 X_NUC_137.L_CORE X_NUC_178.L_CORE 0.001748
K_20918 X_NUC_137.L_CORE X_NUC_179.L_CORE 0.001387
K_20919 X_NUC_137.L_CORE X_NUC_180.L_CORE 0.001383
K_20920 X_NUC_137.L_CORE X_NUC_181.L_CORE 0.001916
K_20921 X_NUC_137.L_CORE X_NUC_182.L_CORE 0.001261
K_20922 X_NUC_137.L_CORE X_NUC_183.L_CORE 0.001750
K_20923 X_NUC_137.L_CORE X_NUC_184.L_CORE 0.001629
K_20924 X_NUC_137.L_CORE X_NUC_185.L_CORE 0.001295
K_20925 X_NUC_137.L_CORE X_NUC_186.L_CORE 0.002338
K_20926 X_NUC_137.L_CORE X_NUC_187.L_CORE 0.001349
K_20927 X_NUC_137.L_CORE X_NUC_188.L_CORE 0.001577
K_20928 X_NUC_137.L_CORE X_NUC_189.L_CORE 0.002154
K_20929 X_NUC_137.L_CORE X_NUC_190.L_CORE 0.001270
K_20930 X_NUC_137.L_CORE X_NUC_191.L_CORE 0.002356
K_20931 X_NUC_137.L_CORE X_NUC_192.L_CORE 0.001591
K_20932 X_NUC_137.L_CORE X_NUC_193.L_CORE 0.001418
K_20933 X_NUC_137.L_CORE X_NUC_194.L_CORE 0.003162
K_20934 X_NUC_137.L_CORE X_NUC_195.L_CORE 0.001337
K_20935 X_NUC_137.L_CORE X_NUC_196.L_CORE 0.001985
K_20936 X_NUC_137.L_CORE X_NUC_197.L_CORE 0.002149
K_20937 X_NUC_137.L_CORE X_NUC_198.L_CORE 0.001347
K_20938 X_NUC_137.L_CORE X_NUC_199.L_CORE 0.003819
K_20939 X_NUC_137.L_CORE X_NUC_200.L_CORE 0.001545
K_20940 X_NUC_137.L_CORE X_NUC_201.L_CORE 0.001673
K_20941 X_NUC_137.L_CORE X_NUC_202.L_CORE 0.003670
K_20942 X_NUC_137.L_CORE X_NUC_203.L_CORE 0.001383
K_20943 X_NUC_137.L_CORE X_NUC_204.L_CORE 0.002897
K_20944 X_NUC_137.L_CORE X_NUC_205.L_CORE 0.002031
K_20945 X_NUC_137.L_CORE X_NUC_206.L_CORE 0.001523
K_20946 X_NUC_137.L_CORE X_NUC_207.L_CORE 0.009504
K_20947 X_NUC_137.L_CORE X_NUC_208.L_CORE 0.001560
K_20948 X_NUC_137.L_CORE X_NUC_209.L_CORE 0.002178
K_20949 X_NUC_137.L_CORE X_NUC_210.L_CORE 0.003322
K_20950 X_NUC_137.L_CORE X_NUC_211.L_CORE 0.001529
K_20951 X_NUC_137.L_CORE X_NUC_212.L_CORE 0.005511
K_20952 X_NUC_137.L_CORE X_NUC_213.L_CORE 0.001983
K_20953 X_NUC_137.L_CORE X_NUC_214.L_CORE 0.001886
K_20954 X_NUC_137.L_CORE X_NUC_215.L_CORE 0.008144
K_20955 X_NUC_137.L_CORE X_NUC_216.L_CORE 0.001722
K_20956 X_NUC_137.L_CORE X_NUC_217.L_CORE 0.003128
K_20957 X_NUC_137.L_CORE X_NUC_218.L_CORE 0.002887
K_20958 X_NUC_137.L_CORE X_NUC_219.L_CORE 0.001933
K_20959 X_NUC_137.L_CORE X_NUC_220.L_CORE 0.005067
K_20960 X_NUC_137.L_CORE X_NUC_221.L_CORE 0.002291
K_20961 X_NUC_137.L_CORE X_NUC_222.L_CORE 0.002685
K_20962 X_NUC_138.L_CORE X_NUC_139.L_CORE 0.207973
K_20963 X_NUC_138.L_CORE X_NUC_140.L_CORE 0.207973
K_20964 X_NUC_138.L_CORE X_NUC_141.L_CORE 0.001810
K_20965 X_NUC_138.L_CORE X_NUC_142.L_CORE 0.001795
K_20966 X_NUC_138.L_CORE X_NUC_143.L_CORE 0.001799
K_20967 X_NUC_138.L_CORE X_NUC_144.L_CORE 0.001805
K_20968 X_NUC_138.L_CORE X_NUC_145.L_CORE 0.002536
K_20969 X_NUC_138.L_CORE X_NUC_146.L_CORE 0.002533
K_20970 X_NUC_138.L_CORE X_NUC_147.L_CORE 0.002518
K_20971 X_NUC_138.L_CORE X_NUC_148.L_CORE 0.002548
K_20972 X_NUC_138.L_CORE X_NUC_149.L_CORE 0.003940
K_20973 X_NUC_138.L_CORE X_NUC_150.L_CORE 0.003870
K_20974 X_NUC_138.L_CORE X_NUC_151.L_CORE 0.003902
K_20975 X_NUC_138.L_CORE X_NUC_152.L_CORE 0.003885
K_20976 X_NUC_138.L_CORE X_NUC_153.L_CORE 0.001851
K_20977 X_NUC_138.L_CORE X_NUC_154.L_CORE 0.001839
K_20978 X_NUC_138.L_CORE X_NUC_155.L_CORE 0.001838
K_20979 X_NUC_138.L_CORE X_NUC_156.L_CORE 0.001849
K_20980 X_NUC_138.L_CORE X_NUC_157.L_CORE 0.005197
K_20981 X_NUC_138.L_CORE X_NUC_158.L_CORE 0.005182
K_20982 X_NUC_138.L_CORE X_NUC_159.L_CORE 0.005092
K_20983 X_NUC_138.L_CORE X_NUC_160.L_CORE 0.005203
K_20984 X_NUC_138.L_CORE X_NUC_161.L_CORE 0.002483
K_20985 X_NUC_138.L_CORE X_NUC_162.L_CORE 0.002455
K_20986 X_NUC_138.L_CORE X_NUC_163.L_CORE 0.002460
K_20987 X_NUC_138.L_CORE X_NUC_164.L_CORE 0.002467
K_20988 X_NUC_138.L_CORE X_NUC_165.L_CORE 0.002448
K_20989 X_NUC_138.L_CORE X_NUC_166.L_CORE 0.002434
K_20990 X_NUC_138.L_CORE X_NUC_167.L_CORE 0.002423
K_20991 X_NUC_138.L_CORE X_NUC_168.L_CORE 0.002446
K_20992 X_NUC_138.L_CORE X_NUC_169.L_CORE 0.003737
K_20993 X_NUC_138.L_CORE X_NUC_170.L_CORE 0.003690
K_20994 X_NUC_138.L_CORE X_NUC_171.L_CORE 0.003673
K_20995 X_NUC_138.L_CORE X_NUC_172.L_CORE 0.003704
K_20996 X_NUC_138.L_CORE X_NUC_173.L_CORE 0.001483
K_20997 X_NUC_138.L_CORE X_NUC_174.L_CORE 0.001330
K_20998 X_NUC_138.L_CORE X_NUC_175.L_CORE 0.001456
K_20999 X_NUC_138.L_CORE X_NUC_176.L_CORE 0.001558
K_21000 X_NUC_138.L_CORE X_NUC_177.L_CORE 0.001276
K_21001 X_NUC_138.L_CORE X_NUC_178.L_CORE 0.001748
K_21002 X_NUC_138.L_CORE X_NUC_179.L_CORE 0.001393
K_21003 X_NUC_138.L_CORE X_NUC_180.L_CORE 0.001385
K_21004 X_NUC_138.L_CORE X_NUC_181.L_CORE 0.001920
K_21005 X_NUC_138.L_CORE X_NUC_182.L_CORE 0.001266
K_21006 X_NUC_138.L_CORE X_NUC_183.L_CORE 0.001748
K_21007 X_NUC_138.L_CORE X_NUC_184.L_CORE 0.001637
K_21008 X_NUC_138.L_CORE X_NUC_185.L_CORE 0.001299
K_21009 X_NUC_138.L_CORE X_NUC_186.L_CORE 0.002333
K_21010 X_NUC_138.L_CORE X_NUC_187.L_CORE 0.001356
K_21011 X_NUC_138.L_CORE X_NUC_188.L_CORE 0.001577
K_21012 X_NUC_138.L_CORE X_NUC_189.L_CORE 0.002164
K_21013 X_NUC_138.L_CORE X_NUC_190.L_CORE 0.001275
K_21014 X_NUC_138.L_CORE X_NUC_191.L_CORE 0.002345
K_21015 X_NUC_138.L_CORE X_NUC_192.L_CORE 0.001601
K_21016 X_NUC_138.L_CORE X_NUC_193.L_CORE 0.001421
K_21017 X_NUC_138.L_CORE X_NUC_194.L_CORE 0.003160
K_21018 X_NUC_138.L_CORE X_NUC_195.L_CORE 0.001345
K_21019 X_NUC_138.L_CORE X_NUC_196.L_CORE 0.001981
K_21020 X_NUC_138.L_CORE X_NUC_197.L_CORE 0.002165
K_21021 X_NUC_138.L_CORE X_NUC_198.L_CORE 0.001352
K_21022 X_NUC_138.L_CORE X_NUC_199.L_CORE 0.003778
K_21023 X_NUC_138.L_CORE X_NUC_200.L_CORE 0.001556
K_21024 X_NUC_138.L_CORE X_NUC_201.L_CORE 0.001674
K_21025 X_NUC_138.L_CORE X_NUC_202.L_CORE 0.003697
K_21026 X_NUC_138.L_CORE X_NUC_203.L_CORE 0.001390
K_21027 X_NUC_138.L_CORE X_NUC_204.L_CORE 0.002879
K_21028 X_NUC_138.L_CORE X_NUC_205.L_CORE 0.002050
K_21029 X_NUC_138.L_CORE X_NUC_206.L_CORE 0.001528
K_21030 X_NUC_138.L_CORE X_NUC_207.L_CORE 0.009268
K_21031 X_NUC_138.L_CORE X_NUC_208.L_CORE 0.001571
K_21032 X_NUC_138.L_CORE X_NUC_209.L_CORE 0.002176
K_21033 X_NUC_138.L_CORE X_NUC_210.L_CORE 0.003368
K_21034 X_NUC_138.L_CORE X_NUC_211.L_CORE 0.001537
K_21035 X_NUC_138.L_CORE X_NUC_212.L_CORE 0.005432
K_21036 X_NUC_138.L_CORE X_NUC_213.L_CORE 0.002003
K_21037 X_NUC_138.L_CORE X_NUC_214.L_CORE 0.001892
K_21038 X_NUC_138.L_CORE X_NUC_215.L_CORE 0.008379
K_21039 X_NUC_138.L_CORE X_NUC_216.L_CORE 0.001734
K_21040 X_NUC_138.L_CORE X_NUC_217.L_CORE 0.003127
K_21041 X_NUC_138.L_CORE X_NUC_218.L_CORE 0.002925
K_21042 X_NUC_138.L_CORE X_NUC_219.L_CORE 0.001943
K_21043 X_NUC_138.L_CORE X_NUC_220.L_CORE 0.005113
K_21044 X_NUC_138.L_CORE X_NUC_221.L_CORE 0.002313
K_21045 X_NUC_138.L_CORE X_NUC_222.L_CORE 0.002703
K_21046 X_NUC_139.L_CORE X_NUC_140.L_CORE 0.207973
K_21047 X_NUC_139.L_CORE X_NUC_141.L_CORE 0.001805
K_21048 X_NUC_139.L_CORE X_NUC_142.L_CORE 0.001791
K_21049 X_NUC_139.L_CORE X_NUC_143.L_CORE 0.001795
K_21050 X_NUC_139.L_CORE X_NUC_144.L_CORE 0.001800
K_21051 X_NUC_139.L_CORE X_NUC_145.L_CORE 0.002552
K_21052 X_NUC_139.L_CORE X_NUC_146.L_CORE 0.002549
K_21053 X_NUC_139.L_CORE X_NUC_147.L_CORE 0.002533
K_21054 X_NUC_139.L_CORE X_NUC_148.L_CORE 0.002564
K_21055 X_NUC_139.L_CORE X_NUC_149.L_CORE 0.003907
K_21056 X_NUC_139.L_CORE X_NUC_150.L_CORE 0.003838
K_21057 X_NUC_139.L_CORE X_NUC_151.L_CORE 0.003870
K_21058 X_NUC_139.L_CORE X_NUC_152.L_CORE 0.003854
K_21059 X_NUC_139.L_CORE X_NUC_153.L_CORE 0.001852
K_21060 X_NUC_139.L_CORE X_NUC_154.L_CORE 0.001841
K_21061 X_NUC_139.L_CORE X_NUC_155.L_CORE 0.001839
K_21062 X_NUC_139.L_CORE X_NUC_156.L_CORE 0.001851
K_21063 X_NUC_139.L_CORE X_NUC_157.L_CORE 0.005291
K_21064 X_NUC_139.L_CORE X_NUC_158.L_CORE 0.005273
K_21065 X_NUC_139.L_CORE X_NUC_159.L_CORE 0.005182
K_21066 X_NUC_139.L_CORE X_NUC_160.L_CORE 0.005297
K_21067 X_NUC_139.L_CORE X_NUC_161.L_CORE 0.002478
K_21068 X_NUC_139.L_CORE X_NUC_162.L_CORE 0.002450
K_21069 X_NUC_139.L_CORE X_NUC_163.L_CORE 0.002455
K_21070 X_NUC_139.L_CORE X_NUC_164.L_CORE 0.002462
K_21071 X_NUC_139.L_CORE X_NUC_165.L_CORE 0.002459
K_21072 X_NUC_139.L_CORE X_NUC_166.L_CORE 0.002445
K_21073 X_NUC_139.L_CORE X_NUC_167.L_CORE 0.002434
K_21074 X_NUC_139.L_CORE X_NUC_168.L_CORE 0.002457
K_21075 X_NUC_139.L_CORE X_NUC_169.L_CORE 0.003754
K_21076 X_NUC_139.L_CORE X_NUC_170.L_CORE 0.003706
K_21077 X_NUC_139.L_CORE X_NUC_171.L_CORE 0.003690
K_21078 X_NUC_139.L_CORE X_NUC_172.L_CORE 0.003720
K_21079 X_NUC_139.L_CORE X_NUC_173.L_CORE 0.001476
K_21080 X_NUC_139.L_CORE X_NUC_174.L_CORE 0.001325
K_21081 X_NUC_139.L_CORE X_NUC_175.L_CORE 0.001452
K_21082 X_NUC_139.L_CORE X_NUC_176.L_CORE 0.001548
K_21083 X_NUC_139.L_CORE X_NUC_177.L_CORE 0.001272
K_21084 X_NUC_139.L_CORE X_NUC_178.L_CORE 0.001740
K_21085 X_NUC_139.L_CORE X_NUC_179.L_CORE 0.001385
K_21086 X_NUC_139.L_CORE X_NUC_180.L_CORE 0.001382
K_21087 X_NUC_139.L_CORE X_NUC_181.L_CORE 0.001905
K_21088 X_NUC_139.L_CORE X_NUC_182.L_CORE 0.001261
K_21089 X_NUC_139.L_CORE X_NUC_183.L_CORE 0.001745
K_21090 X_NUC_139.L_CORE X_NUC_184.L_CORE 0.001625
K_21091 X_NUC_139.L_CORE X_NUC_185.L_CORE 0.001297
K_21092 X_NUC_139.L_CORE X_NUC_186.L_CORE 0.002317
K_21093 X_NUC_139.L_CORE X_NUC_187.L_CORE 0.001350
K_21094 X_NUC_139.L_CORE X_NUC_188.L_CORE 0.001577
K_21095 X_NUC_139.L_CORE X_NUC_189.L_CORE 0.002142
K_21096 X_NUC_139.L_CORE X_NUC_190.L_CORE 0.001272
K_21097 X_NUC_139.L_CORE X_NUC_191.L_CORE 0.002341
K_21098 X_NUC_139.L_CORE X_NUC_192.L_CORE 0.001591
K_21099 X_NUC_139.L_CORE X_NUC_193.L_CORE 0.001420
K_21100 X_NUC_139.L_CORE X_NUC_194.L_CORE 0.003121
K_21101 X_NUC_139.L_CORE X_NUC_195.L_CORE 0.001340
K_21102 X_NUC_139.L_CORE X_NUC_196.L_CORE 0.001984
K_21103 X_NUC_139.L_CORE X_NUC_197.L_CORE 0.002144
K_21104 X_NUC_139.L_CORE X_NUC_198.L_CORE 0.001351
K_21105 X_NUC_139.L_CORE X_NUC_199.L_CORE 0.003767
K_21106 X_NUC_139.L_CORE X_NUC_200.L_CORE 0.001549
K_21107 X_NUC_139.L_CORE X_NUC_201.L_CORE 0.001677
K_21108 X_NUC_139.L_CORE X_NUC_202.L_CORE 0.003635
K_21109 X_NUC_139.L_CORE X_NUC_203.L_CORE 0.001388
K_21110 X_NUC_139.L_CORE X_NUC_204.L_CORE 0.002894
K_21111 X_NUC_139.L_CORE X_NUC_205.L_CORE 0.002035
K_21112 X_NUC_139.L_CORE X_NUC_206.L_CORE 0.001530
K_21113 X_NUC_139.L_CORE X_NUC_207.L_CORE 0.009089
K_21114 X_NUC_139.L_CORE X_NUC_208.L_CORE 0.001566
K_21115 X_NUC_139.L_CORE X_NUC_209.L_CORE 0.002187
K_21116 X_NUC_139.L_CORE X_NUC_210.L_CORE 0.003327
K_21117 X_NUC_139.L_CORE X_NUC_211.L_CORE 0.001537
K_21118 X_NUC_139.L_CORE X_NUC_212.L_CORE 0.005537
K_21119 X_NUC_139.L_CORE X_NUC_213.L_CORE 0.001994
K_21120 X_NUC_139.L_CORE X_NUC_214.L_CORE 0.001898
K_21121 X_NUC_139.L_CORE X_NUC_215.L_CORE 0.008289
K_21122 X_NUC_139.L_CORE X_NUC_216.L_CORE 0.001733
K_21123 X_NUC_139.L_CORE X_NUC_217.L_CORE 0.003160
K_21124 X_NUC_139.L_CORE X_NUC_218.L_CORE 0.002914
K_21125 X_NUC_139.L_CORE X_NUC_219.L_CORE 0.001948
K_21126 X_NUC_139.L_CORE X_NUC_220.L_CORE 0.005192
K_21127 X_NUC_139.L_CORE X_NUC_221.L_CORE 0.002313
K_21128 X_NUC_139.L_CORE X_NUC_222.L_CORE 0.002719
K_21129 X_NUC_140.L_CORE X_NUC_141.L_CORE 0.001800
K_21130 X_NUC_140.L_CORE X_NUC_142.L_CORE 0.001786
K_21131 X_NUC_140.L_CORE X_NUC_143.L_CORE 0.001790
K_21132 X_NUC_140.L_CORE X_NUC_144.L_CORE 0.001795
K_21133 X_NUC_140.L_CORE X_NUC_145.L_CORE 0.002521
K_21134 X_NUC_140.L_CORE X_NUC_146.L_CORE 0.002518
K_21135 X_NUC_140.L_CORE X_NUC_147.L_CORE 0.002503
K_21136 X_NUC_140.L_CORE X_NUC_148.L_CORE 0.002533
K_21137 X_NUC_140.L_CORE X_NUC_149.L_CORE 0.003924
K_21138 X_NUC_140.L_CORE X_NUC_150.L_CORE 0.003854
K_21139 X_NUC_140.L_CORE X_NUC_151.L_CORE 0.003886
K_21140 X_NUC_140.L_CORE X_NUC_152.L_CORE 0.003870
K_21141 X_NUC_140.L_CORE X_NUC_153.L_CORE 0.001841
K_21142 X_NUC_140.L_CORE X_NUC_154.L_CORE 0.001829
K_21143 X_NUC_140.L_CORE X_NUC_155.L_CORE 0.001828
K_21144 X_NUC_140.L_CORE X_NUC_156.L_CORE 0.001839
K_21145 X_NUC_140.L_CORE X_NUC_157.L_CORE 0.005175
K_21146 X_NUC_140.L_CORE X_NUC_158.L_CORE 0.005158
K_21147 X_NUC_140.L_CORE X_NUC_159.L_CORE 0.005071
K_21148 X_NUC_140.L_CORE X_NUC_160.L_CORE 0.005182
K_21149 X_NUC_140.L_CORE X_NUC_161.L_CORE 0.002471
K_21150 X_NUC_140.L_CORE X_NUC_162.L_CORE 0.002444
K_21151 X_NUC_140.L_CORE X_NUC_163.L_CORE 0.002448
K_21152 X_NUC_140.L_CORE X_NUC_164.L_CORE 0.002455
K_21153 X_NUC_140.L_CORE X_NUC_165.L_CORE 0.002435
K_21154 X_NUC_140.L_CORE X_NUC_166.L_CORE 0.002421
K_21155 X_NUC_140.L_CORE X_NUC_167.L_CORE 0.002411
K_21156 X_NUC_140.L_CORE X_NUC_168.L_CORE 0.002434
K_21157 X_NUC_140.L_CORE X_NUC_169.L_CORE 0.003722
K_21158 X_NUC_140.L_CORE X_NUC_170.L_CORE 0.003675
K_21159 X_NUC_140.L_CORE X_NUC_171.L_CORE 0.003659
K_21160 X_NUC_140.L_CORE X_NUC_172.L_CORE 0.003690
K_21161 X_NUC_140.L_CORE X_NUC_173.L_CORE 0.001473
K_21162 X_NUC_140.L_CORE X_NUC_174.L_CORE 0.001322
K_21163 X_NUC_140.L_CORE X_NUC_175.L_CORE 0.001447
K_21164 X_NUC_140.L_CORE X_NUC_176.L_CORE 0.001549
K_21165 X_NUC_140.L_CORE X_NUC_177.L_CORE 0.001268
K_21166 X_NUC_140.L_CORE X_NUC_178.L_CORE 0.001736
K_21167 X_NUC_140.L_CORE X_NUC_179.L_CORE 0.001384
K_21168 X_NUC_140.L_CORE X_NUC_180.L_CORE 0.001376
K_21169 X_NUC_140.L_CORE X_NUC_181.L_CORE 0.001908
K_21170 X_NUC_140.L_CORE X_NUC_182.L_CORE 0.001258
K_21171 X_NUC_140.L_CORE X_NUC_183.L_CORE 0.001737
K_21172 X_NUC_140.L_CORE X_NUC_184.L_CORE 0.001627
K_21173 X_NUC_140.L_CORE X_NUC_185.L_CORE 0.001291
K_21174 X_NUC_140.L_CORE X_NUC_186.L_CORE 0.002317
K_21175 X_NUC_140.L_CORE X_NUC_187.L_CORE 0.001349
K_21176 X_NUC_140.L_CORE X_NUC_188.L_CORE 0.001567
K_21177 X_NUC_140.L_CORE X_NUC_189.L_CORE 0.002151
K_21178 X_NUC_140.L_CORE X_NUC_190.L_CORE 0.001268
K_21179 X_NUC_140.L_CORE X_NUC_191.L_CORE 0.002329
K_21180 X_NUC_140.L_CORE X_NUC_192.L_CORE 0.001593
K_21181 X_NUC_140.L_CORE X_NUC_193.L_CORE 0.001412
K_21182 X_NUC_140.L_CORE X_NUC_194.L_CORE 0.003140
K_21183 X_NUC_140.L_CORE X_NUC_195.L_CORE 0.001337
K_21184 X_NUC_140.L_CORE X_NUC_196.L_CORE 0.001968
K_21185 X_NUC_140.L_CORE X_NUC_197.L_CORE 0.002154
K_21186 X_NUC_140.L_CORE X_NUC_198.L_CORE 0.001344
K_21187 X_NUC_140.L_CORE X_NUC_199.L_CORE 0.003753
K_21188 X_NUC_140.L_CORE X_NUC_200.L_CORE 0.001548
K_21189 X_NUC_140.L_CORE X_NUC_201.L_CORE 0.001664
K_21190 X_NUC_140.L_CORE X_NUC_202.L_CORE 0.003680
K_21191 X_NUC_140.L_CORE X_NUC_203.L_CORE 0.001383
K_21192 X_NUC_140.L_CORE X_NUC_204.L_CORE 0.002862
K_21193 X_NUC_140.L_CORE X_NUC_205.L_CORE 0.002040
K_21194 X_NUC_140.L_CORE X_NUC_206.L_CORE 0.001520
K_21195 X_NUC_140.L_CORE X_NUC_207.L_CORE 0.009276
K_21196 X_NUC_140.L_CORE X_NUC_208.L_CORE 0.001563
K_21197 X_NUC_140.L_CORE X_NUC_209.L_CORE 0.002164
K_21198 X_NUC_140.L_CORE X_NUC_210.L_CORE 0.003356
K_21199 X_NUC_140.L_CORE X_NUC_211.L_CORE 0.001529
K_21200 X_NUC_140.L_CORE X_NUC_212.L_CORE 0.005417
K_21201 X_NUC_140.L_CORE X_NUC_213.L_CORE 0.001993
K_21202 X_NUC_140.L_CORE X_NUC_214.L_CORE 0.001882
K_21203 X_NUC_140.L_CORE X_NUC_215.L_CORE 0.008458
K_21204 X_NUC_140.L_CORE X_NUC_216.L_CORE 0.001726
K_21205 X_NUC_140.L_CORE X_NUC_217.L_CORE 0.003114
K_21206 X_NUC_140.L_CORE X_NUC_218.L_CORE 0.002916
K_21207 X_NUC_140.L_CORE X_NUC_219.L_CORE 0.001934
K_21208 X_NUC_140.L_CORE X_NUC_220.L_CORE 0.005118
K_21209 X_NUC_140.L_CORE X_NUC_221.L_CORE 0.002304
K_21210 X_NUC_140.L_CORE X_NUC_222.L_CORE 0.002693
K_21211 X_NUC_141.L_CORE X_NUC_142.L_CORE 0.207973
K_21212 X_NUC_141.L_CORE X_NUC_143.L_CORE 0.207973
K_21213 X_NUC_141.L_CORE X_NUC_144.L_CORE 0.207973
K_21214 X_NUC_141.L_CORE X_NUC_145.L_CORE 0.001892
K_21215 X_NUC_141.L_CORE X_NUC_146.L_CORE 0.001908
K_21216 X_NUC_141.L_CORE X_NUC_147.L_CORE 0.001897
K_21217 X_NUC_141.L_CORE X_NUC_148.L_CORE 0.001903
K_21218 X_NUC_141.L_CORE X_NUC_149.L_CORE 0.002683
K_21219 X_NUC_141.L_CORE X_NUC_150.L_CORE 0.002709
K_21220 X_NUC_141.L_CORE X_NUC_151.L_CORE 0.002705
K_21221 X_NUC_141.L_CORE X_NUC_152.L_CORE 0.002682
K_21222 X_NUC_141.L_CORE X_NUC_153.L_CORE 0.004092
K_21223 X_NUC_141.L_CORE X_NUC_154.L_CORE 0.004139
K_21224 X_NUC_141.L_CORE X_NUC_155.L_CORE 0.004071
K_21225 X_NUC_141.L_CORE X_NUC_156.L_CORE 0.004135
K_21226 X_NUC_141.L_CORE X_NUC_157.L_CORE 0.001981
K_21227 X_NUC_141.L_CORE X_NUC_158.L_CORE 0.002000
K_21228 X_NUC_141.L_CORE X_NUC_159.L_CORE 0.001989
K_21229 X_NUC_141.L_CORE X_NUC_160.L_CORE 0.001988
K_21230 X_NUC_141.L_CORE X_NUC_161.L_CORE 0.005211
K_21231 X_NUC_141.L_CORE X_NUC_162.L_CORE 0.005310
K_21232 X_NUC_141.L_CORE X_NUC_163.L_CORE 0.005246
K_21233 X_NUC_141.L_CORE X_NUC_164.L_CORE 0.005184
K_21234 X_NUC_141.L_CORE X_NUC_165.L_CORE 0.002696
K_21235 X_NUC_141.L_CORE X_NUC_166.L_CORE 0.002726
K_21236 X_NUC_141.L_CORE X_NUC_167.L_CORE 0.002696
K_21237 X_NUC_141.L_CORE X_NUC_168.L_CORE 0.002711
K_21238 X_NUC_141.L_CORE X_NUC_169.L_CORE 0.002779
K_21239 X_NUC_141.L_CORE X_NUC_170.L_CORE 0.002814
K_21240 X_NUC_141.L_CORE X_NUC_171.L_CORE 0.002790
K_21241 X_NUC_141.L_CORE X_NUC_172.L_CORE 0.002784
K_21242 X_NUC_141.L_CORE X_NUC_173.L_CORE 0.001347
K_21243 X_NUC_141.L_CORE X_NUC_174.L_CORE 0.001526
K_21244 X_NUC_141.L_CORE X_NUC_175.L_CORE 0.001307
K_21245 X_NUC_141.L_CORE X_NUC_176.L_CORE 0.001453
K_21246 X_NUC_141.L_CORE X_NUC_177.L_CORE 0.001558
K_21247 X_NUC_141.L_CORE X_NUC_178.L_CORE 0.001267
K_21248 X_NUC_141.L_CORE X_NUC_179.L_CORE 0.001749
K_21249 X_NUC_141.L_CORE X_NUC_180.L_CORE 0.001388
K_21250 X_NUC_141.L_CORE X_NUC_181.L_CORE 0.001383
K_21251 X_NUC_141.L_CORE X_NUC_182.L_CORE 0.001910
K_21252 X_NUC_141.L_CORE X_NUC_183.L_CORE 0.001267
K_21253 X_NUC_141.L_CORE X_NUC_184.L_CORE 0.001746
K_21254 X_NUC_141.L_CORE X_NUC_185.L_CORE 0.001634
K_21255 X_NUC_141.L_CORE X_NUC_186.L_CORE 0.001306
K_21256 X_NUC_141.L_CORE X_NUC_187.L_CORE 0.002306
K_21257 X_NUC_141.L_CORE X_NUC_188.L_CORE 0.001364
K_21258 X_NUC_141.L_CORE X_NUC_189.L_CORE 0.001586
K_21259 X_NUC_141.L_CORE X_NUC_190.L_CORE 0.002147
K_21260 X_NUC_141.L_CORE X_NUC_191.L_CORE 0.001289
K_21261 X_NUC_141.L_CORE X_NUC_192.L_CORE 0.002334
K_21262 X_NUC_141.L_CORE X_NUC_193.L_CORE 0.001612
K_21263 X_NUC_141.L_CORE X_NUC_194.L_CORE 0.001440
K_21264 X_NUC_141.L_CORE X_NUC_195.L_CORE 0.003089
K_21265 X_NUC_141.L_CORE X_NUC_196.L_CORE 0.001365
K_21266 X_NUC_141.L_CORE X_NUC_197.L_CORE 0.002002
K_21267 X_NUC_141.L_CORE X_NUC_198.L_CORE 0.002174
K_21268 X_NUC_141.L_CORE X_NUC_199.L_CORE 0.001379
K_21269 X_NUC_141.L_CORE X_NUC_200.L_CORE 0.003714
K_21270 X_NUC_141.L_CORE X_NUC_201.L_CORE 0.001586
K_21271 X_NUC_141.L_CORE X_NUC_202.L_CORE 0.001712
K_21272 X_NUC_141.L_CORE X_NUC_203.L_CORE 0.003661
K_21273 X_NUC_141.L_CORE X_NUC_204.L_CORE 0.001426
K_21274 X_NUC_141.L_CORE X_NUC_205.L_CORE 0.002934
K_21275 X_NUC_141.L_CORE X_NUC_206.L_CORE 0.002097
K_21276 X_NUC_141.L_CORE X_NUC_207.L_CORE 0.001577
K_21277 X_NUC_141.L_CORE X_NUC_208.L_CORE 0.008731
K_21278 X_NUC_141.L_CORE X_NUC_209.L_CORE 0.001624
K_21279 X_NUC_141.L_CORE X_NUC_210.L_CORE 0.002259
K_21280 X_NUC_141.L_CORE X_NUC_211.L_CORE 0.003466
K_21281 X_NUC_141.L_CORE X_NUC_212.L_CORE 0.001601
K_21282 X_NUC_141.L_CORE X_NUC_213.L_CORE 0.005703
K_21283 X_NUC_141.L_CORE X_NUC_214.L_CORE 0.002094
K_21284 X_NUC_141.L_CORE X_NUC_215.L_CORE 0.001993
K_21285 X_NUC_141.L_CORE X_NUC_216.L_CORE 0.008664
K_21286 X_NUC_141.L_CORE X_NUC_217.L_CORE 0.001841
K_21287 X_NUC_141.L_CORE X_NUC_218.L_CORE 0.003332
K_21288 X_NUC_141.L_CORE X_NUC_219.L_CORE 0.003109
K_21289 X_NUC_141.L_CORE X_NUC_220.L_CORE 0.002122
K_21290 X_NUC_141.L_CORE X_NUC_221.L_CORE 0.004785
K_21291 X_NUC_141.L_CORE X_NUC_222.L_CORE 0.002647
K_21292 X_NUC_142.L_CORE X_NUC_143.L_CORE 0.207973
K_21293 X_NUC_142.L_CORE X_NUC_144.L_CORE 0.207973
K_21294 X_NUC_142.L_CORE X_NUC_145.L_CORE 0.001877
K_21295 X_NUC_142.L_CORE X_NUC_146.L_CORE 0.001892
K_21296 X_NUC_142.L_CORE X_NUC_147.L_CORE 0.001881
K_21297 X_NUC_142.L_CORE X_NUC_148.L_CORE 0.001887
K_21298 X_NUC_142.L_CORE X_NUC_149.L_CORE 0.002657
K_21299 X_NUC_142.L_CORE X_NUC_150.L_CORE 0.002683
K_21300 X_NUC_142.L_CORE X_NUC_151.L_CORE 0.002679
K_21301 X_NUC_142.L_CORE X_NUC_152.L_CORE 0.002656
K_21302 X_NUC_142.L_CORE X_NUC_153.L_CORE 0.004046
K_21303 X_NUC_142.L_CORE X_NUC_154.L_CORE 0.004092
K_21304 X_NUC_142.L_CORE X_NUC_155.L_CORE 0.004026
K_21305 X_NUC_142.L_CORE X_NUC_156.L_CORE 0.004088
K_21306 X_NUC_142.L_CORE X_NUC_157.L_CORE 0.001963
K_21307 X_NUC_142.L_CORE X_NUC_158.L_CORE 0.001981
K_21308 X_NUC_142.L_CORE X_NUC_159.L_CORE 0.001971
K_21309 X_NUC_142.L_CORE X_NUC_160.L_CORE 0.001970
K_21310 X_NUC_142.L_CORE X_NUC_161.L_CORE 0.005114
K_21311 X_NUC_142.L_CORE X_NUC_162.L_CORE 0.005211
K_21312 X_NUC_142.L_CORE X_NUC_163.L_CORE 0.005150
K_21313 X_NUC_142.L_CORE X_NUC_164.L_CORE 0.005091
K_21314 X_NUC_142.L_CORE X_NUC_165.L_CORE 0.002666
K_21315 X_NUC_142.L_CORE X_NUC_166.L_CORE 0.002696
K_21316 X_NUC_142.L_CORE X_NUC_167.L_CORE 0.002667
K_21317 X_NUC_142.L_CORE X_NUC_168.L_CORE 0.002680
K_21318 X_NUC_142.L_CORE X_NUC_169.L_CORE 0.002745
K_21319 X_NUC_142.L_CORE X_NUC_170.L_CORE 0.002779
K_21320 X_NUC_142.L_CORE X_NUC_171.L_CORE 0.002756
K_21321 X_NUC_142.L_CORE X_NUC_172.L_CORE 0.002750
K_21322 X_NUC_142.L_CORE X_NUC_173.L_CORE 0.001343
K_21323 X_NUC_142.L_CORE X_NUC_174.L_CORE 0.001524
K_21324 X_NUC_142.L_CORE X_NUC_175.L_CORE 0.001303
K_21325 X_NUC_142.L_CORE X_NUC_176.L_CORE 0.001449
K_21326 X_NUC_142.L_CORE X_NUC_177.L_CORE 0.001555
K_21327 X_NUC_142.L_CORE X_NUC_178.L_CORE 0.001262
K_21328 X_NUC_142.L_CORE X_NUC_179.L_CORE 0.001748
K_21329 X_NUC_142.L_CORE X_NUC_180.L_CORE 0.001383
K_21330 X_NUC_142.L_CORE X_NUC_181.L_CORE 0.001378
K_21331 X_NUC_142.L_CORE X_NUC_182.L_CORE 0.001910
K_21332 X_NUC_142.L_CORE X_NUC_183.L_CORE 0.001261
K_21333 X_NUC_142.L_CORE X_NUC_184.L_CORE 0.001743
K_21334 X_NUC_142.L_CORE X_NUC_185.L_CORE 0.001630
K_21335 X_NUC_142.L_CORE X_NUC_186.L_CORE 0.001299
K_21336 X_NUC_142.L_CORE X_NUC_187.L_CORE 0.002311
K_21337 X_NUC_142.L_CORE X_NUC_188.L_CORE 0.001358
K_21338 X_NUC_142.L_CORE X_NUC_189.L_CORE 0.001580
K_21339 X_NUC_142.L_CORE X_NUC_190.L_CORE 0.002147
K_21340 X_NUC_142.L_CORE X_NUC_191.L_CORE 0.001282
K_21341 X_NUC_142.L_CORE X_NUC_192.L_CORE 0.002334
K_21342 X_NUC_142.L_CORE X_NUC_193.L_CORE 0.001606
K_21343 X_NUC_142.L_CORE X_NUC_194.L_CORE 0.001432
K_21344 X_NUC_142.L_CORE X_NUC_195.L_CORE 0.003105
K_21345 X_NUC_142.L_CORE X_NUC_196.L_CORE 0.001357
K_21346 X_NUC_142.L_CORE X_NUC_197.L_CORE 0.001995
K_21347 X_NUC_142.L_CORE X_NUC_198.L_CORE 0.002169
K_21348 X_NUC_142.L_CORE X_NUC_199.L_CORE 0.001370
K_21349 X_NUC_142.L_CORE X_NUC_200.L_CORE 0.003736
K_21350 X_NUC_142.L_CORE X_NUC_201.L_CORE 0.001577
K_21351 X_NUC_142.L_CORE X_NUC_202.L_CORE 0.001702
K_21352 X_NUC_142.L_CORE X_NUC_203.L_CORE 0.003675
K_21353 X_NUC_142.L_CORE X_NUC_204.L_CORE 0.001417
K_21354 X_NUC_142.L_CORE X_NUC_205.L_CORE 0.002926
K_21355 X_NUC_142.L_CORE X_NUC_206.L_CORE 0.002086
K_21356 X_NUC_142.L_CORE X_NUC_207.L_CORE 0.001566
K_21357 X_NUC_142.L_CORE X_NUC_208.L_CORE 0.009015
K_21358 X_NUC_142.L_CORE X_NUC_209.L_CORE 0.001612
K_21359 X_NUC_142.L_CORE X_NUC_210.L_CORE 0.002244
K_21360 X_NUC_142.L_CORE X_NUC_211.L_CORE 0.003452
K_21361 X_NUC_142.L_CORE X_NUC_212.L_CORE 0.001589
K_21362 X_NUC_142.L_CORE X_NUC_213.L_CORE 0.005682
K_21363 X_NUC_142.L_CORE X_NUC_214.L_CORE 0.002078
K_21364 X_NUC_142.L_CORE X_NUC_215.L_CORE 0.001976
K_21365 X_NUC_142.L_CORE X_NUC_216.L_CORE 0.008585
K_21366 X_NUC_142.L_CORE X_NUC_217.L_CORE 0.001825
K_21367 X_NUC_142.L_CORE X_NUC_218.L_CORE 0.003297
K_21368 X_NUC_142.L_CORE X_NUC_219.L_CORE 0.003078
K_21369 X_NUC_142.L_CORE X_NUC_220.L_CORE 0.002101
K_21370 X_NUC_142.L_CORE X_NUC_221.L_CORE 0.004706
K_21371 X_NUC_142.L_CORE X_NUC_222.L_CORE 0.002617
K_21372 X_NUC_143.L_CORE X_NUC_144.L_CORE 0.207973
K_21373 X_NUC_143.L_CORE X_NUC_145.L_CORE 0.001888
K_21374 X_NUC_143.L_CORE X_NUC_146.L_CORE 0.001904
K_21375 X_NUC_143.L_CORE X_NUC_147.L_CORE 0.001892
K_21376 X_NUC_143.L_CORE X_NUC_148.L_CORE 0.001899
K_21377 X_NUC_143.L_CORE X_NUC_149.L_CORE 0.002661
K_21378 X_NUC_143.L_CORE X_NUC_150.L_CORE 0.002686
K_21379 X_NUC_143.L_CORE X_NUC_151.L_CORE 0.002683
K_21380 X_NUC_143.L_CORE X_NUC_152.L_CORE 0.002660
K_21381 X_NUC_143.L_CORE X_NUC_153.L_CORE 0.004113
K_21382 X_NUC_143.L_CORE X_NUC_154.L_CORE 0.004161
K_21383 X_NUC_143.L_CORE X_NUC_155.L_CORE 0.004092
K_21384 X_NUC_143.L_CORE X_NUC_156.L_CORE 0.004156
K_21385 X_NUC_143.L_CORE X_NUC_157.L_CORE 0.001974
K_21386 X_NUC_143.L_CORE X_NUC_158.L_CORE 0.001992
K_21387 X_NUC_143.L_CORE X_NUC_159.L_CORE 0.001981
K_21388 X_NUC_143.L_CORE X_NUC_160.L_CORE 0.001981
K_21389 X_NUC_143.L_CORE X_NUC_161.L_CORE 0.005173
K_21390 X_NUC_143.L_CORE X_NUC_162.L_CORE 0.005271
K_21391 X_NUC_143.L_CORE X_NUC_163.L_CORE 0.005211
K_21392 X_NUC_143.L_CORE X_NUC_164.L_CORE 0.005149
K_21393 X_NUC_143.L_CORE X_NUC_165.L_CORE 0.002694
K_21394 X_NUC_143.L_CORE X_NUC_166.L_CORE 0.002725
K_21395 X_NUC_143.L_CORE X_NUC_167.L_CORE 0.002696
K_21396 X_NUC_143.L_CORE X_NUC_168.L_CORE 0.002710
K_21397 X_NUC_143.L_CORE X_NUC_169.L_CORE 0.002768
K_21398 X_NUC_143.L_CORE X_NUC_170.L_CORE 0.002802
K_21399 X_NUC_143.L_CORE X_NUC_171.L_CORE 0.002779
K_21400 X_NUC_143.L_CORE X_NUC_172.L_CORE 0.002773
K_21401 X_NUC_143.L_CORE X_NUC_173.L_CORE 0.001339
K_21402 X_NUC_143.L_CORE X_NUC_174.L_CORE 0.001518
K_21403 X_NUC_143.L_CORE X_NUC_175.L_CORE 0.001301
K_21404 X_NUC_143.L_CORE X_NUC_176.L_CORE 0.001444
K_21405 X_NUC_143.L_CORE X_NUC_177.L_CORE 0.001551
K_21406 X_NUC_143.L_CORE X_NUC_178.L_CORE 0.001260
K_21407 X_NUC_143.L_CORE X_NUC_179.L_CORE 0.001737
K_21408 X_NUC_143.L_CORE X_NUC_180.L_CORE 0.001382
K_21409 X_NUC_143.L_CORE X_NUC_181.L_CORE 0.001374
K_21410 X_NUC_143.L_CORE X_NUC_182.L_CORE 0.001900
K_21411 X_NUC_143.L_CORE X_NUC_183.L_CORE 0.001262
K_21412 X_NUC_143.L_CORE X_NUC_184.L_CORE 0.001732
K_21413 X_NUC_143.L_CORE X_NUC_185.L_CORE 0.001629
K_21414 X_NUC_143.L_CORE X_NUC_186.L_CORE 0.001298
K_21415 X_NUC_143.L_CORE X_NUC_187.L_CORE 0.002289
K_21416 X_NUC_143.L_CORE X_NUC_188.L_CORE 0.001359
K_21417 X_NUC_143.L_CORE X_NUC_189.L_CORE 0.001574
K_21418 X_NUC_143.L_CORE X_NUC_190.L_CORE 0.002141
K_21419 X_NUC_143.L_CORE X_NUC_191.L_CORE 0.001283
K_21420 X_NUC_143.L_CORE X_NUC_192.L_CORE 0.002311
K_21421 X_NUC_143.L_CORE X_NUC_193.L_CORE 0.001609
K_21422 X_NUC_143.L_CORE X_NUC_194.L_CORE 0.001431
K_21423 X_NUC_143.L_CORE X_NUC_195.L_CORE 0.003074
K_21424 X_NUC_143.L_CORE X_NUC_196.L_CORE 0.001360
K_21425 X_NUC_143.L_CORE X_NUC_197.L_CORE 0.001984
K_21426 X_NUC_143.L_CORE X_NUC_198.L_CORE 0.002173
K_21427 X_NUC_143.L_CORE X_NUC_199.L_CORE 0.001372
K_21428 X_NUC_143.L_CORE X_NUC_200.L_CORE 0.003671
K_21429 X_NUC_143.L_CORE X_NUC_201.L_CORE 0.001582
K_21430 X_NUC_143.L_CORE X_NUC_202.L_CORE 0.001700
K_21431 X_NUC_143.L_CORE X_NUC_203.L_CORE 0.003667
K_21432 X_NUC_143.L_CORE X_NUC_204.L_CORE 0.001421
K_21433 X_NUC_143.L_CORE X_NUC_205.L_CORE 0.002901
K_21434 X_NUC_143.L_CORE X_NUC_206.L_CORE 0.002097
K_21435 X_NUC_143.L_CORE X_NUC_207.L_CORE 0.001568
K_21436 X_NUC_143.L_CORE X_NUC_208.L_CORE 0.008690
K_21437 X_NUC_143.L_CORE X_NUC_209.L_CORE 0.001620
K_21438 X_NUC_143.L_CORE X_NUC_210.L_CORE 0.002240
K_21439 X_NUC_143.L_CORE X_NUC_211.L_CORE 0.003484
K_21440 X_NUC_143.L_CORE X_NUC_212.L_CORE 0.001595
K_21441 X_NUC_143.L_CORE X_NUC_213.L_CORE 0.005621
K_21442 X_NUC_143.L_CORE X_NUC_214.L_CORE 0.002094
K_21443 X_NUC_143.L_CORE X_NUC_215.L_CORE 0.001981
K_21444 X_NUC_143.L_CORE X_NUC_216.L_CORE 0.008911
K_21445 X_NUC_143.L_CORE X_NUC_217.L_CORE 0.001836
K_21446 X_NUC_143.L_CORE X_NUC_218.L_CORE 0.003307
K_21447 X_NUC_143.L_CORE X_NUC_219.L_CORE 0.003119
K_21448 X_NUC_143.L_CORE X_NUC_220.L_CORE 0.002114
K_21449 X_NUC_143.L_CORE X_NUC_221.L_CORE 0.004790
K_21450 X_NUC_143.L_CORE X_NUC_222.L_CORE 0.002645
K_21451 X_NUC_144.L_CORE X_NUC_145.L_CORE 0.001882
K_21452 X_NUC_144.L_CORE X_NUC_146.L_CORE 0.001897
K_21453 X_NUC_144.L_CORE X_NUC_147.L_CORE 0.001886
K_21454 X_NUC_144.L_CORE X_NUC_148.L_CORE 0.001892
K_21455 X_NUC_144.L_CORE X_NUC_149.L_CORE 0.002683
K_21456 X_NUC_144.L_CORE X_NUC_150.L_CORE 0.002709
K_21457 X_NUC_144.L_CORE X_NUC_151.L_CORE 0.002705
K_21458 X_NUC_144.L_CORE X_NUC_152.L_CORE 0.002683
K_21459 X_NUC_144.L_CORE X_NUC_153.L_CORE 0.004050
K_21460 X_NUC_144.L_CORE X_NUC_154.L_CORE 0.004096
K_21461 X_NUC_144.L_CORE X_NUC_155.L_CORE 0.004030
K_21462 X_NUC_144.L_CORE X_NUC_156.L_CORE 0.004092
K_21463 X_NUC_144.L_CORE X_NUC_157.L_CORE 0.001974
K_21464 X_NUC_144.L_CORE X_NUC_158.L_CORE 0.001993
K_21465 X_NUC_144.L_CORE X_NUC_159.L_CORE 0.001982
K_21466 X_NUC_144.L_CORE X_NUC_160.L_CORE 0.001981
K_21467 X_NUC_144.L_CORE X_NUC_161.L_CORE 0.005235
K_21468 X_NUC_144.L_CORE X_NUC_162.L_CORE 0.005336
K_21469 X_NUC_144.L_CORE X_NUC_163.L_CORE 0.005272
K_21470 X_NUC_144.L_CORE X_NUC_164.L_CORE 0.005211
K_21471 X_NUC_144.L_CORE X_NUC_165.L_CORE 0.002680
K_21472 X_NUC_144.L_CORE X_NUC_166.L_CORE 0.002711
K_21473 X_NUC_144.L_CORE X_NUC_167.L_CORE 0.002682
K_21474 X_NUC_144.L_CORE X_NUC_168.L_CORE 0.002696
K_21475 X_NUC_144.L_CORE X_NUC_169.L_CORE 0.002774
K_21476 X_NUC_144.L_CORE X_NUC_170.L_CORE 0.002809
K_21477 X_NUC_144.L_CORE X_NUC_171.L_CORE 0.002785
K_21478 X_NUC_144.L_CORE X_NUC_172.L_CORE 0.002779
K_21479 X_NUC_144.L_CORE X_NUC_173.L_CORE 0.001340
K_21480 X_NUC_144.L_CORE X_NUC_174.L_CORE 0.001517
K_21481 X_NUC_144.L_CORE X_NUC_175.L_CORE 0.001300
K_21482 X_NUC_144.L_CORE X_NUC_176.L_CORE 0.001446
K_21483 X_NUC_144.L_CORE X_NUC_177.L_CORE 0.001547
K_21484 X_NUC_144.L_CORE X_NUC_178.L_CORE 0.001261
K_21485 X_NUC_144.L_CORE X_NUC_179.L_CORE 0.001740
K_21486 X_NUC_144.L_CORE X_NUC_180.L_CORE 0.001379
K_21487 X_NUC_144.L_CORE X_NUC_181.L_CORE 0.001378
K_21488 X_NUC_144.L_CORE X_NUC_182.L_CORE 0.001896
K_21489 X_NUC_144.L_CORE X_NUC_183.L_CORE 0.001260
K_21490 X_NUC_144.L_CORE X_NUC_184.L_CORE 0.001740
K_21491 X_NUC_144.L_CORE X_NUC_185.L_CORE 0.001621
K_21492 X_NUC_144.L_CORE X_NUC_186.L_CORE 0.001300
K_21493 X_NUC_144.L_CORE X_NUC_187.L_CORE 0.002292
K_21494 X_NUC_144.L_CORE X_NUC_188.L_CORE 0.001355
K_21495 X_NUC_144.L_CORE X_NUC_189.L_CORE 0.001581
K_21496 X_NUC_144.L_CORE X_NUC_190.L_CORE 0.002128
K_21497 X_NUC_144.L_CORE X_NUC_191.L_CORE 0.001283
K_21498 X_NUC_144.L_CORE X_NUC_192.L_CORE 0.002327
K_21499 X_NUC_144.L_CORE X_NUC_193.L_CORE 0.001600
K_21500 X_NUC_144.L_CORE X_NUC_194.L_CORE 0.001435
K_21501 X_NUC_144.L_CORE X_NUC_195.L_CORE 0.003062
K_21502 X_NUC_144.L_CORE X_NUC_196.L_CORE 0.001358
K_21503 X_NUC_144.L_CORE X_NUC_197.L_CORE 0.001999
K_21504 X_NUC_144.L_CORE X_NUC_198.L_CORE 0.002154
K_21505 X_NUC_144.L_CORE X_NUC_199.L_CORE 0.001373
K_21506 X_NUC_144.L_CORE X_NUC_200.L_CORE 0.003706
K_21507 X_NUC_144.L_CORE X_NUC_201.L_CORE 0.001575
K_21508 X_NUC_144.L_CORE X_NUC_202.L_CORE 0.001709
K_21509 X_NUC_144.L_CORE X_NUC_203.L_CORE 0.003617
K_21510 X_NUC_144.L_CORE X_NUC_204.L_CORE 0.001420
K_21511 X_NUC_144.L_CORE X_NUC_205.L_CORE 0.002938
K_21512 X_NUC_144.L_CORE X_NUC_206.L_CORE 0.002079
K_21513 X_NUC_144.L_CORE X_NUC_207.L_CORE 0.001572
K_21514 X_NUC_144.L_CORE X_NUC_208.L_CORE 0.008700
K_21515 X_NUC_144.L_CORE X_NUC_209.L_CORE 0.001614
K_21516 X_NUC_144.L_CORE X_NUC_210.L_CORE 0.002259
K_21517 X_NUC_144.L_CORE X_NUC_211.L_CORE 0.003428
K_21518 X_NUC_144.L_CORE X_NUC_212.L_CORE 0.001595
K_21519 X_NUC_144.L_CORE X_NUC_213.L_CORE 0.005776
K_21520 X_NUC_144.L_CORE X_NUC_214.L_CORE 0.002080
K_21521 X_NUC_144.L_CORE X_NUC_215.L_CORE 0.001990
K_21522 X_NUC_144.L_CORE X_NUC_216.L_CORE 0.008599
K_21523 X_NUC_144.L_CORE X_NUC_217.L_CORE 0.001833
K_21524 X_NUC_144.L_CORE X_NUC_218.L_CORE 0.003344
K_21525 X_NUC_144.L_CORE X_NUC_219.L_CORE 0.003089
K_21526 X_NUC_144.L_CORE X_NUC_220.L_CORE 0.002117
K_21527 X_NUC_144.L_CORE X_NUC_221.L_CORE 0.004803
K_21528 X_NUC_144.L_CORE X_NUC_222.L_CORE 0.002638
K_21529 X_NUC_145.L_CORE X_NUC_146.L_CORE 0.207973
K_21530 X_NUC_145.L_CORE X_NUC_147.L_CORE 0.207973
K_21531 X_NUC_145.L_CORE X_NUC_148.L_CORE 0.207973
K_21532 X_NUC_145.L_CORE X_NUC_149.L_CORE 0.002017
K_21533 X_NUC_145.L_CORE X_NUC_150.L_CORE 0.002008
K_21534 X_NUC_145.L_CORE X_NUC_151.L_CORE 0.002021
K_21535 X_NUC_145.L_CORE X_NUC_152.L_CORE 0.002003
K_21536 X_NUC_145.L_CORE X_NUC_153.L_CORE 0.002876
K_21537 X_NUC_145.L_CORE X_NUC_154.L_CORE 0.002837
K_21538 X_NUC_145.L_CORE X_NUC_155.L_CORE 0.002854
K_21539 X_NUC_145.L_CORE X_NUC_156.L_CORE 0.002852
K_21540 X_NUC_145.L_CORE X_NUC_157.L_CORE 0.004370
K_21541 X_NUC_145.L_CORE X_NUC_158.L_CORE 0.004374
K_21542 X_NUC_145.L_CORE X_NUC_159.L_CORE 0.004401
K_21543 X_NUC_145.L_CORE X_NUC_160.L_CORE 0.004313
K_21544 X_NUC_145.L_CORE X_NUC_161.L_CORE 0.002180
K_21545 X_NUC_145.L_CORE X_NUC_162.L_CORE 0.002163
K_21546 X_NUC_145.L_CORE X_NUC_163.L_CORE 0.002176
K_21547 X_NUC_145.L_CORE X_NUC_164.L_CORE 0.002161
K_21548 X_NUC_145.L_CORE X_NUC_165.L_CORE 0.005123
K_21549 X_NUC_145.L_CORE X_NUC_166.L_CORE 0.005019
K_21550 X_NUC_145.L_CORE X_NUC_167.L_CORE 0.005047
K_21551 X_NUC_145.L_CORE X_NUC_168.L_CORE 0.005013
K_21552 X_NUC_145.L_CORE X_NUC_169.L_CORE 0.003076
K_21553 X_NUC_145.L_CORE X_NUC_170.L_CORE 0.003054
K_21554 X_NUC_145.L_CORE X_NUC_171.L_CORE 0.003072
K_21555 X_NUC_145.L_CORE X_NUC_172.L_CORE 0.003036
K_21556 X_NUC_145.L_CORE X_NUC_173.L_CORE 0.001367
K_21557 X_NUC_145.L_CORE X_NUC_174.L_CORE 0.001312
K_21558 X_NUC_145.L_CORE X_NUC_175.L_CORE 0.001546
K_21559 X_NUC_145.L_CORE X_NUC_176.L_CORE 0.001289
K_21560 X_NUC_145.L_CORE X_NUC_177.L_CORE 0.001445
K_21561 X_NUC_145.L_CORE X_NUC_178.L_CORE 0.001556
K_21562 X_NUC_145.L_CORE X_NUC_179.L_CORE 0.001258
K_21563 X_NUC_145.L_CORE X_NUC_180.L_CORE 0.001743
K_21564 X_NUC_145.L_CORE X_NUC_181.L_CORE 0.001383
K_21565 X_NUC_145.L_CORE X_NUC_182.L_CORE 0.001378
K_21566 X_NUC_145.L_CORE X_NUC_183.L_CORE 0.001899
K_21567 X_NUC_145.L_CORE X_NUC_184.L_CORE 0.001268
K_21568 X_NUC_145.L_CORE X_NUC_185.L_CORE 0.001735
K_21569 X_NUC_145.L_CORE X_NUC_186.L_CORE 0.001633
K_21570 X_NUC_145.L_CORE X_NUC_187.L_CORE 0.001309
K_21571 X_NUC_145.L_CORE X_NUC_188.L_CORE 0.002276
K_21572 X_NUC_145.L_CORE X_NUC_189.L_CORE 0.001371
K_21573 X_NUC_145.L_CORE X_NUC_190.L_CORE 0.001587
K_21574 X_NUC_145.L_CORE X_NUC_191.L_CORE 0.002138
K_21575 X_NUC_145.L_CORE X_NUC_192.L_CORE 0.001300
K_21576 X_NUC_145.L_CORE X_NUC_193.L_CORE 0.002310
K_21577 X_NUC_145.L_CORE X_NUC_194.L_CORE 0.001626
K_21578 X_NUC_145.L_CORE X_NUC_195.L_CORE 0.001452
K_21579 X_NUC_145.L_CORE X_NUC_196.L_CORE 0.003035
K_21580 X_NUC_145.L_CORE X_NUC_197.L_CORE 0.001384
K_21581 X_NUC_145.L_CORE X_NUC_198.L_CORE 0.002009
K_21582 X_NUC_145.L_CORE X_NUC_199.L_CORE 0.002194
K_21583 X_NUC_145.L_CORE X_NUC_200.L_CORE 0.001402
K_21584 X_NUC_145.L_CORE X_NUC_201.L_CORE 0.003640
K_21585 X_NUC_145.L_CORE X_NUC_202.L_CORE 0.001617
K_21586 X_NUC_145.L_CORE X_NUC_203.L_CORE 0.001740
K_21587 X_NUC_145.L_CORE X_NUC_204.L_CORE 0.003669
K_21588 X_NUC_145.L_CORE X_NUC_205.L_CORE 0.001461
K_21589 X_NUC_145.L_CORE X_NUC_206.L_CORE 0.002961
K_21590 X_NUC_145.L_CORE X_NUC_207.L_CORE 0.002153
K_21591 X_NUC_145.L_CORE X_NUC_208.L_CORE 0.001620
K_21592 X_NUC_145.L_CORE X_NUC_209.L_CORE 0.008439
K_21593 X_NUC_145.L_CORE X_NUC_210.L_CORE 0.001679
K_21594 X_NUC_145.L_CORE X_NUC_211.L_CORE 0.002328
K_21595 X_NUC_145.L_CORE X_NUC_212.L_CORE 0.003611
K_21596 X_NUC_145.L_CORE X_NUC_213.L_CORE 0.001666
K_21597 X_NUC_145.L_CORE X_NUC_214.L_CORE 0.005895
K_21598 X_NUC_145.L_CORE X_NUC_215.L_CORE 0.002201
K_21599 X_NUC_145.L_CORE X_NUC_216.L_CORE 0.002094
K_21600 X_NUC_145.L_CORE X_NUC_217.L_CORE 0.009132
K_21601 X_NUC_145.L_CORE X_NUC_218.L_CORE 0.001963
K_21602 X_NUC_145.L_CORE X_NUC_219.L_CORE 0.003523
K_21603 X_NUC_145.L_CORE X_NUC_220.L_CORE 0.003329
K_21604 X_NUC_145.L_CORE X_NUC_221.L_CORE 0.002358
K_21605 X_NUC_145.L_CORE X_NUC_222.L_CORE 0.004134
K_21606 X_NUC_146.L_CORE X_NUC_147.L_CORE 0.207973
K_21607 X_NUC_146.L_CORE X_NUC_148.L_CORE 0.207973
K_21608 X_NUC_146.L_CORE X_NUC_149.L_CORE 0.002025
K_21609 X_NUC_146.L_CORE X_NUC_150.L_CORE 0.002017
K_21610 X_NUC_146.L_CORE X_NUC_151.L_CORE 0.002029
K_21611 X_NUC_146.L_CORE X_NUC_152.L_CORE 0.002011
K_21612 X_NUC_146.L_CORE X_NUC_153.L_CORE 0.002916
K_21613 X_NUC_146.L_CORE X_NUC_154.L_CORE 0.002876
K_21614 X_NUC_146.L_CORE X_NUC_155.L_CORE 0.002893
K_21615 X_NUC_146.L_CORE X_NUC_156.L_CORE 0.002892
K_21616 X_NUC_146.L_CORE X_NUC_157.L_CORE 0.004364
K_21617 X_NUC_146.L_CORE X_NUC_158.L_CORE 0.004370
K_21618 X_NUC_146.L_CORE X_NUC_159.L_CORE 0.004396
K_21619 X_NUC_146.L_CORE X_NUC_160.L_CORE 0.004308
K_21620 X_NUC_146.L_CORE X_NUC_161.L_CORE 0.002197
K_21621 X_NUC_146.L_CORE X_NUC_162.L_CORE 0.002180
K_21622 X_NUC_146.L_CORE X_NUC_163.L_CORE 0.002193
K_21623 X_NUC_146.L_CORE X_NUC_164.L_CORE 0.002178
K_21624 X_NUC_146.L_CORE X_NUC_165.L_CORE 0.005231
K_21625 X_NUC_146.L_CORE X_NUC_166.L_CORE 0.005123
K_21626 X_NUC_146.L_CORE X_NUC_167.L_CORE 0.005152
K_21627 X_NUC_146.L_CORE X_NUC_168.L_CORE 0.005116
K_21628 X_NUC_146.L_CORE X_NUC_169.L_CORE 0.003097
K_21629 X_NUC_146.L_CORE X_NUC_170.L_CORE 0.003076
K_21630 X_NUC_146.L_CORE X_NUC_171.L_CORE 0.003094
K_21631 X_NUC_146.L_CORE X_NUC_172.L_CORE 0.003057
K_21632 X_NUC_146.L_CORE X_NUC_173.L_CORE 0.001368
K_21633 X_NUC_146.L_CORE X_NUC_174.L_CORE 0.001316
K_21634 X_NUC_146.L_CORE X_NUC_175.L_CORE 0.001547
K_21635 X_NUC_146.L_CORE X_NUC_176.L_CORE 0.001292
K_21636 X_NUC_146.L_CORE X_NUC_177.L_CORE 0.001450
K_21637 X_NUC_146.L_CORE X_NUC_178.L_CORE 0.001555
K_21638 X_NUC_146.L_CORE X_NUC_179.L_CORE 0.001262
K_21639 X_NUC_146.L_CORE X_NUC_180.L_CORE 0.001745
K_21640 X_NUC_146.L_CORE X_NUC_181.L_CORE 0.001384
K_21641 X_NUC_146.L_CORE X_NUC_182.L_CORE 0.001384
K_21642 X_NUC_146.L_CORE X_NUC_183.L_CORE 0.001895
K_21643 X_NUC_146.L_CORE X_NUC_184.L_CORE 0.001271
K_21644 X_NUC_146.L_CORE X_NUC_185.L_CORE 0.001743
K_21645 X_NUC_146.L_CORE X_NUC_186.L_CORE 0.001631
K_21646 X_NUC_146.L_CORE X_NUC_187.L_CORE 0.001315
K_21647 X_NUC_146.L_CORE X_NUC_188.L_CORE 0.002274
K_21648 X_NUC_146.L_CORE X_NUC_189.L_CORE 0.001373
K_21649 X_NUC_146.L_CORE X_NUC_190.L_CORE 0.001596
K_21650 X_NUC_146.L_CORE X_NUC_191.L_CORE 0.002129
K_21651 X_NUC_146.L_CORE X_NUC_192.L_CORE 0.001305
K_21652 X_NUC_146.L_CORE X_NUC_193.L_CORE 0.002320
K_21653 X_NUC_146.L_CORE X_NUC_194.L_CORE 0.001625
K_21654 X_NUC_146.L_CORE X_NUC_195.L_CORE 0.001461
K_21655 X_NUC_146.L_CORE X_NUC_196.L_CORE 0.003014
K_21656 X_NUC_146.L_CORE X_NUC_197.L_CORE 0.001388
K_21657 X_NUC_146.L_CORE X_NUC_198.L_CORE 0.002025
K_21658 X_NUC_146.L_CORE X_NUC_199.L_CORE 0.002184
K_21659 X_NUC_146.L_CORE X_NUC_200.L_CORE 0.001409
K_21660 X_NUC_146.L_CORE X_NUC_201.L_CORE 0.003644
K_21661 X_NUC_146.L_CORE X_NUC_202.L_CORE 0.001618
K_21662 X_NUC_146.L_CORE X_NUC_203.L_CORE 0.001754
K_21663 X_NUC_146.L_CORE X_NUC_204.L_CORE 0.003624
K_21664 X_NUC_146.L_CORE X_NUC_205.L_CORE 0.001467
K_21665 X_NUC_146.L_CORE X_NUC_206.L_CORE 0.002992
K_21666 X_NUC_146.L_CORE X_NUC_207.L_CORE 0.002149
K_21667 X_NUC_146.L_CORE X_NUC_208.L_CORE 0.001631
K_21668 X_NUC_146.L_CORE X_NUC_209.L_CORE 0.008254
K_21669 X_NUC_146.L_CORE X_NUC_210.L_CORE 0.001684
K_21670 X_NUC_146.L_CORE X_NUC_211.L_CORE 0.002354
K_21671 X_NUC_146.L_CORE X_NUC_212.L_CORE 0.003580
K_21672 X_NUC_146.L_CORE X_NUC_213.L_CORE 0.001677
K_21673 X_NUC_146.L_CORE X_NUC_214.L_CORE 0.006024
K_21674 X_NUC_146.L_CORE X_NUC_215.L_CORE 0.002203
K_21675 X_NUC_146.L_CORE X_NUC_216.L_CORE 0.002115
K_21676 X_NUC_146.L_CORE X_NUC_217.L_CORE 0.008988
K_21677 X_NUC_146.L_CORE X_NUC_218.L_CORE 0.001973
K_21678 X_NUC_146.L_CORE X_NUC_219.L_CORE 0.003581
K_21679 X_NUC_146.L_CORE X_NUC_220.L_CORE 0.003336
K_21680 X_NUC_146.L_CORE X_NUC_221.L_CORE 0.002379
K_21681 X_NUC_146.L_CORE X_NUC_222.L_CORE 0.004186
K_21682 X_NUC_147.L_CORE X_NUC_148.L_CORE 0.207973
K_21683 X_NUC_147.L_CORE X_NUC_149.L_CORE 0.002012
K_21684 X_NUC_147.L_CORE X_NUC_150.L_CORE 0.002004
K_21685 X_NUC_147.L_CORE X_NUC_151.L_CORE 0.002017
K_21686 X_NUC_147.L_CORE X_NUC_152.L_CORE 0.001999
K_21687 X_NUC_147.L_CORE X_NUC_153.L_CORE 0.002897
K_21688 X_NUC_147.L_CORE X_NUC_154.L_CORE 0.002858
K_21689 X_NUC_147.L_CORE X_NUC_155.L_CORE 0.002876
K_21690 X_NUC_147.L_CORE X_NUC_156.L_CORE 0.002874
K_21691 X_NUC_147.L_CORE X_NUC_157.L_CORE 0.004338
K_21692 X_NUC_147.L_CORE X_NUC_158.L_CORE 0.004343
K_21693 X_NUC_147.L_CORE X_NUC_159.L_CORE 0.004370
K_21694 X_NUC_147.L_CORE X_NUC_160.L_CORE 0.004283
K_21695 X_NUC_147.L_CORE X_NUC_161.L_CORE 0.002183
K_21696 X_NUC_147.L_CORE X_NUC_162.L_CORE 0.002166
K_21697 X_NUC_147.L_CORE X_NUC_163.L_CORE 0.002180
K_21698 X_NUC_147.L_CORE X_NUC_164.L_CORE 0.002165
K_21699 X_NUC_147.L_CORE X_NUC_165.L_CORE 0.005199
K_21700 X_NUC_147.L_CORE X_NUC_166.L_CORE 0.005091
K_21701 X_NUC_147.L_CORE X_NUC_167.L_CORE 0.005123
K_21702 X_NUC_147.L_CORE X_NUC_168.L_CORE 0.005086
K_21703 X_NUC_147.L_CORE X_NUC_169.L_CORE 0.003078
K_21704 X_NUC_147.L_CORE X_NUC_170.L_CORE 0.003057
K_21705 X_NUC_147.L_CORE X_NUC_171.L_CORE 0.003076
K_21706 X_NUC_147.L_CORE X_NUC_172.L_CORE 0.003039
K_21707 X_NUC_147.L_CORE X_NUC_173.L_CORE 0.001360
K_21708 X_NUC_147.L_CORE X_NUC_174.L_CORE 0.001308
K_21709 X_NUC_147.L_CORE X_NUC_175.L_CORE 0.001538
K_21710 X_NUC_147.L_CORE X_NUC_176.L_CORE 0.001284
K_21711 X_NUC_147.L_CORE X_NUC_177.L_CORE 0.001441
K_21712 X_NUC_147.L_CORE X_NUC_178.L_CORE 0.001545
K_21713 X_NUC_147.L_CORE X_NUC_179.L_CORE 0.001254
K_21714 X_NUC_147.L_CORE X_NUC_180.L_CORE 0.001735
K_21715 X_NUC_147.L_CORE X_NUC_181.L_CORE 0.001376
K_21716 X_NUC_147.L_CORE X_NUC_182.L_CORE 0.001376
K_21717 X_NUC_147.L_CORE X_NUC_183.L_CORE 0.001884
K_21718 X_NUC_147.L_CORE X_NUC_184.L_CORE 0.001263
K_21719 X_NUC_147.L_CORE X_NUC_185.L_CORE 0.001733
K_21720 X_NUC_147.L_CORE X_NUC_186.L_CORE 0.001621
K_21721 X_NUC_147.L_CORE X_NUC_187.L_CORE 0.001307
K_21722 X_NUC_147.L_CORE X_NUC_188.L_CORE 0.002261
K_21723 X_NUC_147.L_CORE X_NUC_189.L_CORE 0.001365
K_21724 X_NUC_147.L_CORE X_NUC_190.L_CORE 0.001587
K_21725 X_NUC_147.L_CORE X_NUC_191.L_CORE 0.002117
K_21726 X_NUC_147.L_CORE X_NUC_192.L_CORE 0.001297
K_21727 X_NUC_147.L_CORE X_NUC_193.L_CORE 0.002307
K_21728 X_NUC_147.L_CORE X_NUC_194.L_CORE 0.001616
K_21729 X_NUC_147.L_CORE X_NUC_195.L_CORE 0.001453
K_21730 X_NUC_147.L_CORE X_NUC_196.L_CORE 0.002999
K_21731 X_NUC_147.L_CORE X_NUC_197.L_CORE 0.001380
K_21732 X_NUC_147.L_CORE X_NUC_198.L_CORE 0.002013
K_21733 X_NUC_147.L_CORE X_NUC_199.L_CORE 0.002172
K_21734 X_NUC_147.L_CORE X_NUC_200.L_CORE 0.001401
K_21735 X_NUC_147.L_CORE X_NUC_201.L_CORE 0.003628
K_21736 X_NUC_147.L_CORE X_NUC_202.L_CORE 0.001609
K_21737 X_NUC_147.L_CORE X_NUC_203.L_CORE 0.001744
K_21738 X_NUC_147.L_CORE X_NUC_204.L_CORE 0.003608
K_21739 X_NUC_147.L_CORE X_NUC_205.L_CORE 0.001459
K_21740 X_NUC_147.L_CORE X_NUC_206.L_CORE 0.002977
K_21741 X_NUC_147.L_CORE X_NUC_207.L_CORE 0.002137
K_21742 X_NUC_147.L_CORE X_NUC_208.L_CORE 0.001622
K_21743 X_NUC_147.L_CORE X_NUC_209.L_CORE 0.008284
K_21744 X_NUC_147.L_CORE X_NUC_210.L_CORE 0.001674
K_21745 X_NUC_147.L_CORE X_NUC_211.L_CORE 0.002341
K_21746 X_NUC_147.L_CORE X_NUC_212.L_CORE 0.003565
K_21747 X_NUC_147.L_CORE X_NUC_213.L_CORE 0.001667
K_21748 X_NUC_147.L_CORE X_NUC_214.L_CORE 0.006020
K_21749 X_NUC_147.L_CORE X_NUC_215.L_CORE 0.002191
K_21750 X_NUC_147.L_CORE X_NUC_216.L_CORE 0.002103
K_21751 X_NUC_147.L_CORE X_NUC_217.L_CORE 0.009047
K_21752 X_NUC_147.L_CORE X_NUC_218.L_CORE 0.001962
K_21753 X_NUC_147.L_CORE X_NUC_219.L_CORE 0.003566
K_21754 X_NUC_147.L_CORE X_NUC_220.L_CORE 0.003321
K_21755 X_NUC_147.L_CORE X_NUC_221.L_CORE 0.002366
K_21756 X_NUC_147.L_CORE X_NUC_222.L_CORE 0.004172
K_21757 X_NUC_148.L_CORE X_NUC_149.L_CORE 0.002030
K_21758 X_NUC_148.L_CORE X_NUC_150.L_CORE 0.002022
K_21759 X_NUC_148.L_CORE X_NUC_151.L_CORE 0.002034
K_21760 X_NUC_148.L_CORE X_NUC_152.L_CORE 0.002017
K_21761 X_NUC_148.L_CORE X_NUC_153.L_CORE 0.002899
K_21762 X_NUC_148.L_CORE X_NUC_154.L_CORE 0.002859
K_21763 X_NUC_148.L_CORE X_NUC_155.L_CORE 0.002877
K_21764 X_NUC_148.L_CORE X_NUC_156.L_CORE 0.002876
K_21765 X_NUC_148.L_CORE X_NUC_157.L_CORE 0.004428
K_21766 X_NUC_148.L_CORE X_NUC_158.L_CORE 0.004433
K_21767 X_NUC_148.L_CORE X_NUC_159.L_CORE 0.004461
K_21768 X_NUC_148.L_CORE X_NUC_160.L_CORE 0.004370
K_21769 X_NUC_148.L_CORE X_NUC_161.L_CORE 0.002198
K_21770 X_NUC_148.L_CORE X_NUC_162.L_CORE 0.002181
K_21771 X_NUC_148.L_CORE X_NUC_163.L_CORE 0.002194
K_21772 X_NUC_148.L_CORE X_NUC_164.L_CORE 0.002180
K_21773 X_NUC_148.L_CORE X_NUC_165.L_CORE 0.005237
K_21774 X_NUC_148.L_CORE X_NUC_166.L_CORE 0.005127
K_21775 X_NUC_148.L_CORE X_NUC_167.L_CORE 0.005158
K_21776 X_NUC_148.L_CORE X_NUC_168.L_CORE 0.005123
K_21777 X_NUC_148.L_CORE X_NUC_169.L_CORE 0.003116
K_21778 X_NUC_148.L_CORE X_NUC_170.L_CORE 0.003094
K_21779 X_NUC_148.L_CORE X_NUC_171.L_CORE 0.003113
K_21780 X_NUC_148.L_CORE X_NUC_172.L_CORE 0.003076
K_21781 X_NUC_148.L_CORE X_NUC_173.L_CORE 0.001363
K_21782 X_NUC_148.L_CORE X_NUC_174.L_CORE 0.001310
K_21783 X_NUC_148.L_CORE X_NUC_175.L_CORE 0.001539
K_21784 X_NUC_148.L_CORE X_NUC_176.L_CORE 0.001288
K_21785 X_NUC_148.L_CORE X_NUC_177.L_CORE 0.001441
K_21786 X_NUC_148.L_CORE X_NUC_178.L_CORE 0.001550
K_21787 X_NUC_148.L_CORE X_NUC_179.L_CORE 0.001257
K_21788 X_NUC_148.L_CORE X_NUC_180.L_CORE 0.001733
K_21789 X_NUC_148.L_CORE X_NUC_181.L_CORE 0.001382
K_21790 X_NUC_148.L_CORE X_NUC_182.L_CORE 0.001377
K_21791 X_NUC_148.L_CORE X_NUC_183.L_CORE 0.001887
K_21792 X_NUC_148.L_CORE X_NUC_184.L_CORE 0.001268
K_21793 X_NUC_148.L_CORE X_NUC_185.L_CORE 0.001729
K_21794 X_NUC_148.L_CORE X_NUC_186.L_CORE 0.001629
K_21795 X_NUC_148.L_CORE X_NUC_187.L_CORE 0.001310
K_21796 X_NUC_148.L_CORE X_NUC_188.L_CORE 0.002255
K_21797 X_NUC_148.L_CORE X_NUC_189.L_CORE 0.001372
K_21798 X_NUC_148.L_CORE X_NUC_190.L_CORE 0.001585
K_21799 X_NUC_148.L_CORE X_NUC_191.L_CORE 0.002125
K_21800 X_NUC_148.L_CORE X_NUC_192.L_CORE 0.001302
K_21801 X_NUC_148.L_CORE X_NUC_193.L_CORE 0.002294
K_21802 X_NUC_148.L_CORE X_NUC_194.L_CORE 0.001626
K_21803 X_NUC_148.L_CORE X_NUC_195.L_CORE 0.001455
K_21804 X_NUC_148.L_CORE X_NUC_196.L_CORE 0.002996
K_21805 X_NUC_148.L_CORE X_NUC_197.L_CORE 0.001388
K_21806 X_NUC_148.L_CORE X_NUC_198.L_CORE 0.002006
K_21807 X_NUC_148.L_CORE X_NUC_199.L_CORE 0.002189
K_21808 X_NUC_148.L_CORE X_NUC_200.L_CORE 0.001406
K_21809 X_NUC_148.L_CORE X_NUC_201.L_CORE 0.003588
K_21810 X_NUC_148.L_CORE X_NUC_202.L_CORE 0.001621
K_21811 X_NUC_148.L_CORE X_NUC_203.L_CORE 0.001744
K_21812 X_NUC_148.L_CORE X_NUC_204.L_CORE 0.003633
K_21813 X_NUC_148.L_CORE X_NUC_205.L_CORE 0.001466
K_21814 X_NUC_148.L_CORE X_NUC_206.L_CORE 0.002953
K_21815 X_NUC_148.L_CORE X_NUC_207.L_CORE 0.002158
K_21816 X_NUC_148.L_CORE X_NUC_208.L_CORE 0.001626
K_21817 X_NUC_148.L_CORE X_NUC_209.L_CORE 0.008111
K_21818 X_NUC_148.L_CORE X_NUC_210.L_CORE 0.001687
K_21819 X_NUC_148.L_CORE X_NUC_211.L_CORE 0.002337
K_21820 X_NUC_148.L_CORE X_NUC_212.L_CORE 0.003618
K_21821 X_NUC_148.L_CORE X_NUC_213.L_CORE 0.001676
K_21822 X_NUC_148.L_CORE X_NUC_214.L_CORE 0.005907
K_21823 X_NUC_148.L_CORE X_NUC_215.L_CORE 0.002214
K_21824 X_NUC_148.L_CORE X_NUC_216.L_CORE 0.002108
K_21825 X_NUC_148.L_CORE X_NUC_217.L_CORE 0.009367
K_21826 X_NUC_148.L_CORE X_NUC_218.L_CORE 0.001978
K_21827 X_NUC_148.L_CORE X_NUC_219.L_CORE 0.003564
K_21828 X_NUC_148.L_CORE X_NUC_220.L_CORE 0.003371
K_21829 X_NUC_148.L_CORE X_NUC_221.L_CORE 0.002381
K_21830 X_NUC_148.L_CORE X_NUC_222.L_CORE 0.004216
K_21831 X_NUC_149.L_CORE X_NUC_150.L_CORE 0.207973
K_21832 X_NUC_149.L_CORE X_NUC_151.L_CORE 0.207973
K_21833 X_NUC_149.L_CORE X_NUC_152.L_CORE 0.207973
K_21834 X_NUC_149.L_CORE X_NUC_153.L_CORE 0.002180
K_21835 X_NUC_149.L_CORE X_NUC_154.L_CORE 0.002173
K_21836 X_NUC_149.L_CORE X_NUC_155.L_CORE 0.002166
K_21837 X_NUC_149.L_CORE X_NUC_156.L_CORE 0.002187
K_21838 X_NUC_149.L_CORE X_NUC_157.L_CORE 0.003135
K_21839 X_NUC_149.L_CORE X_NUC_158.L_CORE 0.003168
K_21840 X_NUC_149.L_CORE X_NUC_159.L_CORE 0.003130
K_21841 X_NUC_149.L_CORE X_NUC_160.L_CORE 0.003164
K_21842 X_NUC_149.L_CORE X_NUC_161.L_CORE 0.004721
K_21843 X_NUC_149.L_CORE X_NUC_162.L_CORE 0.004653
K_21844 X_NUC_149.L_CORE X_NUC_163.L_CORE 0.004630
K_21845 X_NUC_149.L_CORE X_NUC_164.L_CORE 0.004705
K_21846 X_NUC_149.L_CORE X_NUC_165.L_CORE 0.002485
K_21847 X_NUC_149.L_CORE X_NUC_166.L_CORE 0.002488
K_21848 X_NUC_149.L_CORE X_NUC_167.L_CORE 0.002468
K_21849 X_NUC_149.L_CORE X_NUC_168.L_CORE 0.002497
K_21850 X_NUC_149.L_CORE X_NUC_169.L_CORE 0.004718
K_21851 X_NUC_149.L_CORE X_NUC_170.L_CORE 0.004744
K_21852 X_NUC_149.L_CORE X_NUC_171.L_CORE 0.004654
K_21853 X_NUC_149.L_CORE X_NUC_172.L_CORE 0.004746
K_21854 X_NUC_149.L_CORE X_NUC_173.L_CORE 0.001386
K_21855 X_NUC_149.L_CORE X_NUC_174.L_CORE 0.001361
K_21856 X_NUC_149.L_CORE X_NUC_175.L_CORE 0.001299
K_21857 X_NUC_149.L_CORE X_NUC_176.L_CORE 0.001556
K_21858 X_NUC_149.L_CORE X_NUC_177.L_CORE 0.001282
K_21859 X_NUC_149.L_CORE X_NUC_178.L_CORE 0.001446
K_21860 X_NUC_149.L_CORE X_NUC_179.L_CORE 0.001550
K_21861 X_NUC_149.L_CORE X_NUC_180.L_CORE 0.001260
K_21862 X_NUC_149.L_CORE X_NUC_181.L_CORE 0.001736
K_21863 X_NUC_149.L_CORE X_NUC_182.L_CORE 0.001384
K_21864 X_NUC_149.L_CORE X_NUC_183.L_CORE 0.001386
K_21865 X_NUC_149.L_CORE X_NUC_184.L_CORE 0.001877
K_21866 X_NUC_149.L_CORE X_NUC_185.L_CORE 0.001278
K_21867 X_NUC_149.L_CORE X_NUC_186.L_CORE 0.001737
K_21868 X_NUC_149.L_CORE X_NUC_187.L_CORE 0.001629
K_21869 X_NUC_149.L_CORE X_NUC_188.L_CORE 0.001327
K_21870 X_NUC_149.L_CORE X_NUC_189.L_CORE 0.002236
K_21871 X_NUC_149.L_CORE X_NUC_190.L_CORE 0.001386
K_21872 X_NUC_149.L_CORE X_NUC_191.L_CORE 0.001607
K_21873 X_NUC_149.L_CORE X_NUC_192.L_CORE 0.002110
K_21874 X_NUC_149.L_CORE X_NUC_193.L_CORE 0.001325
K_21875 X_NUC_149.L_CORE X_NUC_194.L_CORE 0.002300
K_21876 X_NUC_149.L_CORE X_NUC_195.L_CORE 0.001642
K_21877 X_NUC_149.L_CORE X_NUC_196.L_CORE 0.001486
K_21878 X_NUC_149.L_CORE X_NUC_197.L_CORE 0.002938
K_21879 X_NUC_149.L_CORE X_NUC_198.L_CORE 0.001416
K_21880 X_NUC_149.L_CORE X_NUC_199.L_CORE 0.002046
K_21881 X_NUC_149.L_CORE X_NUC_200.L_CORE 0.002198
K_21882 X_NUC_149.L_CORE X_NUC_201.L_CORE 0.001445
K_21883 X_NUC_149.L_CORE X_NUC_202.L_CORE 0.003562
K_21884 X_NUC_149.L_CORE X_NUC_203.L_CORE 0.001658
K_21885 X_NUC_149.L_CORE X_NUC_204.L_CORE 0.001800
K_21886 X_NUC_149.L_CORE X_NUC_205.L_CORE 0.003590
K_21887 X_NUC_149.L_CORE X_NUC_206.L_CORE 0.001515
K_21888 X_NUC_149.L_CORE X_NUC_207.L_CORE 0.003047
K_21889 X_NUC_149.L_CORE X_NUC_208.L_CORE 0.002212
K_21890 X_NUC_149.L_CORE X_NUC_209.L_CORE 0.001695
K_21891 X_NUC_149.L_CORE X_NUC_210.L_CORE 0.007799
K_21892 X_NUC_149.L_CORE X_NUC_211.L_CORE 0.001756
K_21893 X_NUC_149.L_CORE X_NUC_212.L_CORE 0.002462
K_21894 X_NUC_149.L_CORE X_NUC_213.L_CORE 0.003726
K_21895 X_NUC_149.L_CORE X_NUC_214.L_CORE 0.001768
K_21896 X_NUC_149.L_CORE X_NUC_215.L_CORE 0.006378
K_21897 X_NUC_149.L_CORE X_NUC_216.L_CORE 0.002341
K_21898 X_NUC_149.L_CORE X_NUC_217.L_CORE 0.002265
K_21899 X_NUC_149.L_CORE X_NUC_218.L_CORE 0.009419
K_21900 X_NUC_149.L_CORE X_NUC_219.L_CORE 0.002149
K_21901 X_NUC_149.L_CORE X_NUC_220.L_CORE 0.003884
K_21902 X_NUC_149.L_CORE X_NUC_221.L_CORE 0.003631
K_21903 X_NUC_149.L_CORE X_NUC_222.L_CORE 0.002841
K_21904 X_NUC_150.L_CORE X_NUC_151.L_CORE 0.207973
K_21905 X_NUC_150.L_CORE X_NUC_152.L_CORE 0.207973
K_21906 X_NUC_150.L_CORE X_NUC_153.L_CORE 0.002187
K_21907 X_NUC_150.L_CORE X_NUC_154.L_CORE 0.002180
K_21908 X_NUC_150.L_CORE X_NUC_155.L_CORE 0.002172
K_21909 X_NUC_150.L_CORE X_NUC_156.L_CORE 0.002194
K_21910 X_NUC_150.L_CORE X_NUC_157.L_CORE 0.003102
K_21911 X_NUC_150.L_CORE X_NUC_158.L_CORE 0.003135
K_21912 X_NUC_150.L_CORE X_NUC_159.L_CORE 0.003098
K_21913 X_NUC_150.L_CORE X_NUC_160.L_CORE 0.003131
K_21914 X_NUC_150.L_CORE X_NUC_161.L_CORE 0.004789
K_21915 X_NUC_150.L_CORE X_NUC_162.L_CORE 0.004721
K_21916 X_NUC_150.L_CORE X_NUC_163.L_CORE 0.004696
K_21917 X_NUC_150.L_CORE X_NUC_164.L_CORE 0.004774
K_21918 X_NUC_150.L_CORE X_NUC_165.L_CORE 0.002481
K_21919 X_NUC_150.L_CORE X_NUC_166.L_CORE 0.002485
K_21920 X_NUC_150.L_CORE X_NUC_167.L_CORE 0.002465
K_21921 X_NUC_150.L_CORE X_NUC_168.L_CORE 0.002494
K_21922 X_NUC_150.L_CORE X_NUC_169.L_CORE 0.004691
K_21923 X_NUC_150.L_CORE X_NUC_170.L_CORE 0.004718
K_21924 X_NUC_150.L_CORE X_NUC_171.L_CORE 0.004628
K_21925 X_NUC_150.L_CORE X_NUC_172.L_CORE 0.004719
K_21926 X_NUC_150.L_CORE X_NUC_173.L_CORE 0.001385
K_21927 X_NUC_150.L_CORE X_NUC_174.L_CORE 0.001362
K_21928 X_NUC_150.L_CORE X_NUC_175.L_CORE 0.001297
K_21929 X_NUC_150.L_CORE X_NUC_176.L_CORE 0.001556
K_21930 X_NUC_150.L_CORE X_NUC_177.L_CORE 0.001283
K_21931 X_NUC_150.L_CORE X_NUC_178.L_CORE 0.001442
K_21932 X_NUC_150.L_CORE X_NUC_179.L_CORE 0.001554
K_21933 X_NUC_150.L_CORE X_NUC_180.L_CORE 0.001259
K_21934 X_NUC_150.L_CORE X_NUC_181.L_CORE 0.001733
K_21935 X_NUC_150.L_CORE X_NUC_182.L_CORE 0.001387
K_21936 X_NUC_150.L_CORE X_NUC_183.L_CORE 0.001382
K_21937 X_NUC_150.L_CORE X_NUC_184.L_CORE 0.001882
K_21938 X_NUC_150.L_CORE X_NUC_185.L_CORE 0.001279
K_21939 X_NUC_150.L_CORE X_NUC_186.L_CORE 0.001729
K_21940 X_NUC_150.L_CORE X_NUC_187.L_CORE 0.001637
K_21941 X_NUC_150.L_CORE X_NUC_188.L_CORE 0.001324
K_21942 X_NUC_150.L_CORE X_NUC_189.L_CORE 0.002233
K_21943 X_NUC_150.L_CORE X_NUC_190.L_CORE 0.001390
K_21944 X_NUC_150.L_CORE X_NUC_191.L_CORE 0.001599
K_21945 X_NUC_150.L_CORE X_NUC_192.L_CORE 0.002123
K_21946 X_NUC_150.L_CORE X_NUC_193.L_CORE 0.001324
K_21947 X_NUC_150.L_CORE X_NUC_194.L_CORE 0.002284
K_21948 X_NUC_150.L_CORE X_NUC_195.L_CORE 0.001650
K_21949 X_NUC_150.L_CORE X_NUC_196.L_CORE 0.001480
K_21950 X_NUC_150.L_CORE X_NUC_197.L_CORE 0.002949
K_21951 X_NUC_150.L_CORE X_NUC_198.L_CORE 0.001419
K_21952 X_NUC_150.L_CORE X_NUC_199.L_CORE 0.002030
K_21953 X_NUC_150.L_CORE X_NUC_200.L_CORE 0.002217
K_21954 X_NUC_150.L_CORE X_NUC_201.L_CORE 0.001442
K_21955 X_NUC_150.L_CORE X_NUC_202.L_CORE 0.003533
K_21956 X_NUC_150.L_CORE X_NUC_203.L_CORE 0.001665
K_21957 X_NUC_150.L_CORE X_NUC_204.L_CORE 0.001789
K_21958 X_NUC_150.L_CORE X_NUC_205.L_CORE 0.003639
K_21959 X_NUC_150.L_CORE X_NUC_206.L_CORE 0.001516
K_21960 X_NUC_150.L_CORE X_NUC_207.L_CORE 0.003006
K_21961 X_NUC_150.L_CORE X_NUC_208.L_CORE 0.002231
K_21962 X_NUC_150.L_CORE X_NUC_209.L_CORE 0.001689
K_21963 X_NUC_150.L_CORE X_NUC_210.L_CORE 0.007810
K_21964 X_NUC_150.L_CORE X_NUC_211.L_CORE 0.001762
K_21965 X_NUC_150.L_CORE X_NUC_212.L_CORE 0.002437
K_21966 X_NUC_150.L_CORE X_NUC_213.L_CORE 0.003791
K_21967 X_NUC_150.L_CORE X_NUC_214.L_CORE 0.001766
K_21968 X_NUC_150.L_CORE X_NUC_215.L_CORE 0.006189
K_21969 X_NUC_150.L_CORE X_NUC_216.L_CORE 0.002357
K_21970 X_NUC_150.L_CORE X_NUC_217.L_CORE 0.002252
K_21971 X_NUC_150.L_CORE X_NUC_218.L_CORE 0.009757
K_21972 X_NUC_150.L_CORE X_NUC_219.L_CORE 0.002152
K_21973 X_NUC_150.L_CORE X_NUC_220.L_CORE 0.003837
K_21974 X_NUC_150.L_CORE X_NUC_221.L_CORE 0.003660
K_21975 X_NUC_150.L_CORE X_NUC_222.L_CORE 0.002835
K_21976 X_NUC_151.L_CORE X_NUC_152.L_CORE 0.207973
K_21977 X_NUC_151.L_CORE X_NUC_153.L_CORE 0.002195
K_21978 X_NUC_151.L_CORE X_NUC_154.L_CORE 0.002188
K_21979 X_NUC_151.L_CORE X_NUC_155.L_CORE 0.002180
K_21980 X_NUC_151.L_CORE X_NUC_156.L_CORE 0.002202
K_21981 X_NUC_151.L_CORE X_NUC_157.L_CORE 0.003139
K_21982 X_NUC_151.L_CORE X_NUC_158.L_CORE 0.003172
K_21983 X_NUC_151.L_CORE X_NUC_159.L_CORE 0.003135
K_21984 X_NUC_151.L_CORE X_NUC_160.L_CORE 0.003169
K_21985 X_NUC_151.L_CORE X_NUC_161.L_CORE 0.004814
K_21986 X_NUC_151.L_CORE X_NUC_162.L_CORE 0.004743
K_21987 X_NUC_151.L_CORE X_NUC_163.L_CORE 0.004721
K_21988 X_NUC_151.L_CORE X_NUC_164.L_CORE 0.004799
K_21989 X_NUC_151.L_CORE X_NUC_165.L_CORE 0.002501
K_21990 X_NUC_151.L_CORE X_NUC_166.L_CORE 0.002505
K_21991 X_NUC_151.L_CORE X_NUC_167.L_CORE 0.002485
K_21992 X_NUC_151.L_CORE X_NUC_168.L_CORE 0.002514
K_21993 X_NUC_151.L_CORE X_NUC_169.L_CORE 0.004784
K_21994 X_NUC_151.L_CORE X_NUC_170.L_CORE 0.004812
K_21995 X_NUC_151.L_CORE X_NUC_171.L_CORE 0.004718
K_21996 X_NUC_151.L_CORE X_NUC_172.L_CORE 0.004813
K_21997 X_NUC_151.L_CORE X_NUC_173.L_CORE 0.001381
K_21998 X_NUC_151.L_CORE X_NUC_174.L_CORE 0.001357
K_21999 X_NUC_151.L_CORE X_NUC_175.L_CORE 0.001295
K_22000 X_NUC_151.L_CORE X_NUC_176.L_CORE 0.001549
K_22001 X_NUC_151.L_CORE X_NUC_177.L_CORE 0.001280
K_22002 X_NUC_151.L_CORE X_NUC_178.L_CORE 0.001439
K_22003 X_NUC_151.L_CORE X_NUC_179.L_CORE 0.001545
K_22004 X_NUC_151.L_CORE X_NUC_180.L_CORE 0.001258
K_22005 X_NUC_151.L_CORE X_NUC_181.L_CORE 0.001724
K_22006 X_NUC_151.L_CORE X_NUC_182.L_CORE 0.001383
K_22007 X_NUC_151.L_CORE X_NUC_183.L_CORE 0.001382
K_22008 X_NUC_151.L_CORE X_NUC_184.L_CORE 0.001867
K_22009 X_NUC_151.L_CORE X_NUC_185.L_CORE 0.001278
K_22010 X_NUC_151.L_CORE X_NUC_186.L_CORE 0.001726
K_22011 X_NUC_151.L_CORE X_NUC_187.L_CORE 0.001628
K_22012 X_NUC_151.L_CORE X_NUC_188.L_CORE 0.001325
K_22013 X_NUC_151.L_CORE X_NUC_189.L_CORE 0.002215
K_22014 X_NUC_151.L_CORE X_NUC_190.L_CORE 0.001388
K_22015 X_NUC_151.L_CORE X_NUC_191.L_CORE 0.001600
K_22016 X_NUC_151.L_CORE X_NUC_192.L_CORE 0.002104
K_22017 X_NUC_151.L_CORE X_NUC_193.L_CORE 0.001325
K_22018 X_NUC_151.L_CORE X_NUC_194.L_CORE 0.002276
K_22019 X_NUC_151.L_CORE X_NUC_195.L_CORE 0.001644
K_22020 X_NUC_151.L_CORE X_NUC_196.L_CORE 0.001483
K_22021 X_NUC_151.L_CORE X_NUC_197.L_CORE 0.002910
K_22022 X_NUC_151.L_CORE X_NUC_198.L_CORE 0.001419
K_22023 X_NUC_151.L_CORE X_NUC_199.L_CORE 0.002033
K_22024 X_NUC_151.L_CORE X_NUC_200.L_CORE 0.002201
K_22025 X_NUC_151.L_CORE X_NUC_201.L_CORE 0.001445
K_22026 X_NUC_151.L_CORE X_NUC_202.L_CORE 0.003502
K_22027 X_NUC_151.L_CORE X_NUC_203.L_CORE 0.001664
K_22028 X_NUC_151.L_CORE X_NUC_204.L_CORE 0.001796
K_22029 X_NUC_151.L_CORE X_NUC_205.L_CORE 0.003582
K_22030 X_NUC_151.L_CORE X_NUC_206.L_CORE 0.001519
K_22031 X_NUC_151.L_CORE X_NUC_207.L_CORE 0.003015
K_22032 X_NUC_151.L_CORE X_NUC_208.L_CORE 0.002224
K_22033 X_NUC_151.L_CORE X_NUC_209.L_CORE 0.001696
K_22034 X_NUC_151.L_CORE X_NUC_210.L_CORE 0.007571
K_22035 X_NUC_151.L_CORE X_NUC_211.L_CORE 0.001765
K_22036 X_NUC_151.L_CORE X_NUC_212.L_CORE 0.002455
K_22037 X_NUC_151.L_CORE X_NUC_213.L_CORE 0.003762
K_22038 X_NUC_151.L_CORE X_NUC_214.L_CORE 0.001774
K_22039 X_NUC_151.L_CORE X_NUC_215.L_CORE 0.006284
K_22040 X_NUC_151.L_CORE X_NUC_216.L_CORE 0.002361
K_22041 X_NUC_151.L_CORE X_NUC_217.L_CORE 0.002270
K_22042 X_NUC_151.L_CORE X_NUC_218.L_CORE 0.009835
K_22043 X_NUC_151.L_CORE X_NUC_219.L_CORE 0.002164
K_22044 X_NUC_151.L_CORE X_NUC_220.L_CORE 0.003902
K_22045 X_NUC_151.L_CORE X_NUC_221.L_CORE 0.003689
K_22046 X_NUC_151.L_CORE X_NUC_222.L_CORE 0.002865
K_22047 X_NUC_152.L_CORE X_NUC_153.L_CORE 0.002174
K_22048 X_NUC_152.L_CORE X_NUC_154.L_CORE 0.002167
K_22049 X_NUC_152.L_CORE X_NUC_155.L_CORE 0.002159
K_22050 X_NUC_152.L_CORE X_NUC_156.L_CORE 0.002180
K_22051 X_NUC_152.L_CORE X_NUC_157.L_CORE 0.003105
K_22052 X_NUC_152.L_CORE X_NUC_158.L_CORE 0.003138
K_22053 X_NUC_152.L_CORE X_NUC_159.L_CORE 0.003101
K_22054 X_NUC_152.L_CORE X_NUC_160.L_CORE 0.003135
K_22055 X_NUC_152.L_CORE X_NUC_161.L_CORE 0.004734
K_22056 X_NUC_152.L_CORE X_NUC_162.L_CORE 0.004666
K_22057 X_NUC_152.L_CORE X_NUC_163.L_CORE 0.004644
K_22058 X_NUC_152.L_CORE X_NUC_164.L_CORE 0.004721
K_22059 X_NUC_152.L_CORE X_NUC_165.L_CORE 0.002472
K_22060 X_NUC_152.L_CORE X_NUC_166.L_CORE 0.002475
K_22061 X_NUC_152.L_CORE X_NUC_167.L_CORE 0.002456
K_22062 X_NUC_152.L_CORE X_NUC_168.L_CORE 0.002485
K_22063 X_NUC_152.L_CORE X_NUC_169.L_CORE 0.004689
K_22064 X_NUC_152.L_CORE X_NUC_170.L_CORE 0.004716
K_22065 X_NUC_152.L_CORE X_NUC_171.L_CORE 0.004627
K_22066 X_NUC_152.L_CORE X_NUC_172.L_CORE 0.004718
K_22067 X_NUC_152.L_CORE X_NUC_173.L_CORE 0.001378
K_22068 X_NUC_152.L_CORE X_NUC_174.L_CORE 0.001354
K_22069 X_NUC_152.L_CORE X_NUC_175.L_CORE 0.001291
K_22070 X_NUC_152.L_CORE X_NUC_176.L_CORE 0.001548
K_22071 X_NUC_152.L_CORE X_NUC_177.L_CORE 0.001276
K_22072 X_NUC_152.L_CORE X_NUC_178.L_CORE 0.001436
K_22073 X_NUC_152.L_CORE X_NUC_179.L_CORE 0.001543
K_22074 X_NUC_152.L_CORE X_NUC_180.L_CORE 0.001253
K_22075 X_NUC_152.L_CORE X_NUC_181.L_CORE 0.001725
K_22076 X_NUC_152.L_CORE X_NUC_182.L_CORE 0.001378
K_22077 X_NUC_152.L_CORE X_NUC_183.L_CORE 0.001377
K_22078 X_NUC_152.L_CORE X_NUC_184.L_CORE 0.001869
K_22079 X_NUC_152.L_CORE X_NUC_185.L_CORE 0.001272
K_22080 X_NUC_152.L_CORE X_NUC_186.L_CORE 0.001724
K_22081 X_NUC_152.L_CORE X_NUC_187.L_CORE 0.001624
K_22082 X_NUC_152.L_CORE X_NUC_188.L_CORE 0.001319
K_22083 X_NUC_152.L_CORE X_NUC_189.L_CORE 0.002222
K_22084 X_NUC_152.L_CORE X_NUC_190.L_CORE 0.001381
K_22085 X_NUC_152.L_CORE X_NUC_191.L_CORE 0.001595
K_22086 X_NUC_152.L_CORE X_NUC_192.L_CORE 0.002105
K_22087 X_NUC_152.L_CORE X_NUC_193.L_CORE 0.001318
K_22088 X_NUC_152.L_CORE X_NUC_194.L_CORE 0.002280
K_22089 X_NUC_152.L_CORE X_NUC_195.L_CORE 0.001637
K_22090 X_NUC_152.L_CORE X_NUC_196.L_CORE 0.001476
K_22091 X_NUC_152.L_CORE X_NUC_197.L_CORE 0.002927
K_22092 X_NUC_152.L_CORE X_NUC_198.L_CORE 0.001411
K_22093 X_NUC_152.L_CORE X_NUC_199.L_CORE 0.002028
K_22094 X_NUC_152.L_CORE X_NUC_200.L_CORE 0.002196
K_22095 X_NUC_152.L_CORE X_NUC_201.L_CORE 0.001436
K_22096 X_NUC_152.L_CORE X_NUC_202.L_CORE 0.003530
K_22097 X_NUC_152.L_CORE X_NUC_203.L_CORE 0.001653
K_22098 X_NUC_152.L_CORE X_NUC_204.L_CORE 0.001786
K_22099 X_NUC_152.L_CORE X_NUC_205.L_CORE 0.003596
K_22100 X_NUC_152.L_CORE X_NUC_206.L_CORE 0.001509
K_22101 X_NUC_152.L_CORE X_NUC_207.L_CORE 0.003014
K_22102 X_NUC_152.L_CORE X_NUC_208.L_CORE 0.002211
K_22103 X_NUC_152.L_CORE X_NUC_209.L_CORE 0.001684
K_22104 X_NUC_152.L_CORE X_NUC_210.L_CORE 0.007795
K_22105 X_NUC_152.L_CORE X_NUC_211.L_CORE 0.001751
K_22106 X_NUC_152.L_CORE X_NUC_212.L_CORE 0.002440
K_22107 X_NUC_152.L_CORE X_NUC_213.L_CORE 0.003743
K_22108 X_NUC_152.L_CORE X_NUC_214.L_CORE 0.001759
K_22109 X_NUC_152.L_CORE X_NUC_215.L_CORE 0.006286
K_22110 X_NUC_152.L_CORE X_NUC_216.L_CORE 0.002339
K_22111 X_NUC_152.L_CORE X_NUC_217.L_CORE 0.002250
K_22112 X_NUC_152.L_CORE X_NUC_218.L_CORE 0.009667
K_22113 X_NUC_152.L_CORE X_NUC_219.L_CORE 0.002142
K_22114 X_NUC_152.L_CORE X_NUC_220.L_CORE 0.003854
K_22115 X_NUC_152.L_CORE X_NUC_221.L_CORE 0.003637
K_22116 X_NUC_152.L_CORE X_NUC_222.L_CORE 0.002829
K_22117 X_NUC_153.L_CORE X_NUC_154.L_CORE 0.207973
K_22118 X_NUC_153.L_CORE X_NUC_155.L_CORE 0.207973
K_22119 X_NUC_153.L_CORE X_NUC_156.L_CORE 0.207973
K_22120 X_NUC_153.L_CORE X_NUC_157.L_CORE 0.002408
K_22121 X_NUC_153.L_CORE X_NUC_158.L_CORE 0.002432
K_22122 X_NUC_153.L_CORE X_NUC_159.L_CORE 0.002426
K_22123 X_NUC_153.L_CORE X_NUC_160.L_CORE 0.002412
K_22124 X_NUC_153.L_CORE X_NUC_161.L_CORE 0.003504
K_22125 X_NUC_153.L_CORE X_NUC_162.L_CORE 0.003504
K_22126 X_NUC_153.L_CORE X_NUC_163.L_CORE 0.003528
K_22127 X_NUC_153.L_CORE X_NUC_164.L_CORE 0.003469
K_22128 X_NUC_153.L_CORE X_NUC_165.L_CORE 0.005151
K_22129 X_NUC_153.L_CORE X_NUC_166.L_CORE 0.005273
K_22130 X_NUC_153.L_CORE X_NUC_167.L_CORE 0.005199
K_22131 X_NUC_153.L_CORE X_NUC_168.L_CORE 0.005170
K_22132 X_NUC_153.L_CORE X_NUC_169.L_CORE 0.003082
K_22133 X_NUC_153.L_CORE X_NUC_170.L_CORE 0.003109
K_22134 X_NUC_153.L_CORE X_NUC_171.L_CORE 0.003106
K_22135 X_NUC_153.L_CORE X_NUC_172.L_CORE 0.003070
K_22136 X_NUC_153.L_CORE X_NUC_173.L_CORE 0.001290
K_22137 X_NUC_153.L_CORE X_NUC_174.L_CORE 0.001402
K_22138 X_NUC_153.L_CORE X_NUC_175.L_CORE 0.001358
K_22139 X_NUC_153.L_CORE X_NUC_176.L_CORE 0.001290
K_22140 X_NUC_153.L_CORE X_NUC_177.L_CORE 0.001557
K_22141 X_NUC_153.L_CORE X_NUC_178.L_CORE 0.001282
K_22142 X_NUC_153.L_CORE X_NUC_179.L_CORE 0.001441
K_22143 X_NUC_153.L_CORE X_NUC_180.L_CORE 0.001548
K_22144 X_NUC_153.L_CORE X_NUC_181.L_CORE 0.001266
K_22145 X_NUC_153.L_CORE X_NUC_182.L_CORE 0.001718
K_22146 X_NUC_153.L_CORE X_NUC_183.L_CORE 0.001393
K_22147 X_NUC_153.L_CORE X_NUC_184.L_CORE 0.001391
K_22148 X_NUC_153.L_CORE X_NUC_185.L_CORE 0.001857
K_22149 X_NUC_153.L_CORE X_NUC_186.L_CORE 0.001295
K_22150 X_NUC_153.L_CORE X_NUC_187.L_CORE 0.001724
K_22151 X_NUC_153.L_CORE X_NUC_188.L_CORE 0.001639
K_22152 X_NUC_153.L_CORE X_NUC_189.L_CORE 0.001345
K_22153 X_NUC_153.L_CORE X_NUC_190.L_CORE 0.002183
K_22154 X_NUC_153.L_CORE X_NUC_191.L_CORE 0.001412
K_22155 X_NUC_153.L_CORE X_NUC_192.L_CORE 0.001616
K_22156 X_NUC_153.L_CORE X_NUC_193.L_CORE 0.002101
K_22157 X_NUC_153.L_CORE X_NUC_194.L_CORE 0.001355
K_22158 X_NUC_153.L_CORE X_NUC_195.L_CORE 0.002257
K_22159 X_NUC_153.L_CORE X_NUC_196.L_CORE 0.001676
K_22160 X_NUC_153.L_CORE X_NUC_197.L_CORE 0.001516
K_22161 X_NUC_153.L_CORE X_NUC_198.L_CORE 0.002849
K_22162 X_NUC_153.L_CORE X_NUC_199.L_CORE 0.001460
K_22163 X_NUC_153.L_CORE X_NUC_200.L_CORE 0.002057
K_22164 X_NUC_153.L_CORE X_NUC_201.L_CORE 0.002236
K_22165 X_NUC_153.L_CORE X_NUC_202.L_CORE 0.001492
K_22166 X_NUC_153.L_CORE X_NUC_203.L_CORE 0.003418
K_22167 X_NUC_153.L_CORE X_NUC_204.L_CORE 0.001721
K_22168 X_NUC_153.L_CORE X_NUC_205.L_CORE 0.001851
K_22169 X_NUC_153.L_CORE X_NUC_206.L_CORE 0.003579
K_22170 X_NUC_153.L_CORE X_NUC_207.L_CORE 0.001584
K_22171 X_NUC_153.L_CORE X_NUC_208.L_CORE 0.003062
K_22172 X_NUC_153.L_CORE X_NUC_209.L_CORE 0.002318
K_22173 X_NUC_153.L_CORE X_NUC_210.L_CORE 0.001776
K_22174 X_NUC_153.L_CORE X_NUC_211.L_CORE 0.007177
K_22175 X_NUC_153.L_CORE X_NUC_212.L_CORE 0.001864
K_22176 X_NUC_153.L_CORE X_NUC_213.L_CORE 0.002579
K_22177 X_NUC_153.L_CORE X_NUC_214.L_CORE 0.003986
K_22178 X_NUC_153.L_CORE X_NUC_215.L_CORE 0.001894
K_22179 X_NUC_153.L_CORE X_NUC_216.L_CORE 0.006595
K_22180 X_NUC_153.L_CORE X_NUC_217.L_CORE 0.002558
K_22181 X_NUC_153.L_CORE X_NUC_218.L_CORE 0.002468
K_22182 X_NUC_153.L_CORE X_NUC_219.L_CORE 0.010426
K_22183 X_NUC_153.L_CORE X_NUC_220.L_CORE 0.002425
K_22184 X_NUC_153.L_CORE X_NUC_221.L_CORE 0.004274
K_22185 X_NUC_153.L_CORE X_NUC_222.L_CORE 0.004068
K_22186 X_NUC_154.L_CORE X_NUC_155.L_CORE 0.207973
K_22187 X_NUC_154.L_CORE X_NUC_156.L_CORE 0.207973
K_22188 X_NUC_154.L_CORE X_NUC_157.L_CORE 0.002384
K_22189 X_NUC_154.L_CORE X_NUC_158.L_CORE 0.002408
K_22190 X_NUC_154.L_CORE X_NUC_159.L_CORE 0.002402
K_22191 X_NUC_154.L_CORE X_NUC_160.L_CORE 0.002388
K_22192 X_NUC_154.L_CORE X_NUC_161.L_CORE 0.003503
K_22193 X_NUC_154.L_CORE X_NUC_162.L_CORE 0.003504
K_22194 X_NUC_154.L_CORE X_NUC_163.L_CORE 0.003527
K_22195 X_NUC_154.L_CORE X_NUC_164.L_CORE 0.003469
K_22196 X_NUC_154.L_CORE X_NUC_165.L_CORE 0.005034
K_22197 X_NUC_154.L_CORE X_NUC_166.L_CORE 0.005151
K_22198 X_NUC_154.L_CORE X_NUC_167.L_CORE 0.005081
K_22199 X_NUC_154.L_CORE X_NUC_168.L_CORE 0.005054
K_22200 X_NUC_154.L_CORE X_NUC_169.L_CORE 0.003055
K_22201 X_NUC_154.L_CORE X_NUC_170.L_CORE 0.003082
K_22202 X_NUC_154.L_CORE X_NUC_171.L_CORE 0.003079
K_22203 X_NUC_154.L_CORE X_NUC_172.L_CORE 0.003044
K_22204 X_NUC_154.L_CORE X_NUC_173.L_CORE 0.001287
K_22205 X_NUC_154.L_CORE X_NUC_174.L_CORE 0.001402
K_22206 X_NUC_154.L_CORE X_NUC_175.L_CORE 0.001355
K_22207 X_NUC_154.L_CORE X_NUC_176.L_CORE 0.001289
K_22208 X_NUC_154.L_CORE X_NUC_177.L_CORE 0.001557
K_22209 X_NUC_154.L_CORE X_NUC_178.L_CORE 0.001278
K_22210 X_NUC_154.L_CORE X_NUC_179.L_CORE 0.001442
K_22211 X_NUC_154.L_CORE X_NUC_180.L_CORE 0.001544
K_22212 X_NUC_154.L_CORE X_NUC_181.L_CORE 0.001263
K_22213 X_NUC_154.L_CORE X_NUC_182.L_CORE 0.001721
K_22214 X_NUC_154.L_CORE X_NUC_183.L_CORE 0.001387
K_22215 X_NUC_154.L_CORE X_NUC_184.L_CORE 0.001391
K_22216 X_NUC_154.L_CORE X_NUC_185.L_CORE 0.001855
K_22217 X_NUC_154.L_CORE X_NUC_186.L_CORE 0.001290
K_22218 X_NUC_154.L_CORE X_NUC_187.L_CORE 0.001729
K_22219 X_NUC_154.L_CORE X_NUC_188.L_CORE 0.001631
K_22220 X_NUC_154.L_CORE X_NUC_189.L_CORE 0.001342
K_22221 X_NUC_154.L_CORE X_NUC_190.L_CORE 0.002190
K_22222 X_NUC_154.L_CORE X_NUC_191.L_CORE 0.001405
K_22223 X_NUC_154.L_CORE X_NUC_192.L_CORE 0.001619
K_22224 X_NUC_154.L_CORE X_NUC_193.L_CORE 0.002092
K_22225 X_NUC_154.L_CORE X_NUC_194.L_CORE 0.001351
K_22226 X_NUC_154.L_CORE X_NUC_195.L_CORE 0.002271
K_22227 X_NUC_154.L_CORE X_NUC_196.L_CORE 0.001665
K_22228 X_NUC_154.L_CORE X_NUC_197.L_CORE 0.001515
K_22229 X_NUC_154.L_CORE X_NUC_198.L_CORE 0.002854
K_22230 X_NUC_154.L_CORE X_NUC_199.L_CORE 0.001452
K_22231 X_NUC_154.L_CORE X_NUC_200.L_CORE 0.002067
K_22232 X_NUC_154.L_CORE X_NUC_201.L_CORE 0.002219
K_22233 X_NUC_154.L_CORE X_NUC_202.L_CORE 0.001488
K_22234 X_NUC_154.L_CORE X_NUC_203.L_CORE 0.003457
K_22235 X_NUC_154.L_CORE X_NUC_204.L_CORE 0.001708
K_22236 X_NUC_154.L_CORE X_NUC_205.L_CORE 0.001853
K_22237 X_NUC_154.L_CORE X_NUC_206.L_CORE 0.003557
K_22238 X_NUC_154.L_CORE X_NUC_207.L_CORE 0.001575
K_22239 X_NUC_154.L_CORE X_NUC_208.L_CORE 0.003094
K_22240 X_NUC_154.L_CORE X_NUC_209.L_CORE 0.002294
K_22241 X_NUC_154.L_CORE X_NUC_210.L_CORE 0.001772
K_22242 X_NUC_154.L_CORE X_NUC_211.L_CORE 0.007310
K_22243 X_NUC_154.L_CORE X_NUC_212.L_CORE 0.001849
K_22244 X_NUC_154.L_CORE X_NUC_213.L_CORE 0.002589
K_22245 X_NUC_154.L_CORE X_NUC_214.L_CORE 0.003921
K_22246 X_NUC_154.L_CORE X_NUC_215.L_CORE 0.001884
K_22247 X_NUC_154.L_CORE X_NUC_216.L_CORE 0.006760
K_22248 X_NUC_154.L_CORE X_NUC_217.L_CORE 0.002527
K_22249 X_NUC_154.L_CORE X_NUC_218.L_CORE 0.002464
K_22250 X_NUC_154.L_CORE X_NUC_219.L_CORE 0.010020
K_22251 X_NUC_154.L_CORE X_NUC_220.L_CORE 0.002404
K_22252 X_NUC_154.L_CORE X_NUC_221.L_CORE 0.004269
K_22253 X_NUC_154.L_CORE X_NUC_222.L_CORE 0.004006
K_22254 X_NUC_155.L_CORE X_NUC_156.L_CORE 0.207973
K_22255 X_NUC_155.L_CORE X_NUC_157.L_CORE 0.002389
K_22256 X_NUC_155.L_CORE X_NUC_158.L_CORE 0.002413
K_22257 X_NUC_155.L_CORE X_NUC_159.L_CORE 0.002408
K_22258 X_NUC_155.L_CORE X_NUC_160.L_CORE 0.002393
K_22259 X_NUC_155.L_CORE X_NUC_161.L_CORE 0.003479
K_22260 X_NUC_155.L_CORE X_NUC_162.L_CORE 0.003480
K_22261 X_NUC_155.L_CORE X_NUC_163.L_CORE 0.003504
K_22262 X_NUC_155.L_CORE X_NUC_164.L_CORE 0.003446
K_22263 X_NUC_155.L_CORE X_NUC_165.L_CORE 0.005101
K_22264 X_NUC_155.L_CORE X_NUC_166.L_CORE 0.005221
K_22265 X_NUC_155.L_CORE X_NUC_167.L_CORE 0.005151
K_22266 X_NUC_155.L_CORE X_NUC_168.L_CORE 0.005121
K_22267 X_NUC_155.L_CORE X_NUC_169.L_CORE 0.003058
K_22268 X_NUC_155.L_CORE X_NUC_170.L_CORE 0.003084
K_22269 X_NUC_155.L_CORE X_NUC_171.L_CORE 0.003082
K_22270 X_NUC_155.L_CORE X_NUC_172.L_CORE 0.003047
K_22271 X_NUC_155.L_CORE X_NUC_173.L_CORE 0.001282
K_22272 X_NUC_155.L_CORE X_NUC_174.L_CORE 0.001394
K_22273 X_NUC_155.L_CORE X_NUC_175.L_CORE 0.001351
K_22274 X_NUC_155.L_CORE X_NUC_176.L_CORE 0.001283
K_22275 X_NUC_155.L_CORE X_NUC_177.L_CORE 0.001549
K_22276 X_NUC_155.L_CORE X_NUC_178.L_CORE 0.001275
K_22277 X_NUC_155.L_CORE X_NUC_179.L_CORE 0.001433
K_22278 X_NUC_155.L_CORE X_NUC_180.L_CORE 0.001540
K_22279 X_NUC_155.L_CORE X_NUC_181.L_CORE 0.001258
K_22280 X_NUC_155.L_CORE X_NUC_182.L_CORE 0.001709
K_22281 X_NUC_155.L_CORE X_NUC_183.L_CORE 0.001385
K_22282 X_NUC_155.L_CORE X_NUC_184.L_CORE 0.001383
K_22283 X_NUC_155.L_CORE X_NUC_185.L_CORE 0.001848
K_22284 X_NUC_155.L_CORE X_NUC_186.L_CORE 0.001287
K_22285 X_NUC_155.L_CORE X_NUC_187.L_CORE 0.001715
K_22286 X_NUC_155.L_CORE X_NUC_188.L_CORE 0.001630
K_22287 X_NUC_155.L_CORE X_NUC_189.L_CORE 0.001337
K_22288 X_NUC_155.L_CORE X_NUC_190.L_CORE 0.002174
K_22289 X_NUC_155.L_CORE X_NUC_191.L_CORE 0.001403
K_22290 X_NUC_155.L_CORE X_NUC_192.L_CORE 0.001607
K_22291 X_NUC_155.L_CORE X_NUC_193.L_CORE 0.002090
K_22292 X_NUC_155.L_CORE X_NUC_194.L_CORE 0.001347
K_22293 X_NUC_155.L_CORE X_NUC_195.L_CORE 0.002248
K_22294 X_NUC_155.L_CORE X_NUC_196.L_CORE 0.001666
K_22295 X_NUC_155.L_CORE X_NUC_197.L_CORE 0.001507
K_22296 X_NUC_155.L_CORE X_NUC_198.L_CORE 0.002839
K_22297 X_NUC_155.L_CORE X_NUC_199.L_CORE 0.001451
K_22298 X_NUC_155.L_CORE X_NUC_200.L_CORE 0.002047
K_22299 X_NUC_155.L_CORE X_NUC_201.L_CORE 0.002224
K_22300 X_NUC_155.L_CORE X_NUC_202.L_CORE 0.001483
K_22301 X_NUC_155.L_CORE X_NUC_203.L_CORE 0.003410
K_22302 X_NUC_155.L_CORE X_NUC_204.L_CORE 0.001710
K_22303 X_NUC_155.L_CORE X_NUC_205.L_CORE 0.001841
K_22304 X_NUC_155.L_CORE X_NUC_206.L_CORE 0.003566
K_22305 X_NUC_155.L_CORE X_NUC_207.L_CORE 0.001574
K_22306 X_NUC_155.L_CORE X_NUC_208.L_CORE 0.003052
K_22307 X_NUC_155.L_CORE X_NUC_209.L_CORE 0.002304
K_22308 X_NUC_155.L_CORE X_NUC_210.L_CORE 0.001765
K_22309 X_NUC_155.L_CORE X_NUC_211.L_CORE 0.007219
K_22310 X_NUC_155.L_CORE X_NUC_212.L_CORE 0.001851
K_22311 X_NUC_155.L_CORE X_NUC_213.L_CORE 0.002566
K_22312 X_NUC_155.L_CORE X_NUC_214.L_CORE 0.003965
K_22313 X_NUC_155.L_CORE X_NUC_215.L_CORE 0.001882
K_22314 X_NUC_155.L_CORE X_NUC_216.L_CORE 0.006612
K_22315 X_NUC_155.L_CORE X_NUC_217.L_CORE 0.002540
K_22316 X_NUC_155.L_CORE X_NUC_218.L_CORE 0.002453
K_22317 X_NUC_155.L_CORE X_NUC_219.L_CORE 0.010464
K_22318 X_NUC_155.L_CORE X_NUC_220.L_CORE 0.002409
K_22319 X_NUC_155.L_CORE X_NUC_221.L_CORE 0.004254
K_22320 X_NUC_155.L_CORE X_NUC_222.L_CORE 0.004042
K_22321 X_NUC_156.L_CORE X_NUC_157.L_CORE 0.002403
K_22322 X_NUC_156.L_CORE X_NUC_158.L_CORE 0.002428
K_22323 X_NUC_156.L_CORE X_NUC_159.L_CORE 0.002422
K_22324 X_NUC_156.L_CORE X_NUC_160.L_CORE 0.002408
K_22325 X_NUC_156.L_CORE X_NUC_161.L_CORE 0.003538
K_22326 X_NUC_156.L_CORE X_NUC_162.L_CORE 0.003538
K_22327 X_NUC_156.L_CORE X_NUC_163.L_CORE 0.003563
K_22328 X_NUC_156.L_CORE X_NUC_164.L_CORE 0.003504
K_22329 X_NUC_156.L_CORE X_NUC_165.L_CORE 0.005129
K_22330 X_NUC_156.L_CORE X_NUC_166.L_CORE 0.005251
K_22331 X_NUC_156.L_CORE X_NUC_167.L_CORE 0.005178
K_22332 X_NUC_156.L_CORE X_NUC_168.L_CORE 0.005151
K_22333 X_NUC_156.L_CORE X_NUC_169.L_CORE 0.003093
K_22334 X_NUC_156.L_CORE X_NUC_170.L_CORE 0.003121
K_22335 X_NUC_156.L_CORE X_NUC_171.L_CORE 0.003118
K_22336 X_NUC_156.L_CORE X_NUC_172.L_CORE 0.003082
K_22337 X_NUC_156.L_CORE X_NUC_173.L_CORE 0.001285
K_22338 X_NUC_156.L_CORE X_NUC_174.L_CORE 0.001396
K_22339 X_NUC_156.L_CORE X_NUC_175.L_CORE 0.001351
K_22340 X_NUC_156.L_CORE X_NUC_176.L_CORE 0.001287
K_22341 X_NUC_156.L_CORE X_NUC_177.L_CORE 0.001549
K_22342 X_NUC_156.L_CORE X_NUC_178.L_CORE 0.001277
K_22343 X_NUC_156.L_CORE X_NUC_179.L_CORE 0.001437
K_22344 X_NUC_156.L_CORE X_NUC_180.L_CORE 0.001538
K_22345 X_NUC_156.L_CORE X_NUC_181.L_CORE 0.001263
K_22346 X_NUC_156.L_CORE X_NUC_182.L_CORE 0.001711
K_22347 X_NUC_156.L_CORE X_NUC_183.L_CORE 0.001386
K_22348 X_NUC_156.L_CORE X_NUC_184.L_CORE 0.001389
K_22349 X_NUC_156.L_CORE X_NUC_185.L_CORE 0.001842
K_22350 X_NUC_156.L_CORE X_NUC_186.L_CORE 0.001291
K_22351 X_NUC_156.L_CORE X_NUC_187.L_CORE 0.001721
K_22352 X_NUC_156.L_CORE X_NUC_188.L_CORE 0.001627
K_22353 X_NUC_156.L_CORE X_NUC_189.L_CORE 0.001343
K_22354 X_NUC_156.L_CORE X_NUC_190.L_CORE 0.002169
K_22355 X_NUC_156.L_CORE X_NUC_191.L_CORE 0.001406
K_22356 X_NUC_156.L_CORE X_NUC_192.L_CORE 0.001616
K_22357 X_NUC_156.L_CORE X_NUC_193.L_CORE 0.002080
K_22358 X_NUC_156.L_CORE X_NUC_194.L_CORE 0.001353
K_22359 X_NUC_156.L_CORE X_NUC_195.L_CORE 0.002254
K_22360 X_NUC_156.L_CORE X_NUC_196.L_CORE 0.001665
K_22361 X_NUC_156.L_CORE X_NUC_197.L_CORE 0.001517
K_22362 X_NUC_156.L_CORE X_NUC_198.L_CORE 0.002818
K_22363 X_NUC_156.L_CORE X_NUC_199.L_CORE 0.001455
K_22364 X_NUC_156.L_CORE X_NUC_200.L_CORE 0.002061
K_22365 X_NUC_156.L_CORE X_NUC_201.L_CORE 0.002214
K_22366 X_NUC_156.L_CORE X_NUC_202.L_CORE 0.001492
K_22367 X_NUC_156.L_CORE X_NUC_203.L_CORE 0.003406
K_22368 X_NUC_156.L_CORE X_NUC_204.L_CORE 0.001713
K_22369 X_NUC_156.L_CORE X_NUC_205.L_CORE 0.001856
K_22370 X_NUC_156.L_CORE X_NUC_206.L_CORE 0.003522
K_22371 X_NUC_156.L_CORE X_NUC_207.L_CORE 0.001582
K_22372 X_NUC_156.L_CORE X_NUC_208.L_CORE 0.003079
K_22373 X_NUC_156.L_CORE X_NUC_209.L_CORE 0.002299
K_22374 X_NUC_156.L_CORE X_NUC_210.L_CORE 0.001780
K_22375 X_NUC_156.L_CORE X_NUC_211.L_CORE 0.007066
K_22376 X_NUC_156.L_CORE X_NUC_212.L_CORE 0.001858
K_22377 X_NUC_156.L_CORE X_NUC_213.L_CORE 0.002597
K_22378 X_NUC_156.L_CORE X_NUC_214.L_CORE 0.003929
K_22379 X_NUC_156.L_CORE X_NUC_215.L_CORE 0.001896
K_22380 X_NUC_156.L_CORE X_NUC_216.L_CORE 0.006749
K_22381 X_NUC_156.L_CORE X_NUC_217.L_CORE 0.002546
K_22382 X_NUC_156.L_CORE X_NUC_218.L_CORE 0.002482
K_22383 X_NUC_156.L_CORE X_NUC_219.L_CORE 0.010365
K_22384 X_NUC_156.L_CORE X_NUC_220.L_CORE 0.002427
K_22385 X_NUC_156.L_CORE X_NUC_221.L_CORE 0.004336
K_22386 X_NUC_156.L_CORE X_NUC_222.L_CORE 0.004078
K_22387 X_NUC_157.L_CORE X_NUC_158.L_CORE 0.207973
K_22388 X_NUC_157.L_CORE X_NUC_159.L_CORE 0.207973
K_22389 X_NUC_157.L_CORE X_NUC_160.L_CORE 0.207973
K_22390 X_NUC_157.L_CORE X_NUC_161.L_CORE 0.002748
K_22391 X_NUC_157.L_CORE X_NUC_162.L_CORE 0.002713
K_22392 X_NUC_157.L_CORE X_NUC_163.L_CORE 0.002733
K_22393 X_NUC_157.L_CORE X_NUC_164.L_CORE 0.002726
K_22394 X_NUC_157.L_CORE X_NUC_165.L_CORE 0.004080
K_22395 X_NUC_157.L_CORE X_NUC_166.L_CORE 0.004023
K_22396 X_NUC_157.L_CORE X_NUC_167.L_CORE 0.004017
K_22397 X_NUC_157.L_CORE X_NUC_168.L_CORE 0.004069
K_22398 X_NUC_157.L_CORE X_NUC_169.L_CORE 0.005529
K_22399 X_NUC_157.L_CORE X_NUC_170.L_CORE 0.005396
K_22400 X_NUC_157.L_CORE X_NUC_171.L_CORE 0.005447
K_22401 X_NUC_157.L_CORE X_NUC_172.L_CORE 0.005414
K_22402 X_NUC_157.L_CORE X_NUC_173.L_CORE 0.001347
K_22403 X_NUC_157.L_CORE X_NUC_174.L_CORE 0.001261
K_22404 X_NUC_157.L_CORE X_NUC_175.L_CORE 0.001405
K_22405 X_NUC_157.L_CORE X_NUC_176.L_CORE 0.001352
K_22406 X_NUC_157.L_CORE X_NUC_177.L_CORE 0.001286
K_22407 X_NUC_157.L_CORE X_NUC_178.L_CORE 0.001550
K_22408 X_NUC_157.L_CORE X_NUC_179.L_CORE 0.001281
K_22409 X_NUC_157.L_CORE X_NUC_180.L_CORE 0.001438
K_22410 X_NUC_157.L_CORE X_NUC_181.L_CORE 0.001538
K_22411 X_NUC_157.L_CORE X_NUC_182.L_CORE 0.001273
K_22412 X_NUC_157.L_CORE X_NUC_183.L_CORE 0.001700
K_22413 X_NUC_157.L_CORE X_NUC_184.L_CORE 0.001396
K_22414 X_NUC_157.L_CORE X_NUC_185.L_CORE 0.001399
K_22415 X_NUC_157.L_CORE X_NUC_186.L_CORE 0.001827
K_22416 X_NUC_157.L_CORE X_NUC_187.L_CORE 0.001310
K_22417 X_NUC_157.L_CORE X_NUC_188.L_CORE 0.001718
K_22418 X_NUC_157.L_CORE X_NUC_189.L_CORE 0.001637
K_22419 X_NUC_157.L_CORE X_NUC_190.L_CORE 0.001365
K_22420 X_NUC_157.L_CORE X_NUC_191.L_CORE 0.002134
K_22421 X_NUC_157.L_CORE X_NUC_192.L_CORE 0.001432
K_22422 X_NUC_157.L_CORE X_NUC_193.L_CORE 0.001633
K_22423 X_NUC_157.L_CORE X_NUC_194.L_CORE 0.002072
K_22424 X_NUC_157.L_CORE X_NUC_195.L_CORE 0.001386
K_22425 X_NUC_157.L_CORE X_NUC_196.L_CORE 0.002233
K_22426 X_NUC_157.L_CORE X_NUC_197.L_CORE 0.001696
K_22427 X_NUC_157.L_CORE X_NUC_198.L_CORE 0.001552
K_22428 X_NUC_157.L_CORE X_NUC_199.L_CORE 0.002755
K_22429 X_NUC_157.L_CORE X_NUC_200.L_CORE 0.001500
K_22430 X_NUC_157.L_CORE X_NUC_201.L_CORE 0.002086
K_22431 X_NUC_157.L_CORE X_NUC_202.L_CORE 0.002245
K_22432 X_NUC_157.L_CORE X_NUC_203.L_CORE 0.001544
K_22433 X_NUC_157.L_CORE X_NUC_204.L_CORE 0.003324
K_22434 X_NUC_157.L_CORE X_NUC_205.L_CORE 0.001775
K_22435 X_NUC_157.L_CORE X_NUC_206.L_CORE 0.001918
K_22436 X_NUC_157.L_CORE X_NUC_207.L_CORE 0.003509
K_22437 X_NUC_157.L_CORE X_NUC_208.L_CORE 0.001654
K_22438 X_NUC_157.L_CORE X_NUC_209.L_CORE 0.003132
K_22439 X_NUC_157.L_CORE X_NUC_210.L_CORE 0.002400
K_22440 X_NUC_157.L_CORE X_NUC_211.L_CORE 0.001872
K_22441 X_NUC_157.L_CORE X_NUC_212.L_CORE 0.006741
K_22442 X_NUC_157.L_CORE X_NUC_213.L_CORE 0.001973
K_22443 X_NUC_157.L_CORE X_NUC_214.L_CORE 0.002747
K_22444 X_NUC_157.L_CORE X_NUC_215.L_CORE 0.004178
K_22445 X_NUC_157.L_CORE X_NUC_216.L_CORE 0.002043
K_22446 X_NUC_157.L_CORE X_NUC_217.L_CORE 0.007187
K_22447 X_NUC_157.L_CORE X_NUC_218.L_CORE 0.002793
K_22448 X_NUC_157.L_CORE X_NUC_219.L_CORE 0.002747
K_22449 X_NUC_157.L_CORE X_NUC_220.L_CORE 0.010816
K_22450 X_NUC_157.L_CORE X_NUC_221.L_CORE 0.002822
K_22451 X_NUC_157.L_CORE X_NUC_222.L_CORE 0.004740
K_22452 X_NUC_158.L_CORE X_NUC_159.L_CORE 0.207973
K_22453 X_NUC_158.L_CORE X_NUC_160.L_CORE 0.207973
K_22454 X_NUC_158.L_CORE X_NUC_161.L_CORE 0.002784
K_22455 X_NUC_158.L_CORE X_NUC_162.L_CORE 0.002748
K_22456 X_NUC_158.L_CORE X_NUC_163.L_CORE 0.002768
K_22457 X_NUC_158.L_CORE X_NUC_164.L_CORE 0.002761
K_22458 X_NUC_158.L_CORE X_NUC_165.L_CORE 0.004138
K_22459 X_NUC_158.L_CORE X_NUC_166.L_CORE 0.004080
K_22460 X_NUC_158.L_CORE X_NUC_167.L_CORE 0.004073
K_22461 X_NUC_158.L_CORE X_NUC_168.L_CORE 0.004128
K_22462 X_NUC_158.L_CORE X_NUC_169.L_CORE 0.005668
K_22463 X_NUC_158.L_CORE X_NUC_170.L_CORE 0.005529
K_22464 X_NUC_158.L_CORE X_NUC_171.L_CORE 0.005582
K_22465 X_NUC_158.L_CORE X_NUC_172.L_CORE 0.005546
K_22466 X_NUC_158.L_CORE X_NUC_173.L_CORE 0.001349
K_22467 X_NUC_158.L_CORE X_NUC_174.L_CORE 0.001265
K_22468 X_NUC_158.L_CORE X_NUC_175.L_CORE 0.001406
K_22469 X_NUC_158.L_CORE X_NUC_176.L_CORE 0.001355
K_22470 X_NUC_158.L_CORE X_NUC_177.L_CORE 0.001289
K_22471 X_NUC_158.L_CORE X_NUC_178.L_CORE 0.001549
K_22472 X_NUC_158.L_CORE X_NUC_179.L_CORE 0.001286
K_22473 X_NUC_158.L_CORE X_NUC_180.L_CORE 0.001440
K_22474 X_NUC_158.L_CORE X_NUC_181.L_CORE 0.001539
K_22475 X_NUC_158.L_CORE X_NUC_182.L_CORE 0.001278
K_22476 X_NUC_158.L_CORE X_NUC_183.L_CORE 0.001697
K_22477 X_NUC_158.L_CORE X_NUC_184.L_CORE 0.001401
K_22478 X_NUC_158.L_CORE X_NUC_185.L_CORE 0.001403
K_22479 X_NUC_158.L_CORE X_NUC_186.L_CORE 0.001824
K_22480 X_NUC_158.L_CORE X_NUC_187.L_CORE 0.001316
K_22481 X_NUC_158.L_CORE X_NUC_188.L_CORE 0.001717
K_22482 X_NUC_158.L_CORE X_NUC_189.L_CORE 0.001640
K_22483 X_NUC_158.L_CORE X_NUC_190.L_CORE 0.001371
K_22484 X_NUC_158.L_CORE X_NUC_191.L_CORE 0.002125
K_22485 X_NUC_158.L_CORE X_NUC_192.L_CORE 0.001439
K_22486 X_NUC_158.L_CORE X_NUC_193.L_CORE 0.001637
K_22487 X_NUC_158.L_CORE X_NUC_194.L_CORE 0.002070
K_22488 X_NUC_158.L_CORE X_NUC_195.L_CORE 0.001393
K_22489 X_NUC_158.L_CORE X_NUC_196.L_CORE 0.002225
K_22490 X_NUC_158.L_CORE X_NUC_197.L_CORE 0.001704
K_22491 X_NUC_158.L_CORE X_NUC_198.L_CORE 0.001559
K_22492 X_NUC_158.L_CORE X_NUC_199.L_CORE 0.002737
K_22493 X_NUC_158.L_CORE X_NUC_200.L_CORE 0.001509
K_22494 X_NUC_158.L_CORE X_NUC_201.L_CORE 0.002088
K_22495 X_NUC_158.L_CORE X_NUC_202.L_CORE 0.002250
K_22496 X_NUC_158.L_CORE X_NUC_203.L_CORE 0.001554
K_22497 X_NUC_158.L_CORE X_NUC_204.L_CORE 0.003292
K_22498 X_NUC_158.L_CORE X_NUC_205.L_CORE 0.001787
K_22499 X_NUC_158.L_CORE X_NUC_206.L_CORE 0.001927
K_22500 X_NUC_158.L_CORE X_NUC_207.L_CORE 0.003492
K_22501 X_NUC_158.L_CORE X_NUC_208.L_CORE 0.001667
K_22502 X_NUC_158.L_CORE X_NUC_209.L_CORE 0.003124
K_22503 X_NUC_158.L_CORE X_NUC_210.L_CORE 0.002415
K_22504 X_NUC_158.L_CORE X_NUC_211.L_CORE 0.001886
K_22505 X_NUC_158.L_CORE X_NUC_212.L_CORE 0.006562
K_22506 X_NUC_158.L_CORE X_NUC_213.L_CORE 0.001991
K_22507 X_NUC_158.L_CORE X_NUC_214.L_CORE 0.002761
K_22508 X_NUC_158.L_CORE X_NUC_215.L_CORE 0.004200
K_22509 X_NUC_158.L_CORE X_NUC_216.L_CORE 0.002062
K_22510 X_NUC_158.L_CORE X_NUC_217.L_CORE 0.007138
K_22511 X_NUC_158.L_CORE X_NUC_218.L_CORE 0.002825
K_22512 X_NUC_158.L_CORE X_NUC_219.L_CORE 0.002775
K_22513 X_NUC_158.L_CORE X_NUC_220.L_CORE 0.011122
K_22514 X_NUC_158.L_CORE X_NUC_221.L_CORE 0.002860
K_22515 X_NUC_158.L_CORE X_NUC_222.L_CORE 0.004826
K_22516 X_NUC_159.L_CORE X_NUC_160.L_CORE 0.207973
K_22517 X_NUC_159.L_CORE X_NUC_161.L_CORE 0.002763
K_22518 X_NUC_159.L_CORE X_NUC_162.L_CORE 0.002728
K_22519 X_NUC_159.L_CORE X_NUC_163.L_CORE 0.002748
K_22520 X_NUC_159.L_CORE X_NUC_164.L_CORE 0.002741
K_22521 X_NUC_159.L_CORE X_NUC_165.L_CORE 0.004145
K_22522 X_NUC_159.L_CORE X_NUC_166.L_CORE 0.004086
K_22523 X_NUC_159.L_CORE X_NUC_167.L_CORE 0.004080
K_22524 X_NUC_159.L_CORE X_NUC_168.L_CORE 0.004135
K_22525 X_NUC_159.L_CORE X_NUC_169.L_CORE 0.005610
K_22526 X_NUC_159.L_CORE X_NUC_170.L_CORE 0.005473
K_22527 X_NUC_159.L_CORE X_NUC_171.L_CORE 0.005529
K_22528 X_NUC_159.L_CORE X_NUC_172.L_CORE 0.005492
K_22529 X_NUC_159.L_CORE X_NUC_173.L_CORE 0.001341
K_22530 X_NUC_159.L_CORE X_NUC_174.L_CORE 0.001258
K_22531 X_NUC_159.L_CORE X_NUC_175.L_CORE 0.001400
K_22532 X_NUC_159.L_CORE X_NUC_176.L_CORE 0.001347
K_22533 X_NUC_159.L_CORE X_NUC_177.L_CORE 0.001284
K_22534 X_NUC_159.L_CORE X_NUC_178.L_CORE 0.001541
K_22535 X_NUC_159.L_CORE X_NUC_179.L_CORE 0.001278
K_22536 X_NUC_159.L_CORE X_NUC_180.L_CORE 0.001435
K_22537 X_NUC_159.L_CORE X_NUC_181.L_CORE 0.001529
K_22538 X_NUC_159.L_CORE X_NUC_182.L_CORE 0.001272
K_22539 X_NUC_159.L_CORE X_NUC_183.L_CORE 0.001691
K_22540 X_NUC_159.L_CORE X_NUC_184.L_CORE 0.001392
K_22541 X_NUC_159.L_CORE X_NUC_185.L_CORE 0.001399
K_22542 X_NUC_159.L_CORE X_NUC_186.L_CORE 0.001813
K_22543 X_NUC_159.L_CORE X_NUC_187.L_CORE 0.001309
K_22544 X_NUC_159.L_CORE X_NUC_188.L_CORE 0.001713
K_22545 X_NUC_159.L_CORE X_NUC_189.L_CORE 0.001628
K_22546 X_NUC_159.L_CORE X_NUC_190.L_CORE 0.001366
K_22547 X_NUC_159.L_CORE X_NUC_191.L_CORE 0.002116
K_22548 X_NUC_159.L_CORE X_NUC_192.L_CORE 0.001429
K_22549 X_NUC_159.L_CORE X_NUC_193.L_CORE 0.001634
K_22550 X_NUC_159.L_CORE X_NUC_194.L_CORE 0.002053
K_22551 X_NUC_159.L_CORE X_NUC_195.L_CORE 0.001387
K_22552 X_NUC_159.L_CORE X_NUC_196.L_CORE 0.002223
K_22553 X_NUC_159.L_CORE X_NUC_197.L_CORE 0.001690
K_22554 X_NUC_159.L_CORE X_NUC_198.L_CORE 0.001555
K_22555 X_NUC_159.L_CORE X_NUC_199.L_CORE 0.002720
K_22556 X_NUC_159.L_CORE X_NUC_200.L_CORE 0.001500
K_22557 X_NUC_159.L_CORE X_NUC_201.L_CORE 0.002088
K_22558 X_NUC_159.L_CORE X_NUC_202.L_CORE 0.002228
K_22559 X_NUC_159.L_CORE X_NUC_203.L_CORE 0.001548
K_22560 X_NUC_159.L_CORE X_NUC_204.L_CORE 0.003292
K_22561 X_NUC_159.L_CORE X_NUC_205.L_CORE 0.001773
K_22562 X_NUC_159.L_CORE X_NUC_206.L_CORE 0.001925
K_22563 X_NUC_159.L_CORE X_NUC_207.L_CORE 0.003455
K_22564 X_NUC_159.L_CORE X_NUC_208.L_CORE 0.001659
K_22565 X_NUC_159.L_CORE X_NUC_209.L_CORE 0.003135
K_22566 X_NUC_159.L_CORE X_NUC_210.L_CORE 0.002391
K_22567 X_NUC_159.L_CORE X_NUC_211.L_CORE 0.001882
K_22568 X_NUC_159.L_CORE X_NUC_212.L_CORE 0.006558
K_22569 X_NUC_159.L_CORE X_NUC_213.L_CORE 0.001977
K_22570 X_NUC_159.L_CORE X_NUC_214.L_CORE 0.002768
K_22571 X_NUC_159.L_CORE X_NUC_215.L_CORE 0.004141
K_22572 X_NUC_159.L_CORE X_NUC_216.L_CORE 0.002054
K_22573 X_NUC_159.L_CORE X_NUC_217.L_CORE 0.007289
K_22574 X_NUC_159.L_CORE X_NUC_218.L_CORE 0.002800
K_22575 X_NUC_159.L_CORE X_NUC_219.L_CORE 0.002775
K_22576 X_NUC_159.L_CORE X_NUC_220.L_CORE 0.011020
K_22577 X_NUC_159.L_CORE X_NUC_221.L_CORE 0.002845
K_22578 X_NUC_159.L_CORE X_NUC_222.L_CORE 0.004841
K_22579 X_NUC_160.L_CORE X_NUC_161.L_CORE 0.002771
K_22580 X_NUC_160.L_CORE X_NUC_162.L_CORE 0.002735
K_22581 X_NUC_160.L_CORE X_NUC_163.L_CORE 0.002755
K_22582 X_NUC_160.L_CORE X_NUC_164.L_CORE 0.002748
K_22583 X_NUC_160.L_CORE X_NUC_165.L_CORE 0.004089
K_22584 X_NUC_160.L_CORE X_NUC_166.L_CORE 0.004032
K_22585 X_NUC_160.L_CORE X_NUC_167.L_CORE 0.004026
K_22586 X_NUC_160.L_CORE X_NUC_168.L_CORE 0.004080
K_22587 X_NUC_160.L_CORE X_NUC_169.L_CORE 0.005647
K_22588 X_NUC_160.L_CORE X_NUC_170.L_CORE 0.005507
K_22589 X_NUC_160.L_CORE X_NUC_171.L_CORE 0.005562
K_22590 X_NUC_160.L_CORE X_NUC_172.L_CORE 0.005529
K_22591 X_NUC_160.L_CORE X_NUC_173.L_CORE 0.001342
K_22592 X_NUC_160.L_CORE X_NUC_174.L_CORE 0.001258
K_22593 X_NUC_160.L_CORE X_NUC_175.L_CORE 0.001398
K_22594 X_NUC_160.L_CORE X_NUC_176.L_CORE 0.001349
K_22595 X_NUC_160.L_CORE X_NUC_177.L_CORE 0.001281
K_22596 X_NUC_160.L_CORE X_NUC_178.L_CORE 0.001542
K_22597 X_NUC_160.L_CORE X_NUC_179.L_CORE 0.001279
K_22598 X_NUC_160.L_CORE X_NUC_180.L_CORE 0.001431
K_22599 X_NUC_160.L_CORE X_NUC_181.L_CORE 0.001533
K_22600 X_NUC_160.L_CORE X_NUC_182.L_CORE 0.001270
K_22601 X_NUC_160.L_CORE X_NUC_183.L_CORE 0.001688
K_22602 X_NUC_160.L_CORE X_NUC_184.L_CORE 0.001396
K_22603 X_NUC_160.L_CORE X_NUC_185.L_CORE 0.001394
K_22604 X_NUC_160.L_CORE X_NUC_186.L_CORE 0.001818
K_22605 X_NUC_160.L_CORE X_NUC_187.L_CORE 0.001309
K_22606 X_NUC_160.L_CORE X_NUC_188.L_CORE 0.001705
K_22607 X_NUC_160.L_CORE X_NUC_189.L_CORE 0.001635
K_22608 X_NUC_160.L_CORE X_NUC_190.L_CORE 0.001362
K_22609 X_NUC_160.L_CORE X_NUC_191.L_CORE 0.002115
K_22610 X_NUC_160.L_CORE X_NUC_192.L_CORE 0.001433
K_22611 X_NUC_160.L_CORE X_NUC_193.L_CORE 0.001625
K_22612 X_NUC_160.L_CORE X_NUC_194.L_CORE 0.002066
K_22613 X_NUC_160.L_CORE X_NUC_195.L_CORE 0.001386
K_22614 X_NUC_160.L_CORE X_NUC_196.L_CORE 0.002209
K_22615 X_NUC_160.L_CORE X_NUC_197.L_CORE 0.001699
K_22616 X_NUC_160.L_CORE X_NUC_198.L_CORE 0.001548
K_22617 X_NUC_160.L_CORE X_NUC_199.L_CORE 0.002731
K_22618 X_NUC_160.L_CORE X_NUC_200.L_CORE 0.001502
K_22619 X_NUC_160.L_CORE X_NUC_201.L_CORE 0.002070
K_22620 X_NUC_160.L_CORE X_NUC_202.L_CORE 0.002248
K_22621 X_NUC_160.L_CORE X_NUC_203.L_CORE 0.001544
K_22622 X_NUC_160.L_CORE X_NUC_204.L_CORE 0.003272
K_22623 X_NUC_160.L_CORE X_NUC_205.L_CORE 0.001781
K_22624 X_NUC_160.L_CORE X_NUC_206.L_CORE 0.001911
K_22625 X_NUC_160.L_CORE X_NUC_207.L_CORE 0.003499
K_22626 X_NUC_160.L_CORE X_NUC_208.L_CORE 0.001658
K_22627 X_NUC_160.L_CORE X_NUC_209.L_CORE 0.003093
K_22628 X_NUC_160.L_CORE X_NUC_210.L_CORE 0.002413
K_22629 X_NUC_160.L_CORE X_NUC_211.L_CORE 0.001872
K_22630 X_NUC_160.L_CORE X_NUC_212.L_CORE 0.006582
K_22631 X_NUC_160.L_CORE X_NUC_213.L_CORE 0.001983
K_22632 X_NUC_160.L_CORE X_NUC_214.L_CORE 0.002734
K_22633 X_NUC_160.L_CORE X_NUC_215.L_CORE 0.004222
K_22634 X_NUC_160.L_CORE X_NUC_216.L_CORE 0.002050
K_22635 X_NUC_160.L_CORE X_NUC_217.L_CORE 0.007047
K_22636 X_NUC_160.L_CORE X_NUC_218.L_CORE 0.002821
K_22637 X_NUC_160.L_CORE X_NUC_219.L_CORE 0.002752
K_22638 X_NUC_160.L_CORE X_NUC_220.L_CORE 0.011399
K_22639 X_NUC_160.L_CORE X_NUC_221.L_CORE 0.002846
K_22640 X_NUC_160.L_CORE X_NUC_222.L_CORE 0.004788
K_22641 X_NUC_161.L_CORE X_NUC_162.L_CORE 0.207973
K_22642 X_NUC_161.L_CORE X_NUC_163.L_CORE 0.207973
K_22643 X_NUC_161.L_CORE X_NUC_164.L_CORE 0.207973
K_22644 X_NUC_161.L_CORE X_NUC_165.L_CORE 0.003336
K_22645 X_NUC_161.L_CORE X_NUC_166.L_CORE 0.003368
K_22646 X_NUC_161.L_CORE X_NUC_167.L_CORE 0.003328
K_22647 X_NUC_161.L_CORE X_NUC_168.L_CORE 0.003372
K_22648 X_NUC_161.L_CORE X_NUC_169.L_CORE 0.005145
K_22649 X_NUC_161.L_CORE X_NUC_170.L_CORE 0.005272
K_22650 X_NUC_161.L_CORE X_NUC_171.L_CORE 0.005179
K_22651 X_NUC_161.L_CORE X_NUC_172.L_CORE 0.005200
K_22652 X_NUC_161.L_CORE X_NUC_173.L_CORE 0.001294
K_22653 X_NUC_161.L_CORE X_NUC_174.L_CORE 0.001360
K_22654 X_NUC_161.L_CORE X_NUC_175.L_CORE 0.001256
K_22655 X_NUC_161.L_CORE X_NUC_176.L_CORE 0.001404
K_22656 X_NUC_161.L_CORE X_NUC_177.L_CORE 0.001352
K_22657 X_NUC_161.L_CORE X_NUC_178.L_CORE 0.001293
K_22658 X_NUC_161.L_CORE X_NUC_179.L_CORE 0.001532
K_22659 X_NUC_161.L_CORE X_NUC_180.L_CORE 0.001294
K_22660 X_NUC_161.L_CORE X_NUC_181.L_CORE 0.001439
K_22661 X_NUC_161.L_CORE X_NUC_182.L_CORE 0.001526
K_22662 X_NUC_161.L_CORE X_NUC_183.L_CORE 0.001296
K_22663 X_NUC_161.L_CORE X_NUC_184.L_CORE 0.001670
K_22664 X_NUC_161.L_CORE X_NUC_185.L_CORE 0.001412
K_22665 X_NUC_161.L_CORE X_NUC_186.L_CORE 0.001420
K_22666 X_NUC_161.L_CORE X_NUC_187.L_CORE 0.001784
K_22667 X_NUC_161.L_CORE X_NUC_188.L_CORE 0.001343
K_22668 X_NUC_161.L_CORE X_NUC_189.L_CORE 0.001708
K_22669 X_NUC_161.L_CORE X_NUC_190.L_CORE 0.001640
K_22670 X_NUC_161.L_CORE X_NUC_191.L_CORE 0.001405
K_22671 X_NUC_161.L_CORE X_NUC_192.L_CORE 0.002056
K_22672 X_NUC_161.L_CORE X_NUC_193.L_CORE 0.001472
K_22673 X_NUC_161.L_CORE X_NUC_194.L_CORE 0.001661
K_22674 X_NUC_161.L_CORE X_NUC_195.L_CORE 0.002031
K_22675 X_NUC_161.L_CORE X_NUC_196.L_CORE 0.001441
K_22676 X_NUC_161.L_CORE X_NUC_197.L_CORE 0.002184
K_22677 X_NUC_161.L_CORE X_NUC_198.L_CORE 0.001736
K_22678 X_NUC_161.L_CORE X_NUC_199.L_CORE 0.001613
K_22679 X_NUC_161.L_CORE X_NUC_200.L_CORE 0.002612
K_22680 X_NUC_161.L_CORE X_NUC_201.L_CORE 0.001571
K_22681 X_NUC_161.L_CORE X_NUC_202.L_CORE 0.002119
K_22682 X_NUC_161.L_CORE X_NUC_203.L_CORE 0.002259
K_22683 X_NUC_161.L_CORE X_NUC_204.L_CORE 0.001631
K_22684 X_NUC_161.L_CORE X_NUC_205.L_CORE 0.003145
K_22685 X_NUC_161.L_CORE X_NUC_206.L_CORE 0.001866
K_22686 X_NUC_161.L_CORE X_NUC_207.L_CORE 0.002018
K_22687 X_NUC_161.L_CORE X_NUC_208.L_CORE 0.003378
K_22688 X_NUC_161.L_CORE X_NUC_209.L_CORE 0.001774
K_22689 X_NUC_161.L_CORE X_NUC_210.L_CORE 0.003177
K_22690 X_NUC_161.L_CORE X_NUC_211.L_CORE 0.002528
K_22691 X_NUC_161.L_CORE X_NUC_212.L_CORE 0.002028
K_22692 X_NUC_161.L_CORE X_NUC_213.L_CORE 0.005947
K_22693 X_NUC_161.L_CORE X_NUC_214.L_CORE 0.002157
K_22694 X_NUC_161.L_CORE X_NUC_215.L_CORE 0.002995
K_22695 X_NUC_161.L_CORE X_NUC_216.L_CORE 0.004445
K_22696 X_NUC_161.L_CORE X_NUC_217.L_CORE 0.002295
K_22697 X_NUC_161.L_CORE X_NUC_218.L_CORE 0.007811
K_22698 X_NUC_161.L_CORE X_NUC_219.L_CORE 0.003214
K_22699 X_NUC_161.L_CORE X_NUC_220.L_CORE 0.003250
K_22700 X_NUC_161.L_CORE X_NUC_221.L_CORE 0.011772
K_22701 X_NUC_161.L_CORE X_NUC_222.L_CORE 0.003771
K_22702 X_NUC_162.L_CORE X_NUC_163.L_CORE 0.207973
K_22703 X_NUC_162.L_CORE X_NUC_164.L_CORE 0.207973
K_22704 X_NUC_162.L_CORE X_NUC_165.L_CORE 0.003304
K_22705 X_NUC_162.L_CORE X_NUC_166.L_CORE 0.003336
K_22706 X_NUC_162.L_CORE X_NUC_167.L_CORE 0.003297
K_22707 X_NUC_162.L_CORE X_NUC_168.L_CORE 0.003339
K_22708 X_NUC_162.L_CORE X_NUC_169.L_CORE 0.005025
K_22709 X_NUC_162.L_CORE X_NUC_170.L_CORE 0.005145
K_22710 X_NUC_162.L_CORE X_NUC_171.L_CORE 0.005058
K_22711 X_NUC_162.L_CORE X_NUC_172.L_CORE 0.005077
K_22712 X_NUC_162.L_CORE X_NUC_173.L_CORE 0.001292
K_22713 X_NUC_162.L_CORE X_NUC_174.L_CORE 0.001360
K_22714 X_NUC_162.L_CORE X_NUC_175.L_CORE 0.001254
K_22715 X_NUC_162.L_CORE X_NUC_176.L_CORE 0.001402
K_22716 X_NUC_162.L_CORE X_NUC_177.L_CORE 0.001351
K_22717 X_NUC_162.L_CORE X_NUC_178.L_CORE 0.001289
K_22718 X_NUC_162.L_CORE X_NUC_179.L_CORE 0.001534
K_22719 X_NUC_162.L_CORE X_NUC_180.L_CORE 0.001291
K_22720 X_NUC_162.L_CORE X_NUC_181.L_CORE 0.001435
K_22721 X_NUC_162.L_CORE X_NUC_182.L_CORE 0.001529
K_22722 X_NUC_162.L_CORE X_NUC_183.L_CORE 0.001291
K_22723 X_NUC_162.L_CORE X_NUC_184.L_CORE 0.001670
K_22724 X_NUC_162.L_CORE X_NUC_185.L_CORE 0.001411
K_22725 X_NUC_162.L_CORE X_NUC_186.L_CORE 0.001414
K_22726 X_NUC_162.L_CORE X_NUC_187.L_CORE 0.001790
K_22727 X_NUC_162.L_CORE X_NUC_188.L_CORE 0.001339
K_22728 X_NUC_162.L_CORE X_NUC_189.L_CORE 0.001703
K_22729 X_NUC_162.L_CORE X_NUC_190.L_CORE 0.001643
K_22730 X_NUC_162.L_CORE X_NUC_191.L_CORE 0.001398
K_22731 X_NUC_162.L_CORE X_NUC_192.L_CORE 0.002063
K_22732 X_NUC_162.L_CORE X_NUC_193.L_CORE 0.001469
K_22733 X_NUC_162.L_CORE X_NUC_194.L_CORE 0.001653
K_22734 X_NUC_162.L_CORE X_NUC_195.L_CORE 0.002042
K_22735 X_NUC_162.L_CORE X_NUC_196.L_CORE 0.001434
K_22736 X_NUC_162.L_CORE X_NUC_197.L_CORE 0.002182
K_22737 X_NUC_162.L_CORE X_NUC_198.L_CORE 0.001737
K_22738 X_NUC_162.L_CORE X_NUC_199.L_CORE 0.001602
K_22739 X_NUC_162.L_CORE X_NUC_200.L_CORE 0.002633
K_22740 X_NUC_162.L_CORE X_NUC_201.L_CORE 0.001565
K_22741 X_NUC_162.L_CORE X_NUC_202.L_CORE 0.002107
K_22742 X_NUC_162.L_CORE X_NUC_203.L_CORE 0.002270
K_22743 X_NUC_162.L_CORE X_NUC_204.L_CORE 0.001620
K_22744 X_NUC_162.L_CORE X_NUC_205.L_CORE 0.003157
K_22745 X_NUC_162.L_CORE X_NUC_206.L_CORE 0.001863
K_22746 X_NUC_162.L_CORE X_NUC_207.L_CORE 0.002001
K_22747 X_NUC_162.L_CORE X_NUC_208.L_CORE 0.003422
K_22748 X_NUC_162.L_CORE X_NUC_209.L_CORE 0.001763
K_22749 X_NUC_162.L_CORE X_NUC_210.L_CORE 0.003157
K_22750 X_NUC_162.L_CORE X_NUC_211.L_CORE 0.002534
K_22751 X_NUC_162.L_CORE X_NUC_212.L_CORE 0.002009
K_22752 X_NUC_162.L_CORE X_NUC_213.L_CORE 0.006072
K_22753 X_NUC_162.L_CORE X_NUC_214.L_CORE 0.002146
K_22754 X_NUC_162.L_CORE X_NUC_215.L_CORE 0.002957
K_22755 X_NUC_162.L_CORE X_NUC_216.L_CORE 0.004496
K_22756 X_NUC_162.L_CORE X_NUC_217.L_CORE 0.002273
K_22757 X_NUC_162.L_CORE X_NUC_218.L_CORE 0.007687
K_22758 X_NUC_162.L_CORE X_NUC_219.L_CORE 0.003202
K_22759 X_NUC_162.L_CORE X_NUC_220.L_CORE 0.003200
K_22760 X_NUC_162.L_CORE X_NUC_221.L_CORE 0.011688
K_22761 X_NUC_162.L_CORE X_NUC_222.L_CORE 0.003722
K_22762 X_NUC_163.L_CORE X_NUC_164.L_CORE 0.207973
K_22763 X_NUC_163.L_CORE X_NUC_165.L_CORE 0.003344
K_22764 X_NUC_163.L_CORE X_NUC_166.L_CORE 0.003376
K_22765 X_NUC_163.L_CORE X_NUC_167.L_CORE 0.003336
K_22766 X_NUC_163.L_CORE X_NUC_168.L_CORE 0.003380
K_22767 X_NUC_163.L_CORE X_NUC_169.L_CORE 0.005109
K_22768 X_NUC_163.L_CORE X_NUC_170.L_CORE 0.005234
K_22769 X_NUC_163.L_CORE X_NUC_171.L_CORE 0.005145
K_22770 X_NUC_163.L_CORE X_NUC_172.L_CORE 0.005164
K_22771 X_NUC_163.L_CORE X_NUC_173.L_CORE 0.001288
K_22772 X_NUC_163.L_CORE X_NUC_174.L_CORE 0.001354
K_22773 X_NUC_163.L_CORE X_NUC_175.L_CORE 0.001251
K_22774 X_NUC_163.L_CORE X_NUC_176.L_CORE 0.001396
K_22775 X_NUC_163.L_CORE X_NUC_177.L_CORE 0.001348
K_22776 X_NUC_163.L_CORE X_NUC_178.L_CORE 0.001286
K_22777 X_NUC_163.L_CORE X_NUC_179.L_CORE 0.001525
K_22778 X_NUC_163.L_CORE X_NUC_180.L_CORE 0.001290
K_22779 X_NUC_163.L_CORE X_NUC_181.L_CORE 0.001430
K_22780 X_NUC_163.L_CORE X_NUC_182.L_CORE 0.001522
K_22781 X_NUC_163.L_CORE X_NUC_183.L_CORE 0.001290
K_22782 X_NUC_163.L_CORE X_NUC_184.L_CORE 0.001659
K_22783 X_NUC_163.L_CORE X_NUC_185.L_CORE 0.001409
K_22784 X_NUC_163.L_CORE X_NUC_186.L_CORE 0.001411
K_22785 X_NUC_163.L_CORE X_NUC_187.L_CORE 0.001778
K_22786 X_NUC_163.L_CORE X_NUC_188.L_CORE 0.001339
K_22787 X_NUC_163.L_CORE X_NUC_189.L_CORE 0.001694
K_22788 X_NUC_163.L_CORE X_NUC_190.L_CORE 0.001639
K_22789 X_NUC_163.L_CORE X_NUC_191.L_CORE 0.001398
K_22790 X_NUC_163.L_CORE X_NUC_192.L_CORE 0.002043
K_22791 X_NUC_163.L_CORE X_NUC_193.L_CORE 0.001470
K_22792 X_NUC_163.L_CORE X_NUC_194.L_CORE 0.001648
K_22793 X_NUC_163.L_CORE X_NUC_195.L_CORE 0.002029
K_22794 X_NUC_163.L_CORE X_NUC_196.L_CORE 0.001436
K_22795 X_NUC_163.L_CORE X_NUC_197.L_CORE 0.002163
K_22796 X_NUC_163.L_CORE X_NUC_198.L_CORE 0.001736
K_22797 X_NUC_163.L_CORE X_NUC_199.L_CORE 0.001603
K_22798 X_NUC_163.L_CORE X_NUC_200.L_CORE 0.002602
K_22799 X_NUC_163.L_CORE X_NUC_201.L_CORE 0.001569
K_22800 X_NUC_163.L_CORE X_NUC_202.L_CORE 0.002098
K_22801 X_NUC_163.L_CORE X_NUC_203.L_CORE 0.002263
K_22802 X_NUC_163.L_CORE X_NUC_204.L_CORE 0.001624
K_22803 X_NUC_163.L_CORE X_NUC_205.L_CORE 0.003113
K_22804 X_NUC_163.L_CORE X_NUC_206.L_CORE 0.001868
K_22805 X_NUC_163.L_CORE X_NUC_207.L_CORE 0.002002
K_22806 X_NUC_163.L_CORE X_NUC_208.L_CORE 0.003386
K_22807 X_NUC_163.L_CORE X_NUC_209.L_CORE 0.001770
K_22808 X_NUC_163.L_CORE X_NUC_210.L_CORE 0.003134
K_22809 X_NUC_163.L_CORE X_NUC_211.L_CORE 0.002539
K_22810 X_NUC_163.L_CORE X_NUC_212.L_CORE 0.002017
K_22811 X_NUC_163.L_CORE X_NUC_213.L_CORE 0.005907
K_22812 X_NUC_163.L_CORE X_NUC_214.L_CORE 0.002159
K_22813 X_NUC_163.L_CORE X_NUC_215.L_CORE 0.002962
K_22814 X_NUC_163.L_CORE X_NUC_216.L_CORE 0.004501
K_22815 X_NUC_163.L_CORE X_NUC_217.L_CORE 0.002289
K_22816 X_NUC_163.L_CORE X_NUC_218.L_CORE 0.007622
K_22817 X_NUC_163.L_CORE X_NUC_219.L_CORE 0.003234
K_22818 X_NUC_163.L_CORE X_NUC_220.L_CORE 0.003230
K_22819 X_NUC_163.L_CORE X_NUC_221.L_CORE 0.012304
K_22820 X_NUC_163.L_CORE X_NUC_222.L_CORE 0.003781
K_22821 X_NUC_164.L_CORE X_NUC_165.L_CORE 0.003301
K_22822 X_NUC_164.L_CORE X_NUC_166.L_CORE 0.003333
K_22823 X_NUC_164.L_CORE X_NUC_167.L_CORE 0.003294
K_22824 X_NUC_164.L_CORE X_NUC_168.L_CORE 0.003336
K_22825 X_NUC_164.L_CORE X_NUC_169.L_CORE 0.005089
K_22826 X_NUC_164.L_CORE X_NUC_170.L_CORE 0.005213
K_22827 X_NUC_164.L_CORE X_NUC_171.L_CORE 0.005124
K_22828 X_NUC_164.L_CORE X_NUC_172.L_CORE 0.005145
K_22829 X_NUC_164.L_CORE X_NUC_173.L_CORE 0.001287
K_22830 X_NUC_164.L_CORE X_NUC_174.L_CORE 0.001353
K_22831 X_NUC_164.L_CORE X_NUC_175.L_CORE 0.001249
K_22832 X_NUC_164.L_CORE X_NUC_176.L_CORE 0.001397
K_22833 X_NUC_164.L_CORE X_NUC_177.L_CORE 0.001344
K_22834 X_NUC_164.L_CORE X_NUC_178.L_CORE 0.001286
K_22835 X_NUC_164.L_CORE X_NUC_179.L_CORE 0.001525
K_22836 X_NUC_164.L_CORE X_NUC_180.L_CORE 0.001286
K_22837 X_NUC_164.L_CORE X_NUC_181.L_CORE 0.001432
K_22838 X_NUC_164.L_CORE X_NUC_182.L_CORE 0.001518
K_22839 X_NUC_164.L_CORE X_NUC_183.L_CORE 0.001288
K_22840 X_NUC_164.L_CORE X_NUC_184.L_CORE 0.001664
K_22841 X_NUC_164.L_CORE X_NUC_185.L_CORE 0.001403
K_22842 X_NUC_164.L_CORE X_NUC_186.L_CORE 0.001412
K_22843 X_NUC_164.L_CORE X_NUC_187.L_CORE 0.001777
K_22844 X_NUC_164.L_CORE X_NUC_188.L_CORE 0.001335
K_22845 X_NUC_164.L_CORE X_NUC_189.L_CORE 0.001701
K_22846 X_NUC_164.L_CORE X_NUC_190.L_CORE 0.001631
K_22847 X_NUC_164.L_CORE X_NUC_191.L_CORE 0.001397
K_22848 X_NUC_164.L_CORE X_NUC_192.L_CORE 0.002050
K_22849 X_NUC_164.L_CORE X_NUC_193.L_CORE 0.001462
K_22850 X_NUC_164.L_CORE X_NUC_194.L_CORE 0.001653
K_22851 X_NUC_164.L_CORE X_NUC_195.L_CORE 0.002022
K_22852 X_NUC_164.L_CORE X_NUC_196.L_CORE 0.001432
K_22853 X_NUC_164.L_CORE X_NUC_197.L_CORE 0.002178
K_22854 X_NUC_164.L_CORE X_NUC_198.L_CORE 0.001724
K_22855 X_NUC_164.L_CORE X_NUC_199.L_CORE 0.001603
K_22856 X_NUC_164.L_CORE X_NUC_200.L_CORE 0.002607
K_22857 X_NUC_164.L_CORE X_NUC_201.L_CORE 0.001560
K_22858 X_NUC_164.L_CORE X_NUC_202.L_CORE 0.002111
K_22859 X_NUC_164.L_CORE X_NUC_203.L_CORE 0.002246
K_22860 X_NUC_164.L_CORE X_NUC_204.L_CORE 0.001620
K_22861 X_NUC_164.L_CORE X_NUC_205.L_CORE 0.003145
K_22862 X_NUC_164.L_CORE X_NUC_206.L_CORE 0.001853
K_22863 X_NUC_164.L_CORE X_NUC_207.L_CORE 0.002007
K_22864 X_NUC_164.L_CORE X_NUC_208.L_CORE 0.003370
K_22865 X_NUC_164.L_CORE X_NUC_209.L_CORE 0.001761
K_22866 X_NUC_164.L_CORE X_NUC_210.L_CORE 0.003172
K_22867 X_NUC_164.L_CORE X_NUC_211.L_CORE 0.002511
K_22868 X_NUC_164.L_CORE X_NUC_212.L_CORE 0.002015
K_22869 X_NUC_164.L_CORE X_NUC_213.L_CORE 0.005991
K_22870 X_NUC_164.L_CORE X_NUC_214.L_CORE 0.002140
K_22871 X_NUC_164.L_CORE X_NUC_215.L_CORE 0.002981
K_22872 X_NUC_164.L_CORE X_NUC_216.L_CORE 0.004421
K_22873 X_NUC_164.L_CORE X_NUC_217.L_CORE 0.002277
K_22874 X_NUC_164.L_CORE X_NUC_218.L_CORE 0.007883
K_22875 X_NUC_164.L_CORE X_NUC_219.L_CORE 0.003186
K_22876 X_NUC_164.L_CORE X_NUC_220.L_CORE 0.003227
K_22877 X_NUC_164.L_CORE X_NUC_221.L_CORE 0.011748
K_22878 X_NUC_164.L_CORE X_NUC_222.L_CORE 0.003737
K_22879 X_NUC_165.L_CORE X_NUC_166.L_CORE 0.207973
K_22880 X_NUC_165.L_CORE X_NUC_167.L_CORE 0.207973
K_22881 X_NUC_165.L_CORE X_NUC_168.L_CORE 0.207973
K_22882 X_NUC_165.L_CORE X_NUC_169.L_CORE 0.004763
K_22883 X_NUC_165.L_CORE X_NUC_170.L_CORE 0.004767
K_22884 X_NUC_165.L_CORE X_NUC_171.L_CORE 0.004813
K_22885 X_NUC_165.L_CORE X_NUC_172.L_CORE 0.004705
K_22886 X_NUC_165.L_CORE X_NUC_173.L_CORE 0.001271
K_22887 X_NUC_165.L_CORE X_NUC_174.L_CORE 0.001287
K_22888 X_NUC_165.L_CORE X_NUC_175.L_CORE 0.001358
K_22889 X_NUC_165.L_CORE X_NUC_176.L_CORE 0.001258
K_22890 X_NUC_165.L_CORE X_NUC_177.L_CORE 0.001392
K_22891 X_NUC_165.L_CORE X_NUC_178.L_CORE 0.001352
K_22892 X_NUC_165.L_CORE X_NUC_179.L_CORE 0.001301
K_22893 X_NUC_165.L_CORE X_NUC_180.L_CORE 0.001506
K_22894 X_NUC_165.L_CORE X_NUC_181.L_CORE 0.001311
K_22895 X_NUC_165.L_CORE X_NUC_182.L_CORE 0.001433
K_22896 X_NUC_165.L_CORE X_NUC_183.L_CORE 0.001514
K_22897 X_NUC_165.L_CORE X_NUC_184.L_CORE 0.001321
K_22898 X_NUC_165.L_CORE X_NUC_185.L_CORE 0.001629
K_22899 X_NUC_165.L_CORE X_NUC_186.L_CORE 0.001432
K_22900 X_NUC_165.L_CORE X_NUC_187.L_CORE 0.001436
K_22901 X_NUC_165.L_CORE X_NUC_188.L_CORE 0.001738
K_22902 X_NUC_165.L_CORE X_NUC_189.L_CORE 0.001383
K_22903 X_NUC_165.L_CORE X_NUC_190.L_CORE 0.001684
K_22904 X_NUC_165.L_CORE X_NUC_191.L_CORE 0.001648
K_22905 X_NUC_165.L_CORE X_NUC_192.L_CORE 0.001446
K_22906 X_NUC_165.L_CORE X_NUC_193.L_CORE 0.001971
K_22907 X_NUC_165.L_CORE X_NUC_194.L_CORE 0.001520
K_22908 X_NUC_165.L_CORE X_NUC_195.L_CORE 0.001678
K_22909 X_NUC_165.L_CORE X_NUC_196.L_CORE 0.001993
K_22910 X_NUC_165.L_CORE X_NUC_197.L_CORE 0.001505
K_22911 X_NUC_165.L_CORE X_NUC_198.L_CORE 0.002113
K_22912 X_NUC_165.L_CORE X_NUC_199.L_CORE 0.001785
K_22913 X_NUC_165.L_CORE X_NUC_200.L_CORE 0.001672
K_22914 X_NUC_165.L_CORE X_NUC_201.L_CORE 0.002475
K_22915 X_NUC_165.L_CORE X_NUC_202.L_CORE 0.001657
K_22916 X_NUC_165.L_CORE X_NUC_203.L_CORE 0.002127
K_22917 X_NUC_165.L_CORE X_NUC_204.L_CORE 0.002282
K_22918 X_NUC_165.L_CORE X_NUC_205.L_CORE 0.001730
K_22919 X_NUC_165.L_CORE X_NUC_206.L_CORE 0.002948
K_22920 X_NUC_165.L_CORE X_NUC_207.L_CORE 0.001981
K_22921 X_NUC_165.L_CORE X_NUC_208.L_CORE 0.002114
K_22922 X_NUC_165.L_CORE X_NUC_209.L_CORE 0.003263
K_22923 X_NUC_165.L_CORE X_NUC_210.L_CORE 0.001922
K_22924 X_NUC_165.L_CORE X_NUC_211.L_CORE 0.003157
K_22925 X_NUC_165.L_CORE X_NUC_212.L_CORE 0.002698
K_22926 X_NUC_165.L_CORE X_NUC_213.L_CORE 0.002212
K_22927 X_NUC_165.L_CORE X_NUC_214.L_CORE 0.005298
K_22928 X_NUC_165.L_CORE X_NUC_215.L_CORE 0.002406
K_22929 X_NUC_165.L_CORE X_NUC_216.L_CORE 0.003252
K_22930 X_NUC_165.L_CORE X_NUC_217.L_CORE 0.004837
K_22931 X_NUC_165.L_CORE X_NUC_218.L_CORE 0.002645
K_22932 X_NUC_165.L_CORE X_NUC_219.L_CORE 0.008217
K_22933 X_NUC_165.L_CORE X_NUC_220.L_CORE 0.003909
K_22934 X_NUC_165.L_CORE X_NUC_221.L_CORE 0.004075
K_22935 X_NUC_165.L_CORE X_NUC_222.L_CORE 0.011668
K_22936 X_NUC_166.L_CORE X_NUC_167.L_CORE 0.207973
K_22937 X_NUC_166.L_CORE X_NUC_168.L_CORE 0.207973
K_22938 X_NUC_166.L_CORE X_NUC_169.L_CORE 0.004757
K_22939 X_NUC_166.L_CORE X_NUC_170.L_CORE 0.004763
K_22940 X_NUC_166.L_CORE X_NUC_171.L_CORE 0.004808
K_22941 X_NUC_166.L_CORE X_NUC_172.L_CORE 0.004700
K_22942 X_NUC_166.L_CORE X_NUC_173.L_CORE 0.001270
K_22943 X_NUC_166.L_CORE X_NUC_174.L_CORE 0.001289
K_22944 X_NUC_166.L_CORE X_NUC_175.L_CORE 0.001356
K_22945 X_NUC_166.L_CORE X_NUC_176.L_CORE 0.001259
K_22946 X_NUC_166.L_CORE X_NUC_177.L_CORE 0.001395
K_22947 X_NUC_166.L_CORE X_NUC_178.L_CORE 0.001350
K_22948 X_NUC_166.L_CORE X_NUC_179.L_CORE 0.001304
K_22949 X_NUC_166.L_CORE X_NUC_180.L_CORE 0.001505
K_22950 X_NUC_166.L_CORE X_NUC_181.L_CORE 0.001310
K_22951 X_NUC_166.L_CORE X_NUC_182.L_CORE 0.001438
K_22952 X_NUC_166.L_CORE X_NUC_183.L_CORE 0.001509
K_22953 X_NUC_166.L_CORE X_NUC_184.L_CORE 0.001323
K_22954 X_NUC_166.L_CORE X_NUC_185.L_CORE 0.001632
K_22955 X_NUC_166.L_CORE X_NUC_186.L_CORE 0.001428
K_22956 X_NUC_166.L_CORE X_NUC_187.L_CORE 0.001442
K_22957 X_NUC_166.L_CORE X_NUC_188.L_CORE 0.001733
K_22958 X_NUC_166.L_CORE X_NUC_189.L_CORE 0.001383
K_22959 X_NUC_166.L_CORE X_NUC_190.L_CORE 0.001691
K_22960 X_NUC_166.L_CORE X_NUC_191.L_CORE 0.001640
K_22961 X_NUC_166.L_CORE X_NUC_192.L_CORE 0.001451
K_22962 X_NUC_166.L_CORE X_NUC_193.L_CORE 0.001971
K_22963 X_NUC_166.L_CORE X_NUC_194.L_CORE 0.001517
K_22964 X_NUC_166.L_CORE X_NUC_195.L_CORE 0.001688
K_22965 X_NUC_166.L_CORE X_NUC_196.L_CORE 0.001981
K_22966 X_NUC_166.L_CORE X_NUC_197.L_CORE 0.001507
K_22967 X_NUC_166.L_CORE X_NUC_198.L_CORE 0.002123
K_22968 X_NUC_166.L_CORE X_NUC_199.L_CORE 0.001776
K_22969 X_NUC_166.L_CORE X_NUC_200.L_CORE 0.001682
K_22970 X_NUC_166.L_CORE X_NUC_201.L_CORE 0.002465
K_22971 X_NUC_166.L_CORE X_NUC_202.L_CORE 0.001655
K_22972 X_NUC_166.L_CORE X_NUC_203.L_CORE 0.002145
K_22973 X_NUC_166.L_CORE X_NUC_204.L_CORE 0.002262
K_22974 X_NUC_166.L_CORE X_NUC_205.L_CORE 0.001737
K_22975 X_NUC_166.L_CORE X_NUC_206.L_CORE 0.002958
K_22976 X_NUC_166.L_CORE X_NUC_207.L_CORE 0.001972
K_22977 X_NUC_166.L_CORE X_NUC_208.L_CORE 0.002132
K_22978 X_NUC_166.L_CORE X_NUC_209.L_CORE 0.003225
K_22979 X_NUC_166.L_CORE X_NUC_210.L_CORE 0.001924
K_22980 X_NUC_166.L_CORE X_NUC_211.L_CORE 0.003196
K_22981 X_NUC_166.L_CORE X_NUC_212.L_CORE 0.002670
K_22982 X_NUC_166.L_CORE X_NUC_213.L_CORE 0.002227
K_22983 X_NUC_166.L_CORE X_NUC_214.L_CORE 0.005271
K_22984 X_NUC_166.L_CORE X_NUC_215.L_CORE 0.002398
K_22985 X_NUC_166.L_CORE X_NUC_216.L_CORE 0.003302
K_22986 X_NUC_166.L_CORE X_NUC_217.L_CORE 0.004729
K_22987 X_NUC_166.L_CORE X_NUC_218.L_CORE 0.002657
K_22988 X_NUC_166.L_CORE X_NUC_219.L_CORE 0.008505
K_22989 X_NUC_166.L_CORE X_NUC_220.L_CORE 0.003872
K_22990 X_NUC_166.L_CORE X_NUC_221.L_CORE 0.004130
K_22991 X_NUC_166.L_CORE X_NUC_222.L_CORE 0.011566
K_22992 X_NUC_167.L_CORE X_NUC_168.L_CORE 0.207973
K_22993 X_NUC_167.L_CORE X_NUC_169.L_CORE 0.004713
K_22994 X_NUC_167.L_CORE X_NUC_170.L_CORE 0.004718
K_22995 X_NUC_167.L_CORE X_NUC_171.L_CORE 0.004763
K_22996 X_NUC_167.L_CORE X_NUC_172.L_CORE 0.004657
K_22997 X_NUC_167.L_CORE X_NUC_173.L_CORE 0.001264
K_22998 X_NUC_167.L_CORE X_NUC_174.L_CORE 0.001282
K_22999 X_NUC_167.L_CORE X_NUC_175.L_CORE 0.001351
K_23000 X_NUC_167.L_CORE X_NUC_176.L_CORE 0.001252
K_23001 X_NUC_167.L_CORE X_NUC_177.L_CORE 0.001387
K_23002 X_NUC_167.L_CORE X_NUC_178.L_CORE 0.001344
K_23003 X_NUC_167.L_CORE X_NUC_179.L_CORE 0.001296
K_23004 X_NUC_167.L_CORE X_NUC_180.L_CORE 0.001499
K_23005 X_NUC_167.L_CORE X_NUC_181.L_CORE 0.001304
K_23006 X_NUC_167.L_CORE X_NUC_182.L_CORE 0.001429
K_23007 X_NUC_167.L_CORE X_NUC_183.L_CORE 0.001504
K_23008 X_NUC_167.L_CORE X_NUC_184.L_CORE 0.001315
K_23009 X_NUC_167.L_CORE X_NUC_185.L_CORE 0.001625
K_23010 X_NUC_167.L_CORE X_NUC_186.L_CORE 0.001422
K_23011 X_NUC_167.L_CORE X_NUC_187.L_CORE 0.001432
K_23012 X_NUC_167.L_CORE X_NUC_188.L_CORE 0.001728
K_23013 X_NUC_167.L_CORE X_NUC_189.L_CORE 0.001375
K_23014 X_NUC_167.L_CORE X_NUC_190.L_CORE 0.001681
K_23015 X_NUC_167.L_CORE X_NUC_191.L_CORE 0.001635
K_23016 X_NUC_167.L_CORE X_NUC_192.L_CORE 0.001441
K_23017 X_NUC_167.L_CORE X_NUC_193.L_CORE 0.001965
K_23018 X_NUC_167.L_CORE X_NUC_194.L_CORE 0.001510
K_23019 X_NUC_167.L_CORE X_NUC_195.L_CORE 0.001676
K_23020 X_NUC_167.L_CORE X_NUC_196.L_CORE 0.001979
K_23021 X_NUC_167.L_CORE X_NUC_197.L_CORE 0.001498
K_23022 X_NUC_167.L_CORE X_NUC_198.L_CORE 0.002112
K_23023 X_NUC_167.L_CORE X_NUC_199.L_CORE 0.001770
K_23024 X_NUC_167.L_CORE X_NUC_200.L_CORE 0.001669
K_23025 X_NUC_167.L_CORE X_NUC_201.L_CORE 0.002463
K_23026 X_NUC_167.L_CORE X_NUC_202.L_CORE 0.001646
K_23027 X_NUC_167.L_CORE X_NUC_203.L_CORE 0.002129
K_23028 X_NUC_167.L_CORE X_NUC_204.L_CORE 0.002261
K_23029 X_NUC_167.L_CORE X_NUC_205.L_CORE 0.001724
K_23030 X_NUC_167.L_CORE X_NUC_206.L_CORE 0.002949
K_23031 X_NUC_167.L_CORE X_NUC_207.L_CORE 0.001964
K_23032 X_NUC_167.L_CORE X_NUC_208.L_CORE 0.002113
K_23033 X_NUC_167.L_CORE X_NUC_209.L_CORE 0.003235
K_23034 X_NUC_167.L_CORE X_NUC_210.L_CORE 0.001911
K_23035 X_NUC_167.L_CORE X_NUC_211.L_CORE 0.003172
K_23036 X_NUC_167.L_CORE X_NUC_212.L_CORE 0.002667
K_23037 X_NUC_167.L_CORE X_NUC_213.L_CORE 0.002207
K_23038 X_NUC_167.L_CORE X_NUC_214.L_CORE 0.005302
K_23039 X_NUC_167.L_CORE X_NUC_215.L_CORE 0.002386
K_23040 X_NUC_167.L_CORE X_NUC_216.L_CORE 0.003266
K_23041 X_NUC_167.L_CORE X_NUC_217.L_CORE 0.004762
K_23042 X_NUC_167.L_CORE X_NUC_218.L_CORE 0.002634
K_23043 X_NUC_167.L_CORE X_NUC_219.L_CORE 0.008444
K_23044 X_NUC_167.L_CORE X_NUC_220.L_CORE 0.003863
K_23045 X_NUC_167.L_CORE X_NUC_221.L_CORE 0.004081
K_23046 X_NUC_167.L_CORE X_NUC_222.L_CORE 0.011622
K_23047 X_NUC_168.L_CORE X_NUC_169.L_CORE 0.004822
K_23048 X_NUC_168.L_CORE X_NUC_170.L_CORE 0.004827
K_23049 X_NUC_168.L_CORE X_NUC_171.L_CORE 0.004875
K_23050 X_NUC_168.L_CORE X_NUC_172.L_CORE 0.004763
K_23051 X_NUC_168.L_CORE X_NUC_173.L_CORE 0.001266
K_23052 X_NUC_168.L_CORE X_NUC_174.L_CORE 0.001284
K_23053 X_NUC_168.L_CORE X_NUC_175.L_CORE 0.001351
K_23054 X_NUC_168.L_CORE X_NUC_176.L_CORE 0.001256
K_23055 X_NUC_168.L_CORE X_NUC_177.L_CORE 0.001387
K_23056 X_NUC_168.L_CORE X_NUC_178.L_CORE 0.001347
K_23057 X_NUC_168.L_CORE X_NUC_179.L_CORE 0.001299
K_23058 X_NUC_168.L_CORE X_NUC_180.L_CORE 0.001497
K_23059 X_NUC_168.L_CORE X_NUC_181.L_CORE 0.001308
K_23060 X_NUC_168.L_CORE X_NUC_182.L_CORE 0.001429
K_23061 X_NUC_168.L_CORE X_NUC_183.L_CORE 0.001505
K_23062 X_NUC_168.L_CORE X_NUC_184.L_CORE 0.001320
K_23063 X_NUC_168.L_CORE X_NUC_185.L_CORE 0.001620
K_23064 X_NUC_168.L_CORE X_NUC_186.L_CORE 0.001427
K_23065 X_NUC_168.L_CORE X_NUC_187.L_CORE 0.001435
K_23066 X_NUC_168.L_CORE X_NUC_188.L_CORE 0.001724
K_23067 X_NUC_168.L_CORE X_NUC_189.L_CORE 0.001381
K_23068 X_NUC_168.L_CORE X_NUC_190.L_CORE 0.001678
K_23069 X_NUC_168.L_CORE X_NUC_191.L_CORE 0.001638
K_23070 X_NUC_168.L_CORE X_NUC_192.L_CORE 0.001447
K_23071 X_NUC_168.L_CORE X_NUC_193.L_CORE 0.001955
K_23072 X_NUC_168.L_CORE X_NUC_194.L_CORE 0.001518
K_23073 X_NUC_168.L_CORE X_NUC_195.L_CORE 0.001677
K_23074 X_NUC_168.L_CORE X_NUC_196.L_CORE 0.001976
K_23075 X_NUC_168.L_CORE X_NUC_197.L_CORE 0.001506
K_23076 X_NUC_168.L_CORE X_NUC_198.L_CORE 0.002101
K_23077 X_NUC_168.L_CORE X_NUC_199.L_CORE 0.001778
K_23078 X_NUC_168.L_CORE X_NUC_200.L_CORE 0.001675
K_23079 X_NUC_168.L_CORE X_NUC_201.L_CORE 0.002447
K_23080 X_NUC_168.L_CORE X_NUC_202.L_CORE 0.001658
K_23081 X_NUC_168.L_CORE X_NUC_203.L_CORE 0.002126
K_23082 X_NUC_168.L_CORE X_NUC_204.L_CORE 0.002264
K_23083 X_NUC_168.L_CORE X_NUC_205.L_CORE 0.001735
K_23084 X_NUC_168.L_CORE X_NUC_206.L_CORE 0.002919
K_23085 X_NUC_168.L_CORE X_NUC_207.L_CORE 0.001978
K_23086 X_NUC_168.L_CORE X_NUC_208.L_CORE 0.002120
K_23087 X_NUC_168.L_CORE X_NUC_209.L_CORE 0.003215
K_23088 X_NUC_168.L_CORE X_NUC_210.L_CORE 0.001928
K_23089 X_NUC_168.L_CORE X_NUC_211.L_CORE 0.003152
K_23090 X_NUC_168.L_CORE X_NUC_212.L_CORE 0.002684
K_23091 X_NUC_168.L_CORE X_NUC_213.L_CORE 0.002224
K_23092 X_NUC_168.L_CORE X_NUC_214.L_CORE 0.005187
K_23093 X_NUC_168.L_CORE X_NUC_215.L_CORE 0.002412
K_23094 X_NUC_168.L_CORE X_NUC_216.L_CORE 0.003275
K_23095 X_NUC_168.L_CORE X_NUC_217.L_CORE 0.004777
K_23096 X_NUC_168.L_CORE X_NUC_218.L_CORE 0.002666
K_23097 X_NUC_168.L_CORE X_NUC_219.L_CORE 0.008271
K_23098 X_NUC_168.L_CORE X_NUC_220.L_CORE 0.003926
K_23099 X_NUC_168.L_CORE X_NUC_221.L_CORE 0.004139
K_23100 X_NUC_168.L_CORE X_NUC_222.L_CORE 0.012173
K_23101 X_NUC_169.L_CORE X_NUC_170.L_CORE 0.207973
K_23102 X_NUC_169.L_CORE X_NUC_171.L_CORE 0.207973
K_23103 X_NUC_169.L_CORE X_NUC_172.L_CORE 0.207973
K_23104 X_NUC_169.L_CORE X_NUC_173.L_CORE 0.001282
K_23105 X_NUC_169.L_CORE X_NUC_174.L_CORE 0.001267
K_23106 X_NUC_169.L_CORE X_NUC_175.L_CORE 0.001289
K_23107 X_NUC_169.L_CORE X_NUC_176.L_CORE 0.001340
K_23108 X_NUC_169.L_CORE X_NUC_177.L_CORE 0.001278
K_23109 X_NUC_169.L_CORE X_NUC_178.L_CORE 0.001374
K_23110 X_NUC_169.L_CORE X_NUC_179.L_CORE 0.001350
K_23111 X_NUC_169.L_CORE X_NUC_180.L_CORE 0.001327
K_23112 X_NUC_169.L_CORE X_NUC_181.L_CORE 0.001457
K_23113 X_NUC_169.L_CORE X_NUC_182.L_CORE 0.001343
K_23114 X_NUC_169.L_CORE X_NUC_183.L_CORE 0.001433
K_23115 X_NUC_169.L_CORE X_NUC_184.L_CORE 0.001482
K_23116 X_NUC_169.L_CORE X_NUC_185.L_CORE 0.001373
K_23117 X_NUC_169.L_CORE X_NUC_186.L_CORE 0.001570
K_23118 X_NUC_169.L_CORE X_NUC_187.L_CORE 0.001457
K_23119 X_NUC_169.L_CORE X_NUC_188.L_CORE 0.001476
K_23120 X_NUC_169.L_CORE X_NUC_189.L_CORE 0.001655
K_23121 X_NUC_169.L_CORE X_NUC_190.L_CORE 0.001451
K_23122 X_NUC_169.L_CORE X_NUC_191.L_CORE 0.001657
K_23123 X_NUC_169.L_CORE X_NUC_192.L_CORE 0.001637
K_23124 X_NUC_169.L_CORE X_NUC_193.L_CORE 0.001527
K_23125 X_NUC_169.L_CORE X_NUC_194.L_CORE 0.001846
K_23126 X_NUC_169.L_CORE X_NUC_195.L_CORE 0.001592
K_23127 X_NUC_169.L_CORE X_NUC_196.L_CORE 0.001719
K_23128 X_NUC_169.L_CORE X_NUC_197.L_CORE 0.001901
K_23129 X_NUC_169.L_CORE X_NUC_198.L_CORE 0.001620
K_23130 X_NUC_169.L_CORE X_NUC_199.L_CORE 0.002017
K_23131 X_NUC_169.L_CORE X_NUC_200.L_CORE 0.001832
K_23132 X_NUC_169.L_CORE X_NUC_201.L_CORE 0.001787
K_23133 X_NUC_169.L_CORE X_NUC_202.L_CORE 0.002256
K_23134 X_NUC_169.L_CORE X_NUC_203.L_CORE 0.001797
K_23135 X_NUC_169.L_CORE X_NUC_204.L_CORE 0.002151
K_23136 X_NUC_169.L_CORE X_NUC_205.L_CORE 0.002242
K_23137 X_NUC_169.L_CORE X_NUC_206.L_CORE 0.001915
K_23138 X_NUC_169.L_CORE X_NUC_207.L_CORE 0.002673
K_23139 X_NUC_169.L_CORE X_NUC_208.L_CORE 0.002139
K_23140 X_NUC_169.L_CORE X_NUC_209.L_CORE 0.002292
K_23141 X_NUC_169.L_CORE X_NUC_210.L_CORE 0.002966
K_23142 X_NUC_169.L_CORE X_NUC_211.L_CORE 0.002189
K_23143 X_NUC_169.L_CORE X_NUC_212.L_CORE 0.003112
K_23144 X_NUC_169.L_CORE X_NUC_213.L_CORE 0.002852
K_23145 X_NUC_169.L_CORE X_NUC_214.L_CORE 0.002570
K_23146 X_NUC_169.L_CORE X_NUC_215.L_CORE 0.004381
K_23147 X_NUC_169.L_CORE X_NUC_216.L_CORE 0.002836
K_23148 X_NUC_169.L_CORE X_NUC_217.L_CORE 0.003728
K_23149 X_NUC_169.L_CORE X_NUC_218.L_CORE 0.004934
K_23150 X_NUC_169.L_CORE X_NUC_219.L_CORE 0.003396
K_23151 X_NUC_169.L_CORE X_NUC_220.L_CORE 0.008523
K_23152 X_NUC_169.L_CORE X_NUC_221.L_CORE 0.005426
K_23153 X_NUC_169.L_CORE X_NUC_222.L_CORE 0.006914
K_23154 X_NUC_170.L_CORE X_NUC_171.L_CORE 0.207973
K_23155 X_NUC_170.L_CORE X_NUC_172.L_CORE 0.207973
K_23156 X_NUC_170.L_CORE X_NUC_173.L_CORE 0.001282
K_23157 X_NUC_170.L_CORE X_NUC_174.L_CORE 0.001269
K_23158 X_NUC_170.L_CORE X_NUC_175.L_CORE 0.001288
K_23159 X_NUC_170.L_CORE X_NUC_176.L_CORE 0.001341
K_23160 X_NUC_170.L_CORE X_NUC_177.L_CORE 0.001280
K_23161 X_NUC_170.L_CORE X_NUC_178.L_CORE 0.001371
K_23162 X_NUC_170.L_CORE X_NUC_179.L_CORE 0.001354
K_23163 X_NUC_170.L_CORE X_NUC_180.L_CORE 0.001327
K_23164 X_NUC_170.L_CORE X_NUC_181.L_CORE 0.001456
K_23165 X_NUC_170.L_CORE X_NUC_182.L_CORE 0.001347
K_23166 X_NUC_170.L_CORE X_NUC_183.L_CORE 0.001429
K_23167 X_NUC_170.L_CORE X_NUC_184.L_CORE 0.001485
K_23168 X_NUC_170.L_CORE X_NUC_185.L_CORE 0.001374
K_23169 X_NUC_170.L_CORE X_NUC_186.L_CORE 0.001565
K_23170 X_NUC_170.L_CORE X_NUC_187.L_CORE 0.001463
K_23171 X_NUC_170.L_CORE X_NUC_188.L_CORE 0.001473
K_23172 X_NUC_170.L_CORE X_NUC_189.L_CORE 0.001655
K_23173 X_NUC_170.L_CORE X_NUC_190.L_CORE 0.001456
K_23174 X_NUC_170.L_CORE X_NUC_191.L_CORE 0.001649
K_23175 X_NUC_170.L_CORE X_NUC_192.L_CORE 0.001644
K_23176 X_NUC_170.L_CORE X_NUC_193.L_CORE 0.001527
K_23177 X_NUC_170.L_CORE X_NUC_194.L_CORE 0.001840
K_23178 X_NUC_170.L_CORE X_NUC_195.L_CORE 0.001600
K_23179 X_NUC_170.L_CORE X_NUC_196.L_CORE 0.001712
K_23180 X_NUC_170.L_CORE X_NUC_197.L_CORE 0.001906
K_23181 X_NUC_170.L_CORE X_NUC_198.L_CORE 0.001624
K_23182 X_NUC_170.L_CORE X_NUC_199.L_CORE 0.002004
K_23183 X_NUC_170.L_CORE X_NUC_200.L_CORE 0.001845
K_23184 X_NUC_170.L_CORE X_NUC_201.L_CORE 0.001784
K_23185 X_NUC_170.L_CORE X_NUC_202.L_CORE 0.002252
K_23186 X_NUC_170.L_CORE X_NUC_203.L_CORE 0.001808
K_23187 X_NUC_170.L_CORE X_NUC_204.L_CORE 0.002134
K_23188 X_NUC_170.L_CORE X_NUC_205.L_CORE 0.002257
K_23189 X_NUC_170.L_CORE X_NUC_206.L_CORE 0.001918
K_23190 X_NUC_170.L_CORE X_NUC_207.L_CORE 0.002650
K_23191 X_NUC_170.L_CORE X_NUC_208.L_CORE 0.002158
K_23192 X_NUC_170.L_CORE X_NUC_209.L_CORE 0.002279
K_23193 X_NUC_170.L_CORE X_NUC_210.L_CORE 0.002973
K_23194 X_NUC_170.L_CORE X_NUC_211.L_CORE 0.002202
K_23195 X_NUC_170.L_CORE X_NUC_212.L_CORE 0.003070
K_23196 X_NUC_170.L_CORE X_NUC_213.L_CORE 0.002887
K_23197 X_NUC_170.L_CORE X_NUC_214.L_CORE 0.002567
K_23198 X_NUC_170.L_CORE X_NUC_215.L_CORE 0.004339
K_23199 X_NUC_170.L_CORE X_NUC_216.L_CORE 0.002870
K_23200 X_NUC_170.L_CORE X_NUC_217.L_CORE 0.003681
K_23201 X_NUC_170.L_CORE X_NUC_218.L_CORE 0.005012
K_23202 X_NUC_170.L_CORE X_NUC_219.L_CORE 0.003418
K_23203 X_NUC_170.L_CORE X_NUC_220.L_CORE 0.008190
K_23204 X_NUC_170.L_CORE X_NUC_221.L_CORE 0.005568
K_23205 X_NUC_170.L_CORE X_NUC_222.L_CORE 0.006907
K_23206 X_NUC_171.L_CORE X_NUC_172.L_CORE 0.207973
K_23207 X_NUC_171.L_CORE X_NUC_173.L_CORE 0.001276
K_23208 X_NUC_171.L_CORE X_NUC_174.L_CORE 0.001263
K_23209 X_NUC_171.L_CORE X_NUC_175.L_CORE 0.001284
K_23210 X_NUC_171.L_CORE X_NUC_176.L_CORE 0.001334
K_23211 X_NUC_171.L_CORE X_NUC_177.L_CORE 0.001276
K_23212 X_NUC_171.L_CORE X_NUC_178.L_CORE 0.001366
K_23213 X_NUC_171.L_CORE X_NUC_179.L_CORE 0.001346
K_23214 X_NUC_171.L_CORE X_NUC_180.L_CORE 0.001324
K_23215 X_NUC_171.L_CORE X_NUC_181.L_CORE 0.001448
K_23216 X_NUC_171.L_CORE X_NUC_182.L_CORE 0.001341
K_23217 X_NUC_171.L_CORE X_NUC_183.L_CORE 0.001426
K_23218 X_NUC_171.L_CORE X_NUC_184.L_CORE 0.001475
K_23219 X_NUC_171.L_CORE X_NUC_185.L_CORE 0.001371
K_23220 X_NUC_171.L_CORE X_NUC_186.L_CORE 0.001559
K_23221 X_NUC_171.L_CORE X_NUC_187.L_CORE 0.001454
K_23222 X_NUC_171.L_CORE X_NUC_188.L_CORE 0.001471
K_23223 X_NUC_171.L_CORE X_NUC_189.L_CORE 0.001644
K_23224 X_NUC_171.L_CORE X_NUC_190.L_CORE 0.001451
K_23225 X_NUC_171.L_CORE X_NUC_191.L_CORE 0.001647
K_23226 X_NUC_171.L_CORE X_NUC_192.L_CORE 0.001631
K_23227 X_NUC_171.L_CORE X_NUC_193.L_CORE 0.001525
K_23228 X_NUC_171.L_CORE X_NUC_194.L_CORE 0.001830
K_23229 X_NUC_171.L_CORE X_NUC_195.L_CORE 0.001592
K_23230 X_NUC_171.L_CORE X_NUC_196.L_CORE 0.001712
K_23231 X_NUC_171.L_CORE X_NUC_197.L_CORE 0.001889
K_23232 X_NUC_171.L_CORE X_NUC_198.L_CORE 0.001621
K_23233 X_NUC_171.L_CORE X_NUC_199.L_CORE 0.001999
K_23234 X_NUC_171.L_CORE X_NUC_200.L_CORE 0.001830
K_23235 X_NUC_171.L_CORE X_NUC_201.L_CORE 0.001785
K_23236 X_NUC_171.L_CORE X_NUC_202.L_CORE 0.002234
K_23237 X_NUC_171.L_CORE X_NUC_203.L_CORE 0.001801
K_23238 X_NUC_171.L_CORE X_NUC_204.L_CORE 0.002137
K_23239 X_NUC_171.L_CORE X_NUC_205.L_CORE 0.002233
K_23240 X_NUC_171.L_CORE X_NUC_206.L_CORE 0.001919
K_23241 X_NUC_171.L_CORE X_NUC_207.L_CORE 0.002640
K_23242 X_NUC_171.L_CORE X_NUC_208.L_CORE 0.002143
K_23243 X_NUC_171.L_CORE X_NUC_209.L_CORE 0.002288
K_23244 X_NUC_171.L_CORE X_NUC_210.L_CORE 0.002937
K_23245 X_NUC_171.L_CORE X_NUC_211.L_CORE 0.002198
K_23246 X_NUC_171.L_CORE X_NUC_212.L_CORE 0.003079
K_23247 X_NUC_171.L_CORE X_NUC_213.L_CORE 0.002853
K_23248 X_NUC_171.L_CORE X_NUC_214.L_CORE 0.002578
K_23249 X_NUC_171.L_CORE X_NUC_215.L_CORE 0.004300
K_23250 X_NUC_171.L_CORE X_NUC_216.L_CORE 0.002856
K_23251 X_NUC_171.L_CORE X_NUC_217.L_CORE 0.003718
K_23252 X_NUC_171.L_CORE X_NUC_218.L_CORE 0.004915
K_23253 X_NUC_171.L_CORE X_NUC_219.L_CORE 0.003431
K_23254 X_NUC_171.L_CORE X_NUC_220.L_CORE 0.008330
K_23255 X_NUC_171.L_CORE X_NUC_221.L_CORE 0.005518
K_23256 X_NUC_171.L_CORE X_NUC_222.L_CORE 0.007062
K_23257 X_NUC_172.L_CORE X_NUC_173.L_CORE 0.001276
K_23258 X_NUC_172.L_CORE X_NUC_174.L_CORE 0.001263
K_23259 X_NUC_172.L_CORE X_NUC_175.L_CORE 0.001282
K_23260 X_NUC_172.L_CORE X_NUC_176.L_CORE 0.001335
K_23261 X_NUC_172.L_CORE X_NUC_177.L_CORE 0.001273
K_23262 X_NUC_172.L_CORE X_NUC_178.L_CORE 0.001366
K_23263 X_NUC_172.L_CORE X_NUC_179.L_CORE 0.001347
K_23264 X_NUC_172.L_CORE X_NUC_180.L_CORE 0.001320
K_23265 X_NUC_172.L_CORE X_NUC_181.L_CORE 0.001451
K_23266 X_NUC_172.L_CORE X_NUC_182.L_CORE 0.001339
K_23267 X_NUC_172.L_CORE X_NUC_183.L_CORE 0.001424
K_23268 X_NUC_172.L_CORE X_NUC_184.L_CORE 0.001479
K_23269 X_NUC_172.L_CORE X_NUC_185.L_CORE 0.001366
K_23270 X_NUC_172.L_CORE X_NUC_186.L_CORE 0.001561
K_23271 X_NUC_172.L_CORE X_NUC_187.L_CORE 0.001454
K_23272 X_NUC_172.L_CORE X_NUC_188.L_CORE 0.001466
K_23273 X_NUC_172.L_CORE X_NUC_189.L_CORE 0.001650
K_23274 X_NUC_172.L_CORE X_NUC_190.L_CORE 0.001446
K_23275 X_NUC_172.L_CORE X_NUC_191.L_CORE 0.001645
K_23276 X_NUC_172.L_CORE X_NUC_192.L_CORE 0.001636
K_23277 X_NUC_172.L_CORE X_NUC_193.L_CORE 0.001517
K_23278 X_NUC_172.L_CORE X_NUC_194.L_CORE 0.001837
K_23279 X_NUC_172.L_CORE X_NUC_195.L_CORE 0.001589
K_23280 X_NUC_172.L_CORE X_NUC_196.L_CORE 0.001705
K_23281 X_NUC_172.L_CORE X_NUC_197.L_CORE 0.001900
K_23282 X_NUC_172.L_CORE X_NUC_198.L_CORE 0.001612
K_23283 X_NUC_172.L_CORE X_NUC_199.L_CORE 0.002002
K_23284 X_NUC_172.L_CORE X_NUC_200.L_CORE 0.001833
K_23285 X_NUC_172.L_CORE X_NUC_201.L_CORE 0.001773
K_23286 X_NUC_172.L_CORE X_NUC_202.L_CORE 0.002251
K_23287 X_NUC_172.L_CORE X_NUC_203.L_CORE 0.001793
K_23288 X_NUC_172.L_CORE X_NUC_204.L_CORE 0.002130
K_23289 X_NUC_172.L_CORE X_NUC_205.L_CORE 0.002247
K_23290 X_NUC_172.L_CORE X_NUC_206.L_CORE 0.001903
K_23291 X_NUC_172.L_CORE X_NUC_207.L_CORE 0.002656
K_23292 X_NUC_172.L_CORE X_NUC_208.L_CORE 0.002140
K_23293 X_NUC_172.L_CORE X_NUC_209.L_CORE 0.002269
K_23294 X_NUC_172.L_CORE X_NUC_210.L_CORE 0.002973
K_23295 X_NUC_172.L_CORE X_NUC_211.L_CORE 0.002181
K_23296 X_NUC_172.L_CORE X_NUC_212.L_CORE 0.003075
K_23297 X_NUC_172.L_CORE X_NUC_213.L_CORE 0.002866
K_23298 X_NUC_172.L_CORE X_NUC_214.L_CORE 0.002548
K_23299 X_NUC_172.L_CORE X_NUC_215.L_CORE 0.004373
K_23300 X_NUC_172.L_CORE X_NUC_216.L_CORE 0.002839
K_23301 X_NUC_172.L_CORE X_NUC_217.L_CORE 0.003674
K_23302 X_NUC_172.L_CORE X_NUC_218.L_CORE 0.005002
K_23303 X_NUC_172.L_CORE X_NUC_219.L_CORE 0.003379
K_23304 X_NUC_172.L_CORE X_NUC_220.L_CORE 0.008366
K_23305 X_NUC_172.L_CORE X_NUC_221.L_CORE 0.005490
K_23306 X_NUC_172.L_CORE X_NUC_222.L_CORE 0.006835
K_23307 X_NUC_173.L_CORE X_NUC_174.L_CORE 0.004751
K_23308 X_NUC_173.L_CORE X_NUC_175.L_CORE 0.005132
K_23309 X_NUC_173.L_CORE X_NUC_176.L_CORE 0.005521
K_23310 X_NUC_173.L_CORE X_NUC_177.L_CORE 0.003070
K_23311 X_NUC_173.L_CORE X_NUC_178.L_CORE 0.004720
K_23312 X_NUC_173.L_CORE X_NUC_179.L_CORE 0.003065
K_23313 X_NUC_173.L_CORE X_NUC_180.L_CORE 0.002768
K_23314 X_NUC_173.L_CORE X_NUC_181.L_CORE 0.003697
K_23315 X_NUC_173.L_CORE X_NUC_182.L_CORE 0.002328
K_23316 X_NUC_173.L_CORE X_NUC_183.L_CORE 0.002831
K_23317 X_NUC_173.L_CORE X_NUC_184.L_CORE 0.002629
K_23318 X_NUC_173.L_CORE X_NUC_185.L_CORE 0.002101
K_23319 X_NUC_173.L_CORE X_NUC_186.L_CORE 0.002779
K_23320 X_NUC_173.L_CORE X_NUC_187.L_CORE 0.002050
K_23321 X_NUC_173.L_CORE X_NUC_188.L_CORE 0.002113
K_23322 X_NUC_173.L_CORE X_NUC_189.L_CORE 0.002357
K_23323 X_NUC_173.L_CORE X_NUC_190.L_CORE 0.001802
K_23324 X_NUC_173.L_CORE X_NUC_191.L_CORE 0.002185
K_23325 X_NUC_173.L_CORE X_NUC_192.L_CORE 0.001915
K_23326 X_NUC_173.L_CORE X_NUC_193.L_CORE 0.001751
K_23327 X_NUC_173.L_CORE X_NUC_194.L_CORE 0.002087
K_23328 X_NUC_173.L_CORE X_NUC_195.L_CORE 0.001653
K_23329 X_NUC_173.L_CORE X_NUC_196.L_CORE 0.001800
K_23330 X_NUC_173.L_CORE X_NUC_197.L_CORE 0.001816
K_23331 X_NUC_173.L_CORE X_NUC_198.L_CORE 0.001551
K_23332 X_NUC_173.L_CORE X_NUC_199.L_CORE 0.001820
K_23333 X_NUC_173.L_CORE X_NUC_200.L_CORE 0.001574
K_23334 X_NUC_173.L_CORE X_NUC_201.L_CORE 0.001554
K_23335 X_NUC_173.L_CORE X_NUC_202.L_CORE 0.001703
K_23336 X_NUC_173.L_CORE X_NUC_203.L_CORE 0.001440
K_23337 X_NUC_173.L_CORE X_NUC_204.L_CORE 0.001590
K_23338 X_NUC_173.L_CORE X_NUC_205.L_CORE 0.001518
K_23339 X_NUC_173.L_CORE X_NUC_206.L_CORE 0.001401
K_23340 X_NUC_173.L_CORE X_NUC_207.L_CORE 0.001564
K_23341 X_NUC_173.L_CORE X_NUC_208.L_CORE 0.001377
K_23342 X_NUC_173.L_CORE X_NUC_209.L_CORE 0.001416
K_23343 X_NUC_173.L_CORE X_NUC_210.L_CORE 0.001455
K_23344 X_NUC_173.L_CORE X_NUC_211.L_CORE 0.001310
K_23345 X_NUC_173.L_CORE X_NUC_212.L_CORE 0.001422
K_23346 X_NUC_173.L_CORE X_NUC_213.L_CORE 0.001333
K_23347 X_NUC_173.L_CORE X_NUC_214.L_CORE 0.001298
K_23348 X_NUC_173.L_CORE X_NUC_215.L_CORE 0.001370
K_23349 X_NUC_173.L_CORE X_NUC_216.L_CORE 0.001256
K_23350 X_NUC_173.L_CORE X_NUC_217.L_CORE 0.001300
K_23351 X_NUC_173.L_CORE X_NUC_218.L_CORE 0.001285
K_23352 X_NUC_173.L_CORE X_NUC_219.L_CORE 0.001226
K_23353 X_NUC_173.L_CORE X_NUC_220.L_CORE 0.001271
K_23354 X_NUC_173.L_CORE X_NUC_221.L_CORE 0.001220
K_23355 X_NUC_173.L_CORE X_NUC_222.L_CORE 0.001215
K_23356 X_NUC_174.L_CORE X_NUC_175.L_CORE 0.003321
K_23357 X_NUC_174.L_CORE X_NUC_176.L_CORE 0.004061
K_23358 X_NUC_174.L_CORE X_NUC_177.L_CORE 0.005133
K_23359 X_NUC_174.L_CORE X_NUC_178.L_CORE 0.002469
K_23360 X_NUC_174.L_CORE X_NUC_179.L_CORE 0.005124
K_23361 X_NUC_174.L_CORE X_NUC_180.L_CORE 0.002679
K_23362 X_NUC_174.L_CORE X_NUC_181.L_CORE 0.002417
K_23363 X_NUC_174.L_CORE X_NUC_182.L_CORE 0.004189
K_23364 X_NUC_174.L_CORE X_NUC_183.L_CORE 0.002022
K_23365 X_NUC_174.L_CORE X_NUC_184.L_CORE 0.002801
K_23366 X_NUC_174.L_CORE X_NUC_185.L_CORE 0.002566
K_23367 X_NUC_174.L_CORE X_NUC_186.L_CORE 0.001872
K_23368 X_NUC_174.L_CORE X_NUC_187.L_CORE 0.003099
K_23369 X_NUC_174.L_CORE X_NUC_188.L_CORE 0.001878
K_23370 X_NUC_174.L_CORE X_NUC_189.L_CORE 0.002008
K_23371 X_NUC_174.L_CORE X_NUC_190.L_CORE 0.002490
K_23372 X_NUC_174.L_CORE X_NUC_191.L_CORE 0.001637
K_23373 X_NUC_174.L_CORE X_NUC_192.L_CORE 0.002284
K_23374 X_NUC_174.L_CORE X_NUC_193.L_CORE 0.001854
K_23375 X_NUC_174.L_CORE X_NUC_194.L_CORE 0.001637
K_23376 X_NUC_174.L_CORE X_NUC_195.L_CORE 0.002260
K_23377 X_NUC_174.L_CORE X_NUC_196.L_CORE 0.001542
K_23378 X_NUC_174.L_CORE X_NUC_197.L_CORE 0.001791
K_23379 X_NUC_174.L_CORE X_NUC_198.L_CORE 0.001851
K_23380 X_NUC_174.L_CORE X_NUC_199.L_CORE 0.001451
K_23381 X_NUC_174.L_CORE X_NUC_200.L_CORE 0.001924
K_23382 X_NUC_174.L_CORE X_NUC_201.L_CORE 0.001518
K_23383 X_NUC_174.L_CORE X_NUC_202.L_CORE 0.001506
K_23384 X_NUC_174.L_CORE X_NUC_203.L_CORE 0.001786
K_23385 X_NUC_174.L_CORE X_NUC_204.L_CORE 0.001364
K_23386 X_NUC_174.L_CORE X_NUC_205.L_CORE 0.001622
K_23387 X_NUC_174.L_CORE X_NUC_206.L_CORE 0.001516
K_23388 X_NUC_174.L_CORE X_NUC_207.L_CORE 0.001345
K_23389 X_NUC_174.L_CORE X_NUC_208.L_CORE 0.001636
K_23390 X_NUC_174.L_CORE X_NUC_209.L_CORE 0.001332
K_23391 X_NUC_174.L_CORE X_NUC_210.L_CORE 0.001407
K_23392 X_NUC_174.L_CORE X_NUC_211.L_CORE 0.001487
K_23393 X_NUC_174.L_CORE X_NUC_212.L_CORE 0.001263
K_23394 X_NUC_174.L_CORE X_NUC_213.L_CORE 0.001457
K_23395 X_NUC_174.L_CORE X_NUC_214.L_CORE 0.001321
K_23396 X_NUC_174.L_CORE X_NUC_215.L_CORE 0.001275
K_23397 X_NUC_174.L_CORE X_NUC_216.L_CORE 0.001405
K_23398 X_NUC_174.L_CORE X_NUC_217.L_CORE 0.001230
K_23399 X_NUC_174.L_CORE X_NUC_218.L_CORE 0.001307
K_23400 X_NUC_174.L_CORE X_NUC_219.L_CORE 0.001292
K_23401 X_NUC_174.L_CORE X_NUC_220.L_CORE 0.001212
K_23402 X_NUC_174.L_CORE X_NUC_221.L_CORE 0.001281
K_23403 X_NUC_174.L_CORE X_NUC_222.L_CORE 0.001220
K_23404 X_NUC_175.L_CORE X_NUC_176.L_CORE 0.002731
K_23405 X_NUC_175.L_CORE X_NUC_177.L_CORE 0.003480
K_23406 X_NUC_175.L_CORE X_NUC_178.L_CORE 0.004693
K_23407 X_NUC_175.L_CORE X_NUC_179.L_CORE 0.002161
K_23408 X_NUC_175.L_CORE X_NUC_180.L_CORE 0.005205
K_23409 X_NUC_175.L_CORE X_NUC_181.L_CORE 0.002434
K_23410 X_NUC_175.L_CORE X_NUC_182.L_CORE 0.002202
K_23411 X_NUC_175.L_CORE X_NUC_183.L_CORE 0.004487
K_23412 X_NUC_175.L_CORE X_NUC_184.L_CORE 0.001846
K_23413 X_NUC_175.L_CORE X_NUC_185.L_CORE 0.002731
K_23414 X_NUC_175.L_CORE X_NUC_186.L_CORE 0.002487
K_23415 X_NUC_175.L_CORE X_NUC_187.L_CORE 0.001737
K_23416 X_NUC_175.L_CORE X_NUC_188.L_CORE 0.003318
K_23417 X_NUC_175.L_CORE X_NUC_189.L_CORE 0.001769
K_23418 X_NUC_175.L_CORE X_NUC_190.L_CORE 0.001927
K_23419 X_NUC_175.L_CORE X_NUC_191.L_CORE 0.002559
K_23420 X_NUC_175.L_CORE X_NUC_192.L_CORE 0.001540
K_23421 X_NUC_175.L_CORE X_NUC_193.L_CORE 0.002334
K_23422 X_NUC_175.L_CORE X_NUC_194.L_CORE 0.001804
K_23423 X_NUC_175.L_CORE X_NUC_195.L_CORE 0.001565
K_23424 X_NUC_175.L_CORE X_NUC_196.L_CORE 0.002377
K_23425 X_NUC_175.L_CORE X_NUC_197.L_CORE 0.001473
K_23426 X_NUC_175.L_CORE X_NUC_198.L_CORE 0.001776
K_23427 X_NUC_175.L_CORE X_NUC_199.L_CORE 0.001863
K_23428 X_NUC_175.L_CORE X_NUC_200.L_CORE 0.001391
K_23429 X_NUC_175.L_CORE X_NUC_201.L_CORE 0.001990
K_23430 X_NUC_175.L_CORE X_NUC_202.L_CORE 0.001480
K_23431 X_NUC_175.L_CORE X_NUC_203.L_CORE 0.001472
K_23432 X_NUC_175.L_CORE X_NUC_204.L_CORE 0.001837
K_23433 X_NUC_175.L_CORE X_NUC_205.L_CORE 0.001319
K_23434 X_NUC_175.L_CORE X_NUC_206.L_CORE 0.001638
K_23435 X_NUC_175.L_CORE X_NUC_207.L_CORE 0.001511
K_23436 X_NUC_175.L_CORE X_NUC_208.L_CORE 0.001312
K_23437 X_NUC_175.L_CORE X_NUC_209.L_CORE 0.001682
K_23438 X_NUC_175.L_CORE X_NUC_210.L_CORE 0.001306
K_23439 X_NUC_175.L_CORE X_NUC_211.L_CORE 0.001400
K_23440 X_NUC_175.L_CORE X_NUC_212.L_CORE 0.001505
K_23441 X_NUC_175.L_CORE X_NUC_213.L_CORE 0.001238
K_23442 X_NUC_175.L_CORE X_NUC_214.L_CORE 0.001477
K_23443 X_NUC_175.L_CORE X_NUC_215.L_CORE 0.001314
K_23444 X_NUC_175.L_CORE X_NUC_216.L_CORE 0.001263
K_23445 X_NUC_175.L_CORE X_NUC_217.L_CORE 0.001422
K_23446 X_NUC_175.L_CORE X_NUC_218.L_CORE 0.001218
K_23447 X_NUC_175.L_CORE X_NUC_219.L_CORE 0.001309
K_23448 X_NUC_175.L_CORE X_NUC_220.L_CORE 0.001293
K_23449 X_NUC_175.L_CORE X_NUC_221.L_CORE 0.001212
K_23450 X_NUC_175.L_CORE X_NUC_222.L_CORE 0.001271
K_23451 X_NUC_176.L_CORE X_NUC_177.L_CORE 0.002388
K_23452 X_NUC_176.L_CORE X_NUC_178.L_CORE 0.003107
K_23453 X_NUC_176.L_CORE X_NUC_179.L_CORE 0.004335
K_23454 X_NUC_176.L_CORE X_NUC_180.L_CORE 0.001960
K_23455 X_NUC_176.L_CORE X_NUC_181.L_CORE 0.005167
K_23456 X_NUC_176.L_CORE X_NUC_182.L_CORE 0.002257
K_23457 X_NUC_176.L_CORE X_NUC_183.L_CORE 0.002049
K_23458 X_NUC_176.L_CORE X_NUC_184.L_CORE 0.004691
K_23459 X_NUC_176.L_CORE X_NUC_185.L_CORE 0.001724
K_23460 X_NUC_176.L_CORE X_NUC_186.L_CORE 0.002656
K_23461 X_NUC_176.L_CORE X_NUC_187.L_CORE 0.002411
K_23462 X_NUC_176.L_CORE X_NUC_188.L_CORE 0.001640
K_23463 X_NUC_176.L_CORE X_NUC_189.L_CORE 0.003489
K_23464 X_NUC_176.L_CORE X_NUC_190.L_CORE 0.001687
K_23465 X_NUC_176.L_CORE X_NUC_191.L_CORE 0.001861
K_23466 X_NUC_176.L_CORE X_NUC_192.L_CORE 0.002600
K_23467 X_NUC_176.L_CORE X_NUC_193.L_CORE 0.001470
K_23468 X_NUC_176.L_CORE X_NUC_194.L_CORE 0.002362
K_23469 X_NUC_176.L_CORE X_NUC_195.L_CORE 0.001761
K_23470 X_NUC_176.L_CORE X_NUC_196.L_CORE 0.001510
K_23471 X_NUC_176.L_CORE X_NUC_197.L_CORE 0.002469
K_23472 X_NUC_176.L_CORE X_NUC_198.L_CORE 0.001423
K_23473 X_NUC_176.L_CORE X_NUC_199.L_CORE 0.001759
K_23474 X_NUC_176.L_CORE X_NUC_200.L_CORE 0.001868
K_23475 X_NUC_176.L_CORE X_NUC_201.L_CORE 0.001347
K_23476 X_NUC_176.L_CORE X_NUC_202.L_CORE 0.002040
K_23477 X_NUC_176.L_CORE X_NUC_203.L_CORE 0.001451
K_23478 X_NUC_176.L_CORE X_NUC_204.L_CORE 0.001446
K_23479 X_NUC_176.L_CORE X_NUC_205.L_CORE 0.001875
K_23480 X_NUC_176.L_CORE X_NUC_206.L_CORE 0.001287
K_23481 X_NUC_176.L_CORE X_NUC_207.L_CORE 0.001647
K_23482 X_NUC_176.L_CORE X_NUC_208.L_CORE 0.001506
K_23483 X_NUC_176.L_CORE X_NUC_209.L_CORE 0.001288
K_23484 X_NUC_176.L_CORE X_NUC_210.L_CORE 0.001714
K_23485 X_NUC_176.L_CORE X_NUC_211.L_CORE 0.001287
K_23486 X_NUC_176.L_CORE X_NUC_212.L_CORE 0.001394
K_23487 X_NUC_176.L_CORE X_NUC_213.L_CORE 0.001517
K_23488 X_NUC_176.L_CORE X_NUC_214.L_CORE 0.001221
K_23489 X_NUC_176.L_CORE X_NUC_215.L_CORE 0.001489
K_23490 X_NUC_176.L_CORE X_NUC_216.L_CORE 0.001309
K_23491 X_NUC_176.L_CORE X_NUC_217.L_CORE 0.001257
K_23492 X_NUC_176.L_CORE X_NUC_218.L_CORE 0.001429
K_23493 X_NUC_176.L_CORE X_NUC_219.L_CORE 0.001215
K_23494 X_NUC_176.L_CORE X_NUC_220.L_CORE 0.001309
K_23495 X_NUC_176.L_CORE X_NUC_221.L_CORE 0.001292
K_23496 X_NUC_176.L_CORE X_NUC_222.L_CORE 0.001226
K_23497 X_NUC_177.L_CORE X_NUC_178.L_CORE 0.002158
K_23498 X_NUC_177.L_CORE X_NUC_179.L_CORE 0.002844
K_23499 X_NUC_177.L_CORE X_NUC_180.L_CORE 0.004050
K_23500 X_NUC_177.L_CORE X_NUC_181.L_CORE 0.001816
K_23501 X_NUC_177.L_CORE X_NUC_182.L_CORE 0.005080
K_23502 X_NUC_177.L_CORE X_NUC_183.L_CORE 0.002123
K_23503 X_NUC_177.L_CORE X_NUC_184.L_CORE 0.001932
K_23504 X_NUC_177.L_CORE X_NUC_185.L_CORE 0.004835
K_23505 X_NUC_177.L_CORE X_NUC_186.L_CORE 0.001632
K_23506 X_NUC_177.L_CORE X_NUC_187.L_CORE 0.002584
K_23507 X_NUC_177.L_CORE X_NUC_188.L_CORE 0.002343
K_23508 X_NUC_177.L_CORE X_NUC_189.L_CORE 0.001565
K_23509 X_NUC_177.L_CORE X_NUC_190.L_CORE 0.003630
K_23510 X_NUC_177.L_CORE X_NUC_191.L_CORE 0.001623
K_23511 X_NUC_177.L_CORE X_NUC_192.L_CORE 0.001806
K_23512 X_NUC_177.L_CORE X_NUC_193.L_CORE 0.002626
K_23513 X_NUC_177.L_CORE X_NUC_194.L_CORE 0.001416
K_23514 X_NUC_177.L_CORE X_NUC_195.L_CORE 0.002378
K_23515 X_NUC_177.L_CORE X_NUC_196.L_CORE 0.001725
K_23516 X_NUC_177.L_CORE X_NUC_197.L_CORE 0.001468
K_23517 X_NUC_177.L_CORE X_NUC_198.L_CORE 0.002544
K_23518 X_NUC_177.L_CORE X_NUC_199.L_CORE 0.001384
K_23519 X_NUC_177.L_CORE X_NUC_200.L_CORE 0.001743
K_23520 X_NUC_177.L_CORE X_NUC_201.L_CORE 0.001868
K_23521 X_NUC_177.L_CORE X_NUC_202.L_CORE 0.001314
K_23522 X_NUC_177.L_CORE X_NUC_203.L_CORE 0.002078
K_23523 X_NUC_177.L_CORE X_NUC_204.L_CORE 0.001428
K_23524 X_NUC_177.L_CORE X_NUC_205.L_CORE 0.001426
K_23525 X_NUC_177.L_CORE X_NUC_206.L_CORE 0.001904
K_23526 X_NUC_177.L_CORE X_NUC_207.L_CORE 0.001263
K_23527 X_NUC_177.L_CORE X_NUC_208.L_CORE 0.001654
K_23528 X_NUC_177.L_CORE X_NUC_209.L_CORE 0.001501
K_23529 X_NUC_177.L_CORE X_NUC_210.L_CORE 0.001270
K_23530 X_NUC_177.L_CORE X_NUC_211.L_CORE 0.001738
K_23531 X_NUC_177.L_CORE X_NUC_212.L_CORE 0.001274
K_23532 X_NUC_177.L_CORE X_NUC_213.L_CORE 0.001390
K_23533 X_NUC_177.L_CORE X_NUC_214.L_CORE 0.001524
K_23534 X_NUC_177.L_CORE X_NUC_215.L_CORE 0.001212
K_23535 X_NUC_177.L_CORE X_NUC_216.L_CORE 0.001496
K_23536 X_NUC_177.L_CORE X_NUC_217.L_CORE 0.001307
K_23537 X_NUC_177.L_CORE X_NUC_218.L_CORE 0.001255
K_23538 X_NUC_177.L_CORE X_NUC_219.L_CORE 0.001429
K_23539 X_NUC_177.L_CORE X_NUC_220.L_CORE 0.001218
K_23540 X_NUC_177.L_CORE X_NUC_221.L_CORE 0.001307
K_23541 X_NUC_177.L_CORE X_NUC_222.L_CORE 0.001285
K_23542 X_NUC_178.L_CORE X_NUC_179.L_CORE 0.001992
K_23543 X_NUC_178.L_CORE X_NUC_180.L_CORE 0.002648
K_23544 X_NUC_178.L_CORE X_NUC_181.L_CORE 0.003821
K_23545 X_NUC_178.L_CORE X_NUC_182.L_CORE 0.001705
K_23546 X_NUC_178.L_CORE X_NUC_183.L_CORE 0.004976
K_23547 X_NUC_178.L_CORE X_NUC_184.L_CORE 0.002016
K_23548 X_NUC_178.L_CORE X_NUC_185.L_CORE 0.001839
K_23549 X_NUC_178.L_CORE X_NUC_186.L_CORE 0.004938
K_23550 X_NUC_178.L_CORE X_NUC_187.L_CORE 0.001559
K_23551 X_NUC_178.L_CORE X_NUC_188.L_CORE 0.002519
K_23552 X_NUC_178.L_CORE X_NUC_189.L_CORE 0.002282
K_23553 X_NUC_178.L_CORE X_NUC_190.L_CORE 0.001506
K_23554 X_NUC_178.L_CORE X_NUC_191.L_CORE 0.003748
K_23555 X_NUC_178.L_CORE X_NUC_192.L_CORE 0.001570
K_23556 X_NUC_178.L_CORE X_NUC_193.L_CORE 0.001760
K_23557 X_NUC_178.L_CORE X_NUC_194.L_CORE 0.002641
K_23558 X_NUC_178.L_CORE X_NUC_195.L_CORE 0.001372
K_23559 X_NUC_178.L_CORE X_NUC_196.L_CORE 0.002387
K_23560 X_NUC_178.L_CORE X_NUC_197.L_CORE 0.001694
K_23561 X_NUC_178.L_CORE X_NUC_198.L_CORE 0.001433
K_23562 X_NUC_178.L_CORE X_NUC_199.L_CORE 0.002608
K_23563 X_NUC_178.L_CORE X_NUC_200.L_CORE 0.001353
K_23564 X_NUC_178.L_CORE X_NUC_201.L_CORE 0.001729
K_23565 X_NUC_178.L_CORE X_NUC_202.L_CORE 0.001867
K_23566 X_NUC_178.L_CORE X_NUC_203.L_CORE 0.001288
K_23567 X_NUC_178.L_CORE X_NUC_204.L_CORE 0.002108
K_23568 X_NUC_178.L_CORE X_NUC_205.L_CORE 0.001409
K_23569 X_NUC_178.L_CORE X_NUC_206.L_CORE 0.001409
K_23570 X_NUC_178.L_CORE X_NUC_207.L_CORE 0.001926
K_23571 X_NUC_178.L_CORE X_NUC_208.L_CORE 0.001245
K_23572 X_NUC_178.L_CORE X_NUC_209.L_CORE 0.001658
K_23573 X_NUC_178.L_CORE X_NUC_210.L_CORE 0.001497
K_23574 X_NUC_178.L_CORE X_NUC_211.L_CORE 0.001258
K_23575 X_NUC_178.L_CORE X_NUC_212.L_CORE 0.001755
K_23576 X_NUC_178.L_CORE X_NUC_213.L_CORE 0.001265
K_23577 X_NUC_178.L_CORE X_NUC_214.L_CORE 0.001387
K_23578 X_NUC_178.L_CORE X_NUC_215.L_CORE 0.001528
K_23579 X_NUC_178.L_CORE X_NUC_216.L_CORE 0.001207
K_23580 X_NUC_178.L_CORE X_NUC_217.L_CORE 0.001498
K_23581 X_NUC_178.L_CORE X_NUC_218.L_CORE 0.001307
K_23582 X_NUC_178.L_CORE X_NUC_219.L_CORE 0.001257
K_23583 X_NUC_178.L_CORE X_NUC_220.L_CORE 0.001422
K_23584 X_NUC_178.L_CORE X_NUC_221.L_CORE 0.001230
K_23585 X_NUC_178.L_CORE X_NUC_222.L_CORE 0.001300
K_23586 X_NUC_179.L_CORE X_NUC_180.L_CORE 0.001865
K_23587 X_NUC_179.L_CORE X_NUC_181.L_CORE 0.002494
K_23588 X_NUC_179.L_CORE X_NUC_182.L_CORE 0.003635
K_23589 X_NUC_179.L_CORE X_NUC_183.L_CORE 0.001618
K_23590 X_NUC_179.L_CORE X_NUC_184.L_CORE 0.004868
K_23591 X_NUC_179.L_CORE X_NUC_185.L_CORE 0.001929
K_23592 X_NUC_179.L_CORE X_NUC_186.L_CORE 0.001764
K_23593 X_NUC_179.L_CORE X_NUC_187.L_CORE 0.005011
K_23594 X_NUC_179.L_CORE X_NUC_188.L_CORE 0.001499
K_23595 X_NUC_179.L_CORE X_NUC_189.L_CORE 0.002461
K_23596 X_NUC_179.L_CORE X_NUC_190.L_CORE 0.002228
K_23597 X_NUC_179.L_CORE X_NUC_191.L_CORE 0.001457
K_23598 X_NUC_179.L_CORE X_NUC_192.L_CORE 0.003848
K_23599 X_NUC_179.L_CORE X_NUC_193.L_CORE 0.001527
K_23600 X_NUC_179.L_CORE X_NUC_194.L_CORE 0.001721
K_23601 X_NUC_179.L_CORE X_NUC_195.L_CORE 0.002650
K_23602 X_NUC_179.L_CORE X_NUC_196.L_CORE 0.001337
K_23603 X_NUC_179.L_CORE X_NUC_197.L_CORE 0.002391
K_23604 X_NUC_179.L_CORE X_NUC_198.L_CORE 0.001668
K_23605 X_NUC_179.L_CORE X_NUC_199.L_CORE 0.001404
K_23606 X_NUC_179.L_CORE X_NUC_200.L_CORE 0.002661
K_23607 X_NUC_179.L_CORE X_NUC_201.L_CORE 0.001328
K_23608 X_NUC_179.L_CORE X_NUC_202.L_CORE 0.001716
K_23609 X_NUC_179.L_CORE X_NUC_203.L_CORE 0.001865
K_23610 X_NUC_179.L_CORE X_NUC_204.L_CORE 0.001267
K_23611 X_NUC_179.L_CORE X_NUC_205.L_CORE 0.002133
K_23612 X_NUC_179.L_CORE X_NUC_206.L_CORE 0.001394
K_23613 X_NUC_179.L_CORE X_NUC_207.L_CORE 0.001396
K_23614 X_NUC_179.L_CORE X_NUC_208.L_CORE 0.001943
K_23615 X_NUC_179.L_CORE X_NUC_209.L_CORE 0.001231
K_23616 X_NUC_179.L_CORE X_NUC_210.L_CORE 0.001660
K_23617 X_NUC_179.L_CORE X_NUC_211.L_CORE 0.001494
K_23618 X_NUC_179.L_CORE X_NUC_212.L_CORE 0.001250
K_23619 X_NUC_179.L_CORE X_NUC_213.L_CORE 0.001766
K_23620 X_NUC_179.L_CORE X_NUC_214.L_CORE 0.001260
K_23621 X_NUC_179.L_CORE X_NUC_215.L_CORE 0.001385
K_23622 X_NUC_179.L_CORE X_NUC_216.L_CORE 0.001529
K_23623 X_NUC_179.L_CORE X_NUC_217.L_CORE 0.001207
K_23624 X_NUC_179.L_CORE X_NUC_218.L_CORE 0.001496
K_23625 X_NUC_179.L_CORE X_NUC_219.L_CORE 0.001309
K_23626 X_NUC_179.L_CORE X_NUC_220.L_CORE 0.001263
K_23627 X_NUC_179.L_CORE X_NUC_221.L_CORE 0.001405
K_23628 X_NUC_179.L_CORE X_NUC_222.L_CORE 0.001256
K_23629 X_NUC_180.L_CORE X_NUC_181.L_CORE 0.001765
K_23630 X_NUC_180.L_CORE X_NUC_182.L_CORE 0.002372
K_23631 X_NUC_180.L_CORE X_NUC_183.L_CORE 0.003481
K_23632 X_NUC_180.L_CORE X_NUC_184.L_CORE 0.001548
K_23633 X_NUC_180.L_CORE X_NUC_185.L_CORE 0.004764
K_23634 X_NUC_180.L_CORE X_NUC_186.L_CORE 0.001858
K_23635 X_NUC_180.L_CORE X_NUC_187.L_CORE 0.001701
K_23636 X_NUC_180.L_CORE X_NUC_188.L_CORE 0.005062
K_23637 X_NUC_180.L_CORE X_NUC_189.L_CORE 0.001450
K_23638 X_NUC_180.L_CORE X_NUC_190.L_CORE 0.002409
K_23639 X_NUC_180.L_CORE X_NUC_191.L_CORE 0.002181
K_23640 X_NUC_180.L_CORE X_NUC_192.L_CORE 0.001417
K_23641 X_NUC_180.L_CORE X_NUC_193.L_CORE 0.003934
K_23642 X_NUC_180.L_CORE X_NUC_194.L_CORE 0.001491
K_23643 X_NUC_180.L_CORE X_NUC_195.L_CORE 0.001688
K_23644 X_NUC_180.L_CORE X_NUC_196.L_CORE 0.002654
K_23645 X_NUC_180.L_CORE X_NUC_197.L_CORE 0.001308
K_23646 X_NUC_180.L_CORE X_NUC_198.L_CORE 0.002393
K_23647 X_NUC_180.L_CORE X_NUC_199.L_CORE 0.001645
K_23648 X_NUC_180.L_CORE X_NUC_200.L_CORE 0.001381
K_23649 X_NUC_180.L_CORE X_NUC_201.L_CORE 0.002706
K_23650 X_NUC_180.L_CORE X_NUC_202.L_CORE 0.001307
K_23651 X_NUC_180.L_CORE X_NUC_203.L_CORE 0.001704
K_23652 X_NUC_180.L_CORE X_NUC_204.L_CORE 0.001862
K_23653 X_NUC_180.L_CORE X_NUC_205.L_CORE 0.001251
K_23654 X_NUC_180.L_CORE X_NUC_206.L_CORE 0.002151
K_23655 X_NUC_180.L_CORE X_NUC_207.L_CORE 0.001383
K_23656 X_NUC_180.L_CORE X_NUC_208.L_CORE 0.001386
K_23657 X_NUC_180.L_CORE X_NUC_209.L_CORE 0.001955
K_23658 X_NUC_180.L_CORE X_NUC_210.L_CORE 0.001222
K_23659 X_NUC_180.L_CORE X_NUC_211.L_CORE 0.001662
K_23660 X_NUC_180.L_CORE X_NUC_212.L_CORE 0.001491
K_23661 X_NUC_180.L_CORE X_NUC_213.L_CORE 0.001245
K_23662 X_NUC_180.L_CORE X_NUC_214.L_CORE 0.001771
K_23663 X_NUC_180.L_CORE X_NUC_215.L_CORE 0.001258
K_23664 X_NUC_180.L_CORE X_NUC_216.L_CORE 0.001385
K_23665 X_NUC_180.L_CORE X_NUC_217.L_CORE 0.001528
K_23666 X_NUC_180.L_CORE X_NUC_218.L_CORE 0.001212
K_23667 X_NUC_180.L_CORE X_NUC_219.L_CORE 0.001489
K_23668 X_NUC_180.L_CORE X_NUC_220.L_CORE 0.001314
K_23669 X_NUC_180.L_CORE X_NUC_221.L_CORE 0.001275
K_23670 X_NUC_180.L_CORE X_NUC_222.L_CORE 0.001370
K_23671 X_NUC_181.L_CORE X_NUC_182.L_CORE 0.001684
K_23672 X_NUC_181.L_CORE X_NUC_183.L_CORE 0.002271
K_23673 X_NUC_181.L_CORE X_NUC_184.L_CORE 0.003352
K_23674 X_NUC_181.L_CORE X_NUC_185.L_CORE 0.001490
K_23675 X_NUC_181.L_CORE X_NUC_186.L_CORE 0.004666
K_23676 X_NUC_181.L_CORE X_NUC_187.L_CORE 0.001798
K_23677 X_NUC_181.L_CORE X_NUC_188.L_CORE 0.001649
K_23678 X_NUC_181.L_CORE X_NUC_189.L_CORE 0.005097
K_23679 X_NUC_181.L_CORE X_NUC_190.L_CORE 0.001409
K_23680 X_NUC_181.L_CORE X_NUC_191.L_CORE 0.002363
K_23681 X_NUC_181.L_CORE X_NUC_192.L_CORE 0.002139
K_23682 X_NUC_181.L_CORE X_NUC_193.L_CORE 0.001383
K_23683 X_NUC_181.L_CORE X_NUC_194.L_CORE 0.004008
K_23684 X_NUC_181.L_CORE X_NUC_195.L_CORE 0.001460
K_23685 X_NUC_181.L_CORE X_NUC_196.L_CORE 0.001659
K_23686 X_NUC_181.L_CORE X_NUC_197.L_CORE 0.002655
K_23687 X_NUC_181.L_CORE X_NUC_198.L_CORE 0.001284
K_23688 X_NUC_181.L_CORE X_NUC_199.L_CORE 0.002393
K_23689 X_NUC_181.L_CORE X_NUC_200.L_CORE 0.001626
K_23690 X_NUC_181.L_CORE X_NUC_201.L_CORE 0.001361
K_23691 X_NUC_181.L_CORE X_NUC_202.L_CORE 0.002743
K_23692 X_NUC_181.L_CORE X_NUC_203.L_CORE 0.001290
K_23693 X_NUC_181.L_CORE X_NUC_204.L_CORE 0.001695
K_23694 X_NUC_181.L_CORE X_NUC_205.L_CORE 0.001859
K_23695 X_NUC_181.L_CORE X_NUC_206.L_CORE 0.001238
K_23696 X_NUC_181.L_CORE X_NUC_207.L_CORE 0.002166
K_23697 X_NUC_181.L_CORE X_NUC_208.L_CORE 0.001374
K_23698 X_NUC_181.L_CORE X_NUC_209.L_CORE 0.001379
K_23699 X_NUC_181.L_CORE X_NUC_210.L_CORE 0.001964
K_23700 X_NUC_181.L_CORE X_NUC_211.L_CORE 0.001216
K_23701 X_NUC_181.L_CORE X_NUC_212.L_CORE 0.001663
K_23702 X_NUC_181.L_CORE X_NUC_213.L_CORE 0.001490
K_23703 X_NUC_181.L_CORE X_NUC_214.L_CORE 0.001243
K_23704 X_NUC_181.L_CORE X_NUC_215.L_CORE 0.001771
K_23705 X_NUC_181.L_CORE X_NUC_216.L_CORE 0.001260
K_23706 X_NUC_181.L_CORE X_NUC_217.L_CORE 0.001387
K_23707 X_NUC_181.L_CORE X_NUC_218.L_CORE 0.001524
K_23708 X_NUC_181.L_CORE X_NUC_219.L_CORE 0.001221
K_23709 X_NUC_181.L_CORE X_NUC_220.L_CORE 0.001477
K_23710 X_NUC_181.L_CORE X_NUC_221.L_CORE 0.001321
K_23711 X_NUC_181.L_CORE X_NUC_222.L_CORE 0.001298
K_23712 X_NUC_182.L_CORE X_NUC_183.L_CORE 0.001617
K_23713 X_NUC_182.L_CORE X_NUC_184.L_CORE 0.002188
K_23714 X_NUC_182.L_CORE X_NUC_185.L_CORE 0.003243
K_23715 X_NUC_182.L_CORE X_NUC_186.L_CORE 0.001441
K_23716 X_NUC_182.L_CORE X_NUC_187.L_CORE 0.004577
K_23717 X_NUC_182.L_CORE X_NUC_188.L_CORE 0.001747
K_23718 X_NUC_182.L_CORE X_NUC_189.L_CORE 0.001605
K_23719 X_NUC_182.L_CORE X_NUC_190.L_CORE 0.005120
K_23720 X_NUC_182.L_CORE X_NUC_191.L_CORE 0.001375
K_23721 X_NUC_182.L_CORE X_NUC_192.L_CORE 0.002322
K_23722 X_NUC_182.L_CORE X_NUC_193.L_CORE 0.002103
K_23723 X_NUC_182.L_CORE X_NUC_194.L_CORE 0.001354
K_23724 X_NUC_182.L_CORE X_NUC_195.L_CORE 0.004070
K_23725 X_NUC_182.L_CORE X_NUC_196.L_CORE 0.001435
K_23726 X_NUC_182.L_CORE X_NUC_197.L_CORE 0.001635
K_23727 X_NUC_182.L_CORE X_NUC_198.L_CORE 0.002655
K_23728 X_NUC_182.L_CORE X_NUC_199.L_CORE 0.001264
K_23729 X_NUC_182.L_CORE X_NUC_200.L_CORE 0.002391
K_23730 X_NUC_182.L_CORE X_NUC_201.L_CORE 0.001610
K_23731 X_NUC_182.L_CORE X_NUC_202.L_CORE 0.001346
K_23732 X_NUC_182.L_CORE X_NUC_203.L_CORE 0.002774
K_23733 X_NUC_182.L_CORE X_NUC_204.L_CORE 0.001277
K_23734 X_NUC_182.L_CORE X_NUC_205.L_CORE 0.001687
K_23735 X_NUC_182.L_CORE X_NUC_206.L_CORE 0.001856
K_23736 X_NUC_182.L_CORE X_NUC_207.L_CORE 0.001229
K_23737 X_NUC_182.L_CORE X_NUC_208.L_CORE 0.002176
K_23738 X_NUC_182.L_CORE X_NUC_209.L_CORE 0.001368
K_23739 X_NUC_182.L_CORE X_NUC_210.L_CORE 0.001374
K_23740 X_NUC_182.L_CORE X_NUC_211.L_CORE 0.001969
K_23741 X_NUC_182.L_CORE X_NUC_212.L_CORE 0.001213
K_23742 X_NUC_182.L_CORE X_NUC_213.L_CORE 0.001663
K_23743 X_NUC_182.L_CORE X_NUC_214.L_CORE 0.001490
K_23744 X_NUC_182.L_CORE X_NUC_215.L_CORE 0.001245
K_23745 X_NUC_182.L_CORE X_NUC_216.L_CORE 0.001766
K_23746 X_NUC_182.L_CORE X_NUC_217.L_CORE 0.001265
K_23747 X_NUC_182.L_CORE X_NUC_218.L_CORE 0.001390
K_23748 X_NUC_182.L_CORE X_NUC_219.L_CORE 0.001517
K_23749 X_NUC_182.L_CORE X_NUC_220.L_CORE 0.001238
K_23750 X_NUC_182.L_CORE X_NUC_221.L_CORE 0.001457
K_23751 X_NUC_182.L_CORE X_NUC_222.L_CORE 0.001333
K_23752 X_NUC_183.L_CORE X_NUC_184.L_CORE 0.001562
K_23753 X_NUC_183.L_CORE X_NUC_185.L_CORE 0.002118
K_23754 X_NUC_183.L_CORE X_NUC_186.L_CORE 0.003150
K_23755 X_NUC_183.L_CORE X_NUC_187.L_CORE 0.001400
K_23756 X_NUC_183.L_CORE X_NUC_188.L_CORE 0.004497
K_23757 X_NUC_183.L_CORE X_NUC_189.L_CORE 0.001704
K_23758 X_NUC_183.L_CORE X_NUC_190.L_CORE 0.001567
K_23759 X_NUC_183.L_CORE X_NUC_191.L_CORE 0.005134
K_23760 X_NUC_183.L_CORE X_NUC_192.L_CORE 0.001345
K_23761 X_NUC_183.L_CORE X_NUC_193.L_CORE 0.002287
K_23762 X_NUC_183.L_CORE X_NUC_194.L_CORE 0.002072
K_23763 X_NUC_183.L_CORE X_NUC_195.L_CORE 0.001330
K_23764 X_NUC_183.L_CORE X_NUC_196.L_CORE 0.004124
K_23765 X_NUC_183.L_CORE X_NUC_197.L_CORE 0.001413
K_23766 X_NUC_183.L_CORE X_NUC_198.L_CORE 0.001614
K_23767 X_NUC_183.L_CORE X_NUC_199.L_CORE 0.002654
K_23768 X_NUC_183.L_CORE X_NUC_200.L_CORE 0.001248
K_23769 X_NUC_183.L_CORE X_NUC_201.L_CORE 0.002389
K_23770 X_NUC_183.L_CORE X_NUC_202.L_CORE 0.001596
K_23771 X_NUC_183.L_CORE X_NUC_203.L_CORE 0.001333
K_23772 X_NUC_183.L_CORE X_NUC_204.L_CORE 0.002799
K_23773 X_NUC_183.L_CORE X_NUC_205.L_CORE 0.001267
K_23774 X_NUC_183.L_CORE X_NUC_206.L_CORE 0.001681
K_23775 X_NUC_183.L_CORE X_NUC_207.L_CORE 0.001854
K_23776 X_NUC_183.L_CORE X_NUC_208.L_CORE 0.001222
K_23777 X_NUC_183.L_CORE X_NUC_209.L_CORE 0.002183
K_23778 X_NUC_183.L_CORE X_NUC_210.L_CORE 0.001364
K_23779 X_NUC_183.L_CORE X_NUC_211.L_CORE 0.001372
K_23780 X_NUC_183.L_CORE X_NUC_212.L_CORE 0.001971
K_23781 X_NUC_183.L_CORE X_NUC_213.L_CORE 0.001213
K_23782 X_NUC_183.L_CORE X_NUC_214.L_CORE 0.001663
K_23783 X_NUC_183.L_CORE X_NUC_215.L_CORE 0.001491
K_23784 X_NUC_183.L_CORE X_NUC_216.L_CORE 0.001250
K_23785 X_NUC_183.L_CORE X_NUC_217.L_CORE 0.001755
K_23786 X_NUC_183.L_CORE X_NUC_218.L_CORE 0.001274
K_23787 X_NUC_183.L_CORE X_NUC_219.L_CORE 0.001394
K_23788 X_NUC_183.L_CORE X_NUC_220.L_CORE 0.001505
K_23789 X_NUC_183.L_CORE X_NUC_221.L_CORE 0.001263
K_23790 X_NUC_183.L_CORE X_NUC_222.L_CORE 0.001422
K_23791 X_NUC_184.L_CORE X_NUC_185.L_CORE 0.001515
K_23792 X_NUC_184.L_CORE X_NUC_186.L_CORE 0.002059
K_23793 X_NUC_184.L_CORE X_NUC_187.L_CORE 0.003071
K_23794 X_NUC_184.L_CORE X_NUC_188.L_CORE 0.001365
K_23795 X_NUC_184.L_CORE X_NUC_189.L_CORE 0.004425
K_23796 X_NUC_184.L_CORE X_NUC_190.L_CORE 0.001667
K_23797 X_NUC_184.L_CORE X_NUC_191.L_CORE 0.001535
K_23798 X_NUC_184.L_CORE X_NUC_192.L_CORE 0.005143
K_23799 X_NUC_184.L_CORE X_NUC_193.L_CORE 0.001320
K_23800 X_NUC_184.L_CORE X_NUC_194.L_CORE 0.002257
K_23801 X_NUC_184.L_CORE X_NUC_195.L_CORE 0.002045
K_23802 X_NUC_184.L_CORE X_NUC_196.L_CORE 0.001310
K_23803 X_NUC_184.L_CORE X_NUC_197.L_CORE 0.004169
K_23804 X_NUC_184.L_CORE X_NUC_198.L_CORE 0.001395
K_23805 X_NUC_184.L_CORE X_NUC_199.L_CORE 0.001597
K_23806 X_NUC_184.L_CORE X_NUC_200.L_CORE 0.002652
K_23807 X_NUC_184.L_CORE X_NUC_201.L_CORE 0.001235
K_23808 X_NUC_184.L_CORE X_NUC_202.L_CORE 0.002387
K_23809 X_NUC_184.L_CORE X_NUC_203.L_CORE 0.001586
K_23810 X_NUC_184.L_CORE X_NUC_204.L_CORE 0.001323
K_23811 X_NUC_184.L_CORE X_NUC_205.L_CORE 0.002818
K_23812 X_NUC_184.L_CORE X_NUC_206.L_CORE 0.001260
K_23813 X_NUC_184.L_CORE X_NUC_207.L_CORE 0.001677
K_23814 X_NUC_184.L_CORE X_NUC_208.L_CORE 0.001853
K_23815 X_NUC_184.L_CORE X_NUC_209.L_CORE 0.001218
K_23816 X_NUC_184.L_CORE X_NUC_210.L_CORE 0.002187
K_23817 X_NUC_184.L_CORE X_NUC_211.L_CORE 0.001363
K_23818 X_NUC_184.L_CORE X_NUC_212.L_CORE 0.001372
K_23819 X_NUC_184.L_CORE X_NUC_213.L_CORE 0.001969
K_23820 X_NUC_184.L_CORE X_NUC_214.L_CORE 0.001216
K_23821 X_NUC_184.L_CORE X_NUC_215.L_CORE 0.001662
K_23822 X_NUC_184.L_CORE X_NUC_216.L_CORE 0.001494
K_23823 X_NUC_184.L_CORE X_NUC_217.L_CORE 0.001258
K_23824 X_NUC_184.L_CORE X_NUC_218.L_CORE 0.001738
K_23825 X_NUC_184.L_CORE X_NUC_219.L_CORE 0.001287
K_23826 X_NUC_184.L_CORE X_NUC_220.L_CORE 0.001400
K_23827 X_NUC_184.L_CORE X_NUC_221.L_CORE 0.001487
K_23828 X_NUC_184.L_CORE X_NUC_222.L_CORE 0.001310
K_23829 X_NUC_185.L_CORE X_NUC_186.L_CORE 0.001475
K_23830 X_NUC_185.L_CORE X_NUC_187.L_CORE 0.002008
K_23831 X_NUC_185.L_CORE X_NUC_188.L_CORE 0.003003
K_23832 X_NUC_185.L_CORE X_NUC_189.L_CORE 0.001335
K_23833 X_NUC_185.L_CORE X_NUC_190.L_CORE 0.004361
K_23834 X_NUC_185.L_CORE X_NUC_191.L_CORE 0.001636
K_23835 X_NUC_185.L_CORE X_NUC_192.L_CORE 0.001508
K_23836 X_NUC_185.L_CORE X_NUC_193.L_CORE 0.005146
K_23837 X_NUC_185.L_CORE X_NUC_194.L_CORE 0.001299
K_23838 X_NUC_185.L_CORE X_NUC_195.L_CORE 0.002230
K_23839 X_NUC_185.L_CORE X_NUC_196.L_CORE 0.002022
K_23840 X_NUC_185.L_CORE X_NUC_197.L_CORE 0.001293
K_23841 X_NUC_185.L_CORE X_NUC_198.L_CORE 0.004207
K_23842 X_NUC_185.L_CORE X_NUC_199.L_CORE 0.001380
K_23843 X_NUC_185.L_CORE X_NUC_200.L_CORE 0.001583
K_23844 X_NUC_185.L_CORE X_NUC_201.L_CORE 0.002649
K_23845 X_NUC_185.L_CORE X_NUC_202.L_CORE 0.001224
K_23846 X_NUC_185.L_CORE X_NUC_203.L_CORE 0.002385
K_23847 X_NUC_185.L_CORE X_NUC_204.L_CORE 0.001578
K_23848 X_NUC_185.L_CORE X_NUC_205.L_CORE 0.001316
K_23849 X_NUC_185.L_CORE X_NUC_206.L_CORE 0.002831
K_23850 X_NUC_185.L_CORE X_NUC_207.L_CORE 0.001255
K_23851 X_NUC_185.L_CORE X_NUC_208.L_CORE 0.001674
K_23852 X_NUC_185.L_CORE X_NUC_209.L_CORE 0.001852
K_23853 X_NUC_185.L_CORE X_NUC_210.L_CORE 0.001217
K_23854 X_NUC_185.L_CORE X_NUC_211.L_CORE 0.002187
K_23855 X_NUC_185.L_CORE X_NUC_212.L_CORE 0.001364
K_23856 X_NUC_185.L_CORE X_NUC_213.L_CORE 0.001374
K_23857 X_NUC_185.L_CORE X_NUC_214.L_CORE 0.001964
K_23858 X_NUC_185.L_CORE X_NUC_215.L_CORE 0.001222
K_23859 X_NUC_185.L_CORE X_NUC_216.L_CORE 0.001660
K_23860 X_NUC_185.L_CORE X_NUC_217.L_CORE 0.001497
K_23861 X_NUC_185.L_CORE X_NUC_218.L_CORE 0.001270
K_23862 X_NUC_185.L_CORE X_NUC_219.L_CORE 0.001714
K_23863 X_NUC_185.L_CORE X_NUC_220.L_CORE 0.001306
K_23864 X_NUC_185.L_CORE X_NUC_221.L_CORE 0.001407
K_23865 X_NUC_185.L_CORE X_NUC_222.L_CORE 0.001455
K_23866 X_NUC_186.L_CORE X_NUC_187.L_CORE 0.001441
K_23867 X_NUC_186.L_CORE X_NUC_188.L_CORE 0.001965
K_23868 X_NUC_186.L_CORE X_NUC_189.L_CORE 0.002944
K_23869 X_NUC_186.L_CORE X_NUC_190.L_CORE 0.001309
K_23870 X_NUC_186.L_CORE X_NUC_191.L_CORE 0.004304
K_23871 X_NUC_186.L_CORE X_NUC_192.L_CORE 0.001609
K_23872 X_NUC_186.L_CORE X_NUC_193.L_CORE 0.001484
K_23873 X_NUC_186.L_CORE X_NUC_194.L_CORE 0.005147
K_23874 X_NUC_186.L_CORE X_NUC_195.L_CORE 0.001282
K_23875 X_NUC_186.L_CORE X_NUC_196.L_CORE 0.002208
K_23876 X_NUC_186.L_CORE X_NUC_197.L_CORE 0.002003
K_23877 X_NUC_186.L_CORE X_NUC_198.L_CORE 0.001279
K_23878 X_NUC_186.L_CORE X_NUC_199.L_CORE 0.004238
K_23879 X_NUC_186.L_CORE X_NUC_200.L_CORE 0.001368
K_23880 X_NUC_186.L_CORE X_NUC_201.L_CORE 0.001572
K_23881 X_NUC_186.L_CORE X_NUC_202.L_CORE 0.002647
K_23882 X_NUC_186.L_CORE X_NUC_203.L_CORE 0.001216
K_23883 X_NUC_186.L_CORE X_NUC_204.L_CORE 0.002384
K_23884 X_NUC_186.L_CORE X_NUC_205.L_CORE 0.001572
K_23885 X_NUC_186.L_CORE X_NUC_206.L_CORE 0.001311
K_23886 X_NUC_186.L_CORE X_NUC_207.L_CORE 0.002839
K_23887 X_NUC_186.L_CORE X_NUC_208.L_CORE 0.001252
K_23888 X_NUC_186.L_CORE X_NUC_209.L_CORE 0.001673
K_23889 X_NUC_186.L_CORE X_NUC_210.L_CORE 0.001852
K_23890 X_NUC_186.L_CORE X_NUC_211.L_CORE 0.001218
K_23891 X_NUC_186.L_CORE X_NUC_212.L_CORE 0.002183
K_23892 X_NUC_186.L_CORE X_NUC_213.L_CORE 0.001368
K_23893 X_NUC_186.L_CORE X_NUC_214.L_CORE 0.001379
K_23894 X_NUC_186.L_CORE X_NUC_215.L_CORE 0.001955
K_23895 X_NUC_186.L_CORE X_NUC_216.L_CORE 0.001231
K_23896 X_NUC_186.L_CORE X_NUC_217.L_CORE 0.001658
K_23897 X_NUC_186.L_CORE X_NUC_218.L_CORE 0.001501
K_23898 X_NUC_186.L_CORE X_NUC_219.L_CORE 0.001288
K_23899 X_NUC_186.L_CORE X_NUC_220.L_CORE 0.001682
K_23900 X_NUC_186.L_CORE X_NUC_221.L_CORE 0.001332
K_23901 X_NUC_186.L_CORE X_NUC_222.L_CORE 0.001416
K_23902 X_NUC_187.L_CORE X_NUC_188.L_CORE 0.001412
K_23903 X_NUC_187.L_CORE X_NUC_189.L_CORE 0.001928
K_23904 X_NUC_187.L_CORE X_NUC_190.L_CORE 0.002894
K_23905 X_NUC_187.L_CORE X_NUC_191.L_CORE 0.001288
K_23906 X_NUC_187.L_CORE X_NUC_192.L_CORE 0.004255
K_23907 X_NUC_187.L_CORE X_NUC_193.L_CORE 0.001586
K_23908 X_NUC_187.L_CORE X_NUC_194.L_CORE 0.001465
K_23909 X_NUC_187.L_CORE X_NUC_195.L_CORE 0.005146
K_23910 X_NUC_187.L_CORE X_NUC_196.L_CORE 0.001267
K_23911 X_NUC_187.L_CORE X_NUC_197.L_CORE 0.002189
K_23912 X_NUC_187.L_CORE X_NUC_198.L_CORE 0.001987
K_23913 X_NUC_187.L_CORE X_NUC_199.L_CORE 0.001268
K_23914 X_NUC_187.L_CORE X_NUC_200.L_CORE 0.004262
K_23915 X_NUC_187.L_CORE X_NUC_201.L_CORE 0.001359
K_23916 X_NUC_187.L_CORE X_NUC_202.L_CORE 0.001563
K_23917 X_NUC_187.L_CORE X_NUC_203.L_CORE 0.002646
K_23918 X_NUC_187.L_CORE X_NUC_204.L_CORE 0.001211
K_23919 X_NUC_187.L_CORE X_NUC_205.L_CORE 0.002383
K_23920 X_NUC_187.L_CORE X_NUC_206.L_CORE 0.001568
K_23921 X_NUC_187.L_CORE X_NUC_207.L_CORE 0.001309
K_23922 X_NUC_187.L_CORE X_NUC_208.L_CORE 0.002842
K_23923 X_NUC_187.L_CORE X_NUC_209.L_CORE 0.001252
K_23924 X_NUC_187.L_CORE X_NUC_210.L_CORE 0.001674
K_23925 X_NUC_187.L_CORE X_NUC_211.L_CORE 0.001853
K_23926 X_NUC_187.L_CORE X_NUC_212.L_CORE 0.001222
K_23927 X_NUC_187.L_CORE X_NUC_213.L_CORE 0.002176
K_23928 X_NUC_187.L_CORE X_NUC_214.L_CORE 0.001374
K_23929 X_NUC_187.L_CORE X_NUC_215.L_CORE 0.001386
K_23930 X_NUC_187.L_CORE X_NUC_216.L_CORE 0.001943
K_23931 X_NUC_187.L_CORE X_NUC_217.L_CORE 0.001245
K_23932 X_NUC_187.L_CORE X_NUC_218.L_CORE 0.001654
K_23933 X_NUC_187.L_CORE X_NUC_219.L_CORE 0.001506
K_23934 X_NUC_187.L_CORE X_NUC_220.L_CORE 0.001312
K_23935 X_NUC_187.L_CORE X_NUC_221.L_CORE 0.001636
K_23936 X_NUC_187.L_CORE X_NUC_222.L_CORE 0.001377
K_23937 X_NUC_188.L_CORE X_NUC_189.L_CORE 0.001387
K_23938 X_NUC_188.L_CORE X_NUC_190.L_CORE 0.001896
K_23939 X_NUC_188.L_CORE X_NUC_191.L_CORE 0.002851
K_23940 X_NUC_188.L_CORE X_NUC_192.L_CORE 0.001269
K_23941 X_NUC_188.L_CORE X_NUC_193.L_CORE 0.004213
K_23942 X_NUC_188.L_CORE X_NUC_194.L_CORE 0.001567
K_23943 X_NUC_188.L_CORE X_NUC_195.L_CORE 0.001448
K_23944 X_NUC_188.L_CORE X_NUC_196.L_CORE 0.005144
K_23945 X_NUC_188.L_CORE X_NUC_197.L_CORE 0.001255
K_23946 X_NUC_188.L_CORE X_NUC_198.L_CORE 0.002174
K_23947 X_NUC_188.L_CORE X_NUC_199.L_CORE 0.001974
K_23948 X_NUC_188.L_CORE X_NUC_200.L_CORE 0.001259
K_23949 X_NUC_188.L_CORE X_NUC_201.L_CORE 0.004281
K_23950 X_NUC_188.L_CORE X_NUC_202.L_CORE 0.001352
K_23951 X_NUC_188.L_CORE X_NUC_203.L_CORE 0.001557
K_23952 X_NUC_188.L_CORE X_NUC_204.L_CORE 0.002645
K_23953 X_NUC_188.L_CORE X_NUC_205.L_CORE 0.001207
K_23954 X_NUC_188.L_CORE X_NUC_206.L_CORE 0.002382
K_23955 X_NUC_188.L_CORE X_NUC_207.L_CORE 0.001567
K_23956 X_NUC_188.L_CORE X_NUC_208.L_CORE 0.001309
K_23957 X_NUC_188.L_CORE X_NUC_209.L_CORE 0.002839
K_23958 X_NUC_188.L_CORE X_NUC_210.L_CORE 0.001255
K_23959 X_NUC_188.L_CORE X_NUC_211.L_CORE 0.001677
K_23960 X_NUC_188.L_CORE X_NUC_212.L_CORE 0.001854
K_23961 X_NUC_188.L_CORE X_NUC_213.L_CORE 0.001229
K_23962 X_NUC_188.L_CORE X_NUC_214.L_CORE 0.002166
K_23963 X_NUC_188.L_CORE X_NUC_215.L_CORE 0.001383
K_23964 X_NUC_188.L_CORE X_NUC_216.L_CORE 0.001396
K_23965 X_NUC_188.L_CORE X_NUC_217.L_CORE 0.001926
K_23966 X_NUC_188.L_CORE X_NUC_218.L_CORE 0.001263
K_23967 X_NUC_188.L_CORE X_NUC_219.L_CORE 0.001647
K_23968 X_NUC_188.L_CORE X_NUC_220.L_CORE 0.001511
K_23969 X_NUC_188.L_CORE X_NUC_221.L_CORE 0.001345
K_23970 X_NUC_188.L_CORE X_NUC_222.L_CORE 0.001564
K_23971 X_NUC_189.L_CORE X_NUC_190.L_CORE 0.001366
K_23972 X_NUC_189.L_CORE X_NUC_191.L_CORE 0.001869
K_23973 X_NUC_189.L_CORE X_NUC_192.L_CORE 0.002815
K_23974 X_NUC_189.L_CORE X_NUC_193.L_CORE 0.001254
K_23975 X_NUC_189.L_CORE X_NUC_194.L_CORE 0.004177
K_23976 X_NUC_189.L_CORE X_NUC_195.L_CORE 0.001551
K_23977 X_NUC_189.L_CORE X_NUC_196.L_CORE 0.001435
K_23978 X_NUC_189.L_CORE X_NUC_197.L_CORE 0.005142
K_23979 X_NUC_189.L_CORE X_NUC_198.L_CORE 0.001245
K_23980 X_NUC_189.L_CORE X_NUC_199.L_CORE 0.002161
K_23981 X_NUC_189.L_CORE X_NUC_200.L_CORE 0.001964
K_23982 X_NUC_189.L_CORE X_NUC_201.L_CORE 0.001253
K_23983 X_NUC_189.L_CORE X_NUC_202.L_CORE 0.004294
K_23984 X_NUC_189.L_CORE X_NUC_203.L_CORE 0.001347
K_23985 X_NUC_189.L_CORE X_NUC_204.L_CORE 0.001554
K_23986 X_NUC_189.L_CORE X_NUC_205.L_CORE 0.002644
K_23987 X_NUC_189.L_CORE X_NUC_206.L_CORE 0.001206
K_23988 X_NUC_189.L_CORE X_NUC_207.L_CORE 0.002382
K_23989 X_NUC_189.L_CORE X_NUC_208.L_CORE 0.001568
K_23990 X_NUC_189.L_CORE X_NUC_209.L_CORE 0.001311
K_23991 X_NUC_189.L_CORE X_NUC_210.L_CORE 0.002831
K_23992 X_NUC_189.L_CORE X_NUC_211.L_CORE 0.001260
K_23993 X_NUC_189.L_CORE X_NUC_212.L_CORE 0.001681
K_23994 X_NUC_189.L_CORE X_NUC_213.L_CORE 0.001856
K_23995 X_NUC_189.L_CORE X_NUC_214.L_CORE 0.001238
K_23996 X_NUC_189.L_CORE X_NUC_215.L_CORE 0.002151
K_23997 X_NUC_189.L_CORE X_NUC_216.L_CORE 0.001394
K_23998 X_NUC_189.L_CORE X_NUC_217.L_CORE 0.001409
K_23999 X_NUC_189.L_CORE X_NUC_218.L_CORE 0.001904
K_24000 X_NUC_189.L_CORE X_NUC_219.L_CORE 0.001287
K_24001 X_NUC_189.L_CORE X_NUC_220.L_CORE 0.001638
K_24002 X_NUC_189.L_CORE X_NUC_221.L_CORE 0.001516
K_24003 X_NUC_189.L_CORE X_NUC_222.L_CORE 0.001401
K_24004 X_NUC_190.L_CORE X_NUC_191.L_CORE 0.001348
K_24005 X_NUC_190.L_CORE X_NUC_192.L_CORE 0.001847
K_24006 X_NUC_190.L_CORE X_NUC_193.L_CORE 0.002785
K_24007 X_NUC_190.L_CORE X_NUC_194.L_CORE 0.001241
K_24008 X_NUC_190.L_CORE X_NUC_195.L_CORE 0.004147
K_24009 X_NUC_190.L_CORE X_NUC_196.L_CORE 0.001538
K_24010 X_NUC_190.L_CORE X_NUC_197.L_CORE 0.001424
K_24011 X_NUC_190.L_CORE X_NUC_198.L_CORE 0.005139
K_24012 X_NUC_190.L_CORE X_NUC_199.L_CORE 0.001238
K_24013 X_NUC_190.L_CORE X_NUC_200.L_CORE 0.002153
K_24014 X_NUC_190.L_CORE X_NUC_201.L_CORE 0.001957
K_24015 X_NUC_190.L_CORE X_NUC_202.L_CORE 0.001248
K_24016 X_NUC_190.L_CORE X_NUC_203.L_CORE 0.004302
K_24017 X_NUC_190.L_CORE X_NUC_204.L_CORE 0.001345
K_24018 X_NUC_190.L_CORE X_NUC_205.L_CORE 0.001552
K_24019 X_NUC_190.L_CORE X_NUC_206.L_CORE 0.002644
K_24020 X_NUC_190.L_CORE X_NUC_207.L_CORE 0.001207
K_24021 X_NUC_190.L_CORE X_NUC_208.L_CORE 0.002383
K_24022 X_NUC_190.L_CORE X_NUC_209.L_CORE 0.001572
K_24023 X_NUC_190.L_CORE X_NUC_210.L_CORE 0.001316
K_24024 X_NUC_190.L_CORE X_NUC_211.L_CORE 0.002818
K_24025 X_NUC_190.L_CORE X_NUC_212.L_CORE 0.001267
K_24026 X_NUC_190.L_CORE X_NUC_213.L_CORE 0.001687
K_24027 X_NUC_190.L_CORE X_NUC_214.L_CORE 0.001859
K_24028 X_NUC_190.L_CORE X_NUC_215.L_CORE 0.001251
K_24029 X_NUC_190.L_CORE X_NUC_216.L_CORE 0.002133
K_24030 X_NUC_190.L_CORE X_NUC_217.L_CORE 0.001409
K_24031 X_NUC_190.L_CORE X_NUC_218.L_CORE 0.001426
K_24032 X_NUC_190.L_CORE X_NUC_219.L_CORE 0.001875
K_24033 X_NUC_190.L_CORE X_NUC_220.L_CORE 0.001319
K_24034 X_NUC_190.L_CORE X_NUC_221.L_CORE 0.001622
K_24035 X_NUC_190.L_CORE X_NUC_222.L_CORE 0.001518
K_24036 X_NUC_191.L_CORE X_NUC_192.L_CORE 0.001333
K_24037 X_NUC_191.L_CORE X_NUC_193.L_CORE 0.001828
K_24038 X_NUC_191.L_CORE X_NUC_194.L_CORE 0.002760
K_24039 X_NUC_191.L_CORE X_NUC_195.L_CORE 0.001231
K_24040 X_NUC_191.L_CORE X_NUC_196.L_CORE 0.004122
K_24041 X_NUC_191.L_CORE X_NUC_197.L_CORE 0.001528
K_24042 X_NUC_191.L_CORE X_NUC_198.L_CORE 0.001416
K_24043 X_NUC_191.L_CORE X_NUC_199.L_CORE 0.005137
K_24044 X_NUC_191.L_CORE X_NUC_200.L_CORE 0.001233
K_24045 X_NUC_191.L_CORE X_NUC_201.L_CORE 0.002147
K_24046 X_NUC_191.L_CORE X_NUC_202.L_CORE 0.001953
K_24047 X_NUC_191.L_CORE X_NUC_203.L_CORE 0.001246
K_24048 X_NUC_191.L_CORE X_NUC_204.L_CORE 0.004305
K_24049 X_NUC_191.L_CORE X_NUC_205.L_CORE 0.001345
K_24050 X_NUC_191.L_CORE X_NUC_206.L_CORE 0.001554
K_24051 X_NUC_191.L_CORE X_NUC_207.L_CORE 0.002645
K_24052 X_NUC_191.L_CORE X_NUC_208.L_CORE 0.001211
K_24053 X_NUC_191.L_CORE X_NUC_209.L_CORE 0.002384
K_24054 X_NUC_191.L_CORE X_NUC_210.L_CORE 0.001578
K_24055 X_NUC_191.L_CORE X_NUC_211.L_CORE 0.001323
K_24056 X_NUC_191.L_CORE X_NUC_212.L_CORE 0.002799
K_24057 X_NUC_191.L_CORE X_NUC_213.L_CORE 0.001277
K_24058 X_NUC_191.L_CORE X_NUC_214.L_CORE 0.001695
K_24059 X_NUC_191.L_CORE X_NUC_215.L_CORE 0.001862
K_24060 X_NUC_191.L_CORE X_NUC_216.L_CORE 0.001267
K_24061 X_NUC_191.L_CORE X_NUC_217.L_CORE 0.002108
K_24062 X_NUC_191.L_CORE X_NUC_218.L_CORE 0.001428
K_24063 X_NUC_191.L_CORE X_NUC_219.L_CORE 0.001446
K_24064 X_NUC_191.L_CORE X_NUC_220.L_CORE 0.001837
K_24065 X_NUC_191.L_CORE X_NUC_221.L_CORE 0.001364
K_24066 X_NUC_191.L_CORE X_NUC_222.L_CORE 0.001590
K_24067 X_NUC_192.L_CORE X_NUC_193.L_CORE 0.001320
K_24068 X_NUC_192.L_CORE X_NUC_194.L_CORE 0.001813
K_24069 X_NUC_192.L_CORE X_NUC_195.L_CORE 0.002740
K_24070 X_NUC_192.L_CORE X_NUC_196.L_CORE 0.001223
K_24071 X_NUC_192.L_CORE X_NUC_197.L_CORE 0.004104
K_24072 X_NUC_192.L_CORE X_NUC_198.L_CORE 0.001521
K_24073 X_NUC_192.L_CORE X_NUC_199.L_CORE 0.001410
K_24074 X_NUC_192.L_CORE X_NUC_200.L_CORE 0.005135
K_24075 X_NUC_192.L_CORE X_NUC_201.L_CORE 0.001230
K_24076 X_NUC_192.L_CORE X_NUC_202.L_CORE 0.002144
K_24077 X_NUC_192.L_CORE X_NUC_203.L_CORE 0.001952
K_24078 X_NUC_192.L_CORE X_NUC_204.L_CORE 0.001246
K_24079 X_NUC_192.L_CORE X_NUC_205.L_CORE 0.004302
K_24080 X_NUC_192.L_CORE X_NUC_206.L_CORE 0.001347
K_24081 X_NUC_192.L_CORE X_NUC_207.L_CORE 0.001557
K_24082 X_NUC_192.L_CORE X_NUC_208.L_CORE 0.002646
K_24083 X_NUC_192.L_CORE X_NUC_209.L_CORE 0.001216
K_24084 X_NUC_192.L_CORE X_NUC_210.L_CORE 0.002385
K_24085 X_NUC_192.L_CORE X_NUC_211.L_CORE 0.001586
K_24086 X_NUC_192.L_CORE X_NUC_212.L_CORE 0.001333
K_24087 X_NUC_192.L_CORE X_NUC_213.L_CORE 0.002774
K_24088 X_NUC_192.L_CORE X_NUC_214.L_CORE 0.001290
K_24089 X_NUC_192.L_CORE X_NUC_215.L_CORE 0.001704
K_24090 X_NUC_192.L_CORE X_NUC_216.L_CORE 0.001865
K_24091 X_NUC_192.L_CORE X_NUC_217.L_CORE 0.001288
K_24092 X_NUC_192.L_CORE X_NUC_218.L_CORE 0.002078
K_24093 X_NUC_192.L_CORE X_NUC_219.L_CORE 0.001451
K_24094 X_NUC_192.L_CORE X_NUC_220.L_CORE 0.001472
K_24095 X_NUC_192.L_CORE X_NUC_221.L_CORE 0.001786
K_24096 X_NUC_192.L_CORE X_NUC_222.L_CORE 0.001440
K_24097 X_NUC_193.L_CORE X_NUC_194.L_CORE 0.001311
K_24098 X_NUC_193.L_CORE X_NUC_195.L_CORE 0.001801
K_24099 X_NUC_193.L_CORE X_NUC_196.L_CORE 0.002725
K_24100 X_NUC_193.L_CORE X_NUC_197.L_CORE 0.001217
K_24101 X_NUC_193.L_CORE X_NUC_198.L_CORE 0.004091
K_24102 X_NUC_193.L_CORE X_NUC_199.L_CORE 0.001516
K_24103 X_NUC_193.L_CORE X_NUC_200.L_CORE 0.001407
K_24104 X_NUC_193.L_CORE X_NUC_201.L_CORE 0.005134
K_24105 X_NUC_193.L_CORE X_NUC_202.L_CORE 0.001229
K_24106 X_NUC_193.L_CORE X_NUC_203.L_CORE 0.002144
K_24107 X_NUC_193.L_CORE X_NUC_204.L_CORE 0.001953
K_24108 X_NUC_193.L_CORE X_NUC_205.L_CORE 0.001248
K_24109 X_NUC_193.L_CORE X_NUC_206.L_CORE 0.004294
K_24110 X_NUC_193.L_CORE X_NUC_207.L_CORE 0.001352
K_24111 X_NUC_193.L_CORE X_NUC_208.L_CORE 0.001563
K_24112 X_NUC_193.L_CORE X_NUC_209.L_CORE 0.002647
K_24113 X_NUC_193.L_CORE X_NUC_210.L_CORE 0.001224
K_24114 X_NUC_193.L_CORE X_NUC_211.L_CORE 0.002387
K_24115 X_NUC_193.L_CORE X_NUC_212.L_CORE 0.001596
K_24116 X_NUC_193.L_CORE X_NUC_213.L_CORE 0.001346
K_24117 X_NUC_193.L_CORE X_NUC_214.L_CORE 0.002743
K_24118 X_NUC_193.L_CORE X_NUC_215.L_CORE 0.001307
K_24119 X_NUC_193.L_CORE X_NUC_216.L_CORE 0.001716
K_24120 X_NUC_193.L_CORE X_NUC_217.L_CORE 0.001867
K_24121 X_NUC_193.L_CORE X_NUC_218.L_CORE 0.001314
K_24122 X_NUC_193.L_CORE X_NUC_219.L_CORE 0.002040
K_24123 X_NUC_193.L_CORE X_NUC_220.L_CORE 0.001480
K_24124 X_NUC_193.L_CORE X_NUC_221.L_CORE 0.001506
K_24125 X_NUC_193.L_CORE X_NUC_222.L_CORE 0.001703
K_24126 X_NUC_194.L_CORE X_NUC_195.L_CORE 0.001303
K_24127 X_NUC_194.L_CORE X_NUC_196.L_CORE 0.001792
K_24128 X_NUC_194.L_CORE X_NUC_197.L_CORE 0.002714
K_24129 X_NUC_194.L_CORE X_NUC_198.L_CORE 0.001213
K_24130 X_NUC_194.L_CORE X_NUC_199.L_CORE 0.004083
K_24131 X_NUC_194.L_CORE X_NUC_200.L_CORE 0.001513
K_24132 X_NUC_194.L_CORE X_NUC_201.L_CORE 0.001406
K_24133 X_NUC_194.L_CORE X_NUC_202.L_CORE 0.005134
K_24134 X_NUC_194.L_CORE X_NUC_203.L_CORE 0.001230
K_24135 X_NUC_194.L_CORE X_NUC_204.L_CORE 0.002147
K_24136 X_NUC_194.L_CORE X_NUC_205.L_CORE 0.001957
K_24137 X_NUC_194.L_CORE X_NUC_206.L_CORE 0.001253
K_24138 X_NUC_194.L_CORE X_NUC_207.L_CORE 0.004281
K_24139 X_NUC_194.L_CORE X_NUC_208.L_CORE 0.001359
K_24140 X_NUC_194.L_CORE X_NUC_209.L_CORE 0.001572
K_24141 X_NUC_194.L_CORE X_NUC_210.L_CORE 0.002649
K_24142 X_NUC_194.L_CORE X_NUC_211.L_CORE 0.001235
K_24143 X_NUC_194.L_CORE X_NUC_212.L_CORE 0.002389
K_24144 X_NUC_194.L_CORE X_NUC_213.L_CORE 0.001610
K_24145 X_NUC_194.L_CORE X_NUC_214.L_CORE 0.001361
K_24146 X_NUC_194.L_CORE X_NUC_215.L_CORE 0.002706
K_24147 X_NUC_194.L_CORE X_NUC_216.L_CORE 0.001328
K_24148 X_NUC_194.L_CORE X_NUC_217.L_CORE 0.001729
K_24149 X_NUC_194.L_CORE X_NUC_218.L_CORE 0.001868
K_24150 X_NUC_194.L_CORE X_NUC_219.L_CORE 0.001347
K_24151 X_NUC_194.L_CORE X_NUC_220.L_CORE 0.001990
K_24152 X_NUC_194.L_CORE X_NUC_221.L_CORE 0.001518
K_24153 X_NUC_194.L_CORE X_NUC_222.L_CORE 0.001554
K_24154 X_NUC_195.L_CORE X_NUC_196.L_CORE 0.001298
K_24155 X_NUC_195.L_CORE X_NUC_197.L_CORE 0.001787
K_24156 X_NUC_195.L_CORE X_NUC_198.L_CORE 0.002708
K_24157 X_NUC_195.L_CORE X_NUC_199.L_CORE 0.001211
K_24158 X_NUC_195.L_CORE X_NUC_200.L_CORE 0.004080
K_24159 X_NUC_195.L_CORE X_NUC_201.L_CORE 0.001513
K_24160 X_NUC_195.L_CORE X_NUC_202.L_CORE 0.001407
K_24161 X_NUC_195.L_CORE X_NUC_203.L_CORE 0.005135
K_24162 X_NUC_195.L_CORE X_NUC_204.L_CORE 0.001233
K_24163 X_NUC_195.L_CORE X_NUC_205.L_CORE 0.002153
K_24164 X_NUC_195.L_CORE X_NUC_206.L_CORE 0.001964
K_24165 X_NUC_195.L_CORE X_NUC_207.L_CORE 0.001259
K_24166 X_NUC_195.L_CORE X_NUC_208.L_CORE 0.004262
K_24167 X_NUC_195.L_CORE X_NUC_209.L_CORE 0.001368
K_24168 X_NUC_195.L_CORE X_NUC_210.L_CORE 0.001583
K_24169 X_NUC_195.L_CORE X_NUC_211.L_CORE 0.002652
K_24170 X_NUC_195.L_CORE X_NUC_212.L_CORE 0.001248
K_24171 X_NUC_195.L_CORE X_NUC_213.L_CORE 0.002391
K_24172 X_NUC_195.L_CORE X_NUC_214.L_CORE 0.001626
K_24173 X_NUC_195.L_CORE X_NUC_215.L_CORE 0.001381
K_24174 X_NUC_195.L_CORE X_NUC_216.L_CORE 0.002661
K_24175 X_NUC_195.L_CORE X_NUC_217.L_CORE 0.001353
K_24176 X_NUC_195.L_CORE X_NUC_218.L_CORE 0.001743
K_24177 X_NUC_195.L_CORE X_NUC_219.L_CORE 0.001868
K_24178 X_NUC_195.L_CORE X_NUC_220.L_CORE 0.001391
K_24179 X_NUC_195.L_CORE X_NUC_221.L_CORE 0.001924
K_24180 X_NUC_195.L_CORE X_NUC_222.L_CORE 0.001574
K_24181 X_NUC_196.L_CORE X_NUC_197.L_CORE 0.001295
K_24182 X_NUC_196.L_CORE X_NUC_198.L_CORE 0.001784
K_24183 X_NUC_196.L_CORE X_NUC_199.L_CORE 0.002705
K_24184 X_NUC_196.L_CORE X_NUC_200.L_CORE 0.001211
K_24185 X_NUC_196.L_CORE X_NUC_201.L_CORE 0.004083
K_24186 X_NUC_196.L_CORE X_NUC_202.L_CORE 0.001516
K_24187 X_NUC_196.L_CORE X_NUC_203.L_CORE 0.001410
K_24188 X_NUC_196.L_CORE X_NUC_204.L_CORE 0.005137
K_24189 X_NUC_196.L_CORE X_NUC_205.L_CORE 0.001238
K_24190 X_NUC_196.L_CORE X_NUC_206.L_CORE 0.002161
K_24191 X_NUC_196.L_CORE X_NUC_207.L_CORE 0.001974
K_24192 X_NUC_196.L_CORE X_NUC_208.L_CORE 0.001268
K_24193 X_NUC_196.L_CORE X_NUC_209.L_CORE 0.004238
K_24194 X_NUC_196.L_CORE X_NUC_210.L_CORE 0.001380
K_24195 X_NUC_196.L_CORE X_NUC_211.L_CORE 0.001597
K_24196 X_NUC_196.L_CORE X_NUC_212.L_CORE 0.002654
K_24197 X_NUC_196.L_CORE X_NUC_213.L_CORE 0.001264
K_24198 X_NUC_196.L_CORE X_NUC_214.L_CORE 0.002393
K_24199 X_NUC_196.L_CORE X_NUC_215.L_CORE 0.001645
K_24200 X_NUC_196.L_CORE X_NUC_216.L_CORE 0.001404
K_24201 X_NUC_196.L_CORE X_NUC_217.L_CORE 0.002608
K_24202 X_NUC_196.L_CORE X_NUC_218.L_CORE 0.001384
K_24203 X_NUC_196.L_CORE X_NUC_219.L_CORE 0.001759
K_24204 X_NUC_196.L_CORE X_NUC_220.L_CORE 0.001863
K_24205 X_NUC_196.L_CORE X_NUC_221.L_CORE 0.001451
K_24206 X_NUC_196.L_CORE X_NUC_222.L_CORE 0.001820
K_24207 X_NUC_197.L_CORE X_NUC_198.L_CORE 0.001294
K_24208 X_NUC_197.L_CORE X_NUC_199.L_CORE 0.001784
K_24209 X_NUC_197.L_CORE X_NUC_200.L_CORE 0.002708
K_24210 X_NUC_197.L_CORE X_NUC_201.L_CORE 0.001213
K_24211 X_NUC_197.L_CORE X_NUC_202.L_CORE 0.004091
K_24212 X_NUC_197.L_CORE X_NUC_203.L_CORE 0.001521
K_24213 X_NUC_197.L_CORE X_NUC_204.L_CORE 0.001416
K_24214 X_NUC_197.L_CORE X_NUC_205.L_CORE 0.005139
K_24215 X_NUC_197.L_CORE X_NUC_206.L_CORE 0.001245
K_24216 X_NUC_197.L_CORE X_NUC_207.L_CORE 0.002174
K_24217 X_NUC_197.L_CORE X_NUC_208.L_CORE 0.001987
K_24218 X_NUC_197.L_CORE X_NUC_209.L_CORE 0.001279
K_24219 X_NUC_197.L_CORE X_NUC_210.L_CORE 0.004207
K_24220 X_NUC_197.L_CORE X_NUC_211.L_CORE 0.001395
K_24221 X_NUC_197.L_CORE X_NUC_212.L_CORE 0.001614
K_24222 X_NUC_197.L_CORE X_NUC_213.L_CORE 0.002655
K_24223 X_NUC_197.L_CORE X_NUC_214.L_CORE 0.001284
K_24224 X_NUC_197.L_CORE X_NUC_215.L_CORE 0.002393
K_24225 X_NUC_197.L_CORE X_NUC_216.L_CORE 0.001668
K_24226 X_NUC_197.L_CORE X_NUC_217.L_CORE 0.001433
K_24227 X_NUC_197.L_CORE X_NUC_218.L_CORE 0.002544
K_24228 X_NUC_197.L_CORE X_NUC_219.L_CORE 0.001423
K_24229 X_NUC_197.L_CORE X_NUC_220.L_CORE 0.001776
K_24230 X_NUC_197.L_CORE X_NUC_221.L_CORE 0.001851
K_24231 X_NUC_197.L_CORE X_NUC_222.L_CORE 0.001551
K_24232 X_NUC_198.L_CORE X_NUC_199.L_CORE 0.001295
K_24233 X_NUC_198.L_CORE X_NUC_200.L_CORE 0.001787
K_24234 X_NUC_198.L_CORE X_NUC_201.L_CORE 0.002714
K_24235 X_NUC_198.L_CORE X_NUC_202.L_CORE 0.001217
K_24236 X_NUC_198.L_CORE X_NUC_203.L_CORE 0.004104
K_24237 X_NUC_198.L_CORE X_NUC_204.L_CORE 0.001528
K_24238 X_NUC_198.L_CORE X_NUC_205.L_CORE 0.001424
K_24239 X_NUC_198.L_CORE X_NUC_206.L_CORE 0.005142
K_24240 X_NUC_198.L_CORE X_NUC_207.L_CORE 0.001255
K_24241 X_NUC_198.L_CORE X_NUC_208.L_CORE 0.002189
K_24242 X_NUC_198.L_CORE X_NUC_209.L_CORE 0.002003
K_24243 X_NUC_198.L_CORE X_NUC_210.L_CORE 0.001293
K_24244 X_NUC_198.L_CORE X_NUC_211.L_CORE 0.004169
K_24245 X_NUC_198.L_CORE X_NUC_212.L_CORE 0.001413
K_24246 X_NUC_198.L_CORE X_NUC_213.L_CORE 0.001635
K_24247 X_NUC_198.L_CORE X_NUC_214.L_CORE 0.002655
K_24248 X_NUC_198.L_CORE X_NUC_215.L_CORE 0.001308
K_24249 X_NUC_198.L_CORE X_NUC_216.L_CORE 0.002391
K_24250 X_NUC_198.L_CORE X_NUC_217.L_CORE 0.001694
K_24251 X_NUC_198.L_CORE X_NUC_218.L_CORE 0.001468
K_24252 X_NUC_198.L_CORE X_NUC_219.L_CORE 0.002469
K_24253 X_NUC_198.L_CORE X_NUC_220.L_CORE 0.001473
K_24254 X_NUC_198.L_CORE X_NUC_221.L_CORE 0.001791
K_24255 X_NUC_198.L_CORE X_NUC_222.L_CORE 0.001816
K_24256 X_NUC_199.L_CORE X_NUC_200.L_CORE 0.001298
K_24257 X_NUC_199.L_CORE X_NUC_201.L_CORE 0.001792
K_24258 X_NUC_199.L_CORE X_NUC_202.L_CORE 0.002725
K_24259 X_NUC_199.L_CORE X_NUC_203.L_CORE 0.001223
K_24260 X_NUC_199.L_CORE X_NUC_204.L_CORE 0.004122
K_24261 X_NUC_199.L_CORE X_NUC_205.L_CORE 0.001538
K_24262 X_NUC_199.L_CORE X_NUC_206.L_CORE 0.001435
K_24263 X_NUC_199.L_CORE X_NUC_207.L_CORE 0.005144
K_24264 X_NUC_199.L_CORE X_NUC_208.L_CORE 0.001267
K_24265 X_NUC_199.L_CORE X_NUC_209.L_CORE 0.002208
K_24266 X_NUC_199.L_CORE X_NUC_210.L_CORE 0.002022
K_24267 X_NUC_199.L_CORE X_NUC_211.L_CORE 0.001310
K_24268 X_NUC_199.L_CORE X_NUC_212.L_CORE 0.004124
K_24269 X_NUC_199.L_CORE X_NUC_213.L_CORE 0.001435
K_24270 X_NUC_199.L_CORE X_NUC_214.L_CORE 0.001659
K_24271 X_NUC_199.L_CORE X_NUC_215.L_CORE 0.002654
K_24272 X_NUC_199.L_CORE X_NUC_216.L_CORE 0.001337
K_24273 X_NUC_199.L_CORE X_NUC_217.L_CORE 0.002387
K_24274 X_NUC_199.L_CORE X_NUC_218.L_CORE 0.001725
K_24275 X_NUC_199.L_CORE X_NUC_219.L_CORE 0.001510
K_24276 X_NUC_199.L_CORE X_NUC_220.L_CORE 0.002377
K_24277 X_NUC_199.L_CORE X_NUC_221.L_CORE 0.001542
K_24278 X_NUC_199.L_CORE X_NUC_222.L_CORE 0.001800
K_24279 X_NUC_200.L_CORE X_NUC_201.L_CORE 0.001303
K_24280 X_NUC_200.L_CORE X_NUC_202.L_CORE 0.001801
K_24281 X_NUC_200.L_CORE X_NUC_203.L_CORE 0.002740
K_24282 X_NUC_200.L_CORE X_NUC_204.L_CORE 0.001231
K_24283 X_NUC_200.L_CORE X_NUC_205.L_CORE 0.004147
K_24284 X_NUC_200.L_CORE X_NUC_206.L_CORE 0.001551
K_24285 X_NUC_200.L_CORE X_NUC_207.L_CORE 0.001448
K_24286 X_NUC_200.L_CORE X_NUC_208.L_CORE 0.005146
K_24287 X_NUC_200.L_CORE X_NUC_209.L_CORE 0.001282
K_24288 X_NUC_200.L_CORE X_NUC_210.L_CORE 0.002230
K_24289 X_NUC_200.L_CORE X_NUC_211.L_CORE 0.002045
K_24290 X_NUC_200.L_CORE X_NUC_212.L_CORE 0.001330
K_24291 X_NUC_200.L_CORE X_NUC_213.L_CORE 0.004070
K_24292 X_NUC_200.L_CORE X_NUC_214.L_CORE 0.001460
K_24293 X_NUC_200.L_CORE X_NUC_215.L_CORE 0.001688
K_24294 X_NUC_200.L_CORE X_NUC_216.L_CORE 0.002650
K_24295 X_NUC_200.L_CORE X_NUC_217.L_CORE 0.001372
K_24296 X_NUC_200.L_CORE X_NUC_218.L_CORE 0.002378
K_24297 X_NUC_200.L_CORE X_NUC_219.L_CORE 0.001761
K_24298 X_NUC_200.L_CORE X_NUC_220.L_CORE 0.001565
K_24299 X_NUC_200.L_CORE X_NUC_221.L_CORE 0.002260
K_24300 X_NUC_200.L_CORE X_NUC_222.L_CORE 0.001653
K_24301 X_NUC_201.L_CORE X_NUC_202.L_CORE 0.001311
K_24302 X_NUC_201.L_CORE X_NUC_203.L_CORE 0.001813
K_24303 X_NUC_201.L_CORE X_NUC_204.L_CORE 0.002760
K_24304 X_NUC_201.L_CORE X_NUC_205.L_CORE 0.001241
K_24305 X_NUC_201.L_CORE X_NUC_206.L_CORE 0.004177
K_24306 X_NUC_201.L_CORE X_NUC_207.L_CORE 0.001567
K_24307 X_NUC_201.L_CORE X_NUC_208.L_CORE 0.001465
K_24308 X_NUC_201.L_CORE X_NUC_209.L_CORE 0.005147
K_24309 X_NUC_201.L_CORE X_NUC_210.L_CORE 0.001299
K_24310 X_NUC_201.L_CORE X_NUC_211.L_CORE 0.002257
K_24311 X_NUC_201.L_CORE X_NUC_212.L_CORE 0.002072
K_24312 X_NUC_201.L_CORE X_NUC_213.L_CORE 0.001354
K_24313 X_NUC_201.L_CORE X_NUC_214.L_CORE 0.004008
K_24314 X_NUC_201.L_CORE X_NUC_215.L_CORE 0.001491
K_24315 X_NUC_201.L_CORE X_NUC_216.L_CORE 0.001721
K_24316 X_NUC_201.L_CORE X_NUC_217.L_CORE 0.002641
K_24317 X_NUC_201.L_CORE X_NUC_218.L_CORE 0.001416
K_24318 X_NUC_201.L_CORE X_NUC_219.L_CORE 0.002362
K_24319 X_NUC_201.L_CORE X_NUC_220.L_CORE 0.001804
K_24320 X_NUC_201.L_CORE X_NUC_221.L_CORE 0.001637
K_24321 X_NUC_201.L_CORE X_NUC_222.L_CORE 0.002087
K_24322 X_NUC_202.L_CORE X_NUC_203.L_CORE 0.001320
K_24323 X_NUC_202.L_CORE X_NUC_204.L_CORE 0.001828
K_24324 X_NUC_202.L_CORE X_NUC_205.L_CORE 0.002785
K_24325 X_NUC_202.L_CORE X_NUC_206.L_CORE 0.001254
K_24326 X_NUC_202.L_CORE X_NUC_207.L_CORE 0.004213
K_24327 X_NUC_202.L_CORE X_NUC_208.L_CORE 0.001586
K_24328 X_NUC_202.L_CORE X_NUC_209.L_CORE 0.001484
K_24329 X_NUC_202.L_CORE X_NUC_210.L_CORE 0.005146
K_24330 X_NUC_202.L_CORE X_NUC_211.L_CORE 0.001320
K_24331 X_NUC_202.L_CORE X_NUC_212.L_CORE 0.002287
K_24332 X_NUC_202.L_CORE X_NUC_213.L_CORE 0.002103
K_24333 X_NUC_202.L_CORE X_NUC_214.L_CORE 0.001383
K_24334 X_NUC_202.L_CORE X_NUC_215.L_CORE 0.003934
K_24335 X_NUC_202.L_CORE X_NUC_216.L_CORE 0.001527
K_24336 X_NUC_202.L_CORE X_NUC_217.L_CORE 0.001760
K_24337 X_NUC_202.L_CORE X_NUC_218.L_CORE 0.002626
K_24338 X_NUC_202.L_CORE X_NUC_219.L_CORE 0.001470
K_24339 X_NUC_202.L_CORE X_NUC_220.L_CORE 0.002334
K_24340 X_NUC_202.L_CORE X_NUC_221.L_CORE 0.001854
K_24341 X_NUC_202.L_CORE X_NUC_222.L_CORE 0.001751
K_24342 X_NUC_203.L_CORE X_NUC_204.L_CORE 0.001333
K_24343 X_NUC_203.L_CORE X_NUC_205.L_CORE 0.001847
K_24344 X_NUC_203.L_CORE X_NUC_206.L_CORE 0.002815
K_24345 X_NUC_203.L_CORE X_NUC_207.L_CORE 0.001269
K_24346 X_NUC_203.L_CORE X_NUC_208.L_CORE 0.004255
K_24347 X_NUC_203.L_CORE X_NUC_209.L_CORE 0.001609
K_24348 X_NUC_203.L_CORE X_NUC_210.L_CORE 0.001508
K_24349 X_NUC_203.L_CORE X_NUC_211.L_CORE 0.005143
K_24350 X_NUC_203.L_CORE X_NUC_212.L_CORE 0.001345
K_24351 X_NUC_203.L_CORE X_NUC_213.L_CORE 0.002322
K_24352 X_NUC_203.L_CORE X_NUC_214.L_CORE 0.002139
K_24353 X_NUC_203.L_CORE X_NUC_215.L_CORE 0.001417
K_24354 X_NUC_203.L_CORE X_NUC_216.L_CORE 0.003848
K_24355 X_NUC_203.L_CORE X_NUC_217.L_CORE 0.001570
K_24356 X_NUC_203.L_CORE X_NUC_218.L_CORE 0.001806
K_24357 X_NUC_203.L_CORE X_NUC_219.L_CORE 0.002600
K_24358 X_NUC_203.L_CORE X_NUC_220.L_CORE 0.001540
K_24359 X_NUC_203.L_CORE X_NUC_221.L_CORE 0.002284
K_24360 X_NUC_203.L_CORE X_NUC_222.L_CORE 0.001915
K_24361 X_NUC_204.L_CORE X_NUC_205.L_CORE 0.001348
K_24362 X_NUC_204.L_CORE X_NUC_206.L_CORE 0.001869
K_24363 X_NUC_204.L_CORE X_NUC_207.L_CORE 0.002851
K_24364 X_NUC_204.L_CORE X_NUC_208.L_CORE 0.001288
K_24365 X_NUC_204.L_CORE X_NUC_209.L_CORE 0.004304
K_24366 X_NUC_204.L_CORE X_NUC_210.L_CORE 0.001636
K_24367 X_NUC_204.L_CORE X_NUC_211.L_CORE 0.001535
K_24368 X_NUC_204.L_CORE X_NUC_212.L_CORE 0.005134
K_24369 X_NUC_204.L_CORE X_NUC_213.L_CORE 0.001375
K_24370 X_NUC_204.L_CORE X_NUC_214.L_CORE 0.002363
K_24371 X_NUC_204.L_CORE X_NUC_215.L_CORE 0.002181
K_24372 X_NUC_204.L_CORE X_NUC_216.L_CORE 0.001457
K_24373 X_NUC_204.L_CORE X_NUC_217.L_CORE 0.003748
K_24374 X_NUC_204.L_CORE X_NUC_218.L_CORE 0.001623
K_24375 X_NUC_204.L_CORE X_NUC_219.L_CORE 0.001861
K_24376 X_NUC_204.L_CORE X_NUC_220.L_CORE 0.002559
K_24377 X_NUC_204.L_CORE X_NUC_221.L_CORE 0.001637
K_24378 X_NUC_204.L_CORE X_NUC_222.L_CORE 0.002185
K_24379 X_NUC_205.L_CORE X_NUC_206.L_CORE 0.001366
K_24380 X_NUC_205.L_CORE X_NUC_207.L_CORE 0.001896
K_24381 X_NUC_205.L_CORE X_NUC_208.L_CORE 0.002894
K_24382 X_NUC_205.L_CORE X_NUC_209.L_CORE 0.001309
K_24383 X_NUC_205.L_CORE X_NUC_210.L_CORE 0.004361
K_24384 X_NUC_205.L_CORE X_NUC_211.L_CORE 0.001667
K_24385 X_NUC_205.L_CORE X_NUC_212.L_CORE 0.001567
K_24386 X_NUC_205.L_CORE X_NUC_213.L_CORE 0.005120
K_24387 X_NUC_205.L_CORE X_NUC_214.L_CORE 0.001409
K_24388 X_NUC_205.L_CORE X_NUC_215.L_CORE 0.002409
K_24389 X_NUC_205.L_CORE X_NUC_216.L_CORE 0.002228
K_24390 X_NUC_205.L_CORE X_NUC_217.L_CORE 0.001506
K_24391 X_NUC_205.L_CORE X_NUC_218.L_CORE 0.003630
K_24392 X_NUC_205.L_CORE X_NUC_219.L_CORE 0.001687
K_24393 X_NUC_205.L_CORE X_NUC_220.L_CORE 0.001927
K_24394 X_NUC_205.L_CORE X_NUC_221.L_CORE 0.002490
K_24395 X_NUC_205.L_CORE X_NUC_222.L_CORE 0.001802
K_24396 X_NUC_206.L_CORE X_NUC_207.L_CORE 0.001387
K_24397 X_NUC_206.L_CORE X_NUC_208.L_CORE 0.001928
K_24398 X_NUC_206.L_CORE X_NUC_209.L_CORE 0.002944
K_24399 X_NUC_206.L_CORE X_NUC_210.L_CORE 0.001335
K_24400 X_NUC_206.L_CORE X_NUC_211.L_CORE 0.004425
K_24401 X_NUC_206.L_CORE X_NUC_212.L_CORE 0.001704
K_24402 X_NUC_206.L_CORE X_NUC_213.L_CORE 0.001605
K_24403 X_NUC_206.L_CORE X_NUC_214.L_CORE 0.005097
K_24404 X_NUC_206.L_CORE X_NUC_215.L_CORE 0.001450
K_24405 X_NUC_206.L_CORE X_NUC_216.L_CORE 0.002461
K_24406 X_NUC_206.L_CORE X_NUC_217.L_CORE 0.002282
K_24407 X_NUC_206.L_CORE X_NUC_218.L_CORE 0.001565
K_24408 X_NUC_206.L_CORE X_NUC_219.L_CORE 0.003489
K_24409 X_NUC_206.L_CORE X_NUC_220.L_CORE 0.001769
K_24410 X_NUC_206.L_CORE X_NUC_221.L_CORE 0.002008
K_24411 X_NUC_206.L_CORE X_NUC_222.L_CORE 0.002357
K_24412 X_NUC_207.L_CORE X_NUC_208.L_CORE 0.001412
K_24413 X_NUC_207.L_CORE X_NUC_209.L_CORE 0.001965
K_24414 X_NUC_207.L_CORE X_NUC_210.L_CORE 0.003003
K_24415 X_NUC_207.L_CORE X_NUC_211.L_CORE 0.001365
K_24416 X_NUC_207.L_CORE X_NUC_212.L_CORE 0.004497
K_24417 X_NUC_207.L_CORE X_NUC_213.L_CORE 0.001747
K_24418 X_NUC_207.L_CORE X_NUC_214.L_CORE 0.001649
K_24419 X_NUC_207.L_CORE X_NUC_215.L_CORE 0.005062
K_24420 X_NUC_207.L_CORE X_NUC_216.L_CORE 0.001499
K_24421 X_NUC_207.L_CORE X_NUC_217.L_CORE 0.002519
K_24422 X_NUC_207.L_CORE X_NUC_218.L_CORE 0.002343
K_24423 X_NUC_207.L_CORE X_NUC_219.L_CORE 0.001640
K_24424 X_NUC_207.L_CORE X_NUC_220.L_CORE 0.003318
K_24425 X_NUC_207.L_CORE X_NUC_221.L_CORE 0.001878
K_24426 X_NUC_207.L_CORE X_NUC_222.L_CORE 0.002113
K_24427 X_NUC_208.L_CORE X_NUC_209.L_CORE 0.001441
K_24428 X_NUC_208.L_CORE X_NUC_210.L_CORE 0.002008
K_24429 X_NUC_208.L_CORE X_NUC_211.L_CORE 0.003071
K_24430 X_NUC_208.L_CORE X_NUC_212.L_CORE 0.001400
K_24431 X_NUC_208.L_CORE X_NUC_213.L_CORE 0.004577
K_24432 X_NUC_208.L_CORE X_NUC_214.L_CORE 0.001798
K_24433 X_NUC_208.L_CORE X_NUC_215.L_CORE 0.001701
K_24434 X_NUC_208.L_CORE X_NUC_216.L_CORE 0.005011
K_24435 X_NUC_208.L_CORE X_NUC_217.L_CORE 0.001559
K_24436 X_NUC_208.L_CORE X_NUC_218.L_CORE 0.002584
K_24437 X_NUC_208.L_CORE X_NUC_219.L_CORE 0.002411
K_24438 X_NUC_208.L_CORE X_NUC_220.L_CORE 0.001737
K_24439 X_NUC_208.L_CORE X_NUC_221.L_CORE 0.003099
K_24440 X_NUC_208.L_CORE X_NUC_222.L_CORE 0.002050
K_24441 X_NUC_209.L_CORE X_NUC_210.L_CORE 0.001475
K_24442 X_NUC_209.L_CORE X_NUC_211.L_CORE 0.002059
K_24443 X_NUC_209.L_CORE X_NUC_212.L_CORE 0.003150
K_24444 X_NUC_209.L_CORE X_NUC_213.L_CORE 0.001441
K_24445 X_NUC_209.L_CORE X_NUC_214.L_CORE 0.004666
K_24446 X_NUC_209.L_CORE X_NUC_215.L_CORE 0.001858
K_24447 X_NUC_209.L_CORE X_NUC_216.L_CORE 0.001764
K_24448 X_NUC_209.L_CORE X_NUC_217.L_CORE 0.004938
K_24449 X_NUC_209.L_CORE X_NUC_218.L_CORE 0.001632
K_24450 X_NUC_209.L_CORE X_NUC_219.L_CORE 0.002656
K_24451 X_NUC_209.L_CORE X_NUC_220.L_CORE 0.002487
K_24452 X_NUC_209.L_CORE X_NUC_221.L_CORE 0.001872
K_24453 X_NUC_209.L_CORE X_NUC_222.L_CORE 0.002779
K_24454 X_NUC_210.L_CORE X_NUC_211.L_CORE 0.001515
K_24455 X_NUC_210.L_CORE X_NUC_212.L_CORE 0.002118
K_24456 X_NUC_210.L_CORE X_NUC_213.L_CORE 0.003243
K_24457 X_NUC_210.L_CORE X_NUC_214.L_CORE 0.001490
K_24458 X_NUC_210.L_CORE X_NUC_215.L_CORE 0.004764
K_24459 X_NUC_210.L_CORE X_NUC_216.L_CORE 0.001929
K_24460 X_NUC_210.L_CORE X_NUC_217.L_CORE 0.001839
K_24461 X_NUC_210.L_CORE X_NUC_218.L_CORE 0.004835
K_24462 X_NUC_210.L_CORE X_NUC_219.L_CORE 0.001724
K_24463 X_NUC_210.L_CORE X_NUC_220.L_CORE 0.002731
K_24464 X_NUC_210.L_CORE X_NUC_221.L_CORE 0.002566
K_24465 X_NUC_210.L_CORE X_NUC_222.L_CORE 0.002101
K_24466 X_NUC_211.L_CORE X_NUC_212.L_CORE 0.001562
K_24467 X_NUC_211.L_CORE X_NUC_213.L_CORE 0.002188
K_24468 X_NUC_211.L_CORE X_NUC_214.L_CORE 0.003352
K_24469 X_NUC_211.L_CORE X_NUC_215.L_CORE 0.001548
K_24470 X_NUC_211.L_CORE X_NUC_216.L_CORE 0.004868
K_24471 X_NUC_211.L_CORE X_NUC_217.L_CORE 0.002016
K_24472 X_NUC_211.L_CORE X_NUC_218.L_CORE 0.001932
K_24473 X_NUC_211.L_CORE X_NUC_219.L_CORE 0.004691
K_24474 X_NUC_211.L_CORE X_NUC_220.L_CORE 0.001846
K_24475 X_NUC_211.L_CORE X_NUC_221.L_CORE 0.002801
K_24476 X_NUC_211.L_CORE X_NUC_222.L_CORE 0.002629
K_24477 X_NUC_212.L_CORE X_NUC_213.L_CORE 0.001617
K_24478 X_NUC_212.L_CORE X_NUC_214.L_CORE 0.002271
K_24479 X_NUC_212.L_CORE X_NUC_215.L_CORE 0.003481
K_24480 X_NUC_212.L_CORE X_NUC_216.L_CORE 0.001618
K_24481 X_NUC_212.L_CORE X_NUC_217.L_CORE 0.004976
K_24482 X_NUC_212.L_CORE X_NUC_218.L_CORE 0.002123
K_24483 X_NUC_212.L_CORE X_NUC_219.L_CORE 0.002049
K_24484 X_NUC_212.L_CORE X_NUC_220.L_CORE 0.004487
K_24485 X_NUC_212.L_CORE X_NUC_221.L_CORE 0.002022
K_24486 X_NUC_212.L_CORE X_NUC_222.L_CORE 0.002831
K_24487 X_NUC_213.L_CORE X_NUC_214.L_CORE 0.001684
K_24488 X_NUC_213.L_CORE X_NUC_215.L_CORE 0.002372
K_24489 X_NUC_213.L_CORE X_NUC_216.L_CORE 0.003635
K_24490 X_NUC_213.L_CORE X_NUC_217.L_CORE 0.001705
K_24491 X_NUC_213.L_CORE X_NUC_218.L_CORE 0.005080
K_24492 X_NUC_213.L_CORE X_NUC_219.L_CORE 0.002257
K_24493 X_NUC_213.L_CORE X_NUC_220.L_CORE 0.002202
K_24494 X_NUC_213.L_CORE X_NUC_221.L_CORE 0.004189
K_24495 X_NUC_213.L_CORE X_NUC_222.L_CORE 0.002328
K_24496 X_NUC_214.L_CORE X_NUC_215.L_CORE 0.001765
K_24497 X_NUC_214.L_CORE X_NUC_216.L_CORE 0.002494
K_24498 X_NUC_214.L_CORE X_NUC_217.L_CORE 0.003821
K_24499 X_NUC_214.L_CORE X_NUC_218.L_CORE 0.001816
K_24500 X_NUC_214.L_CORE X_NUC_219.L_CORE 0.005167
K_24501 X_NUC_214.L_CORE X_NUC_220.L_CORE 0.002434
K_24502 X_NUC_214.L_CORE X_NUC_221.L_CORE 0.002417
K_24503 X_NUC_214.L_CORE X_NUC_222.L_CORE 0.003697
K_24504 X_NUC_215.L_CORE X_NUC_216.L_CORE 0.001865
K_24505 X_NUC_215.L_CORE X_NUC_217.L_CORE 0.002648
K_24506 X_NUC_215.L_CORE X_NUC_218.L_CORE 0.004050
K_24507 X_NUC_215.L_CORE X_NUC_219.L_CORE 0.001960
K_24508 X_NUC_215.L_CORE X_NUC_220.L_CORE 0.005205
K_24509 X_NUC_215.L_CORE X_NUC_221.L_CORE 0.002679
K_24510 X_NUC_215.L_CORE X_NUC_222.L_CORE 0.002768
K_24511 X_NUC_216.L_CORE X_NUC_217.L_CORE 0.001992
K_24512 X_NUC_216.L_CORE X_NUC_218.L_CORE 0.002844
K_24513 X_NUC_216.L_CORE X_NUC_219.L_CORE 0.004335
K_24514 X_NUC_216.L_CORE X_NUC_220.L_CORE 0.002161
K_24515 X_NUC_216.L_CORE X_NUC_221.L_CORE 0.005124
K_24516 X_NUC_216.L_CORE X_NUC_222.L_CORE 0.003065
K_24517 X_NUC_217.L_CORE X_NUC_218.L_CORE 0.002158
K_24518 X_NUC_217.L_CORE X_NUC_219.L_CORE 0.003107
K_24519 X_NUC_217.L_CORE X_NUC_220.L_CORE 0.004693
K_24520 X_NUC_217.L_CORE X_NUC_221.L_CORE 0.002469
K_24521 X_NUC_217.L_CORE X_NUC_222.L_CORE 0.004720
K_24522 X_NUC_218.L_CORE X_NUC_219.L_CORE 0.002388
K_24523 X_NUC_218.L_CORE X_NUC_220.L_CORE 0.003480
K_24524 X_NUC_218.L_CORE X_NUC_221.L_CORE 0.005133
K_24525 X_NUC_218.L_CORE X_NUC_222.L_CORE 0.003070
K_24526 X_NUC_219.L_CORE X_NUC_220.L_CORE 0.002731
K_24527 X_NUC_219.L_CORE X_NUC_221.L_CORE 0.004061
K_24528 X_NUC_219.L_CORE X_NUC_222.L_CORE 0.005521
K_24529 X_NUC_220.L_CORE X_NUC_221.L_CORE 0.003321
K_24530 X_NUC_220.L_CORE X_NUC_222.L_CORE 0.005132
K_24531 X_NUC_221.L_CORE X_NUC_222.L_CORE 0.004751

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
