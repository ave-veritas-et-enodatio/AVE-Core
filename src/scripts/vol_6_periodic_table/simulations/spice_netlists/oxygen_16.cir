* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Oxygen-16 (Z=8, A=16)
* Auto-generated topological mutual impedance array
* Nodes: 16

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.006634
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.006429
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.006527
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.006527
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.006634
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.006527
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.006429
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.006527
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.006634
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.006527
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.006527
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.006429
K_16 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_17 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_18 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.006853
K_19 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.006634
K_20 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.006739
K_21 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.006739
K_22 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.006739
K_23 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.006634
K_24 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.006527
K_25 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.006631
K_26 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.006739
K_27 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.006634
K_28 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.006631
K_29 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.006527
K_30 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_31 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.006739
K_32 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.006527
K_33 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.006634
K_34 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.006631
K_35 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.006853
K_36 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.006739
K_37 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.006634
K_38 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.006739
K_39 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.006739
K_40 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.006631
K_41 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.006634
K_42 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.006527
K_43 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.006739
K_44 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.006527
K_45 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.006631
K_46 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.006634
K_47 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.006739
K_48 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.006631
K_49 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.006527
K_50 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.006634
K_51 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.006853
K_52 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.006739
K_53 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.006739
K_54 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.006634
K_55 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_56 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_57 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_58 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.006634
K_59 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.006739
K_60 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.006527
K_61 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.006631
K_62 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.006634
K_63 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.006739
K_64 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.006631
K_65 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.006527
K_66 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_67 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_68 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.006527
K_69 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.006634
K_70 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.006429
K_71 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.006527
K_72 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.006527
K_73 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.006634
K_74 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.006527
K_75 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.006429
K_76 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_77 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.006739
K_78 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.006853
K_79 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.006634
K_80 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.006739
K_81 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.006631
K_82 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.006739
K_83 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.006634
K_84 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.006527
K_85 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.006631
K_86 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.006739
K_87 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.006527
K_88 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.006634
K_89 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.006739
K_90 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.006853
K_91 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.006739
K_92 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.006634
K_93 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_94 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_95 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_96 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.006634
K_97 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.006631
K_98 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.006739
K_99 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.006527
K_100 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_101 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_102 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.006631
K_103 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.006634
K_104 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.006739
K_105 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.006527
K_106 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_107 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.006527
K_108 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.006527
K_109 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.006634
K_110 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.006429
K_111 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.006739
K_112 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.006739
K_113 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.006853
K_114 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.006634
K_115 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_116 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_117 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_118 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_119 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_120 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
