* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Argon-40 (Z=18, A=40)
* Auto-generated topological mutual impedance array
* Nodes: 40

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.009666
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.009264
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.009333
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.009462
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.010404
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.010571
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.010118
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.010548
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.010773
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.010523
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.010561
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.010248
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.006515
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.006407
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.006323
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.006452
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.008663
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.008838
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.008511
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.008541
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.006404
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.006280
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.006245
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.006232
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.005933
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.005921
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.005785
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.005874
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.006218
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.006202
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.006087
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.006078
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.026373
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.006220
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.006112
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.005427
K_40 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_41 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_42 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.010102
K_43 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.009666
K_44 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.009734
K_45 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.009880
K_46 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.010219
K_47 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.010404
K_48 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.009960
K_49 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.010368
K_50 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.011011
K_51 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.010773
K_52 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.010800
K_53 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.010465
K_54 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.006622
K_55 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.006515
K_56 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.006424
K_57 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.006559
K_58 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.008485
K_59 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.008663
K_60 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.008348
K_61 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.008377
K_62 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.006530
K_63 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.006404
K_64 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.006364
K_65 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.006350
K_66 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.005939
K_67 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.005933
K_68 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.005793
K_69 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.005883
K_70 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.006229
K_71 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.006218
K_72 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.006099
K_73 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.006090
K_74 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.024254
K_75 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.006396
K_76 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.006047
K_77 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.005458
K_78 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_79 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.010014
K_80 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.009579
K_81 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.009666
K_82 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.009798
K_83 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.010686
K_84 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.010883
K_85 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.010404
K_86 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.010857
K_87 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.010967
K_88 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.010718
K_89 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.010773
K_90 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.010428
K_91 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.006718
K_92 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.006604
K_93 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.006515
K_94 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.006653
K_95 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.008808
K_96 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.009000
K_97 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.008663
K_98 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.008687
K_99 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.006571
K_100 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.006439
K_101 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.006404
K_102 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.006387
K_103 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.006087
K_104 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.006077
K_105 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.005933
K_106 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.006026
K_107 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.006352
K_108 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.006338
K_109 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.006218
K_110 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.006206
K_111 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.023763
K_112 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.006370
K_113 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.006225
K_114 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.005518
K_115 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.009862
K_116 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.009446
K_117 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.009520
K_118 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.009666
K_119 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.010240
K_120 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.010413
K_121 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.009979
K_122 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.010404
K_123 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.011354
K_124 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.011078
K_125 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.011123
K_126 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.010773
K_127 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.006573
K_128 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.006465
K_129 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.006379
K_130 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.006515
K_131 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.008775
K_132 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.008965
K_133 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.008624
K_134 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.008663
K_135 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.006586
K_136 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.006454
K_137 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.006415
K_138 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.006404
K_139 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.005988
K_140 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.005979
K_141 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.005839
K_142 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.005933
K_143 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.006363
K_144 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006348
K_145 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.006225
K_146 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.006218
K_147 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.025745
K_148 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.006328
K_149 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.006107
K_150 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.005559
K_151 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_152 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_153 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_154 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.007176
K_155 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.007412
K_156 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.007218
K_157 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.007308
K_158 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.008839
K_159 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.009021
K_160 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.008982
K_161 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.008684
K_162 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.010616
K_163 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.010692
K_164 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.010222
K_165 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.010606
K_166 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.005749
K_167 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.005891
K_168 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.005775
K_169 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.005754
K_170 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.009167
K_171 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.009148
K_172 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008977
K_173 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008830
K_174 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.006226
K_175 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.006327
K_176 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.006142
K_177 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.006211
K_178 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.005933
K_179 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.006017
K_180 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.005894
K_181 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.005854
K_182 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.007249
K_183 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.016409
K_184 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.005168
K_185 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.005515
K_186 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_187 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_188 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.006954
K_189 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.007176
K_190 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.006996
K_191 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.007078
K_192 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.008653
K_193 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.008839
K_194 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.008795
K_195 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.008514
K_196 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.010515
K_197 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.010616
K_198 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.010143
K_199 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.010519
K_200 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.005612
K_201 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.005749
K_202 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.005638
K_203 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.005619
K_204 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.009169
K_205 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.009167
K_206 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008987
K_207 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008840
K_208 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.006125
K_209 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.006226
K_210 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.006047
K_211 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.006113
K_212 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.005847
K_213 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.005933
K_214 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.005812
K_215 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.005775
K_216 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.007033
K_217 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.017579
K_218 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.005067
K_219 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.005470
K_220 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_221 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.007126
K_222 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.007362
K_223 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.007176
K_224 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.007260
K_225 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.008687
K_226 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.008868
K_227 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.008839
K_228 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.008547
K_229 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.011029
K_230 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.011130
K_231 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.010616
K_232 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.011034
K_233 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.005719
K_234 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.005861
K_235 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.005749
K_236 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.005726
K_237 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.009351
K_238 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.009340
K_239 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.009167
K_240 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.009003
K_241 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.006309
K_242 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.006417
K_243 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.006226
K_244 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.006296
K_245 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.005967
K_246 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.006056
K_247 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.005933
K_248 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.005890
K_249 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.007051
K_250 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.017511
K_251 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.005182
K_252 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.005546
K_253 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.007043
K_254 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.007270
K_255 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.007087
K_256 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.007176
K_257 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.008986
K_258 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.009186
K_259 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.009145
K_260 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.008839
K_261 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.010598
K_262 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.010688
K_263 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.010218
K_264 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.010616
K_265 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.005738
K_266 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.005883
K_267 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.005767
K_268 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.005749
K_269 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.009526
K_270 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.009514
K_271 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.009322
K_272 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.009167
K_273 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.006236
K_274 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.006341
K_275 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.006154
K_276 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.006226
K_277 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.006009
K_278 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.006099
K_279 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.005971
K_280 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.005933
K_281 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.007153
K_282 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.017455
K_283 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.005134
K_284 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.005614
K_285 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_286 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_287 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_288 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.006313
K_289 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.006224
K_290 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.006333
K_291 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.006170
K_292 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.008175
K_293 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.007886
K_294 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.007928
K_295 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.007981
K_296 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.010419
K_297 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.010538
K_298 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.010433
K_299 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.010066
K_300 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.005566
K_301 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.005458
K_302 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.005502
K_303 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.005430
K_304 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.009167
K_305 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.009008
K_306 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008817
K_307 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.008858
K_308 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.006404
K_309 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.006346
K_310 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.006324
K_311 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.006218
K_312 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.008400
K_313 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.005339
K_314 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.012547
K_315 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.004985
K_316 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_317 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_318 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.006401
K_319 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.006313
K_320 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.006425
K_321 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.006254
K_322 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.008483
K_323 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.008175
K_324 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.008214
K_325 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.008274
K_326 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.010279
K_327 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.010419
K_328 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.010305
K_329 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.009951
K_330 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.005677
K_331 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.005566
K_332 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.005611
K_333 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.005534
K_334 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.009316
K_335 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.009167
K_336 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.008958
K_337 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.009000
K_338 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.006458
K_339 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.006404
K_340 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.006379
K_341 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.006270
K_342 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.008415
K_343 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.005475
K_344 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.012292
K_345 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.005029
K_346 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_347 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.006288
K_348 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.006202
K_349 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.006313
K_350 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.006149
K_351 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.008432
K_352 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.008123
K_353 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.008175
K_354 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.008227
K_355 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.010379
K_356 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.010510
K_357 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.010419
K_358 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.010042
K_359 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.005629
K_360 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.005519
K_361 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.005566
K_362 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.005490
K_363 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009542
K_364 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.009373
K_365 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.009167
K_366 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.009203
K_367 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.006482
K_368 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.006424
K_369 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.006404
K_370 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.006292
K_371 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.008162
K_372 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.005393
K_373 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.013023
K_374 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.005023
K_375 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.006461
K_376 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.006368
K_377 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.006485
K_378 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.006313
K_379 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.008370
K_380 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.008067
K_381 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.008111
K_382 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.008175
K_383 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.010783
K_384 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.010930
K_385 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.010813
K_386 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.010419
K_387 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.005710
K_388 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.005595
K_389 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.005642
K_390 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.005566
K_391 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.009491
K_392 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.009325
K_393 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.009114
K_394 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.009167
K_395 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.006602
K_396 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.006541
K_397 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.006517
K_398 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.006404
K_399 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.008461
K_400 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.005429
K_401 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.012783
K_402 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.005105
K_403 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_404 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_405 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_406 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.005986
K_407 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.005943
K_408 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.005869
K_409 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.006032
K_410 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.007984
K_411 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.008227
K_412 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.007945
K_413 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.008114
K_414 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.010419
K_415 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.010103
K_416 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.009926
K_417 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.010154
K_418 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.005749
K_419 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.005776
K_420 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.005643
K_421 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.005778
K_422 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.008663
K_423 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.008747
K_424 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.008413
K_425 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.008559
K_426 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.010015
K_427 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.007042
K_428 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.005081
K_429 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.008886
K_430 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_431 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_432 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.006025
K_433 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.005986
K_434 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.005908
K_435 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.006074
K_436 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.007751
K_437 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.007984
K_438 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.007720
K_439 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.007875
K_440 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.010738
K_441 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.010419
K_442 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.010213
K_443 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.010462
K_444 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.005718
K_445 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.005749
K_446 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.005616
K_447 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.005749
K_448 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.008567
K_449 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.008663
K_450 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008332
K_451 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.008473
K_452 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.009702
K_453 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.007226
K_454 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.005019
K_455 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.008883
K_456 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_457 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.006105
K_458 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.006062
K_459 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.005986
K_460 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.006156
K_461 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.008012
K_462 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.008263
K_463 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.007984
K_464 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.008149
K_465 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.010963
K_466 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.010611
K_467 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.010419
K_468 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.010669
K_469 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.005856
K_470 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.005887
K_471 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.005749
K_472 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.005890
K_473 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.008921
K_474 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.009021
K_475 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.008663
K_476 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.008815
K_477 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.009700
K_478 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.007201
K_479 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.005124
K_480 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.009175
K_481 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.005936
K_482 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.005896
K_483 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.005824
K_484 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.005986
K_485 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.007849
K_486 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.008085
K_487 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.007817
K_488 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.007984
K_489 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.010678
K_490 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.010352
K_491 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.010162
K_492 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.010419
K_493 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.005715
K_494 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.005744
K_495 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.005613
K_496 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.005749
K_497 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.008756
K_498 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.008850
K_499 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.008505
K_500 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.008663
K_501 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.009568
K_502 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.007041
K_503 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.005022
K_504 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.009146
K_505 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_506 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_507 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_508 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.005986
K_509 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.006130
K_510 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.006090
K_511 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.005992
K_512 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.008175
K_513 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.008121
K_514 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.008220
K_515 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.007931
K_516 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.010616
K_517 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.011040
K_518 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.010593
K_519 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.010537
K_520 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.006515
K_521 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.006605
K_522 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.006557
K_523 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.006411
K_524 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.005268
K_525 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.009954
K_526 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.007022
K_527 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.005471
K_528 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_529 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_530 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.005847
K_531 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.005986
K_532 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.005946
K_533 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.005855
K_534 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.008217
K_535 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.008175
K_536 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.008270
K_537 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.007976
K_538 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.010213
K_539 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.010616
K_540 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.010205
K_541 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.010155
K_542 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.006422
K_543 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.006515
K_544 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.006465
K_545 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.006325
K_546 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.005194
K_547 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.010278
K_548 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.006799
K_549 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.005439
K_550 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_551 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.005882
K_552 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.006021
K_553 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.005986
K_554 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.005890
K_555 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.008117
K_556 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.008071
K_557 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.008175
K_558 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.007885
K_559 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.010612
K_560 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.011051
K_561 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.010616
K_562 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.010547
K_563 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.006468
K_564 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.006559
K_565 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.006515
K_566 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.006369
K_567 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.005144
K_568 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.009846
K_569 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.006943
K_570 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.005445
K_571 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.005975
K_572 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.006121
K_573 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.006081
K_574 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.005986
K_575 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.008428
K_576 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.008376
K_577 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.008485
K_578 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.008175
K_579 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.010668
K_580 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.011115
K_581 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.010659
K_582 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.010616
K_583 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.006617
K_584 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.006716
K_585 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.006665
K_586 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.006515
K_587 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.005231
K_588 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.010178
K_589 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.006941
K_590 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.005568
K_591 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_592 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_593 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_594 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.006313
K_595 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.006130
K_596 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.006214
K_597 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.006190
K_598 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.008839
K_599 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.008622
K_600 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.008510
K_601 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.008767
K_602 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.010773
K_603 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.010371
K_604 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.010376
K_605 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.010279
K_606 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.008377
K_607 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.004718
K_608 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.010535
K_609 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.007343
K_610 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_611 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_612 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.006507
K_613 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.006313
K_614 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.006402
K_615 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.006376
K_616 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.009056
K_617 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.008839
K_618 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.008711
K_619 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.008987
K_620 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.011193
K_621 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.010773
K_622 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.010764
K_623 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.010655
K_624 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.008461
K_625 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.004824
K_626 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.010514
K_627 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.007533
K_628 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_629 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.006411
K_630 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.006223
K_631 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.006313
K_632 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.006285
K_633 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.009192
K_634 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.008957
K_635 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.008839
K_636 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.009120
K_637 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.011187
K_638 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.010753
K_639 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.010773
K_640 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.010650
K_641 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.008154
K_642 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.004758
K_643 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.010842
K_644 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.007476
K_645 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.006438
K_646 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.006247
K_647 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.006336
K_648 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.006313
K_649 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.008896
K_650 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.008683
K_651 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.008568
K_652 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.008839
K_653 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.011312
K_654 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.010865
K_655 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.010870
K_656 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.010773
K_657 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.008253
K_658 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.004745
K_659 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.010308
K_660 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.007600
K_661 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_662 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_663 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_664 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.007176
K_665 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.007337
K_666 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.007134
K_667 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.007324
K_668 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.010404
K_669 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.010896
K_670 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.010466
K_671 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.010482
K_672 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.005569
K_673 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.010437
K_674 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.005126
K_675 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.011555
K_676 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_677 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_678 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.007017
K_679 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.007176
K_680 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.006982
K_681 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.007159
K_682 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.009949
K_683 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.010404
K_684 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.010016
K_685 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.010030
K_686 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.005467
K_687 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.010702
K_688 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.005026
K_689 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.011138
K_690 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_691 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.007210
K_692 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.007378
K_693 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.007176
K_694 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.007364
K_695 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.010316
K_696 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.010811
K_697 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.010404
K_698 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.010406
K_699 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.005438
K_700 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.010417
K_701 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.005107
K_702 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.011456
K_703 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.007029
K_704 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.007184
K_705 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.006994
K_706 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.007176
K_707 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.010301
K_708 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.010793
K_709 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.010375
K_710 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.010404
K_711 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.005451
K_712 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.010179
K_713 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.005035
K_714 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.011748
K_715 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_716 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_717 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_718 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.009666
K_719 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.009643
K_720 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.009812
K_721 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.009381
K_722 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.005142
K_723 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.005703
K_724 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.013620
K_725 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.006647
K_726 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_727 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_728 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.009668
K_729 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.009666
K_730 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.009825
K_731 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.009392
K_732 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.005118
K_733 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.005829
K_734 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.012849
K_735 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.006691
K_736 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_737 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.009507
K_738 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.009495
K_739 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.009666
K_740 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.009244
K_741 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.005025
K_742 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.005681
K_743 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.013047
K_744 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.006599
K_745 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.009956
K_746 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.009943
K_747 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.010127
K_748 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.009666
K_749 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.005100
K_750 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.005734
K_751 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.012931
K_752 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.006806
K_753 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_754 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_755 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_756 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.005751
K_757 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.005569
K_758 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.007098
K_759 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.018886
K_760 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_761 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_762 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.005715
K_763 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.005684
K_764 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.006977
K_765 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.019859
K_766 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_767 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.005619
K_768 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.005577
K_769 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.007072
K_770 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.018901
K_771 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.005635
K_772 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.005542
K_773 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.006888
K_774 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.020421
K_775 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.005169
K_776 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.005507
K_777 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.005145
K_778 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.004424
K_779 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.005507
K_780 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.005169

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
