* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Cobalt-59 (Z=27, A=59)
* Auto-generated topological mutual impedance array
* Nodes: 59

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.008529
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.008212
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.008276
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.008377
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.009194
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.009338
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.008993
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.009341
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.009672
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.009464
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.009550
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.009257
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.005643
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.005557
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005503
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.005608
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.007986
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.008193
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.007915
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.007931
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.005582
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.005469
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.005472
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.005450
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.005101
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.005101
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.004998
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.005089
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.006037
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.006051
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.005971
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.005899
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.004436
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.004381
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.004345
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.004375
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.004879
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.004910
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.004804
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.004839
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.004576
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.004544
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.004503
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.004487
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.004160
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.004144
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.004086
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.004112
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.029279
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.006022
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.006137
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.005813
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.004032
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.004597
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.003790
K_59 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_60 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_61 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.008869
K_62 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.008529
K_63 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.008593
K_64 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.008706
K_65 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.009039
K_66 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.009194
K_67 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.008856
K_68 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.009188
K_69 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.009871
K_70 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.009672
K_71 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.009753
K_72 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.009441
K_73 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.005728
K_74 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.005643
K_75 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.005584
K_76 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.005694
K_77 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.007784
K_78 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.007986
K_79 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.007722
K_80 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.007738
K_81 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.005699
K_82 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.005582
K_83 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.005583
K_84 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.005560
K_85 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.005097
K_86 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.005101
K_87 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.004996
K_88 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.005087
K_89 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.006018
K_90 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.006037
K_91 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.005955
K_92 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.005884
K_93 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.004492
K_94 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.004436
K_95 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.004398
K_96 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.004429
K_97 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.004847
K_98 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.004879
K_99 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.004774
K_100 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.004809
K_101 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.004607
K_102 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.004576
K_103 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.004533
K_104 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.004517
K_105 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.004175
K_106 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.004160
K_107 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.004101
K_108 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.004127
K_109 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.026911
K_110 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.006194
K_111 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.006052
K_112 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.005864
K_113 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.004069
K_114 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.004557
K_115 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.003816
K_116 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_117 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.008790
K_118 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.008452
K_119 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.008529
K_120 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.008632
K_121 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.009390
K_122 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.009554
K_123 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.009194
K_124 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.009557
K_125 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.009777
K_126 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.009573
K_127 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.009672
K_128 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.009358
K_129 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.005789
K_130 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.005699
K_131 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.005643
K_132 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.005754
K_133 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.008048
K_134 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.008266
K_135 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.007986
K_136 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.007998
K_137 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.005696
K_138 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.005577
K_139 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.005582
K_140 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.005557
K_141 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.005207
K_142 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.005209
K_143 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.005101
K_144 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.005196
K_145 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.006101
K_146 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.006118
K_147 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.006037
K_148 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.005961
K_149 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.004531
K_150 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.004473
K_151 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.004436
K_152 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.004467
K_153 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.004956
K_154 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.004989
K_155 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.004879
K_156 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.004915
K_157 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.004651
K_158 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.004618
K_159 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.004576
K_160 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.004559
K_161 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.004237
K_162 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.004221
K_163 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.004160
K_164 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.004187
K_165 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.025777
K_166 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.006147
K_167 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.006219
K_168 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.005858
K_169 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.004111
K_170 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.004644
K_171 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.003848
K_172 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.008674
K_173 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.008349
K_174 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.008416
K_175 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.008529
K_176 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.009037
K_177 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.009182
K_178 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.008854
K_179 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.009194
K_180 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.010124
K_181 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.009898
K_182 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.009996
K_183 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.009672
K_184 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.005674
K_185 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.005589
K_186 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.005534
K_187 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.005643
K_188 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.008031
K_189 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.008248
K_190 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.007964
K_191 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.007986
K_192 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.005720
K_193 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.005600
K_194 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.005603
K_195 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.005582
K_196 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.005110
K_197 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.005112
K_198 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.005008
K_199 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.005101
K_200 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.006180
K_201 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006198
K_202 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.006112
K_203 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.006037
K_204 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.004498
K_205 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.004442
K_206 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.004405
K_207 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.004436
K_208 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.004918
K_209 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.004950
K_210 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.004842
K_211 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.004879
K_212 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.004668
K_213 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.004635
K_214 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.004592
K_215 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.004576
K_216 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.004209
K_217 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.004193
K_218 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.004133
K_219 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.004160
K_220 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.027835
K_221 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.006104
K_222 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.006078
K_223 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.005975
K_224 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.004061
K_225 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.004641
K_226 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.003850
K_227 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_228 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_229 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_230 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.006178
K_231 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.006352
K_232 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.006213
K_233 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.006280
K_234 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.007587
K_235 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.007718
K_236 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.007711
K_237 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.007480
K_238 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.009334
K_239 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.009368
K_240 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.009030
K_241 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.009370
K_242 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.004775
K_243 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.004878
K_244 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.004804
K_245 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.004789
K_246 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.008624
K_247 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.008533
K_248 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008473
K_249 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008293
K_250 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.005170
K_251 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.005245
K_252 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.005118
K_253 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.005190
K_254 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.004753
K_255 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.004818
K_256 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.004765
K_257 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.004710
K_258 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006455
K_259 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.006424
K_260 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.006284
K_261 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.006330
K_262 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.004204
K_263 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.004264
K_264 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.004186
K_265 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.004196
K_266 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.004915
K_267 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.004937
K_268 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.004872
K_269 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.004832
K_270 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.004576
K_271 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.004605
K_272 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.004515
K_273 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.004534
K_274 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.006817
K_275 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.019953
K_276 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.004701
K_277 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.005307
K_278 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.005554
K_279 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.003723
K_280 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.004378
K_281 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_282 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_283 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.006012
K_284 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.006178
K_285 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.006047
K_286 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.006109
K_287 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.007453
K_288 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.007587
K_289 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.007576
K_290 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.007356
K_291 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.009281
K_292 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.009334
K_293 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.008991
K_294 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.009326
K_295 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.004675
K_296 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.004775
K_297 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.004704
K_298 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.004690
K_299 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.008702
K_300 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.008624
K_301 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008555
K_302 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008370
K_303 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.005095
K_304 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.005170
K_305 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.005046
K_306 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.005116
K_307 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.004689
K_308 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.004753
K_309 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.004701
K_310 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.004648
K_311 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006480
K_312 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006455
K_313 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.006310
K_314 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.006357
K_315 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.004145
K_316 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.004204
K_317 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.004128
K_318 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.004138
K_319 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.004890
K_320 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.004915
K_321 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.004849
K_322 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.004810
K_323 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.004545
K_324 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.004576
K_325 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.004487
K_326 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.004505
K_327 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.006624
K_328 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.022034
K_329 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.004610
K_330 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.005266
K_331 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.005559
K_332 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.003675
K_333 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.004374
K_334 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_335 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.006138
K_336 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.006312
K_337 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.006178
K_338 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.006242
K_339 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.007459
K_340 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.007588
K_341 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.007587
K_342 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.007362
K_343 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.009649
K_344 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.009698
K_345 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.009334
K_346 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.009700
K_347 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.004743
K_348 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.004845
K_349 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.004775
K_350 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.004758
K_351 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.008766
K_352 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.008679
K_353 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.008624
K_354 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.008427
K_355 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.005221
K_356 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.005300
K_357 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.005170
K_358 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.005243
K_359 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.004739
K_360 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.004805
K_361 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.004753
K_362 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.004697
K_363 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006633
K_364 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006603
K_365 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006455
K_366 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006501
K_367 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.004221
K_368 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.004283
K_369 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.004204
K_370 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.004214
K_371 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.004957
K_372 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.004981
K_373 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.004915
K_374 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.004873
K_375 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.004638
K_376 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.004669
K_377 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.004576
K_378 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.004594
K_379 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.006639
K_380 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.021165
K_381 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.004694
K_382 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.005278
K_383 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.005688
K_384 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.003727
K_385 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.004432
K_386 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.006075
K_387 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.006243
K_388 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.006111
K_389 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.006178
K_390 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.007688
K_391 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.007829
K_392 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.007823
K_393 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.007587
K_394 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.009279
K_395 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.009323
K_396 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.008989
K_397 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.009334
K_398 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.004758
K_399 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.004862
K_400 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.004789
K_401 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.004775
K_402 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.008980
K_403 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.008886
K_404 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.008819
K_405 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.008624
K_406 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.005147
K_407 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.005222
K_408 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.005097
K_409 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.005170
K_410 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.004795
K_411 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.004863
K_412 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.004809
K_413 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.004753
K_414 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006581
K_415 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006551
K_416 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.006403
K_417 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006455
K_418 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.004211
K_419 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.004272
K_420 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.004193
K_421 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.004204
K_422 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.005000
K_423 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.005025
K_424 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.004955
K_425 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.004915
K_426 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.004618
K_427 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.004649
K_428 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.004556
K_429 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.004576
K_430 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.006723
K_431 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.021072
K_432 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.004650
K_433 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.005390
K_434 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.005588
K_435 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.003734
K_436 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.004449
K_437 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_438 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_439 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_440 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.005275
K_441 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.005213
K_442 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.005293
K_443 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.005177
K_444 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.006782
K_445 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.006580
K_446 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.006617
K_447 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.006663
K_448 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.008913
K_449 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.009056
K_450 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.008994
K_451 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.008704
K_452 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.004393
K_453 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.004321
K_454 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.004359
K_455 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.004312
K_456 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.008851
K_457 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.008722
K_458 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008497
K_459 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.008656
K_460 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.004976
K_461 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.004960
K_462 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.004970
K_463 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.004875
K_464 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.004619
K_465 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.004539
K_466 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.004540
K_467 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.004531
K_468 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006565
K_469 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006585
K_470 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006453
K_471 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006416
K_472 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.004204
K_473 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.004165
K_474 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.004165
K_475 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.004121
K_476 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.004879
K_477 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.004831
K_478 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.004788
K_479 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.004779
K_480 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.007710
K_481 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.004822
K_482 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.017192
K_483 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.004101
K_484 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.004840
K_485 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.005249
K_486 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.003706
K_487 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_488 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_489 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.005336
K_490 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.005275
K_491 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.005356
K_492 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.005236
K_493 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.006997
K_494 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.006782
K_495 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.006819
K_496 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.006870
K_497 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.008760
K_498 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.008913
K_499 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.008845
K_500 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.008569
K_501 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.004466
K_502 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.004393
K_503 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.004432
K_504 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.004382
K_505 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.008968
K_506 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.008851
K_507 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.008608
K_508 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.008774
K_509 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.004989
K_510 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.004976
K_511 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.004984
K_512 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.004889
K_513 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.004702
K_514 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.004619
K_515 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.004620
K_516 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.004610
K_517 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006540
K_518 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006565
K_519 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006432
K_520 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.006395
K_521 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.004243
K_522 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.004204
K_523 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.004204
K_524 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.004158
K_525 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.004926
K_526 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.004879
K_527 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.004833
K_528 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.004825
K_529 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.007749
K_530 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.004932
K_531 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.016328
K_532 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.004132
K_533 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.004928
K_534 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.005216
K_535 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.003741
K_536 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_537 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.005255
K_538 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.005195
K_539 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.005275
K_540 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.005159
K_541 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.006953
K_542 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.006739
K_543 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.006782
K_544 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.006829
K_545 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.008818
K_546 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.008965
K_547 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.008913
K_548 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.008623
K_549 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.004425
K_550 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.004353
K_551 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.004393
K_552 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.004343
K_553 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009234
K_554 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.009098
K_555 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.008851
K_556 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.009023
K_557 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.004980
K_558 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.004965
K_559 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.004976
K_560 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.004880
K_561 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.004700
K_562 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.004616
K_563 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.004619
K_564 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.004608
K_565 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006677
K_566 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006701
K_567 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006565
K_568 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006523
K_569 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.004242
K_570 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.004203
K_571 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.004204
K_572 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.004158
K_573 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.004973
K_574 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.004924
K_575 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.004879
K_576 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.004869
K_577 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.007522
K_578 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.004856
K_579 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.017673
K_580 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.004098
K_581 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.004948
K_582 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.005281
K_583 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.003747
K_584 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.005375
K_585 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.005312
K_586 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.005396
K_587 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.005275
K_588 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.006900
K_589 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.006691
K_590 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.006730
K_591 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.006782
K_592 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.009120
K_593 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.009283
K_594 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.009216
K_595 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.008913
K_596 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.004476
K_597 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.004402
K_598 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.004442
K_599 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.004393
K_600 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.009041
K_601 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.008913
K_602 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.008673
K_603 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.008851
K_604 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.005081
K_605 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.005066
K_606 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.005076
K_607 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.004976
K_608 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.004710
K_609 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.004626
K_610 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.004627
K_611 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.004619
K_612 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006719
K_613 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006743
K_614 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006602
K_615 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006565
K_616 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.004291
K_617 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.004250
K_618 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.004250
K_619 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.004204
K_620 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.004983
K_621 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.004933
K_622 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.004887
K_623 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.004879
K_624 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.007772
K_625 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.004887
K_626 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.016880
K_627 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.004170
K_628 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.004914
K_629 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.005344
K_630 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.003773
K_631 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_632 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_633 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_634 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.004812
K_635 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.004783
K_636 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.004737
K_637 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.004843
K_638 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.006341
K_639 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.006504
K_640 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.006337
K_641 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.006437
K_642 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.008629
K_643 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.008356
K_644 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.008308
K_645 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.008438
K_646 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.004209
K_647 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.004227
K_648 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.004160
K_649 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.004238
K_650 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.008930
K_651 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.009143
K_652 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.008803
K_653 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.008809
K_654 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.004917
K_655 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.004868
K_656 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.004808
K_657 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.004889
K_658 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.004619
K_659 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.004668
K_660 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.004567
K_661 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.004632
K_662 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006455
K_663 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006424
K_664 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006284
K_665 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006330
K_666 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.004436
K_667 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.004436
K_668 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.004357
K_669 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.004418
K_670 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.009018
K_671 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.006206
K_672 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.004262
K_673 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.013748
K_674 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.003895
K_675 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.004732
K_676 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.004839
K_677 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_678 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_679 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.004838
K_680 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.004812
K_681 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.004764
K_682 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.004872
K_683 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.006184
K_684 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.006341
K_685 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.006183
K_686 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.006276
K_687 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.008916
K_688 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.008629
K_689 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.008570
K_690 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.008712
K_691 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.004191
K_692 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.004209
K_693 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.004143
K_694 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.004220
K_695 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.008715
K_696 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.008930
K_697 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008605
K_698 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.008611
K_699 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.004965
K_700 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.004917
K_701 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.004854
K_702 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.004937
K_703 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.004570
K_704 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.004619
K_705 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.004520
K_706 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.004583
K_707 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006480
K_708 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006455
K_709 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006310
K_710 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006357
K_711 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.004434
K_712 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.004436
K_713 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.004356
K_714 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.004417
K_715 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.008784
K_716 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.006336
K_717 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.004216
K_718 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.013821
K_719 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.003914
K_720 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.004664
K_721 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.004869
K_722 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_723 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.004887
K_724 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.004858
K_725 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.004812
K_726 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.004921
K_727 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.006340
K_728 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.006506
K_729 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.006341
K_730 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.006439
K_731 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.008974
K_732 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.008675
K_733 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.008629
K_734 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.008767
K_735 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.004259
K_736 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.004277
K_737 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.004209
K_738 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.004290
K_739 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.009045
K_740 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.009276
K_741 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.008930
K_742 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.008928
K_743 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.005031
K_744 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.004980
K_745 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.004917
K_746 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.005002
K_747 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.004671
K_748 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.004722
K_749 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.004619
K_750 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.004685
K_751 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006633
K_752 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006603
K_753 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006455
K_754 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.006501
K_755 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.004518
K_756 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.004519
K_757 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.004436
K_758 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.004500
K_759 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.008809
K_760 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.006311
K_761 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.004279
K_762 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.014011
K_763 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.003958
K_764 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.004769
K_765 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.004947
K_766 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.004778
K_767 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.004751
K_768 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.004706
K_769 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.004812
K_770 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.006243
K_771 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.006402
K_772 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.006242
K_773 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.006341
K_774 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.008819
K_775 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.008534
K_776 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.008484
K_777 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.008629
K_778 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.004179
K_779 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.004197
K_780 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.004132
K_781 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.004209
K_782 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.009038
K_783 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.009268
K_784 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.008915
K_785 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.008930
K_786 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.004943
K_787 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.004895
K_788 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.004834
K_789 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.004917
K_790 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.004604
K_791 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.004654
K_792 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.004554
K_793 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.004619
K_794 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006581
K_795 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006551
K_796 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006403
K_797 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006455
K_798 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.004453
K_799 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.004454
K_800 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.004373
K_801 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.004436
K_802 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.008646
K_803 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.006180
K_804 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.004206
K_805 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.014629
K_806 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.003892
K_807 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.004728
K_808 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.004908
K_809 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_810 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_811 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_812 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.004563
K_813 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.004648
K_814 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.004626
K_815 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.004570
K_816 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.006114
K_817 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.006069
K_818 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.006146
K_819 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.005981
K_820 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.008491
K_821 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.008800
K_822 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.008489
K_823 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.008548
K_824 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.004154
K_825 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.004193
K_826 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.004189
K_827 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.004121
K_828 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.008930
K_829 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.008811
K_830 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.008737
K_831 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.008572
K_832 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.004976
K_833 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.005069
K_834 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.004992
K_835 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.004956
K_836 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.004753
K_837 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.004768
K_838 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.004754
K_839 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.004672
K_840 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006037
K_841 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006093
K_842 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.005979
K_843 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.005929
K_844 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.004734
K_845 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.008505
K_846 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.005725
K_847 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.003982
K_848 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.011366
K_849 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.003937
K_850 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.004654
K_851 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_852 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_853 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.004481
K_854 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.004563
K_855 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.004542
K_856 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.004489
K_857 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.006154
K_858 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.006114
K_859 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.006190
K_860 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.006021
K_861 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.008200
K_862 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.008491
K_863 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.008205
K_864 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.008257
K_865 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.004114
K_866 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.004154
K_867 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.004150
K_868 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.004083
K_869 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.009037
K_870 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.008930
K_871 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.008845
K_872 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.008674
K_873 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.004885
K_874 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.004976
K_875 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.004902
K_876 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.004867
K_877 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.004737
K_878 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.004753
K_879 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.004739
K_880 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.004658
K_881 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.005979
K_882 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006037
K_883 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.005924
K_884 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.005876
K_885 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.004673
K_886 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.008683
K_887 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.005571
K_888 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.003968
K_889 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.011490
K_890 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.003883
K_891 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.004655
K_892 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_893 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.004500
K_894 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.004582
K_895 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.004563
K_896 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.004508
K_897 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.006077
K_898 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.006036
K_899 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.006114
K_900 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.005949
K_901 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.008479
K_902 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.008795
K_903 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.008491
K_904 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.008543
K_905 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.004118
K_906 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.004157
K_907 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.004154
K_908 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.004086
K_909 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.009118
K_910 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.009000
K_911 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.008930
K_912 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.008746
K_913 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.004957
K_914 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.005051
K_915 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.004976
K_916 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.004939
K_917 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.004750
K_918 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.004765
K_919 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.004753
K_920 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.004670
K_921 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006092
K_922 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006152
K_923 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006037
K_924 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.005983
K_925 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.004635
K_926 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.008361
K_927 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.005642
K_928 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.003946
K_929 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.011959
K_930 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.003917
K_931 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.004680
K_932 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.004554
K_933 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.004639
K_934 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.004618
K_935 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.004563
K_936 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.006251
K_937 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.006206
K_938 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.006288
K_939 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.006114
K_940 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.008423
K_941 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.008731
K_942 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.008427
K_943 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.008491
K_944 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.004186
K_945 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.004227
K_946 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.004223
K_947 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.004154
K_948 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.009318
K_949 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.009192
K_950 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.009108
K_951 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.008930
K_952 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.004994
K_953 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.005090
K_954 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.005012
K_955 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.004976
K_956 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.004836
K_957 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.004852
K_958 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.004838
K_959 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.004753
K_960 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006146
K_961 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.006208
K_962 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006088
K_963 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006037
K_964 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.004708
K_965 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.008622
K_966 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.005643
K_967 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.004020
K_968 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.011761
K_969 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.003953
K_970 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.004747
K_971 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_972 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_973 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_974 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.004453
K_975 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.004361
K_976 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.004407
K_977 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.004393
K_978 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.006044
K_979 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.005958
K_980 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.005902
K_981 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.006045
K_982 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.008491
K_983 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.008291
K_984 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.008385
K_985 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.008172
K_986 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.004209
K_987 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.004133
K_988 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.004141
K_989 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.004164
K_990 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.008851
K_991 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.008754
K_992 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.008503
K_993 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.008681
K_994 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.005170
K_995 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.005070
K_996 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.005082
K_997 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.005055
K_998 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.005101
K_999 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.005019
K_1000 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.004981
K_1001 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.005024
K_1002 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.007691
K_1003 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.003940
K_1004 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.008225
K_1005 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.005340
K_1006 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.003898
K_1007 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.009362
K_1008 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.004172
K_1009 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_1010 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_1011 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.004549
K_1012 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.004453
K_1013 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.004501
K_1014 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.004486
K_1015 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.006128
K_1016 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.006044
K_1017 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.005983
K_1018 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.006132
K_1019 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.008692
K_1020 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.008491
K_1021 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.008585
K_1022 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.008357
K_1023 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.004288
K_1024 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.004209
K_1025 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.004216
K_1026 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.004241
K_1027 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.008934
K_1028 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.008851
K_1029 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.008584
K_1030 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.008767
K_1031 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.005272
K_1032 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.005170
K_1033 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.005181
K_1034 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.005153
K_1035 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.005183
K_1036 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.005101
K_1037 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.005060
K_1038 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.005104
K_1039 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.007829
K_1040 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.004012
K_1041 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.008240
K_1042 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.005442
K_1043 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.003956
K_1044 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.009343
K_1045 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.004238
K_1046 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_1047 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.004498
K_1048 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.004404
K_1049 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.004453
K_1050 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.004437
K_1051 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.006191
K_1052 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.006101
K_1053 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.006044
K_1054 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.006195
K_1055 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.008587
K_1056 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.008387
K_1057 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.008491
K_1058 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.008263
K_1059 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.004280
K_1060 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.004201
K_1061 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.004209
K_1062 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.004233
K_1063 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.009226
K_1064 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.009126
K_1065 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.008851
K_1066 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.009043
K_1067 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.005259
K_1068 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.005156
K_1069 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.005170
K_1070 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.005140
K_1071 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.005226
K_1072 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.005140
K_1073 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.005101
K_1074 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.005145
K_1075 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.007558
K_1076 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.003966
K_1077 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.008348
K_1078 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.005354
K_1079 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.003961
K_1080 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.009657
K_1081 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.004240
K_1082 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.004513
K_1083 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.004418
K_1084 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.004466
K_1085 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.004453
K_1086 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.006038
K_1087 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.005954
K_1088 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.005898
K_1089 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.006044
K_1090 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.008836
K_1091 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.008618
K_1092 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.008724
K_1093 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.008491
K_1094 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.004255
K_1095 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.004177
K_1096 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.004185
K_1097 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.004209
K_1098 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.009014
K_1099 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.008920
K_1100 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.008655
K_1101 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.008851
K_1102 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.005289
K_1103 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.005184
K_1104 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.005197
K_1105 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.005170
K_1106 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.005178
K_1107 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.005095
K_1108 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.005055
K_1109 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.005101
K_1110 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.007619
K_1111 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.003956
K_1112 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.008033
K_1113 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.005448
K_1114 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.003918
K_1115 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.009661
K_1116 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.004245
K_1117 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_1118 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_1119 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_1120 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.004453
K_1121 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.004513
K_1122 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.004439
K_1123 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.004514
K_1124 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.006114
K_1125 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.006287
K_1126 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.006192
K_1127 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.006143
K_1128 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.008629
K_1129 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.008640
K_1130 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.008365
K_1131 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.008666
K_1132 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.004393
K_1133 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.004473
K_1134 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.004391
K_1135 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.004429
K_1136 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.008624
K_1137 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.008836
K_1138 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.008534
K_1139 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.008510
K_1140 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.005582
K_1141 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.005659
K_1142 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.005510
K_1143 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.005597
K_1144 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.004927
K_1145 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.009132
K_1146 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.003757
K_1147 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.008204
K_1148 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.005384
K_1149 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.004122
K_1150 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.007266
K_1151 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_1152 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_1153 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.004393
K_1154 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.004453
K_1155 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.004381
K_1156 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.004453
K_1157 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.005950
K_1158 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.006114
K_1159 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.006025
K_1160 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.005979
K_1161 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.008604
K_1162 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.008629
K_1163 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.008349
K_1164 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.008648
K_1165 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.004315
K_1166 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.004393
K_1167 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.004314
K_1168 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.004350
K_1169 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.008412
K_1170 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.008624
K_1171 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.008335
K_1172 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.008312
K_1173 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.005504
K_1174 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.005582
K_1175 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.005437
K_1176 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.005521
K_1177 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.004838
K_1178 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.009204
K_1179 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.003703
K_1180 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.007988
K_1181 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.005368
K_1182 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.004048
K_1183 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.007198
K_1184 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_1185 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.004464
K_1186 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.004526
K_1187 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.004453
K_1188 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.004527
K_1189 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.006034
K_1190 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.006202
K_1191 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.006114
K_1192 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.006064
K_1193 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.008904
K_1194 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.008924
K_1195 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.008629
K_1196 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.008953
K_1197 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.004392
K_1198 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.004474
K_1199 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.004393
K_1200 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.004430
K_1201 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.008701
K_1202 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.008928
K_1203 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.008624
K_1204 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.008591
K_1205 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.005653
K_1206 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.005735
K_1207 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.005582
K_1208 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.005670
K_1209 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.004832
K_1210 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.009064
K_1211 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.003742
K_1212 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.007982
K_1213 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.005468
K_1214 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.004110
K_1215 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.007426
K_1216 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.004392
K_1217 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.004450
K_1218 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.004380
K_1219 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.004453
K_1220 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.006081
K_1221 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.006253
K_1222 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.006160
K_1223 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.006114
K_1224 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.008579
K_1225 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.008596
K_1226 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.008325
K_1227 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.008629
K_1228 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.004355
K_1229 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.004434
K_1230 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.004354
K_1231 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.004393
K_1232 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.008727
K_1233 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.008956
K_1234 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.008641
K_1235 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.008624
K_1236 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.005563
K_1237 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.005642
K_1238 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.005494
K_1239 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.005582
K_1240 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.004830
K_1241 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.008838
K_1242 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.003703
K_1243 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.008211
K_1244 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.005333
K_1245 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.004099
K_1246 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.007384
K_1247 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_1248 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_1249 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_1250 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.004563
K_1251 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.004568
K_1252 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.004609
K_1253 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.004510
K_1254 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.006341
K_1255 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.006179
K_1256 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.006269
K_1257 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.006185
K_1258 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.008913
K_1259 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.009092
K_1260 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.009001
K_1261 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.008729
K_1262 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.004775
K_1263 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.004736
K_1264 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.004775
K_1265 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.004682
K_1266 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.007986
K_1267 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.007866
K_1268 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.007849
K_1269 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.007693
K_1270 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.004458
K_1271 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.004525
K_1272 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.010351
K_1273 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.003694
K_1274 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.008033
K_1275 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.005632
K_1276 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.004598
K_1277 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_1278 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_1279 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.004556
K_1280 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.004563
K_1281 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.004604
K_1282 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.004505
K_1283 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.006510
K_1284 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.006341
K_1285 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.006435
K_1286 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.006344
K_1287 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.008728
K_1288 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.008913
K_1289 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.008819
K_1290 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.008563
K_1291 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.004811
K_1292 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.004775
K_1293 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.004813
K_1294 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.004718
K_1295 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.008100
K_1296 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.007986
K_1297 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.007963
K_1298 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.007801
K_1299 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.004450
K_1300 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.004598
K_1301 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.009972
K_1302 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.003707
K_1303 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.008348
K_1304 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.005560
K_1305 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.004648
K_1306 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_1307 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.004516
K_1308 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.004522
K_1309 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.004563
K_1310 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.004466
K_1311 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.006410
K_1312 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.006245
K_1313 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.006341
K_1314 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.006251
K_1315 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.008811
K_1316 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.008992
K_1317 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.008913
K_1318 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.008641
K_1319 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.004772
K_1320 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.004735
K_1321 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.004775
K_1322 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.004681
K_1323 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.008119
K_1324 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.007998
K_1325 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.007986
K_1326 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.007817
K_1327 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.004376
K_1328 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.004503
K_1329 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.009895
K_1330 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.003665
K_1331 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.008239
K_1332 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.005577
K_1333 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.004624
K_1334 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.004616
K_1335 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.004622
K_1336 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.004665
K_1337 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.004563
K_1338 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.006504
K_1339 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.006332
K_1340 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.006429
K_1341 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.006341
K_1342 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.009091
K_1343 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.009291
K_1344 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.009194
K_1345 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.008913
K_1346 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.004870
K_1347 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.004831
K_1348 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.004872
K_1349 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.004775
K_1350 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.008302
K_1351 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.008173
K_1352 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.008154
K_1353 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.007986
K_1354 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.004445
K_1355 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.004552
K_1356 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.009992
K_1357 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.003730
K_1358 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.008226
K_1359 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.005698
K_1360 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.004698
K_1361 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_1362 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_1363 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_1364 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.004812
K_1365 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.004733
K_1366 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.004727
K_1367 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.004803
K_1368 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.006782
K_1369 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.006841
K_1370 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.006670
K_1371 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.006874
K_1372 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.009334
K_1373 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.009013
K_1374 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.008959
K_1375 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.009086
K_1376 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.005643
K_1377 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.005589
K_1378 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.005510
K_1379 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.005634
K_1380 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.005800
K_1381 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.004170
K_1382 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.004526
K_1383 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.010938
K_1384 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.003841
K_1385 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.008598
K_1386 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.006066
K_1387 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_1388 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_1389 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.004891
K_1390 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.004812
K_1391 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.004804
K_1392 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.004883
K_1393 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.006718
K_1394 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.006782
K_1395 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.006612
K_1396 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.006811
K_1397 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.009671
K_1398 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.009334
K_1399 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.009266
K_1400 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.009406
K_1401 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.005694
K_1402 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.005643
K_1403 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.005559
K_1404 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.005686
K_1405 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.005794
K_1406 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.004231
K_1407 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.004499
K_1408 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.011395
K_1409 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.003877
K_1410 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.008383
K_1411 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.006195
K_1412 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_1413 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.004898
K_1414 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.004817
K_1415 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.004812
K_1416 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.004890
K_1417 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.006892
K_1418 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.006958
K_1419 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.006782
K_1420 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.006993
K_1421 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.009738
K_1422 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.009384
K_1423 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.009334
K_1424 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.009467
K_1425 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.005782
K_1426 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.005726
K_1427 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.005643
K_1428 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.005774
K_1429 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.005711
K_1430 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.004189
K_1431 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.004531
K_1432 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.010845
K_1433 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.003891
K_1434 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.008713
K_1435 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.006241
K_1436 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.004818
K_1437 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.004740
K_1438 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.004734
K_1439 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.004812
K_1440 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.006687
K_1441 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.006747
K_1442 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.006583
K_1443 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.006782
K_1444 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.009583
K_1445 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.009245
K_1446 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.009188
K_1447 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.009334
K_1448 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.005648
K_1449 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.005596
K_1450 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.005516
K_1451 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.005643
K_1452 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.005668
K_1453 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.004150
K_1454 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.004445
K_1455 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.011137
K_1456 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.003830
K_1457 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.008477
K_1458 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.006166
K_1459 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_1460 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_1461 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_1462 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.005275
K_1463 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.005412
K_1464 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.005335
K_1465 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.005328
K_1466 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.007587
K_1467 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.007718
K_1468 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.007711
K_1469 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.007480
K_1470 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.009672
K_1471 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.010062
K_1472 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.009671
K_1473 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.009687
K_1474 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.003891
K_1475 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.006775
K_1476 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.004252
K_1477 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.004695
K_1478 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.012557
K_1479 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.004338
K_1480 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.008777
K_1481 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_1482 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_1483 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.005145
K_1484 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.005275
K_1485 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.005202
K_1486 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.005196
K_1487 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.007453
K_1488 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.007587
K_1489 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.007575
K_1490 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.007356
K_1491 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.009305
K_1492 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.009672
K_1493 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.009314
K_1494 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.009328
K_1495 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.003848
K_1496 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.006812
K_1497 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.004176
K_1498 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.004656
K_1499 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.012409
K_1500 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.004254
K_1501 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.008677
K_1502 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_1503 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.005214
K_1504 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.005348
K_1505 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.005275
K_1506 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.005267
K_1507 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.007459
K_1508 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.007588
K_1509 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.007587
K_1510 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.007362
K_1511 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.009652
K_1512 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.010052
K_1513 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.009672
K_1514 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.009678
K_1515 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.003820
K_1516 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.006622
K_1517 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.004198
K_1518 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.004610
K_1519 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.012773
K_1520 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.004291
K_1521 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.008766
K_1522 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.005220
K_1523 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.005354
K_1524 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.005280
K_1525 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.005275
K_1526 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.007688
K_1527 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.007830
K_1528 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.007822
K_1529 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.007587
K_1530 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.009636
K_1531 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.010033
K_1532 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.009645
K_1533 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.009672
K_1534 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.003846
K_1535 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.006672
K_1536 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.004179
K_1537 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.004703
K_1538 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.012059
K_1539 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.004317
K_1540 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.009037
K_1541 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_1542 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_1543 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_1544 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.006178
K_1545 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.006038
K_1546 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.006147
K_1547 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.006037
K_1548 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.009194
K_1549 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.008829
K_1550 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.008890
K_1551 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.008932
K_1552 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.004473
K_1553 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.003708
K_1554 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.007561
K_1555 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.004425
K_1556 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.005065
K_1557 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.014769
K_1558 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.005440
K_1559 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_1560 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_1561 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.006322
K_1562 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.006178
K_1563 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.006291
K_1564 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.006174
K_1565 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.009588
K_1566 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.009194
K_1567 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.009254
K_1568 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.009301
K_1569 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.004488
K_1570 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.003762
K_1571 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.007516
K_1572 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.004471
K_1573 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.005176
K_1574 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.014301
K_1575 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.005566
K_1576 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_1577 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.006204
K_1578 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.006065
K_1579 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.006178
K_1580 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.006064
K_1581 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.009512
K_1582 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.009118
K_1583 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.009194
K_1584 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.009232
K_1585 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.004401
K_1586 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.003703
K_1587 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.007432
K_1588 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.004388
K_1589 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.005134
K_1590 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.014228
K_1591 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.005505
K_1592 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.006323
K_1593 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.006176
K_1594 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.006292
K_1595 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.006178
K_1596 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.009461
K_1597 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.009073
K_1598 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.009139
K_1599 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.009194
K_1600 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.004437
K_1601 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.003710
K_1602 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.007315
K_1603 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.004464
K_1604 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.005078
K_1605 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.015130
K_1606 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.005563
K_1607 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_1608 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_1609 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_1610 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.008529
K_1611 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.008593
K_1612 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.008354
K_1613 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.008691
K_1614 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.004195
K_1615 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.004700
K_1616 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.003920
K_1617 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.008118
K_1618 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.005009
K_1619 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.006245
K_1620 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.016841
K_1621 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_1622 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_1623 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.008452
K_1624 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.008529
K_1625 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.008289
K_1626 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.008617
K_1627 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.004163
K_1628 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.004744
K_1629 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.003878
K_1630 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.008078
K_1631 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.005038
K_1632 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.006069
K_1633 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.017623
K_1634 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_1635 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.008699
K_1636 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.008776
K_1637 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.008529
K_1638 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.008880
K_1639 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.004127
K_1640 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.004677
K_1641 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.003894
K_1642 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.007839
K_1643 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.005059
K_1644 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.006173
K_1645 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.018317
K_1646 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.008361
K_1647 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.008429
K_1648 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.008203
K_1649 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.008529
K_1650 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.004122
K_1651 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.004641
K_1652 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.003849
K_1653 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.008035
K_1654 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.004947
K_1655 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.006127
K_1656 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.017504
K_1657 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_1658 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_1659 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_1660 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.003738
K_1661 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.004335
K_1662 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.004980
K_1663 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.004464
K_1664 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.008079
K_1665 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.006620
K_1666 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.009627
K_1667 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_1668 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_1669 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.003721
K_1670 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.004379
K_1671 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.004908
K_1672 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.004468
K_1673 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.008266
K_1674 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.006441
K_1675 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.009874
K_1676 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_1677 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.003676
K_1678 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.004295
K_1679 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.004895
K_1680 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.004392
K_1681 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.008142
K_1682 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.006458
K_1683 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.009621
K_1684 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.003700
K_1685 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.004310
K_1686 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.004868
K_1687 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.004474
K_1688 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.007956
K_1689 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.006553
K_1690 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.010002
K_1691 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.005152
K_1692 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.005536
K_1693 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.005637
K_1694 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.003550
K_1695 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.004388
K_1696 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.003478
K_1697 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.003924
K_1698 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.004848
K_1699 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.005645
K_1700 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.003311
K_1701 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.004388
K_1702 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.003575
K_1703 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.004668
K_1704 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.005645
K_1705 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.003550
K_1706 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.003575
K_1707 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.004848
K_1708 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.005637
K_1709 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.003924
K_1710 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.005536
K_1711 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.005152

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
