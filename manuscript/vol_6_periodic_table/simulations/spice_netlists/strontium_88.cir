* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Strontium-88 (Z=38, A=88)
* Auto-generated topological mutual impedance array
* Nodes: 88

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON
X_NUC_65 NODE_65 0 NUCLEON
X_NUC_66 NODE_66 0 NUCLEON
X_NUC_67 NODE_67 0 NUCLEON
X_NUC_68 NODE_68 0 NUCLEON
X_NUC_69 NODE_69 0 NUCLEON
X_NUC_70 NODE_70 0 NUCLEON
X_NUC_71 NODE_71 0 NUCLEON
X_NUC_72 NODE_72 0 NUCLEON
X_NUC_73 NODE_73 0 NUCLEON
X_NUC_74 NODE_74 0 NUCLEON
X_NUC_75 NODE_75 0 NUCLEON
X_NUC_76 NODE_76 0 NUCLEON
X_NUC_77 NODE_77 0 NUCLEON
X_NUC_78 NODE_78 0 NUCLEON
X_NUC_79 NODE_79 0 NUCLEON
X_NUC_80 NODE_80 0 NUCLEON
X_NUC_81 NODE_81 0 NUCLEON
X_NUC_82 NODE_82 0 NUCLEON
X_NUC_83 NODE_83 0 NUCLEON
X_NUC_84 NODE_84 0 NUCLEON
X_NUC_85 NODE_85 0 NUCLEON
X_NUC_86 NODE_86 0 NUCLEON
X_NUC_87 NODE_87 0 NUCLEON
X_NUC_88 NODE_88 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.007349
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.007111
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.007165
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.007240
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.007930
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.008043
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.007793
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.008058
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.008426
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.008266
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.008364
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.008119
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.004809
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.004745
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.004711
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.004791
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.007069
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.007260
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.007049
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.007057
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.004777
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.004687
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.004704
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.004683
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.004340
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.004344
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.004271
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.004345
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.005441
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.005464
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.005418
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.005333
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.003706
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.003659
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.003643
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.003667
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.004295
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.004340
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.004252
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.004287
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.004012
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.003976
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.003968
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.003936
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.003375
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.003360
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.003323
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.003358
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.003995
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.004022
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.003965
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.003952
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.003279
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.003249
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.003234
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.003236
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.003304
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.003311
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.003263
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.003287
K_64 X_NUC_1.L_CORE X_NUC_65.L_CORE 0.003408
K_65 X_NUC_1.L_CORE X_NUC_66.L_CORE 0.003402
K_66 X_NUC_1.L_CORE X_NUC_67.L_CORE 0.003374
K_67 X_NUC_1.L_CORE X_NUC_68.L_CORE 0.003360
K_68 X_NUC_1.L_CORE X_NUC_69.L_CORE 0.003005
K_69 X_NUC_1.L_CORE X_NUC_70.L_CORE 0.002991
K_70 X_NUC_1.L_CORE X_NUC_71.L_CORE 0.002965
K_71 X_NUC_1.L_CORE X_NUC_72.L_CORE 0.002977
K_72 X_NUC_1.L_CORE X_NUC_73.L_CORE 0.003123
K_73 X_NUC_1.L_CORE X_NUC_74.L_CORE 0.003125
K_74 X_NUC_1.L_CORE X_NUC_75.L_CORE 0.003089
K_75 X_NUC_1.L_CORE X_NUC_76.L_CORE 0.003094
K_76 X_NUC_1.L_CORE X_NUC_77.L_CORE 0.031286
K_77 X_NUC_1.L_CORE X_NUC_78.L_CORE 0.005643
K_78 X_NUC_1.L_CORE X_NUC_79.L_CORE 0.005882
K_79 X_NUC_1.L_CORE X_NUC_80.L_CORE 0.005778
K_80 X_NUC_1.L_CORE X_NUC_81.L_CORE 0.003701
K_81 X_NUC_1.L_CORE X_NUC_82.L_CORE 0.004767
K_82 X_NUC_1.L_CORE X_NUC_83.L_CORE 0.003541
K_83 X_NUC_1.L_CORE X_NUC_84.L_CORE 0.003275
K_84 X_NUC_1.L_CORE X_NUC_85.L_CORE 0.003625
K_85 X_NUC_1.L_CORE X_NUC_86.L_CORE 0.002864
K_86 X_NUC_1.L_CORE X_NUC_87.L_CORE 0.003025
K_87 X_NUC_1.L_CORE X_NUC_88.L_CORE 0.002839
K_88 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_89 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_90 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.007601
K_91 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.007349
K_92 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.007403
K_93 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.007486
K_94 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.007809
K_95 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.007930
K_96 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.007685
K_97 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.007938
K_98 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.008582
K_99 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.008426
K_100 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.008523
K_101 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.008265
K_102 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.004873
K_103 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.004809
K_104 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.004772
K_105 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.004855
K_106 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.006885
K_107 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.007069
K_108 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.006870
K_109 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.006878
K_110 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.004871
K_111 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.004777
K_112 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.004794
K_113 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.004772
K_114 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.004335
K_115 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.004340
K_116 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.004266
K_117 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.004341
K_118 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.005414
K_119 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.005441
K_120 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.005393
K_121 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.005310
K_122 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.003753
K_123 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.003706
K_124 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.003689
K_125 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.003714
K_126 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.004249
K_127 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.004295
K_128 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.004208
K_129 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.004243
K_130 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.004047
K_131 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.004012
K_132 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.004003
K_133 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.003970
K_134 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.003390
K_135 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.003375
K_136 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.003337
K_137 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.003372
K_138 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.003966
K_139 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.003995
K_140 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.003938
K_141 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.003925
K_142 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.003309
K_143 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.003279
K_144 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.003263
K_145 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.003265
K_146 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.003296
K_147 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.003304
K_148 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.003256
K_149 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.003280
K_150 X_NUC_2.L_CORE X_NUC_65.L_CORE 0.003413
K_151 X_NUC_2.L_CORE X_NUC_66.L_CORE 0.003408
K_152 X_NUC_2.L_CORE X_NUC_67.L_CORE 0.003379
K_153 X_NUC_2.L_CORE X_NUC_68.L_CORE 0.003366
K_154 X_NUC_2.L_CORE X_NUC_69.L_CORE 0.003019
K_155 X_NUC_2.L_CORE X_NUC_70.L_CORE 0.003005
K_156 X_NUC_2.L_CORE X_NUC_71.L_CORE 0.002978
K_157 X_NUC_2.L_CORE X_NUC_72.L_CORE 0.002991
K_158 X_NUC_2.L_CORE X_NUC_73.L_CORE 0.003120
K_159 X_NUC_2.L_CORE X_NUC_74.L_CORE 0.003123
K_160 X_NUC_2.L_CORE X_NUC_75.L_CORE 0.003086
K_161 X_NUC_2.L_CORE X_NUC_76.L_CORE 0.003092
K_162 X_NUC_2.L_CORE X_NUC_77.L_CORE 0.028923
K_163 X_NUC_2.L_CORE X_NUC_78.L_CORE 0.005795
K_164 X_NUC_2.L_CORE X_NUC_79.L_CORE 0.005801
K_165 X_NUC_2.L_CORE X_NUC_80.L_CORE 0.005836
K_166 X_NUC_2.L_CORE X_NUC_81.L_CORE 0.003737
K_167 X_NUC_2.L_CORE X_NUC_82.L_CORE 0.004689
K_168 X_NUC_2.L_CORE X_NUC_83.L_CORE 0.003587
K_169 X_NUC_2.L_CORE X_NUC_84.L_CORE 0.003272
K_170 X_NUC_2.L_CORE X_NUC_85.L_CORE 0.003616
K_171 X_NUC_2.L_CORE X_NUC_86.L_CORE 0.002885
K_172 X_NUC_2.L_CORE X_NUC_87.L_CORE 0.003014
K_173 X_NUC_2.L_CORE X_NUC_88.L_CORE 0.002847
K_174 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_175 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.007537
K_176 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.007286
K_177 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.007349
K_178 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.007425
K_179 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.008061
K_180 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.008187
K_181 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.007930
K_182 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.008203
K_183 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.008476
K_184 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.008319
K_185 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.008426
K_186 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.008170
K_187 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.004911
K_188 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.004844
K_189 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.004809
K_190 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.004893
K_191 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.007082
K_192 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.007278
K_193 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.007069
K_194 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.007074
K_195 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.004852
K_196 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.004759
K_197 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.004777
K_198 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.004755
K_199 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.004411
K_200 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.004416
K_201 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.004340
K_202 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.004417
K_203 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.005460
K_204 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.005485
K_205 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.005441
K_206 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.005353
K_207 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.003770
K_208 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.003722
K_209 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.003706
K_210 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.003730
K_211 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.004337
K_212 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.004385
K_213 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.004295
K_214 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.004330
K_215 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.004055
K_216 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.004019
K_217 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.004012
K_218 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.003978
K_219 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.003429
K_220 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.003414
K_221 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.003375
K_222 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.003411
K_223 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.004023
K_224 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.004052
K_225 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.003995
K_226 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.003980
K_227 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.003325
K_228 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.003294
K_229 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.003279
K_230 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.003281
K_231 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.003345
K_232 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.003353
K_233 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.003304
K_234 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.003328
K_235 X_NUC_3.L_CORE X_NUC_65.L_CORE 0.003441
K_236 X_NUC_3.L_CORE X_NUC_66.L_CORE 0.003436
K_237 X_NUC_3.L_CORE X_NUC_67.L_CORE 0.003408
K_238 X_NUC_3.L_CORE X_NUC_68.L_CORE 0.003393
K_239 X_NUC_3.L_CORE X_NUC_69.L_CORE 0.003047
K_240 X_NUC_3.L_CORE X_NUC_70.L_CORE 0.003033
K_241 X_NUC_3.L_CORE X_NUC_71.L_CORE 0.003005
K_242 X_NUC_3.L_CORE X_NUC_72.L_CORE 0.003018
K_243 X_NUC_3.L_CORE X_NUC_73.L_CORE 0.003158
K_244 X_NUC_3.L_CORE X_NUC_74.L_CORE 0.003160
K_245 X_NUC_3.L_CORE X_NUC_75.L_CORE 0.003123
K_246 X_NUC_3.L_CORE X_NUC_76.L_CORE 0.003128
K_247 X_NUC_3.L_CORE X_NUC_77.L_CORE 0.027205
K_248 X_NUC_3.L_CORE X_NUC_78.L_CORE 0.005744
K_249 X_NUC_3.L_CORE X_NUC_79.L_CORE 0.005941
K_250 X_NUC_3.L_CORE X_NUC_80.L_CORE 0.005791
K_251 X_NUC_3.L_CORE X_NUC_81.L_CORE 0.003763
K_252 X_NUC_3.L_CORE X_NUC_82.L_CORE 0.004778
K_253 X_NUC_3.L_CORE X_NUC_83.L_CORE 0.003584
K_254 X_NUC_3.L_CORE X_NUC_84.L_CORE 0.003318
K_255 X_NUC_3.L_CORE X_NUC_85.L_CORE 0.003646
K_256 X_NUC_3.L_CORE X_NUC_86.L_CORE 0.002903
K_257 X_NUC_3.L_CORE X_NUC_87.L_CORE 0.003054
K_258 X_NUC_3.L_CORE X_NUC_88.L_CORE 0.002868
K_259 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.007453
K_260 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.007210
K_261 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.007266
K_262 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.007349
K_263 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.007796
K_264 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.007910
K_265 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.007671
K_266 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.007930
K_267 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.008755
K_268 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.008583
K_269 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.008693
K_270 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.008426
K_271 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.004825
K_272 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.004762
K_273 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.004727
K_274 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.004809
K_275 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.007073
K_276 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.007269
K_277 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.007057
K_278 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.007069
K_279 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.004875
K_280 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.004780
K_281 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.004798
K_282 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.004777
K_283 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.004333
K_284 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.004337
K_285 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.004265
K_286 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.004340
K_287 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.005550
K_288 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.005577
K_289 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.005528
K_290 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.005441
K_291 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.003744
K_292 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.003697
K_293 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.003680
K_294 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.003706
K_295 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.004301
K_296 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.004347
K_297 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.004258
K_298 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.004295
K_299 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.004090
K_300 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.004053
K_301 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.004045
K_302 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.004012
K_303 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.003392
K_304 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.003378
K_305 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.003340
K_306 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.003375
K_307 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.004037
K_308 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.004066
K_309 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.004007
K_310 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.003995
K_311 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.003323
K_312 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.003292
K_313 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.003276
K_314 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.003279
K_315 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.003320
K_316 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.003328
K_317 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.003279
K_318 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.003304
K_319 X_NUC_4.L_CORE X_NUC_65.L_CORE 0.003456
K_320 X_NUC_4.L_CORE X_NUC_66.L_CORE 0.003450
K_321 X_NUC_4.L_CORE X_NUC_67.L_CORE 0.003422
K_322 X_NUC_4.L_CORE X_NUC_68.L_CORE 0.003408
K_323 X_NUC_4.L_CORE X_NUC_69.L_CORE 0.003033
K_324 X_NUC_4.L_CORE X_NUC_70.L_CORE 0.003020
K_325 X_NUC_4.L_CORE X_NUC_71.L_CORE 0.002992
K_326 X_NUC_4.L_CORE X_NUC_72.L_CORE 0.003005
K_327 X_NUC_4.L_CORE X_NUC_73.L_CORE 0.003152
K_328 X_NUC_4.L_CORE X_NUC_74.L_CORE 0.003154
K_329 X_NUC_4.L_CORE X_NUC_75.L_CORE 0.003117
K_330 X_NUC_4.L_CORE X_NUC_76.L_CORE 0.003123
K_331 X_NUC_4.L_CORE X_NUC_77.L_CORE 0.029144
K_332 X_NUC_4.L_CORE X_NUC_78.L_CORE 0.005704
K_333 X_NUC_4.L_CORE X_NUC_79.L_CORE 0.005803
K_334 X_NUC_4.L_CORE X_NUC_80.L_CORE 0.005927
K_335 X_NUC_4.L_CORE X_NUC_81.L_CORE 0.003714
K_336 X_NUC_4.L_CORE X_NUC_82.L_CORE 0.004781
K_337 X_NUC_4.L_CORE X_NUC_83.L_CORE 0.003598
K_338 X_NUC_4.L_CORE X_NUC_84.L_CORE 0.003279
K_339 X_NUC_4.L_CORE X_NUC_85.L_CORE 0.003675
K_340 X_NUC_4.L_CORE X_NUC_86.L_CORE 0.002891
K_341 X_NUC_4.L_CORE X_NUC_87.L_CORE 0.003043
K_342 X_NUC_4.L_CORE X_NUC_88.L_CORE 0.002872
K_343 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_344 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_345 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_346 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.005239
K_347 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.005364
K_348 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.005266
K_349 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.005315
K_350 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.006421
K_351 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.006514
K_352 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.006520
K_353 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.006350
K_354 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.008004
K_355 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.008020
K_356 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.007787
K_357 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.008056
K_358 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.003973
K_359 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.004047
K_360 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.004000
K_361 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.003988
K_362 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.007672
K_363 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.007566
K_364 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.007573
K_365 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.007404
K_366 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.004306
K_367 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.004360
K_368 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.004275
K_369 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.004333
K_370 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.003919
K_371 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.003966
K_372 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.003939
K_373 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.003894
K_374 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006006
K_375 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.005937
K_376 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.005841
K_377 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.005900
K_378 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.003351
K_379 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.003397
K_380 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.003348
K_381 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.003358
K_382 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.004319
K_383 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.004324
K_384 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.004302
K_385 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.004246
K_386 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.003999
K_387 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.004014
K_388 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.003942
K_389 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.003987
K_390 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.003164
K_391 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.003197
K_392 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.003164
K_393 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.003151
K_394 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.004228
K_395 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.004209
K_396 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.004166
K_397 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.004156
K_398 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.003169
K_399 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.003195
K_400 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.003147
K_401 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.003162
K_402 X_NUC_5.L_CORE X_NUC_65.L_CORE 0.003267
K_403 X_NUC_5.L_CORE X_NUC_66.L_CORE 0.003283
K_404 X_NUC_5.L_CORE X_NUC_67.L_CORE 0.003253
K_405 X_NUC_5.L_CORE X_NUC_68.L_CORE 0.003234
K_406 X_NUC_5.L_CORE X_NUC_69.L_CORE 0.003460
K_407 X_NUC_5.L_CORE X_NUC_70.L_CORE 0.003464
K_408 X_NUC_5.L_CORE X_NUC_71.L_CORE 0.003417
K_409 X_NUC_5.L_CORE X_NUC_72.L_CORE 0.003428
K_410 X_NUC_5.L_CORE X_NUC_73.L_CORE 0.003005
K_411 X_NUC_5.L_CORE X_NUC_74.L_CORE 0.003024
K_412 X_NUC_5.L_CORE X_NUC_75.L_CORE 0.002987
K_413 X_NUC_5.L_CORE X_NUC_76.L_CORE 0.002987
K_414 X_NUC_5.L_CORE X_NUC_77.L_CORE 0.006223
K_415 X_NUC_5.L_CORE X_NUC_78.L_CORE 0.022987
K_416 X_NUC_5.L_CORE X_NUC_79.L_CORE 0.004253
K_417 X_NUC_5.L_CORE X_NUC_80.L_CORE 0.004932
K_418 X_NUC_5.L_CORE X_NUC_81.L_CORE 0.005530
K_419 X_NUC_5.L_CORE X_NUC_82.L_CORE 0.003211
K_420 X_NUC_5.L_CORE X_NUC_83.L_CORE 0.004831
K_421 X_NUC_5.L_CORE X_NUC_84.L_CORE 0.003327
K_422 X_NUC_5.L_CORE X_NUC_85.L_CORE 0.003076
K_423 X_NUC_5.L_CORE X_NUC_86.L_CORE 0.003680
K_424 X_NUC_5.L_CORE X_NUC_87.L_CORE 0.002760
K_425 X_NUC_5.L_CORE X_NUC_88.L_CORE 0.002969
K_426 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_427 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_428 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.005119
K_429 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.005239
K_430 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.005146
K_431 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.005192
K_432 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.006327
K_433 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.006421
K_434 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.006424
K_435 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.006261
K_436 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.007977
K_437 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.008004
K_438 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.007767
K_439 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.008035
K_440 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.003903
K_441 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.003973
K_442 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.003928
K_443 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.003917
K_444 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.007772
K_445 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.007672
K_446 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.007674
K_447 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.007499
K_448 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.004253
K_449 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.004306
K_450 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.004223
K_451 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.004279
K_452 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.003873
K_453 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.003919
K_454 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.003893
K_455 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.003849
K_456 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006071
K_457 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006006
K_458 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.005904
K_459 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.005965
K_460 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.003307
K_461 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.003351
K_462 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.003305
K_463 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.003314
K_464 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.004313
K_465 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.004319
K_466 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.004296
K_467 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.004241
K_468 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.003983
K_469 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.003999
K_470 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.003927
K_471 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.003972
K_472 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.003131
K_473 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.003164
K_474 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.003131
K_475 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.003119
K_476 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.004246
K_477 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.004228
K_478 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.004184
K_479 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.004174
K_480 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.003143
K_481 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.003169
K_482 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.003122
K_483 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.003137
K_484 X_NUC_6.L_CORE X_NUC_65.L_CORE 0.003250
K_485 X_NUC_6.L_CORE X_NUC_66.L_CORE 0.003267
K_486 X_NUC_6.L_CORE X_NUC_67.L_CORE 0.003237
K_487 X_NUC_6.L_CORE X_NUC_68.L_CORE 0.003218
K_488 X_NUC_6.L_CORE X_NUC_69.L_CORE 0.003455
K_489 X_NUC_6.L_CORE X_NUC_70.L_CORE 0.003460
K_490 X_NUC_6.L_CORE X_NUC_71.L_CORE 0.003412
K_491 X_NUC_6.L_CORE X_NUC_72.L_CORE 0.003423
K_492 X_NUC_6.L_CORE X_NUC_73.L_CORE 0.002986
K_493 X_NUC_6.L_CORE X_NUC_74.L_CORE 0.003005
K_494 X_NUC_6.L_CORE X_NUC_75.L_CORE 0.002969
K_495 X_NUC_6.L_CORE X_NUC_76.L_CORE 0.002968
K_496 X_NUC_6.L_CORE X_NUC_77.L_CORE 0.006060
K_497 X_NUC_6.L_CORE X_NUC_78.L_CORE 0.025808
K_498 X_NUC_6.L_CORE X_NUC_79.L_CORE 0.004176
K_499 X_NUC_6.L_CORE X_NUC_80.L_CORE 0.004894
K_500 X_NUC_6.L_CORE X_NUC_81.L_CORE 0.005546
K_501 X_NUC_6.L_CORE X_NUC_82.L_CORE 0.003167
K_502 X_NUC_6.L_CORE X_NUC_83.L_CORE 0.004875
K_503 X_NUC_6.L_CORE X_NUC_84.L_CORE 0.003301
K_504 X_NUC_6.L_CORE X_NUC_85.L_CORE 0.003053
K_505 X_NUC_6.L_CORE X_NUC_86.L_CORE 0.003694
K_506 X_NUC_6.L_CORE X_NUC_87.L_CORE 0.002739
K_507 X_NUC_6.L_CORE X_NUC_88.L_CORE 0.002962
K_508 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_509 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.005209
K_510 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.005334
K_511 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.005239
K_512 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.005286
K_513 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.006321
K_514 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.006412
K_515 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.006421
K_516 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.006256
K_517 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.008228
K_518 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.008251
K_519 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.008004
K_520 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.008291
K_521 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.003947
K_522 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.004019
K_523 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.003973
K_524 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.003962
K_525 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.007765
K_526 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.007661
K_527 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.007672
K_528 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.007493
K_529 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.004337
K_530 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.004393
K_531 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.004306
K_532 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.004365
K_533 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.003898
K_534 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.003945
K_535 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.003919
K_536 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.003874
K_537 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006179
K_538 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006107
K_539 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006006
K_540 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006067
K_541 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.003354
K_542 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.003399
K_543 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.003351
K_544 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.003361
K_545 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.004335
K_546 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.004341
K_547 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.004319
K_548 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.004262
K_549 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.004057
K_550 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.004073
K_551 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.003999
K_552 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.004045
K_553 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.003163
K_554 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.003197
K_555 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.003164
K_556 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.003150
K_557 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.004292
K_558 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.004273
K_559 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.004228
K_560 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.004217
K_561 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.003190
K_562 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.003217
K_563 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.003169
K_564 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.003184
K_565 X_NUC_7.L_CORE X_NUC_65.L_CORE 0.003280
K_566 X_NUC_7.L_CORE X_NUC_66.L_CORE 0.003297
K_567 X_NUC_7.L_CORE X_NUC_67.L_CORE 0.003267
K_568 X_NUC_7.L_CORE X_NUC_68.L_CORE 0.003247
K_569 X_NUC_7.L_CORE X_NUC_69.L_CORE 0.003503
K_570 X_NUC_7.L_CORE X_NUC_70.L_CORE 0.003508
K_571 X_NUC_7.L_CORE X_NUC_71.L_CORE 0.003460
K_572 X_NUC_7.L_CORE X_NUC_72.L_CORE 0.003471
K_573 X_NUC_7.L_CORE X_NUC_73.L_CORE 0.003023
K_574 X_NUC_7.L_CORE X_NUC_74.L_CORE 0.003043
K_575 X_NUC_7.L_CORE X_NUC_75.L_CORE 0.003005
K_576 X_NUC_7.L_CORE X_NUC_76.L_CORE 0.003004
K_577 X_NUC_7.L_CORE X_NUC_77.L_CORE 0.006076
K_578 X_NUC_7.L_CORE X_NUC_78.L_CORE 0.023977
K_579 X_NUC_7.L_CORE X_NUC_79.L_CORE 0.004239
K_580 X_NUC_7.L_CORE X_NUC_80.L_CORE 0.004885
K_581 X_NUC_7.L_CORE X_NUC_81.L_CORE 0.005657
K_582 X_NUC_7.L_CORE X_NUC_82.L_CORE 0.003199
K_583 X_NUC_7.L_CORE X_NUC_83.L_CORE 0.004886
K_584 X_NUC_7.L_CORE X_NUC_84.L_CORE 0.003354
K_585 X_NUC_7.L_CORE X_NUC_85.L_CORE 0.003075
K_586 X_NUC_7.L_CORE X_NUC_86.L_CORE 0.003739
K_587 X_NUC_7.L_CORE X_NUC_87.L_CORE 0.002772
K_588 X_NUC_7.L_CORE X_NUC_88.L_CORE 0.002990
K_589 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.005163
K_590 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.005284
K_591 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.005190
K_592 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.005239
K_593 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.006489
K_594 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.006587
K_595 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.006594
K_596 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.006421
K_597 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.007941
K_598 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.007962
K_599 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.007734
K_600 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.008004
K_601 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.003957
K_602 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.004031
K_603 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.003984
K_604 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.003973
K_605 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.007960
K_606 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.007847
K_607 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.007855
K_608 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.007672
K_609 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.004278
K_610 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.004332
K_611 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.004248
K_612 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.004306
K_613 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.003943
K_614 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.003991
K_615 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.003964
K_616 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.003919
K_617 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006112
K_618 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006042
K_619 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.005941
K_620 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006006
K_621 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.003344
K_622 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.003390
K_623 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.003341
K_624 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.003351
K_625 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.004395
K_626 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.004401
K_627 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.004377
K_628 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.004319
K_629 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.004010
K_630 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.004025
K_631 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.003953
K_632 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.003999
K_633 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.003176
K_634 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.003210
K_635 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.003177
K_636 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.003164
K_637 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.004303
K_638 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.004284
K_639 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.004238
K_640 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.004228
K_641 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.003175
K_642 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.003201
K_643 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.003153
K_644 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.003169
K_645 X_NUC_8.L_CORE X_NUC_65.L_CORE 0.003300
K_646 X_NUC_8.L_CORE X_NUC_66.L_CORE 0.003317
K_647 X_NUC_8.L_CORE X_NUC_67.L_CORE 0.003286
K_648 X_NUC_8.L_CORE X_NUC_68.L_CORE 0.003267
K_649 X_NUC_8.L_CORE X_NUC_69.L_CORE 0.003491
K_650 X_NUC_8.L_CORE X_NUC_70.L_CORE 0.003496
K_651 X_NUC_8.L_CORE X_NUC_71.L_CORE 0.003448
K_652 X_NUC_8.L_CORE X_NUC_72.L_CORE 0.003460
K_653 X_NUC_8.L_CORE X_NUC_73.L_CORE 0.003024
K_654 X_NUC_8.L_CORE X_NUC_74.L_CORE 0.003043
K_655 X_NUC_8.L_CORE X_NUC_75.L_CORE 0.003006
K_656 X_NUC_8.L_CORE X_NUC_76.L_CORE 0.003005
K_657 X_NUC_8.L_CORE X_NUC_77.L_CORE 0.006142
K_658 X_NUC_8.L_CORE X_NUC_78.L_CORE 0.023860
K_659 X_NUC_8.L_CORE X_NUC_79.L_CORE 0.004203
K_660 X_NUC_8.L_CORE X_NUC_80.L_CORE 0.004990
K_661 X_NUC_8.L_CORE X_NUC_81.L_CORE 0.005528
K_662 X_NUC_8.L_CORE X_NUC_82.L_CORE 0.003207
K_663 X_NUC_8.L_CORE X_NUC_83.L_CORE 0.004945
K_664 X_NUC_8.L_CORE X_NUC_84.L_CORE 0.003322
K_665 X_NUC_8.L_CORE X_NUC_85.L_CORE 0.003098
K_666 X_NUC_8.L_CORE X_NUC_86.L_CORE 0.003724
K_667 X_NUC_8.L_CORE X_NUC_87.L_CORE 0.002768
K_668 X_NUC_8.L_CORE X_NUC_88.L_CORE 0.002999
K_669 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_670 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_671 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_672 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.004395
K_673 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.004353
K_674 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.004409
K_675 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.004329
K_676 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.005628
K_677 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.005487
K_678 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.005516
K_679 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.005552
K_680 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.007497
K_681 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.007620
K_682 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.007587
K_683 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.007374
K_684 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.003567
K_685 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.003518
K_686 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.003547
K_687 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.003515
K_688 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.007871
K_689 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.007780
K_690 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.007593
K_691 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.007775
K_692 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.004028
K_693 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.004022
K_694 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.004036
K_695 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.003967
K_696 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.003683
K_697 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.003626
K_698 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.003635
K_699 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.003633
K_700 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006316
K_701 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006400
K_702 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006246
K_703 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006227
K_704 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.003174
K_705 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.003149
K_706 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.003161
K_707 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.003128
K_708 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.004304
K_709 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.004255
K_710 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.004218
K_711 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.004247
K_712 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.003974
K_713 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.003986
K_714 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.003962
K_715 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.003916
K_716 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.003072
K_717 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.003041
K_718 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.003043
K_719 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.003030
K_720 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.004320
K_721 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.004316
K_722 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.004251
K_723 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.004262
K_724 X_NUC_9.L_CORE X_NUC_65.L_CORE 0.003139
K_725 X_NUC_9.L_CORE X_NUC_66.L_CORE 0.003127
K_726 X_NUC_9.L_CORE X_NUC_67.L_CORE 0.003121
K_727 X_NUC_9.L_CORE X_NUC_68.L_CORE 0.003094
K_728 X_NUC_9.L_CORE X_NUC_69.L_CORE 0.003267
K_729 X_NUC_9.L_CORE X_NUC_70.L_CORE 0.003241
K_730 X_NUC_9.L_CORE X_NUC_71.L_CORE 0.003224
K_731 X_NUC_9.L_CORE X_NUC_72.L_CORE 0.003222
K_732 X_NUC_9.L_CORE X_NUC_73.L_CORE 0.003408
K_733 X_NUC_9.L_CORE X_NUC_74.L_CORE 0.003401
K_734 X_NUC_9.L_CORE X_NUC_75.L_CORE 0.003373
K_735 X_NUC_9.L_CORE X_NUC_76.L_CORE 0.003360
K_736 X_NUC_9.L_CORE X_NUC_77.L_CORE 0.006918
K_737 X_NUC_9.L_CORE X_NUC_78.L_CORE 0.004322
K_738 X_NUC_9.L_CORE X_NUC_79.L_CORE 0.021343
K_739 X_NUC_9.L_CORE X_NUC_80.L_CORE 0.003586
K_740 X_NUC_9.L_CORE X_NUC_81.L_CORE 0.004362
K_741 X_NUC_9.L_CORE X_NUC_82.L_CORE 0.005276
K_742 X_NUC_9.L_CORE X_NUC_83.L_CORE 0.002920
K_743 X_NUC_9.L_CORE X_NUC_84.L_CORE 0.004786
K_744 X_NUC_9.L_CORE X_NUC_85.L_CORE 0.003176
K_745 X_NUC_9.L_CORE X_NUC_86.L_CORE 0.002952
K_746 X_NUC_9.L_CORE X_NUC_87.L_CORE 0.003605
K_747 X_NUC_9.L_CORE X_NUC_88.L_CORE 0.002768
K_748 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_749 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_750 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.004437
K_751 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.004395
K_752 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.004453
K_753 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.004370
K_754 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.005776
K_755 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.005628
K_756 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.005658
K_757 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.005696
K_758 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.007370
K_759 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.007497
K_760 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.007461
K_761 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.007258
K_762 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.003616
K_763 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.003567
K_764 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.003597
K_765 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.003563
K_766 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.007955
K_767 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.007871
K_768 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.007673
K_769 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.007861
K_770 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.004032
K_771 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.004028
K_772 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.004041
K_773 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.003972
K_774 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.003742
K_775 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.003683
K_776 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.003692
K_777 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.003690
K_778 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006231
K_779 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006316
K_780 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006165
K_781 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.006148
K_782 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.003199
K_783 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.003174
K_784 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.003186
K_785 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.003153
K_786 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.004353
K_787 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.004304
K_788 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.004264
K_789 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.004295
K_790 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.003961
K_791 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.003974
K_792 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.003949
K_793 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.003904
K_794 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.003104
K_795 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.003072
K_796 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.003074
K_797 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.003060
K_798 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.004322
K_799 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.004320
K_800 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.004254
K_801 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.004265
K_802 X_NUC_10.L_CORE X_NUC_65.L_CORE 0.003150
K_803 X_NUC_10.L_CORE X_NUC_66.L_CORE 0.003139
K_804 X_NUC_10.L_CORE X_NUC_67.L_CORE 0.003132
K_805 X_NUC_10.L_CORE X_NUC_68.L_CORE 0.003105
K_806 X_NUC_10.L_CORE X_NUC_69.L_CORE 0.003293
K_807 X_NUC_10.L_CORE X_NUC_70.L_CORE 0.003267
K_808 X_NUC_10.L_CORE X_NUC_71.L_CORE 0.003249
K_809 X_NUC_10.L_CORE X_NUC_72.L_CORE 0.003247
K_810 X_NUC_10.L_CORE X_NUC_73.L_CORE 0.003413
K_811 X_NUC_10.L_CORE X_NUC_74.L_CORE 0.003408
K_812 X_NUC_10.L_CORE X_NUC_75.L_CORE 0.003380
K_813 X_NUC_10.L_CORE X_NUC_76.L_CORE 0.003366
K_814 X_NUC_10.L_CORE X_NUC_77.L_CORE 0.006968
K_815 X_NUC_10.L_CORE X_NUC_78.L_CORE 0.004409
K_816 X_NUC_10.L_CORE X_NUC_79.L_CORE 0.019817
K_817 X_NUC_10.L_CORE X_NUC_80.L_CORE 0.003610
K_818 X_NUC_10.L_CORE X_NUC_81.L_CORE 0.004443
K_819 X_NUC_10.L_CORE X_NUC_82.L_CORE 0.005202
K_820 X_NUC_10.L_CORE X_NUC_83.L_CORE 0.002951
K_821 X_NUC_10.L_CORE X_NUC_84.L_CORE 0.004801
K_822 X_NUC_10.L_CORE X_NUC_85.L_CORE 0.003177
K_823 X_NUC_10.L_CORE X_NUC_86.L_CORE 0.002982
K_824 X_NUC_10.L_CORE X_NUC_87.L_CORE 0.003597
K_825 X_NUC_10.L_CORE X_NUC_88.L_CORE 0.002781
K_826 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_827 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.004380
K_828 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.004338
K_829 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.004395
K_830 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.004314
K_831 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.005741
K_832 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.005594
K_833 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.005628
K_834 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.005663
K_835 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.007400
K_836 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.007523
K_837 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.007497
K_838 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.007287
K_839 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.003585
K_840 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.003536
K_841 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.003567
K_842 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.003533
K_843 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.008170
K_844 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.008073
K_845 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.007871
K_846 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.008068
K_847 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.004018
K_848 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.004013
K_849 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.004028
K_850 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.003958
K_851 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.003733
K_852 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.003674
K_853 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.003683
K_854 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.003681
K_855 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006383
K_856 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006473
K_857 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006316
K_858 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006294
K_859 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.003187
K_860 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.003162
K_861 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.003174
K_862 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.003141
K_863 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.004393
K_864 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.004342
K_865 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.004304
K_866 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.004334
K_867 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.003985
K_868 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.003998
K_869 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.003974
K_870 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.003928
K_871 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.003102
K_872 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.003070
K_873 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.003072
K_874 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.003059
K_875 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.004391
K_876 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.004388
K_877 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.004320
K_878 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.004331
K_879 X_NUC_11.L_CORE X_NUC_65.L_CORE 0.003157
K_880 X_NUC_11.L_CORE X_NUC_66.L_CORE 0.003145
K_881 X_NUC_11.L_CORE X_NUC_67.L_CORE 0.003139
K_882 X_NUC_11.L_CORE X_NUC_68.L_CORE 0.003112
K_883 X_NUC_11.L_CORE X_NUC_69.L_CORE 0.003311
K_884 X_NUC_11.L_CORE X_NUC_70.L_CORE 0.003284
K_885 X_NUC_11.L_CORE X_NUC_71.L_CORE 0.003267
K_886 X_NUC_11.L_CORE X_NUC_72.L_CORE 0.003265
K_887 X_NUC_11.L_CORE X_NUC_73.L_CORE 0.003442
K_888 X_NUC_11.L_CORE X_NUC_74.L_CORE 0.003435
K_889 X_NUC_11.L_CORE X_NUC_75.L_CORE 0.003408
K_890 X_NUC_11.L_CORE X_NUC_76.L_CORE 0.003393
K_891 X_NUC_11.L_CORE X_NUC_77.L_CORE 0.006779
K_892 X_NUC_11.L_CORE X_NUC_78.L_CORE 0.004344
K_893 X_NUC_11.L_CORE X_NUC_79.L_CORE 0.021467
K_894 X_NUC_11.L_CORE X_NUC_80.L_CORE 0.003576
K_895 X_NUC_11.L_CORE X_NUC_81.L_CORE 0.004441
K_896 X_NUC_11.L_CORE X_NUC_82.L_CORE 0.005251
K_897 X_NUC_11.L_CORE X_NUC_83.L_CORE 0.002937
K_898 X_NUC_11.L_CORE X_NUC_84.L_CORE 0.004890
K_899 X_NUC_11.L_CORE X_NUC_85.L_CORE 0.003181
K_900 X_NUC_11.L_CORE X_NUC_86.L_CORE 0.002988
K_901 X_NUC_11.L_CORE X_NUC_87.L_CORE 0.003641
K_902 X_NUC_11.L_CORE X_NUC_88.L_CORE 0.002789
K_903 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.004463
K_904 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.004420
K_905 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.004479
K_906 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.004395
K_907 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.005702
K_908 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.005557
K_909 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.005588
K_910 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.005628
K_911 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.007615
K_912 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.007749
K_913 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.007715
K_914 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.007497
K_915 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.003619
K_916 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.003569
K_917 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.003600
K_918 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.003567
K_919 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.007959
K_920 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.007870
K_921 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.007677
K_922 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.007871
K_923 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.004090
K_924 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.004084
K_925 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.004099
K_926 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.004028
K_927 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.003735
K_928 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.003676
K_929 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.003685
K_930 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.003683
K_931 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006404
K_932 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006494
K_933 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006333
K_934 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006316
K_935 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.003222
K_936 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.003196
K_937 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.003208
K_938 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.003174
K_939 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.004361
K_940 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.004311
K_941 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.004272
K_942 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.004304
K_943 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.004033
K_944 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.004046
K_945 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.004021
K_946 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.003974
K_947 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.003117
K_948 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.003084
K_949 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.003086
K_950 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.003072
K_951 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.004379
K_952 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.004376
K_953 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.004308
K_954 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.004320
K_955 X_NUC_12.L_CORE X_NUC_65.L_CORE 0.003185
K_956 X_NUC_12.L_CORE X_NUC_66.L_CORE 0.003173
K_957 X_NUC_12.L_CORE X_NUC_67.L_CORE 0.003167
K_958 X_NUC_12.L_CORE X_NUC_68.L_CORE 0.003139
K_959 X_NUC_12.L_CORE X_NUC_69.L_CORE 0.003313
K_960 X_NUC_12.L_CORE X_NUC_70.L_CORE 0.003286
K_961 X_NUC_12.L_CORE X_NUC_71.L_CORE 0.003269
K_962 X_NUC_12.L_CORE X_NUC_72.L_CORE 0.003267
K_963 X_NUC_12.L_CORE X_NUC_73.L_CORE 0.003456
K_964 X_NUC_12.L_CORE X_NUC_74.L_CORE 0.003450
K_965 X_NUC_12.L_CORE X_NUC_75.L_CORE 0.003421
K_966 X_NUC_12.L_CORE X_NUC_76.L_CORE 0.003408
K_967 X_NUC_12.L_CORE X_NUC_77.L_CORE 0.006981
K_968 X_NUC_12.L_CORE X_NUC_78.L_CORE 0.004371
K_969 X_NUC_12.L_CORE X_NUC_79.L_CORE 0.020143
K_970 X_NUC_12.L_CORE X_NUC_80.L_CORE 0.003633
K_971 X_NUC_12.L_CORE X_NUC_81.L_CORE 0.004406
K_972 X_NUC_12.L_CORE X_NUC_82.L_CORE 0.005333
K_973 X_NUC_12.L_CORE X_NUC_83.L_CORE 0.002958
K_974 X_NUC_12.L_CORE X_NUC_84.L_CORE 0.004829
K_975 X_NUC_12.L_CORE X_NUC_85.L_CORE 0.003218
K_976 X_NUC_12.L_CORE X_NUC_86.L_CORE 0.002989
K_977 X_NUC_12.L_CORE X_NUC_87.L_CORE 0.003648
K_978 X_NUC_12.L_CORE X_NUC_88.L_CORE 0.002804
K_979 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_980 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_981 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_982 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.003927
K_983 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.003908
K_984 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.003879
K_985 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.003950
K_986 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.005144
K_987 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.005254
K_988 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.005149
K_989 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.005213
K_990 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.007101
K_991 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.006898
K_992 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.006895
K_993 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.006974
K_994 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.003321
K_995 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.003332
K_996 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.003293
K_997 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.003343
K_998 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.007930
K_999 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.008142
K_1000 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.007906
K_1001 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.007854
K_1002 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.003849
K_1003 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.003811
K_1004 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.003784
K_1005 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.003835
K_1006 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.003538
K_1007 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.003575
K_1008 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.003518
K_1009 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.003557
K_1010 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006501
K_1011 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006422
K_1012 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006344
K_1013 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006324
K_1014 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.003077
K_1015 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.003073
K_1016 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.003040
K_1017 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.003079
K_1018 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.004288
K_1019 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.004343
K_1020 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.004259
K_1021 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.004276
K_1022 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.003959
K_1023 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.003922
K_1024 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.003886
K_1025 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.003916
K_1026 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.003045
K_1027 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.003058
K_1028 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.003016
K_1029 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.003047
K_1030 X_NUC_13.L_CORE X_NUC_65.L_CORE 0.004320
K_1031 X_NUC_13.L_CORE X_NUC_66.L_CORE 0.004330
K_1032 X_NUC_13.L_CORE X_NUC_67.L_CORE 0.004260
K_1033 X_NUC_13.L_CORE X_NUC_68.L_CORE 0.004266
K_1034 X_NUC_13.L_CORE X_NUC_69.L_CORE 0.003169
K_1035 X_NUC_13.L_CORE X_NUC_70.L_CORE 0.003161
K_1036 X_NUC_13.L_CORE X_NUC_71.L_CORE 0.003124
K_1037 X_NUC_13.L_CORE X_NUC_72.L_CORE 0.003153
K_1038 X_NUC_13.L_CORE X_NUC_73.L_CORE 0.003304
K_1039 X_NUC_13.L_CORE X_NUC_74.L_CORE 0.003316
K_1040 X_NUC_13.L_CORE X_NUC_75.L_CORE 0.003267
K_1041 X_NUC_13.L_CORE X_NUC_76.L_CORE 0.003288
K_1042 X_NUC_13.L_CORE X_NUC_77.L_CORE 0.007959
K_1043 X_NUC_13.L_CORE X_NUC_78.L_CORE 0.005476
K_1044 X_NUC_13.L_CORE X_NUC_79.L_CORE 0.003700
K_1045 X_NUC_13.L_CORE X_NUC_80.L_CORE 0.017720
K_1046 X_NUC_13.L_CORE X_NUC_81.L_CORE 0.003256
K_1047 X_NUC_13.L_CORE X_NUC_82.L_CORE 0.004127
K_1048 X_NUC_13.L_CORE X_NUC_83.L_CORE 0.004950
K_1049 X_NUC_13.L_CORE X_NUC_84.L_CORE 0.002804
K_1050 X_NUC_13.L_CORE X_NUC_85.L_CORE 0.004685
K_1051 X_NUC_13.L_CORE X_NUC_86.L_CORE 0.003099
K_1052 X_NUC_13.L_CORE X_NUC_87.L_CORE 0.002952
K_1053 X_NUC_13.L_CORE X_NUC_88.L_CORE 0.003379
K_1054 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_1055 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_1056 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.003946
K_1057 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.003927
K_1058 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.003897
K_1059 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.003969
K_1060 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.005037
K_1061 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.005144
K_1062 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.005043
K_1063 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.005104
K_1064 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.007314
K_1065 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.007101
K_1066 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.007093
K_1067 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.007180
K_1068 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.003309
K_1069 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.003321
K_1070 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.003282
K_1071 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.003331
K_1072 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.007723
K_1073 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.007930
K_1074 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.007707
K_1075 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.007658
K_1076 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.003887
K_1077 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.003849
K_1078 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.003820
K_1079 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.003873
K_1080 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.003501
K_1081 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.003538
K_1082 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.003482
K_1083 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.003520
K_1084 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006577
K_1085 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006501
K_1086 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006418
K_1087 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006397
K_1088 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.003080
K_1089 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.003077
K_1090 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.003044
K_1091 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.003083
K_1092 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.004233
K_1093 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.004288
K_1094 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.004206
K_1095 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.004223
K_1096 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.003996
K_1097 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.003959
K_1098 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.003921
K_1099 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.003952
K_1100 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.003032
K_1101 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.003045
K_1102 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.003003
K_1103 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.003034
K_1104 X_NUC_14.L_CORE X_NUC_65.L_CORE 0.004309
K_1105 X_NUC_14.L_CORE X_NUC_66.L_CORE 0.004320
K_1106 X_NUC_14.L_CORE X_NUC_67.L_CORE 0.004250
K_1107 X_NUC_14.L_CORE X_NUC_68.L_CORE 0.004256
K_1108 X_NUC_14.L_CORE X_NUC_69.L_CORE 0.003176
K_1109 X_NUC_14.L_CORE X_NUC_70.L_CORE 0.003169
K_1110 X_NUC_14.L_CORE X_NUC_71.L_CORE 0.003132
K_1111 X_NUC_14.L_CORE X_NUC_72.L_CORE 0.003160
K_1112 X_NUC_14.L_CORE X_NUC_73.L_CORE 0.003291
K_1113 X_NUC_14.L_CORE X_NUC_74.L_CORE 0.003304
K_1114 X_NUC_14.L_CORE X_NUC_75.L_CORE 0.003255
K_1115 X_NUC_14.L_CORE X_NUC_76.L_CORE 0.003276
K_1116 X_NUC_14.L_CORE X_NUC_77.L_CORE 0.007787
K_1117 X_NUC_14.L_CORE X_NUC_78.L_CORE 0.005569
K_1118 X_NUC_14.L_CORE X_NUC_79.L_CORE 0.003666
K_1119 X_NUC_14.L_CORE X_NUC_80.L_CORE 0.017899
K_1120 X_NUC_14.L_CORE X_NUC_81.L_CORE 0.003272
K_1121 X_NUC_14.L_CORE X_NUC_82.L_CORE 0.004058
K_1122 X_NUC_14.L_CORE X_NUC_83.L_CORE 0.005042
K_1123 X_NUC_14.L_CORE X_NUC_84.L_CORE 0.002796
K_1124 X_NUC_14.L_CORE X_NUC_85.L_CORE 0.004640
K_1125 X_NUC_14.L_CORE X_NUC_86.L_CORE 0.003118
K_1126 X_NUC_14.L_CORE X_NUC_87.L_CORE 0.002935
K_1127 X_NUC_14.L_CORE X_NUC_88.L_CORE 0.003382
K_1128 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_1129 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.003977
K_1130 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.003957
K_1131 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.003927
K_1132 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.004000
K_1133 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.005136
K_1134 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.005247
K_1135 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.005144
K_1136 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.005206
K_1137 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.007317
K_1138 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.007099
K_1139 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.007101
K_1140 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.007183
K_1141 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.003349
K_1142 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.003361
K_1143 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.003321
K_1144 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.003372
K_1145 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.007943
K_1146 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.008162
K_1147 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.007930
K_1148 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.007872
K_1149 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.003916
K_1150 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.003877
K_1151 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.003849
K_1152 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.003902
K_1153 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.003557
K_1154 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.003596
K_1155 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.003538
K_1156 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.003577
K_1157 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006664
K_1158 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006582
K_1159 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006501
K_1160 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.006477
K_1161 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.003115
K_1162 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.003111
K_1163 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.003077
K_1164 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.003117
K_1165 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.004316
K_1166 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.004373
K_1167 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.004288
K_1168 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.004305
K_1169 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.004036
K_1170 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.003997
K_1171 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.003959
K_1172 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.003990
K_1173 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.003075
K_1174 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.003088
K_1175 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.003045
K_1176 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.003077
K_1177 X_NUC_15.L_CORE X_NUC_65.L_CORE 0.004381
K_1178 X_NUC_15.L_CORE X_NUC_66.L_CORE 0.004392
K_1179 X_NUC_15.L_CORE X_NUC_67.L_CORE 0.004320
K_1180 X_NUC_15.L_CORE X_NUC_68.L_CORE 0.004326
K_1181 X_NUC_15.L_CORE X_NUC_69.L_CORE 0.003214
K_1182 X_NUC_15.L_CORE X_NUC_70.L_CORE 0.003207
K_1183 X_NUC_15.L_CORE X_NUC_71.L_CORE 0.003169
K_1184 X_NUC_15.L_CORE X_NUC_72.L_CORE 0.003198
K_1185 X_NUC_15.L_CORE X_NUC_73.L_CORE 0.003342
K_1186 X_NUC_15.L_CORE X_NUC_74.L_CORE 0.003354
K_1187 X_NUC_15.L_CORE X_NUC_75.L_CORE 0.003304
K_1188 X_NUC_15.L_CORE X_NUC_76.L_CORE 0.003326
K_1189 X_NUC_15.L_CORE X_NUC_77.L_CORE 0.007832
K_1190 X_NUC_15.L_CORE X_NUC_78.L_CORE 0.005552
K_1191 X_NUC_15.L_CORE X_NUC_79.L_CORE 0.003709
K_1192 X_NUC_15.L_CORE X_NUC_80.L_CORE 0.017584
K_1193 X_NUC_15.L_CORE X_NUC_81.L_CORE 0.003295
K_1194 X_NUC_15.L_CORE X_NUC_82.L_CORE 0.004128
K_1195 X_NUC_15.L_CORE X_NUC_83.L_CORE 0.005058
K_1196 X_NUC_15.L_CORE X_NUC_84.L_CORE 0.002829
K_1197 X_NUC_15.L_CORE X_NUC_85.L_CORE 0.004720
K_1198 X_NUC_15.L_CORE X_NUC_86.L_CORE 0.003145
K_1199 X_NUC_15.L_CORE X_NUC_87.L_CORE 0.002976
K_1200 X_NUC_15.L_CORE X_NUC_88.L_CORE 0.003425
K_1201 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.003904
K_1202 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.003886
K_1203 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.003857
K_1204 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.003927
K_1205 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.005074
K_1206 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.005182
K_1207 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.005081
K_1208 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.005144
K_1209 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.007226
K_1210 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.007016
K_1211 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.007013
K_1212 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.007101
K_1213 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.003299
K_1214 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.003310
K_1215 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.003272
K_1216 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.003321
K_1217 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.007997
K_1218 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.008221
K_1219 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.007978
K_1220 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.007930
K_1221 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.003861
K_1222 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.003824
K_1223 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.003796
K_1224 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.003849
K_1225 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.003518
K_1226 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.003555
K_1227 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.003498
K_1228 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.003538
K_1229 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006688
K_1230 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006604
K_1231 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006520
K_1232 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006501
K_1233 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.003074
K_1234 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.003071
K_1235 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.003038
K_1236 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.003077
K_1237 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.004298
K_1238 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.004354
K_1239 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.004269
K_1240 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.004288
K_1241 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.004003
K_1242 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.003966
K_1243 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.003928
K_1244 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.003959
K_1245 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.003043
K_1246 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.003056
K_1247 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.003014
K_1248 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.003045
K_1249 X_NUC_16.L_CORE X_NUC_65.L_CORE 0.004375
K_1250 X_NUC_16.L_CORE X_NUC_66.L_CORE 0.004386
K_1251 X_NUC_16.L_CORE X_NUC_67.L_CORE 0.004313
K_1252 X_NUC_16.L_CORE X_NUC_68.L_CORE 0.004320
K_1253 X_NUC_16.L_CORE X_NUC_69.L_CORE 0.003184
K_1254 X_NUC_16.L_CORE X_NUC_70.L_CORE 0.003177
K_1255 X_NUC_16.L_CORE X_NUC_71.L_CORE 0.003140
K_1256 X_NUC_16.L_CORE X_NUC_72.L_CORE 0.003169
K_1257 X_NUC_16.L_CORE X_NUC_73.L_CORE 0.003319
K_1258 X_NUC_16.L_CORE X_NUC_74.L_CORE 0.003331
K_1259 X_NUC_16.L_CORE X_NUC_75.L_CORE 0.003281
K_1260 X_NUC_16.L_CORE X_NUC_76.L_CORE 0.003304
K_1261 X_NUC_16.L_CORE X_NUC_77.L_CORE 0.007669
K_1262 X_NUC_16.L_CORE X_NUC_78.L_CORE 0.005445
K_1263 X_NUC_16.L_CORE X_NUC_79.L_CORE 0.003653
K_1264 X_NUC_16.L_CORE X_NUC_80.L_CORE 0.019051
K_1265 X_NUC_16.L_CORE X_NUC_81.L_CORE 0.003247
K_1266 X_NUC_16.L_CORE X_NUC_82.L_CORE 0.004099
K_1267 X_NUC_16.L_CORE X_NUC_83.L_CORE 0.005039
K_1268 X_NUC_16.L_CORE X_NUC_84.L_CORE 0.002795
K_1269 X_NUC_16.L_CORE X_NUC_85.L_CORE 0.004737
K_1270 X_NUC_16.L_CORE X_NUC_86.L_CORE 0.003117
K_1271 X_NUC_16.L_CORE X_NUC_87.L_CORE 0.002955
K_1272 X_NUC_16.L_CORE X_NUC_88.L_CORE 0.003413
K_1273 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_1274 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_1275 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_1276 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.003635
K_1277 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.003688
K_1278 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.003676
K_1279 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.003640
K_1280 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.004829
K_1281 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.004797
K_1282 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.004852
K_1283 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.004748
K_1284 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.006813
K_1285 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.007017
K_1286 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.006822
K_1287 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.006883
K_1288 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.003164
K_1289 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.003187
K_1290 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.003189
K_1291 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.003148
K_1292 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.007936
K_1293 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.007761
K_1294 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.007761
K_1295 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.007646
K_1296 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.003736
K_1297 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.003797
K_1298 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.003754
K_1299 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.003739
K_1300 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.003451
K_1301 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.003452
K_1302 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.003460
K_1303 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.003409
K_1304 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006601
K_1305 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006655
K_1306 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.006467
K_1307 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.006515
K_1308 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.003033
K_1309 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.003061
K_1310 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.003045
K_1311 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.003018
K_1312 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.004282
K_1313 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.004259
K_1314 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.004250
K_1315 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.004199
K_1316 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.003959
K_1317 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.004008
K_1318 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.003944
K_1319 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.003940
K_1320 X_NUC_17.L_CORE X_NUC_65.L_CORE 0.003072
K_1321 X_NUC_17.L_CORE X_NUC_66.L_CORE 0.003085
K_1322 X_NUC_17.L_CORE X_NUC_67.L_CORE 0.003074
K_1323 X_NUC_17.L_CORE X_NUC_68.L_CORE 0.003042
K_1324 X_NUC_17.L_CORE X_NUC_69.L_CORE 0.004228
K_1325 X_NUC_17.L_CORE X_NUC_70.L_CORE 0.004233
K_1326 X_NUC_17.L_CORE X_NUC_71.L_CORE 0.004182
K_1327 X_NUC_17.L_CORE X_NUC_72.L_CORE 0.004163
K_1328 X_NUC_17.L_CORE X_NUC_73.L_CORE 0.003279
K_1329 X_NUC_17.L_CORE X_NUC_74.L_CORE 0.003302
K_1330 X_NUC_17.L_CORE X_NUC_75.L_CORE 0.003270
K_1331 X_NUC_17.L_CORE X_NUC_76.L_CORE 0.003251
K_1332 X_NUC_17.L_CORE X_NUC_77.L_CORE 0.004204
K_1333 X_NUC_17.L_CORE X_NUC_78.L_CORE 0.007361
K_1334 X_NUC_17.L_CORE X_NUC_79.L_CORE 0.004885
K_1335 X_NUC_17.L_CORE X_NUC_80.L_CORE 0.003325
K_1336 X_NUC_17.L_CORE X_NUC_81.L_CORE 0.015409
K_1337 X_NUC_17.L_CORE X_NUC_82.L_CORE 0.003087
K_1338 X_NUC_17.L_CORE X_NUC_83.L_CORE 0.003887
K_1339 X_NUC_17.L_CORE X_NUC_84.L_CORE 0.004842
K_1340 X_NUC_17.L_CORE X_NUC_85.L_CORE 0.002749
K_1341 X_NUC_17.L_CORE X_NUC_86.L_CORE 0.004468
K_1342 X_NUC_17.L_CORE X_NUC_87.L_CORE 0.003114
K_1343 X_NUC_17.L_CORE X_NUC_88.L_CORE 0.003007
K_1344 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_1345 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_1346 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.003582
K_1347 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.003635
K_1348 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.003622
K_1349 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.003588
K_1350 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.004858
K_1351 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.004829
K_1352 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.004883
K_1353 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.004777
K_1354 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.006618
K_1355 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.006813
K_1356 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.006630
K_1357 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.006686
K_1358 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.003141
K_1359 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.003164
K_1360 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.003165
K_1361 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.003125
K_1362 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.008112
K_1363 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.007936
K_1364 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.007931
K_1365 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.007808
K_1366 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.003677
K_1367 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.003736
K_1368 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.003695
K_1369 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.003681
K_1370 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.003450
K_1371 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.003451
K_1372 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.003459
K_1373 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.003408
K_1374 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.006542
K_1375 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006601
K_1376 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.006414
K_1377 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.006462
K_1378 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.003005
K_1379 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.003033
K_1380 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.003017
K_1381 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.002991
K_1382 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.004303
K_1383 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.004282
K_1384 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.004272
K_1385 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.004220
K_1386 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.003912
K_1387 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.003959
K_1388 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.003897
K_1389 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.003893
K_1390 X_NUC_18.L_CORE X_NUC_65.L_CORE 0.003059
K_1391 X_NUC_18.L_CORE X_NUC_66.L_CORE 0.003072
K_1392 X_NUC_18.L_CORE X_NUC_67.L_CORE 0.003061
K_1393 X_NUC_18.L_CORE X_NUC_68.L_CORE 0.003030
K_1394 X_NUC_18.L_CORE X_NUC_69.L_CORE 0.004222
K_1395 X_NUC_18.L_CORE X_NUC_70.L_CORE 0.004228
K_1396 X_NUC_18.L_CORE X_NUC_71.L_CORE 0.004177
K_1397 X_NUC_18.L_CORE X_NUC_72.L_CORE 0.004158
K_1398 X_NUC_18.L_CORE X_NUC_73.L_CORE 0.003256
K_1399 X_NUC_18.L_CORE X_NUC_74.L_CORE 0.003279
K_1400 X_NUC_18.L_CORE X_NUC_75.L_CORE 0.003248
K_1401 X_NUC_18.L_CORE X_NUC_76.L_CORE 0.003229
K_1402 X_NUC_18.L_CORE X_NUC_77.L_CORE 0.004155
K_1403 X_NUC_18.L_CORE X_NUC_78.L_CORE 0.007457
K_1404 X_NUC_18.L_CORE X_NUC_79.L_CORE 0.004774
K_1405 X_NUC_18.L_CORE X_NUC_80.L_CORE 0.003315
K_1406 X_NUC_18.L_CORE X_NUC_81.L_CORE 0.015932
K_1407 X_NUC_18.L_CORE X_NUC_82.L_CORE 0.003049
K_1408 X_NUC_18.L_CORE X_NUC_83.L_CORE 0.003913
K_1409 X_NUC_18.L_CORE X_NUC_84.L_CORE 0.004768
K_1410 X_NUC_18.L_CORE X_NUC_85.L_CORE 0.002733
K_1411 X_NUC_18.L_CORE X_NUC_86.L_CORE 0.004497
K_1412 X_NUC_18.L_CORE X_NUC_87.L_CORE 0.003084
K_1413 X_NUC_18.L_CORE X_NUC_88.L_CORE 0.003002
K_1414 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_1415 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.003594
K_1416 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.003646
K_1417 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.003635
K_1418 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.003600
K_1419 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.004803
K_1420 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.004773
K_1421 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.004829
K_1422 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.004725
K_1423 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.006796
K_1424 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.007003
K_1425 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.006813
K_1426 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.006870
K_1427 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.003140
K_1428 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.003163
K_1429 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.003164
K_1430 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.003124
K_1431 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.008111
K_1432 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.007929
K_1433 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.007936
K_1434 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.007807
K_1435 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.003717
K_1436 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.003777
K_1437 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.003736
K_1438 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.003721
K_1439 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.003442
K_1440 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.003443
K_1441 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.003451
K_1442 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.003400
K_1443 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006737
K_1444 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006798
K_1445 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006601
K_1446 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.006649
K_1447 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.003020
K_1448 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.003049
K_1449 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.003033
K_1450 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.003006
K_1451 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.004313
K_1452 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.004290
K_1453 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.004282
K_1454 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.004229
K_1455 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.003974
K_1456 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.004023
K_1457 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.003959
K_1458 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.003955
K_1459 X_NUC_19.L_CORE X_NUC_65.L_CORE 0.003071
K_1460 X_NUC_19.L_CORE X_NUC_66.L_CORE 0.003083
K_1461 X_NUC_19.L_CORE X_NUC_67.L_CORE 0.003072
K_1462 X_NUC_19.L_CORE X_NUC_68.L_CORE 0.003041
K_1463 X_NUC_19.L_CORE X_NUC_69.L_CORE 0.004274
K_1464 X_NUC_19.L_CORE X_NUC_70.L_CORE 0.004280
K_1465 X_NUC_19.L_CORE X_NUC_71.L_CORE 0.004228
K_1466 X_NUC_19.L_CORE X_NUC_72.L_CORE 0.004207
K_1467 X_NUC_19.L_CORE X_NUC_73.L_CORE 0.003287
K_1468 X_NUC_19.L_CORE X_NUC_74.L_CORE 0.003310
K_1469 X_NUC_19.L_CORE X_NUC_75.L_CORE 0.003279
K_1470 X_NUC_19.L_CORE X_NUC_76.L_CORE 0.003259
K_1471 X_NUC_19.L_CORE X_NUC_77.L_CORE 0.004127
K_1472 X_NUC_19.L_CORE X_NUC_78.L_CORE 0.007223
K_1473 X_NUC_19.L_CORE X_NUC_79.L_CORE 0.004815
K_1474 X_NUC_19.L_CORE X_NUC_80.L_CORE 0.003295
K_1475 X_NUC_19.L_CORE X_NUC_81.L_CORE 0.016625
K_1476 X_NUC_19.L_CORE X_NUC_82.L_CORE 0.003064
K_1477 X_NUC_19.L_CORE X_NUC_83.L_CORE 0.003890
K_1478 X_NUC_19.L_CORE X_NUC_84.L_CORE 0.004876
K_1479 X_NUC_19.L_CORE X_NUC_85.L_CORE 0.002739
K_1480 X_NUC_19.L_CORE X_NUC_86.L_CORE 0.004534
K_1481 X_NUC_19.L_CORE X_NUC_87.L_CORE 0.003118
K_1482 X_NUC_19.L_CORE X_NUC_88.L_CORE 0.003017
K_1483 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.003628
K_1484 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.003682
K_1485 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.003669
K_1486 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.003635
K_1487 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.004911
K_1488 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.004880
K_1489 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.004937
K_1490 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.004829
K_1491 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.006737
K_1492 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.006939
K_1493 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.006750
K_1494 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.006813
K_1495 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.003181
K_1496 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.003204
K_1497 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.003206
K_1498 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.003164
K_1499 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.008249
K_1500 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.008058
K_1501 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.008059
K_1502 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.007936
K_1503 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.003732
K_1504 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.003793
K_1505 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.003751
K_1506 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.003736
K_1507 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.003494
K_1508 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.003495
K_1509 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.003504
K_1510 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.003451
K_1511 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006684
K_1512 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.006743
K_1513 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006548
K_1514 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006601
K_1515 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.003047
K_1516 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.003076
K_1517 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.003060
K_1518 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.003033
K_1519 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.004368
K_1520 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.004345
K_1521 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.004335
K_1522 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.004282
K_1523 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.003978
K_1524 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.004028
K_1525 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.003963
K_1526 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.003959
K_1527 X_NUC_20.L_CORE X_NUC_65.L_CORE 0.003103
K_1528 X_NUC_20.L_CORE X_NUC_66.L_CORE 0.003116
K_1529 X_NUC_20.L_CORE X_NUC_67.L_CORE 0.003105
K_1530 X_NUC_20.L_CORE X_NUC_68.L_CORE 0.003072
K_1531 X_NUC_20.L_CORE X_NUC_69.L_CORE 0.004295
K_1532 X_NUC_20.L_CORE X_NUC_70.L_CORE 0.004301
K_1533 X_NUC_20.L_CORE X_NUC_71.L_CORE 0.004248
K_1534 X_NUC_20.L_CORE X_NUC_72.L_CORE 0.004228
K_1535 X_NUC_20.L_CORE X_NUC_73.L_CORE 0.003307
K_1536 X_NUC_20.L_CORE X_NUC_74.L_CORE 0.003331
K_1537 X_NUC_20.L_CORE X_NUC_75.L_CORE 0.003299
K_1538 X_NUC_20.L_CORE X_NUC_76.L_CORE 0.003279
K_1539 X_NUC_20.L_CORE X_NUC_77.L_CORE 0.004186
K_1540 X_NUC_20.L_CORE X_NUC_78.L_CORE 0.007433
K_1541 X_NUC_20.L_CORE X_NUC_79.L_CORE 0.004822
K_1542 X_NUC_20.L_CORE X_NUC_80.L_CORE 0.003347
K_1543 X_NUC_20.L_CORE X_NUC_81.L_CORE 0.015797
K_1544 X_NUC_20.L_CORE X_NUC_82.L_CORE 0.003086
K_1545 X_NUC_20.L_CORE X_NUC_83.L_CORE 0.003953
K_1546 X_NUC_20.L_CORE X_NUC_84.L_CORE 0.004839
K_1547 X_NUC_20.L_CORE X_NUC_85.L_CORE 0.002767
K_1548 X_NUC_20.L_CORE X_NUC_86.L_CORE 0.004559
K_1549 X_NUC_20.L_CORE X_NUC_87.L_CORE 0.003128
K_1550 X_NUC_20.L_CORE X_NUC_88.L_CORE 0.003042
K_1551 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_1552 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_1553 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_1554 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.003443
K_1555 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.003387
K_1556 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.003416
K_1557 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.003408
K_1558 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.004620
K_1559 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.004572
K_1560 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.004541
K_1561 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.004628
K_1562 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.006614
K_1563 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.006504
K_1564 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.006586
K_1565 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.006430
K_1566 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.003066
K_1567 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.003024
K_1568 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.003032
K_1569 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.003045
K_1570 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.007926
K_1571 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.007940
K_1572 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.007685
K_1573 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.007889
K_1574 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.003673
K_1575 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.003620
K_1576 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.003642
K_1577 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.003616
K_1578 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.003411
K_1579 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.003375
K_1580 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.003359
K_1581 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.003394
K_1582 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.006633
K_1583 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.006601
K_1584 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.006513
K_1585 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.006449
K_1586 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.003033
K_1587 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.002995
K_1588 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.002998
K_1589 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.002999
K_1590 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.004288
K_1591 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.004261
K_1592 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.004203
K_1593 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.004253
K_1594 X_NUC_21.L_CORE X_NUC_65.L_CORE 0.003974
K_1595 X_NUC_21.L_CORE X_NUC_66.L_CORE 0.003932
K_1596 X_NUC_21.L_CORE X_NUC_67.L_CORE 0.003924
K_1597 X_NUC_21.L_CORE X_NUC_68.L_CORE 0.003901
K_1598 X_NUC_21.L_CORE X_NUC_69.L_CORE 0.003164
K_1599 X_NUC_21.L_CORE X_NUC_70.L_CORE 0.003131
K_1600 X_NUC_21.L_CORE X_NUC_71.L_CORE 0.003118
K_1601 X_NUC_21.L_CORE X_NUC_72.L_CORE 0.003132
K_1602 X_NUC_21.L_CORE X_NUC_73.L_CORE 0.003995
K_1603 X_NUC_21.L_CORE X_NUC_74.L_CORE 0.003965
K_1604 X_NUC_21.L_CORE X_NUC_75.L_CORE 0.003926
K_1605 X_NUC_21.L_CORE X_NUC_76.L_CORE 0.003936
K_1606 X_NUC_21.L_CORE X_NUC_77.L_CORE 0.006822
K_1607 X_NUC_21.L_CORE X_NUC_78.L_CORE 0.003395
K_1608 X_NUC_21.L_CORE X_NUC_79.L_CORE 0.006859
K_1609 X_NUC_21.L_CORE X_NUC_80.L_CORE 0.004397
K_1610 X_NUC_21.L_CORE X_NUC_81.L_CORE 0.003090
K_1611 X_NUC_21.L_CORE X_NUC_82.L_CORE 0.014183
K_1612 X_NUC_21.L_CORE X_NUC_83.L_CORE 0.002938
K_1613 X_NUC_21.L_CORE X_NUC_84.L_CORE 0.003776
K_1614 X_NUC_21.L_CORE X_NUC_85.L_CORE 0.004633
K_1615 X_NUC_21.L_CORE X_NUC_86.L_CORE 0.002732
K_1616 X_NUC_21.L_CORE X_NUC_87.L_CORE 0.004241
K_1617 X_NUC_21.L_CORE X_NUC_88.L_CORE 0.003146
K_1618 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_1619 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_1620 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.003500
K_1621 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.003443
K_1622 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.003473
K_1623 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.003463
K_1624 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.004666
K_1625 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.004620
K_1626 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.004586
K_1627 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.004676
K_1628 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.006721
K_1629 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.006614
K_1630 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.006696
K_1631 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.006532
K_1632 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.003108
K_1633 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.003066
K_1634 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.003073
K_1635 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.003087
K_1636 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.007901
K_1637 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.007926
K_1638 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.007667
K_1639 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.007869
K_1640 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.003727
K_1641 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.003673
K_1642 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.003695
K_1643 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.003668
K_1644 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.003447
K_1645 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.003411
K_1646 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.003394
K_1647 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.003430
K_1648 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.006658
K_1649 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.006633
K_1650 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.006540
K_1651 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.006475
K_1652 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.003072
K_1653 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.003033
K_1654 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.003036
K_1655 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.003038
K_1656 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.004313
K_1657 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.004288
K_1658 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.004228
K_1659 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.004279
K_1660 X_NUC_22.L_CORE X_NUC_65.L_CORE 0.004016
K_1661 X_NUC_22.L_CORE X_NUC_66.L_CORE 0.003974
K_1662 X_NUC_22.L_CORE X_NUC_67.L_CORE 0.003965
K_1663 X_NUC_22.L_CORE X_NUC_68.L_CORE 0.003941
K_1664 X_NUC_22.L_CORE X_NUC_69.L_CORE 0.003197
K_1665 X_NUC_22.L_CORE X_NUC_70.L_CORE 0.003164
K_1666 X_NUC_22.L_CORE X_NUC_71.L_CORE 0.003150
K_1667 X_NUC_22.L_CORE X_NUC_72.L_CORE 0.003164
K_1668 X_NUC_22.L_CORE X_NUC_73.L_CORE 0.004023
K_1669 X_NUC_22.L_CORE X_NUC_74.L_CORE 0.003995
K_1670 X_NUC_22.L_CORE X_NUC_75.L_CORE 0.003954
K_1671 X_NUC_22.L_CORE X_NUC_76.L_CORE 0.003964
K_1672 X_NUC_22.L_CORE X_NUC_77.L_CORE 0.006967
K_1673 X_NUC_22.L_CORE X_NUC_78.L_CORE 0.003449
K_1674 X_NUC_22.L_CORE X_NUC_79.L_CORE 0.006898
K_1675 X_NUC_22.L_CORE X_NUC_80.L_CORE 0.004469
K_1676 X_NUC_22.L_CORE X_NUC_81.L_CORE 0.003127
K_1677 X_NUC_22.L_CORE X_NUC_82.L_CORE 0.013611
K_1678 X_NUC_22.L_CORE X_NUC_83.L_CORE 0.002978
K_1679 X_NUC_22.L_CORE X_NUC_84.L_CORE 0.003800
K_1680 X_NUC_22.L_CORE X_NUC_85.L_CORE 0.004668
K_1681 X_NUC_22.L_CORE X_NUC_86.L_CORE 0.002762
K_1682 X_NUC_22.L_CORE X_NUC_87.L_CORE 0.004250
K_1683 X_NUC_22.L_CORE X_NUC_88.L_CORE 0.003174
K_1684 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_1685 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.003468
K_1686 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.003412
K_1687 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.003443
K_1688 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.003433
K_1689 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.004701
K_1690 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.004652
K_1691 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.004620
K_1692 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.004711
K_1693 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.006635
K_1694 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.006527
K_1695 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.006614
K_1696 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.006452
K_1697 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.003101
K_1698 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.003058
K_1699 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.003066
K_1700 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.003079
K_1701 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.008179
K_1702 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.008201
K_1703 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.007926
K_1704 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.008144
K_1705 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.003704
K_1706 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.003651
K_1707 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.003673
K_1708 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.003646
K_1709 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.003464
K_1710 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.003427
K_1711 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.003411
K_1712 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.003447
K_1713 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.006753
K_1714 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.006723
K_1715 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.006633
K_1716 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.006562
K_1717 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.003068
K_1718 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.003029
K_1719 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.003033
K_1720 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.003034
K_1721 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.004376
K_1722 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.004348
K_1723 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.004288
K_1724 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.004340
K_1725 X_NUC_23.L_CORE X_NUC_65.L_CORE 0.004025
K_1726 X_NUC_23.L_CORE X_NUC_66.L_CORE 0.003982
K_1727 X_NUC_23.L_CORE X_NUC_67.L_CORE 0.003974
K_1728 X_NUC_23.L_CORE X_NUC_68.L_CORE 0.003950
K_1729 X_NUC_23.L_CORE X_NUC_69.L_CORE 0.003211
K_1730 X_NUC_23.L_CORE X_NUC_70.L_CORE 0.003177
K_1731 X_NUC_23.L_CORE X_NUC_71.L_CORE 0.003164
K_1732 X_NUC_23.L_CORE X_NUC_72.L_CORE 0.003178
K_1733 X_NUC_23.L_CORE X_NUC_73.L_CORE 0.004065
K_1734 X_NUC_23.L_CORE X_NUC_74.L_CORE 0.004035
K_1735 X_NUC_23.L_CORE X_NUC_75.L_CORE 0.003995
K_1736 X_NUC_23.L_CORE X_NUC_76.L_CORE 0.004004
K_1737 X_NUC_23.L_CORE X_NUC_77.L_CORE 0.006756
K_1738 X_NUC_23.L_CORE X_NUC_78.L_CORE 0.003415
K_1739 X_NUC_23.L_CORE X_NUC_79.L_CORE 0.006936
K_1740 X_NUC_23.L_CORE X_NUC_80.L_CORE 0.004398
K_1741 X_NUC_23.L_CORE X_NUC_81.L_CORE 0.003124
K_1742 X_NUC_23.L_CORE X_NUC_82.L_CORE 0.014338
K_1743 X_NUC_23.L_CORE X_NUC_83.L_CORE 0.002961
K_1744 X_NUC_23.L_CORE X_NUC_84.L_CORE 0.003839
K_1745 X_NUC_23.L_CORE X_NUC_85.L_CORE 0.004672
K_1746 X_NUC_23.L_CORE X_NUC_86.L_CORE 0.002765
K_1747 X_NUC_23.L_CORE X_NUC_87.L_CORE 0.004318
K_1748 X_NUC_23.L_CORE X_NUC_88.L_CORE 0.003184
K_1749 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.003478
K_1750 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.003421
K_1751 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.003451
K_1752 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.003443
K_1753 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.004609
K_1754 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.004563
K_1755 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.004531
K_1756 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.004620
K_1757 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.006807
K_1758 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.006691
K_1759 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.006781
K_1760 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.006614
K_1761 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.003087
K_1762 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.003045
K_1763 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.003052
K_1764 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.003066
K_1765 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.007953
K_1766 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.007973
K_1767 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.007714
K_1768 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.007926
K_1769 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.003732
K_1770 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.003677
K_1771 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.003700
K_1772 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.003673
K_1773 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.003427
K_1774 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.003391
K_1775 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.003375
K_1776 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.003411
K_1777 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.006826
K_1778 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.006795
K_1779 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.006699
K_1780 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.006633
K_1781 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.003067
K_1782 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.003028
K_1783 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.003032
K_1784 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.003033
K_1785 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.004322
K_1786 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.004296
K_1787 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.004236
K_1788 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.004288
K_1789 X_NUC_24.L_CORE X_NUC_65.L_CORE 0.004050
K_1790 X_NUC_24.L_CORE X_NUC_66.L_CORE 0.004006
K_1791 X_NUC_24.L_CORE X_NUC_67.L_CORE 0.003998
K_1792 X_NUC_24.L_CORE X_NUC_68.L_CORE 0.003974
K_1793 X_NUC_24.L_CORE X_NUC_69.L_CORE 0.003196
K_1794 X_NUC_24.L_CORE X_NUC_70.L_CORE 0.003163
K_1795 X_NUC_24.L_CORE X_NUC_71.L_CORE 0.003149
K_1796 X_NUC_24.L_CORE X_NUC_72.L_CORE 0.003164
K_1797 X_NUC_24.L_CORE X_NUC_73.L_CORE 0.004054
K_1798 X_NUC_24.L_CORE X_NUC_74.L_CORE 0.004024
K_1799 X_NUC_24.L_CORE X_NUC_75.L_CORE 0.003984
K_1800 X_NUC_24.L_CORE X_NUC_76.L_CORE 0.003995
K_1801 X_NUC_24.L_CORE X_NUC_77.L_CORE 0.006790
K_1802 X_NUC_24.L_CORE X_NUC_78.L_CORE 0.003408
K_1803 X_NUC_24.L_CORE X_NUC_79.L_CORE 0.006727
K_1804 X_NUC_24.L_CORE X_NUC_80.L_CORE 0.004459
K_1805 X_NUC_24.L_CORE X_NUC_81.L_CORE 0.003097
K_1806 X_NUC_24.L_CORE X_NUC_82.L_CORE 0.014480
K_1807 X_NUC_24.L_CORE X_NUC_83.L_CORE 0.002969
K_1808 X_NUC_24.L_CORE X_NUC_84.L_CORE 0.003782
K_1809 X_NUC_24.L_CORE X_NUC_85.L_CORE 0.004737
K_1810 X_NUC_24.L_CORE X_NUC_86.L_CORE 0.002755
K_1811 X_NUC_24.L_CORE X_NUC_87.L_CORE 0.004289
K_1812 X_NUC_24.L_CORE X_NUC_88.L_CORE 0.003190
K_1813 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_1814 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_1815 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_1816 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.003317
K_1817 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.003350
K_1818 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.003310
K_1819 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.003352
K_1820 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.004486
K_1821 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.004578
K_1822 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.004536
K_1823 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.004504
K_1824 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.006489
K_1825 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.006463
K_1826 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.006336
K_1827 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.006520
K_1828 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.003011
K_1829 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.003051
K_1830 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.003015
K_1831 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.003033
K_1832 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.007918
K_1833 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.008064
K_1834 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.007916
K_1835 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.007763
K_1836 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.003653
K_1837 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.003676
K_1838 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.003620
K_1839 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.003674
K_1840 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.003411
K_1841 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.003462
K_1842 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.003419
K_1843 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.003419
K_1844 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.006601
K_1845 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.006594
K_1846 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.006427
K_1847 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.006499
K_1848 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.003077
K_1849 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.003108
K_1850 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.003064
K_1851 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.003089
K_1852 X_NUC_25.L_CORE X_NUC_65.L_CORE 0.004304
K_1853 X_NUC_25.L_CORE X_NUC_66.L_CORE 0.004360
K_1854 X_NUC_25.L_CORE X_NUC_67.L_CORE 0.004290
K_1855 X_NUC_25.L_CORE X_NUC_68.L_CORE 0.004277
K_1856 X_NUC_25.L_CORE X_NUC_69.L_CORE 0.003999
K_1857 X_NUC_25.L_CORE X_NUC_70.L_CORE 0.004020
K_1858 X_NUC_25.L_CORE X_NUC_71.L_CORE 0.003946
K_1859 X_NUC_25.L_CORE X_NUC_72.L_CORE 0.003989
K_1860 X_NUC_25.L_CORE X_NUC_73.L_CORE 0.003375
K_1861 X_NUC_25.L_CORE X_NUC_74.L_CORE 0.003411
K_1862 X_NUC_25.L_CORE X_NUC_75.L_CORE 0.003358
K_1863 X_NUC_25.L_CORE X_NUC_76.L_CORE 0.003372
K_1864 X_NUC_25.L_CORE X_NUC_77.L_CORE 0.004330
K_1865 X_NUC_25.L_CORE X_NUC_78.L_CORE 0.007878
K_1866 X_NUC_25.L_CORE X_NUC_79.L_CORE 0.003099
K_1867 X_NUC_25.L_CORE X_NUC_80.L_CORE 0.006575
K_1868 X_NUC_25.L_CORE X_NUC_81.L_CORE 0.004200
K_1869 X_NUC_25.L_CORE X_NUC_82.L_CORE 0.003008
K_1870 X_NUC_25.L_CORE X_NUC_83.L_CORE 0.012208
K_1871 X_NUC_25.L_CORE X_NUC_84.L_CORE 0.002923
K_1872 X_NUC_25.L_CORE X_NUC_85.L_CORE 0.003765
K_1873 X_NUC_25.L_CORE X_NUC_86.L_CORE 0.004513
K_1874 X_NUC_25.L_CORE X_NUC_87.L_CORE 0.002844
K_1875 X_NUC_25.L_CORE X_NUC_88.L_CORE 0.003902
K_1876 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_1877 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_1878 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.003284
K_1879 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.003317
K_1880 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.003278
K_1881 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.003319
K_1882 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.004397
K_1883 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.004486
K_1884 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.004445
K_1885 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.004415
K_1886 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.006508
K_1887 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.006489
K_1888 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.006357
K_1889 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.006542
K_1890 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.002973
K_1891 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.003011
K_1892 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.002977
K_1893 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.002994
K_1894 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.007769
K_1895 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.007918
K_1896 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.007772
K_1897 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.007628
K_1898 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.003630
K_1899 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.003653
K_1900 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.003598
K_1901 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.003651
K_1902 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.003361
K_1903 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.003411
K_1904 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.003369
K_1905 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.003369
K_1906 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.006602
K_1907 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.006601
K_1908 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.006431
K_1909 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.006502
K_1910 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.003047
K_1911 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.003077
K_1912 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.003034
K_1913 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.003059
K_1914 X_NUC_26.L_CORE X_NUC_65.L_CORE 0.004247
K_1915 X_NUC_26.L_CORE X_NUC_66.L_CORE 0.004304
K_1916 X_NUC_26.L_CORE X_NUC_67.L_CORE 0.004235
K_1917 X_NUC_26.L_CORE X_NUC_68.L_CORE 0.004223
K_1918 X_NUC_26.L_CORE X_NUC_69.L_CORE 0.003977
K_1919 X_NUC_26.L_CORE X_NUC_70.L_CORE 0.003999
K_1920 X_NUC_26.L_CORE X_NUC_71.L_CORE 0.003926
K_1921 X_NUC_26.L_CORE X_NUC_72.L_CORE 0.003967
K_1922 X_NUC_26.L_CORE X_NUC_73.L_CORE 0.003340
K_1923 X_NUC_26.L_CORE X_NUC_74.L_CORE 0.003375
K_1924 X_NUC_26.L_CORE X_NUC_75.L_CORE 0.003323
K_1925 X_NUC_26.L_CORE X_NUC_76.L_CORE 0.003338
K_1926 X_NUC_26.L_CORE X_NUC_77.L_CORE 0.004256
K_1927 X_NUC_26.L_CORE X_NUC_78.L_CORE 0.007862
K_1928 X_NUC_26.L_CORE X_NUC_79.L_CORE 0.003062
K_1929 X_NUC_26.L_CORE X_NUC_80.L_CORE 0.006425
K_1930 X_NUC_26.L_CORE X_NUC_81.L_CORE 0.004190
K_1931 X_NUC_26.L_CORE X_NUC_82.L_CORE 0.002966
K_1932 X_NUC_26.L_CORE X_NUC_83.L_CORE 0.012511
K_1933 X_NUC_26.L_CORE X_NUC_84.L_CORE 0.002899
K_1934 X_NUC_26.L_CORE X_NUC_85.L_CORE 0.003711
K_1935 X_NUC_26.L_CORE X_NUC_86.L_CORE 0.004518
K_1936 X_NUC_26.L_CORE X_NUC_87.L_CORE 0.002816
K_1937 X_NUC_26.L_CORE X_NUC_88.L_CORE 0.003873
K_1938 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_1939 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.003323
K_1940 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.003357
K_1941 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.003317
K_1942 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.003359
K_1943 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.004436
K_1944 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.004526
K_1945 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.004486
K_1946 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.004454
K_1947 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.006646
K_1948 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.006622
K_1949 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.006489
K_1950 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.006683
K_1951 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.003007
K_1952 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.003047
K_1953 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.003011
K_1954 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.003029
K_1955 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.007909
K_1956 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.008060
K_1957 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.007918
K_1958 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.007760
K_1959 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.003687
K_1960 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.003710
K_1961 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.003653
K_1962 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.003709
K_1963 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.003402
K_1964 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.003453
K_1965 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.003411
K_1966 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.003410
K_1967 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.006783
K_1968 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.006779
K_1969 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.006601
K_1970 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.006675
K_1971 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.003090
K_1972 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.003121
K_1973 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.003077
K_1974 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.003103
K_1975 X_NUC_27.L_CORE X_NUC_65.L_CORE 0.004316
K_1976 X_NUC_27.L_CORE X_NUC_66.L_CORE 0.004374
K_1977 X_NUC_27.L_CORE X_NUC_67.L_CORE 0.004304
K_1978 X_NUC_27.L_CORE X_NUC_68.L_CORE 0.004290
K_1979 X_NUC_27.L_CORE X_NUC_69.L_CORE 0.004052
K_1980 X_NUC_27.L_CORE X_NUC_70.L_CORE 0.004075
K_1981 X_NUC_27.L_CORE X_NUC_71.L_CORE 0.003999
K_1982 X_NUC_27.L_CORE X_NUC_72.L_CORE 0.004042
K_1983 X_NUC_27.L_CORE X_NUC_73.L_CORE 0.003392
K_1984 X_NUC_27.L_CORE X_NUC_74.L_CORE 0.003429
K_1985 X_NUC_27.L_CORE X_NUC_75.L_CORE 0.003375
K_1986 X_NUC_27.L_CORE X_NUC_76.L_CORE 0.003390
K_1987 X_NUC_27.L_CORE X_NUC_77.L_CORE 0.004263
K_1988 X_NUC_27.L_CORE X_NUC_78.L_CORE 0.007812
K_1989 X_NUC_27.L_CORE X_NUC_79.L_CORE 0.003087
K_1990 X_NUC_27.L_CORE X_NUC_80.L_CORE 0.006408
K_1991 X_NUC_27.L_CORE X_NUC_81.L_CORE 0.004239
K_1992 X_NUC_27.L_CORE X_NUC_82.L_CORE 0.002992
K_1993 X_NUC_27.L_CORE X_NUC_83.L_CORE 0.012731
K_1994 X_NUC_27.L_CORE X_NUC_84.L_CORE 0.002935
K_1995 X_NUC_27.L_CORE X_NUC_85.L_CORE 0.003751
K_1996 X_NUC_27.L_CORE X_NUC_86.L_CORE 0.004602
K_1997 X_NUC_27.L_CORE X_NUC_87.L_CORE 0.002852
K_1998 X_NUC_27.L_CORE X_NUC_88.L_CORE 0.003937
K_1999 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.003282
K_2000 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.003314
K_2001 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.003276
K_2002 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.003317
K_2003 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.004466
K_2004 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.004558
K_2005 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.004516
K_2006 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.004486
K_2007 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.006452
K_2008 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.006430
K_2009 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.006305
K_2010 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.006489
K_2011 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.002990
K_2012 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.003028
K_2013 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.002993
K_2014 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.003011
K_2015 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.008070
K_2016 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.008231
K_2017 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.008074
K_2018 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.007918
K_2019 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.003632
K_2020 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.003654
K_2021 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.003599
K_2022 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.003653
K_2023 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.003402
K_2024 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.003453
K_2025 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.003411
K_2026 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.003411
K_2027 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.006702
K_2028 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.006698
K_2029 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.006523
K_2030 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.006601
K_2031 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.003065
K_2032 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.003095
K_2033 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.003052
K_2034 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.003077
K_2035 X_NUC_28.L_CORE X_NUC_65.L_CORE 0.004329
K_2036 X_NUC_28.L_CORE X_NUC_66.L_CORE 0.004388
K_2037 X_NUC_28.L_CORE X_NUC_67.L_CORE 0.004316
K_2038 X_NUC_28.L_CORE X_NUC_68.L_CORE 0.004304
K_2039 X_NUC_28.L_CORE X_NUC_69.L_CORE 0.004008
K_2040 X_NUC_28.L_CORE X_NUC_70.L_CORE 0.004030
K_2041 X_NUC_28.L_CORE X_NUC_71.L_CORE 0.003956
K_2042 X_NUC_28.L_CORE X_NUC_72.L_CORE 0.003999
K_2043 X_NUC_28.L_CORE X_NUC_73.L_CORE 0.003378
K_2044 X_NUC_28.L_CORE X_NUC_74.L_CORE 0.003414
K_2045 X_NUC_28.L_CORE X_NUC_75.L_CORE 0.003360
K_2046 X_NUC_28.L_CORE X_NUC_76.L_CORE 0.003375
K_2047 X_NUC_28.L_CORE X_NUC_77.L_CORE 0.004254
K_2048 X_NUC_28.L_CORE X_NUC_78.L_CORE 0.007624
K_2049 X_NUC_28.L_CORE X_NUC_79.L_CORE 0.003062
K_2050 X_NUC_28.L_CORE X_NUC_80.L_CORE 0.006537
K_2051 X_NUC_28.L_CORE X_NUC_81.L_CORE 0.004154
K_2052 X_NUC_28.L_CORE X_NUC_82.L_CORE 0.002988
K_2053 X_NUC_28.L_CORE X_NUC_83.L_CORE 0.012926
K_2054 X_NUC_28.L_CORE X_NUC_84.L_CORE 0.002904
K_2055 X_NUC_28.L_CORE X_NUC_85.L_CORE 0.003773
K_2056 X_NUC_28.L_CORE X_NUC_86.L_CORE 0.004537
K_2057 X_NUC_28.L_CORE X_NUC_87.L_CORE 0.002839
K_2058 X_NUC_28.L_CORE X_NUC_88.L_CORE 0.003934
K_2059 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_2060 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_2061 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_2062 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.003241
K_2063 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.003244
K_2064 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.003265
K_2065 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.003215
K_2066 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.004411
K_2067 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.004328
K_2068 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.004377
K_2069 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.004341
K_2070 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.006428
K_2071 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.006567
K_2072 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.006511
K_2073 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.006383
K_2074 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.002994
K_2075 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.002978
K_2076 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.002999
K_2077 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.002960
K_2078 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.007918
K_2079 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.007706
K_2080 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.007671
K_2081 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.007665
K_2082 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.003673
K_2083 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.003692
K_2084 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.003693
K_2085 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.003637
K_2086 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.003451
K_2087 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.003414
K_2088 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.003433
K_2089 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.003398
K_2090 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.006501
K_2091 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.006538
K_2092 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.006423
K_2093 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.006356
K_2094 X_NUC_29.L_CORE X_NUC_65.L_CORE 0.003174
K_2095 X_NUC_29.L_CORE X_NUC_66.L_CORE 0.003168
K_2096 X_NUC_29.L_CORE X_NUC_67.L_CORE 0.003174
K_2097 X_NUC_29.L_CORE X_NUC_68.L_CORE 0.003134
K_2098 X_NUC_29.L_CORE X_NUC_69.L_CORE 0.004319
K_2099 X_NUC_29.L_CORE X_NUC_70.L_CORE 0.004274
K_2100 X_NUC_29.L_CORE X_NUC_71.L_CORE 0.004267
K_2101 X_NUC_29.L_CORE X_NUC_72.L_CORE 0.004232
K_2102 X_NUC_29.L_CORE X_NUC_73.L_CORE 0.004012
K_2103 X_NUC_29.L_CORE X_NUC_74.L_CORE 0.004012
K_2104 X_NUC_29.L_CORE X_NUC_75.L_CORE 0.003993
K_2105 X_NUC_29.L_CORE X_NUC_76.L_CORE 0.003946
K_2106 X_NUC_29.L_CORE X_NUC_77.L_CORE 0.003892
K_2107 X_NUC_29.L_CORE X_NUC_78.L_CORE 0.003820
K_2108 X_NUC_29.L_CORE X_NUC_79.L_CORE 0.008425
K_2109 X_NUC_29.L_CORE X_NUC_80.L_CORE 0.002888
K_2110 X_NUC_29.L_CORE X_NUC_81.L_CORE 0.006161
K_2111 X_NUC_29.L_CORE X_NUC_82.L_CORE 0.004084
K_2112 X_NUC_29.L_CORE X_NUC_83.L_CORE 0.002917
K_2113 X_NUC_29.L_CORE X_NUC_84.L_CORE 0.011015
K_2114 X_NUC_29.L_CORE X_NUC_85.L_CORE 0.002923
K_2115 X_NUC_29.L_CORE X_NUC_86.L_CORE 0.003716
K_2116 X_NUC_29.L_CORE X_NUC_87.L_CORE 0.004385
K_2117 X_NUC_29.L_CORE X_NUC_88.L_CORE 0.003058
K_2118 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_2119 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_2120 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.003237
K_2121 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.003241
K_2122 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.003262
K_2123 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.003212
K_2124 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.004497
K_2125 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.004411
K_2126 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.004462
K_2127 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.004423
K_2128 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.006293
K_2129 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.006428
K_2130 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.006373
K_2131 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.006253
K_2132 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.003010
K_2133 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.002994
K_2134 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.003015
K_2135 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.002976
K_2136 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.008137
K_2137 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.007918
K_2138 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.007875
K_2139 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.007869
K_2140 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.003654
K_2141 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.003673
K_2142 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.003674
K_2143 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.003618
K_2144 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.003489
K_2145 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.003451
K_2146 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.003470
K_2147 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.003435
K_2148 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.006459
K_2149 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.006501
K_2150 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.006385
K_2151 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.006319
K_2152 X_NUC_30.L_CORE X_NUC_65.L_CORE 0.003180
K_2153 X_NUC_30.L_CORE X_NUC_66.L_CORE 0.003174
K_2154 X_NUC_30.L_CORE X_NUC_67.L_CORE 0.003181
K_2155 X_NUC_30.L_CORE X_NUC_68.L_CORE 0.003140
K_2156 X_NUC_30.L_CORE X_NUC_69.L_CORE 0.004364
K_2157 X_NUC_30.L_CORE X_NUC_70.L_CORE 0.004319
K_2158 X_NUC_30.L_CORE X_NUC_71.L_CORE 0.004311
K_2159 X_NUC_30.L_CORE X_NUC_72.L_CORE 0.004275
K_2160 X_NUC_30.L_CORE X_NUC_73.L_CORE 0.004010
K_2161 X_NUC_30.L_CORE X_NUC_74.L_CORE 0.004012
K_2162 X_NUC_30.L_CORE X_NUC_75.L_CORE 0.003992
K_2163 X_NUC_30.L_CORE X_NUC_76.L_CORE 0.003945
K_2164 X_NUC_30.L_CORE X_NUC_77.L_CORE 0.003890
K_2165 X_NUC_30.L_CORE X_NUC_78.L_CORE 0.003869
K_2166 X_NUC_30.L_CORE X_NUC_79.L_CORE 0.008221
K_2167 X_NUC_30.L_CORE X_NUC_80.L_CORE 0.002896
K_2168 X_NUC_30.L_CORE X_NUC_81.L_CORE 0.006348
K_2169 X_NUC_30.L_CORE X_NUC_82.L_CORE 0.004038
K_2170 X_NUC_30.L_CORE X_NUC_83.L_CORE 0.002944
K_2171 X_NUC_30.L_CORE X_NUC_84.L_CORE 0.010961
K_2172 X_NUC_30.L_CORE X_NUC_85.L_CORE 0.002920
K_2173 X_NUC_30.L_CORE X_NUC_86.L_CORE 0.003766
K_2174 X_NUC_30.L_CORE X_NUC_87.L_CORE 0.004355
K_2175 X_NUC_30.L_CORE X_NUC_88.L_CORE 0.003070
K_2176 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_2177 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.003216
K_2178 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.003219
K_2179 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.003241
K_2180 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.003191
K_2181 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.004444
K_2182 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.004360
K_2183 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.004411
K_2184 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.004373
K_2185 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.006343
K_2186 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.006479
K_2187 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.006428
K_2188 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.006302
K_2189 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.002989
K_2190 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.002973
K_2191 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.002994
K_2192 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.002955
K_2193 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.008178
K_2194 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.007951
K_2195 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.007918
K_2196 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.007906
K_2197 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.003653
K_2198 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.003672
K_2199 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.003673
K_2200 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.003617
K_2201 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.003469
K_2202 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.003432
K_2203 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.003451
K_2204 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.003416
K_2205 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.006576
K_2206 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.006618
K_2207 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.006501
K_2208 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.006429
K_2209 X_NUC_31.L_CORE X_NUC_65.L_CORE 0.003174
K_2210 X_NUC_31.L_CORE X_NUC_66.L_CORE 0.003168
K_2211 X_NUC_31.L_CORE X_NUC_67.L_CORE 0.003174
K_2212 X_NUC_31.L_CORE X_NUC_68.L_CORE 0.003133
K_2213 X_NUC_31.L_CORE X_NUC_69.L_CORE 0.004372
K_2214 X_NUC_31.L_CORE X_NUC_70.L_CORE 0.004326
K_2215 X_NUC_31.L_CORE X_NUC_71.L_CORE 0.004319
K_2216 X_NUC_31.L_CORE X_NUC_72.L_CORE 0.004282
K_2217 X_NUC_31.L_CORE X_NUC_73.L_CORE 0.004029
K_2218 X_NUC_31.L_CORE X_NUC_74.L_CORE 0.004030
K_2219 X_NUC_31.L_CORE X_NUC_75.L_CORE 0.004012
K_2220 X_NUC_31.L_CORE X_NUC_76.L_CORE 0.003963
K_2221 X_NUC_31.L_CORE X_NUC_77.L_CORE 0.003833
K_2222 X_NUC_31.L_CORE X_NUC_78.L_CORE 0.003802
K_2223 X_NUC_31.L_CORE X_NUC_79.L_CORE 0.008100
K_2224 X_NUC_31.L_CORE X_NUC_80.L_CORE 0.002869
K_2225 X_NUC_31.L_CORE X_NUC_81.L_CORE 0.006241
K_2226 X_NUC_31.L_CORE X_NUC_82.L_CORE 0.004034
K_2227 X_NUC_31.L_CORE X_NUC_83.L_CORE 0.002919
K_2228 X_NUC_31.L_CORE X_NUC_84.L_CORE 0.011488
K_2229 X_NUC_31.L_CORE X_NUC_85.L_CORE 0.002912
K_2230 X_NUC_31.L_CORE X_NUC_86.L_CORE 0.003756
K_2231 X_NUC_31.L_CORE X_NUC_87.L_CORE 0.004400
K_2232 X_NUC_31.L_CORE X_NUC_88.L_CORE 0.003069
K_2233 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.003266
K_2234 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.003269
K_2235 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.003292
K_2236 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.003241
K_2237 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.004483
K_2238 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.004397
K_2239 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.004449
K_2240 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.004411
K_2241 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.006468
K_2242 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.006613
K_2243 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.006556
K_2244 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.006428
K_2245 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.003028
K_2246 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.003012
K_2247 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.003033
K_2248 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.002994
K_2249 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.008185
K_2250 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.007957
K_2251 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.007918
K_2252 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.007918
K_2253 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.003710
K_2254 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.003730
K_2255 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.003731
K_2256 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.003673
K_2257 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.003506
K_2258 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.003467
K_2259 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.003487
K_2260 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.003451
K_2261 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.006651
K_2262 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.006693
K_2263 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.006570
K_2264 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.006501
K_2265 X_NUC_32.L_CORE X_NUC_65.L_CORE 0.003216
K_2266 X_NUC_32.L_CORE X_NUC_66.L_CORE 0.003209
K_2267 X_NUC_32.L_CORE X_NUC_67.L_CORE 0.003216
K_2268 X_NUC_32.L_CORE X_NUC_68.L_CORE 0.003174
K_2269 X_NUC_32.L_CORE X_NUC_69.L_CORE 0.004411
K_2270 X_NUC_32.L_CORE X_NUC_70.L_CORE 0.004363
K_2271 X_NUC_32.L_CORE X_NUC_71.L_CORE 0.004356
K_2272 X_NUC_32.L_CORE X_NUC_72.L_CORE 0.004319
K_2273 X_NUC_32.L_CORE X_NUC_73.L_CORE 0.004079
K_2274 X_NUC_32.L_CORE X_NUC_74.L_CORE 0.004080
K_2275 X_NUC_32.L_CORE X_NUC_75.L_CORE 0.004060
K_2276 X_NUC_32.L_CORE X_NUC_76.L_CORE 0.004012
K_2277 X_NUC_32.L_CORE X_NUC_77.L_CORE 0.003892
K_2278 X_NUC_32.L_CORE X_NUC_78.L_CORE 0.003843
K_2279 X_NUC_32.L_CORE X_NUC_79.L_CORE 0.008238
K_2280 X_NUC_32.L_CORE X_NUC_80.L_CORE 0.002908
K_2281 X_NUC_32.L_CORE X_NUC_81.L_CORE 0.006240
K_2282 X_NUC_32.L_CORE X_NUC_82.L_CORE 0.004098
K_2283 X_NUC_32.L_CORE X_NUC_83.L_CORE 0.002950
K_2284 X_NUC_32.L_CORE X_NUC_84.L_CORE 0.011298
K_2285 X_NUC_32.L_CORE X_NUC_85.L_CORE 0.002951
K_2286 X_NUC_32.L_CORE X_NUC_86.L_CORE 0.003780
K_2287 X_NUC_32.L_CORE X_NUC_87.L_CORE 0.004446
K_2288 X_NUC_32.L_CORE X_NUC_88.L_CORE 0.003101
K_2289 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_2290 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_2291 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_2292 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.003204
K_2293 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.003169
K_2294 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.003168
K_2295 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.003201
K_2296 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.004387
K_2297 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.004422
K_2298 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.004352
K_2299 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.004437
K_2300 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.006428
K_2301 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.006246
K_2302 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.006285
K_2303 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.006292
K_2304 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.003011
K_2305 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.002997
K_2306 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.002978
K_2307 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.003017
K_2308 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.007926
K_2309 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.008062
K_2310 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.007763
K_2311 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.007923
K_2312 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.003736
K_2313 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.003684
K_2314 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.003676
K_2315 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.003707
K_2316 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.003538
K_2317 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.003539
K_2318 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.003493
K_2319 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.003547
K_2320 X_NUC_33.L_CORE X_NUC_65.L_CORE 0.006316
K_2321 X_NUC_33.L_CORE X_NUC_66.L_CORE 0.006241
K_2322 X_NUC_33.L_CORE X_NUC_67.L_CORE 0.006140
K_2323 X_NUC_33.L_CORE X_NUC_68.L_CORE 0.006183
K_2324 X_NUC_33.L_CORE X_NUC_69.L_CORE 0.003351
K_2325 X_NUC_33.L_CORE X_NUC_70.L_CORE 0.003327
K_2326 X_NUC_33.L_CORE X_NUC_71.L_CORE 0.003300
K_2327 X_NUC_33.L_CORE X_NUC_72.L_CORE 0.003338
K_2328 X_NUC_33.L_CORE X_NUC_73.L_CORE 0.004295
K_2329 X_NUC_33.L_CORE X_NUC_74.L_CORE 0.004288
K_2330 X_NUC_33.L_CORE X_NUC_75.L_CORE 0.004217
K_2331 X_NUC_33.L_CORE X_NUC_76.L_CORE 0.004272
K_2332 X_NUC_33.L_CORE X_NUC_77.L_CORE 0.005293
K_2333 X_NUC_33.L_CORE X_NUC_78.L_CORE 0.003475
K_2334 X_NUC_33.L_CORE X_NUC_79.L_CORE 0.003612
K_2335 X_NUC_33.L_CORE X_NUC_80.L_CORE 0.008444
K_2336 X_NUC_33.L_CORE X_NUC_81.L_CORE 0.002780
K_2337 X_NUC_33.L_CORE X_NUC_82.L_CORE 0.006183
K_2338 X_NUC_33.L_CORE X_NUC_83.L_CORE 0.003968
K_2339 X_NUC_33.L_CORE X_NUC_84.L_CORE 0.002928
K_2340 X_NUC_33.L_CORE X_NUC_85.L_CORE 0.009735
K_2341 X_NUC_33.L_CORE X_NUC_86.L_CORE 0.002981
K_2342 X_NUC_33.L_CORE X_NUC_87.L_CORE 0.003803
K_2343 X_NUC_33.L_CORE X_NUC_88.L_CORE 0.004119
K_2344 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_2345 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_2346 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.003240
K_2347 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.003204
K_2348 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.003203
K_2349 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.003237
K_2350 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.004351
K_2351 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.004387
K_2352 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.004318
K_2353 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.004401
K_2354 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.006620
K_2355 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.006428
K_2356 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.006467
K_2357 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.006475
K_2358 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.003026
K_2359 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.003011
K_2360 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.002992
K_2361 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.003032
K_2362 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.007786
K_2363 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.007926
K_2364 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.007636
K_2365 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.007789
K_2366 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.003789
K_2367 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.003736
K_2368 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.003727
K_2369 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.003759
K_2370 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.003535
K_2371 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.003538
K_2372 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.003492
K_2373 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.003545
K_2374 X_NUC_34.L_CORE X_NUC_65.L_CORE 0.006388
K_2375 X_NUC_34.L_CORE X_NUC_66.L_CORE 0.006316
K_2376 X_NUC_34.L_CORE X_NUC_67.L_CORE 0.006209
K_2377 X_NUC_34.L_CORE X_NUC_68.L_CORE 0.006253
K_2378 X_NUC_34.L_CORE X_NUC_69.L_CORE 0.003376
K_2379 X_NUC_34.L_CORE X_NUC_70.L_CORE 0.003351
K_2380 X_NUC_34.L_CORE X_NUC_71.L_CORE 0.003324
K_2381 X_NUC_34.L_CORE X_NUC_72.L_CORE 0.003362
K_2382 X_NUC_34.L_CORE X_NUC_73.L_CORE 0.004300
K_2383 X_NUC_34.L_CORE X_NUC_74.L_CORE 0.004295
K_2384 X_NUC_34.L_CORE X_NUC_75.L_CORE 0.004223
K_2385 X_NUC_34.L_CORE X_NUC_76.L_CORE 0.004278
K_2386 X_NUC_34.L_CORE X_NUC_77.L_CORE 0.005304
K_2387 X_NUC_34.L_CORE X_NUC_78.L_CORE 0.003516
K_2388 X_NUC_34.L_CORE X_NUC_79.L_CORE 0.003600
K_2389 X_NUC_34.L_CORE X_NUC_80.L_CORE 0.008729
K_2390 X_NUC_34.L_CORE X_NUC_81.L_CORE 0.002799
K_2391 X_NUC_34.L_CORE X_NUC_82.L_CORE 0.006048
K_2392 X_NUC_34.L_CORE X_NUC_83.L_CORE 0.004043
K_2393 X_NUC_34.L_CORE X_NUC_84.L_CORE 0.002930
K_2394 X_NUC_34.L_CORE X_NUC_85.L_CORE 0.009710
K_2395 X_NUC_34.L_CORE X_NUC_86.L_CORE 0.003009
K_2396 X_NUC_34.L_CORE X_NUC_87.L_CORE 0.003789
K_2397 X_NUC_34.L_CORE X_NUC_88.L_CORE 0.004156
K_2398 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_2399 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.003241
K_2400 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.003205
K_2401 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.003204
K_2402 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.003238
K_2403 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.004421
K_2404 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.004458
K_2405 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.004387
K_2406 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.004473
K_2407 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.006575
K_2408 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.006384
K_2409 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.006428
K_2410 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.006433
K_2411 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.003046
K_2412 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.003031
K_2413 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.003011
K_2414 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.003052
K_2415 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.008088
K_2416 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.008240
K_2417 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.007926
K_2418 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.008091
K_2419 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.003798
K_2420 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.003744
K_2421 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.003736
K_2422 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.003768
K_2423 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.003583
K_2424 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.003585
K_2425 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.003538
K_2426 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.003593
K_2427 X_NUC_35.L_CORE X_NUC_65.L_CORE 0.006502
K_2428 X_NUC_35.L_CORE X_NUC_66.L_CORE 0.006423
K_2429 X_NUC_35.L_CORE X_NUC_67.L_CORE 0.006316
K_2430 X_NUC_35.L_CORE X_NUC_68.L_CORE 0.006360
K_2431 X_NUC_35.L_CORE X_NUC_69.L_CORE 0.003404
K_2432 X_NUC_35.L_CORE X_NUC_70.L_CORE 0.003378
K_2433 X_NUC_35.L_CORE X_NUC_71.L_CORE 0.003351
K_2434 X_NUC_35.L_CORE X_NUC_72.L_CORE 0.003390
K_2435 X_NUC_35.L_CORE X_NUC_73.L_CORE 0.004376
K_2436 X_NUC_35.L_CORE X_NUC_74.L_CORE 0.004369
K_2437 X_NUC_35.L_CORE X_NUC_75.L_CORE 0.004295
K_2438 X_NUC_35.L_CORE X_NUC_76.L_CORE 0.004353
K_2439 X_NUC_35.L_CORE X_NUC_77.L_CORE 0.005250
K_2440 X_NUC_35.L_CORE X_NUC_78.L_CORE 0.003492
K_2441 X_NUC_35.L_CORE X_NUC_79.L_CORE 0.003619
K_2442 X_NUC_35.L_CORE X_NUC_80.L_CORE 0.008407
K_2443 X_NUC_35.L_CORE X_NUC_81.L_CORE 0.002803
K_2444 X_NUC_35.L_CORE X_NUC_82.L_CORE 0.006175
K_2445 X_NUC_35.L_CORE X_NUC_83.L_CORE 0.004021
K_2446 X_NUC_35.L_CORE X_NUC_84.L_CORE 0.002955
K_2447 X_NUC_35.L_CORE X_NUC_85.L_CORE 0.010022
K_2448 X_NUC_35.L_CORE X_NUC_86.L_CORE 0.003021
K_2449 X_NUC_35.L_CORE X_NUC_87.L_CORE 0.003854
K_2450 X_NUC_35.L_CORE X_NUC_88.L_CORE 0.004201
K_2451 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.003207
K_2452 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.003172
K_2453 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.003170
K_2454 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.003204
K_2455 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.004337
K_2456 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.004372
K_2457 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.004304
K_2458 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.004387
K_2459 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.006567
K_2460 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.006376
K_2461 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.006418
K_2462 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.006428
K_2463 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.003005
K_2464 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.002991
K_2465 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.002972
K_2466 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.003011
K_2467 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.007918
K_2468 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.008059
K_2469 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.007760
K_2470 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.007926
K_2471 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.003765
K_2472 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.003712
K_2473 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.003704
K_2474 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.003736
K_2475 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.003528
K_2476 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.003530
K_2477 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.003484
K_2478 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.003538
K_2479 X_NUC_36.L_CORE X_NUC_65.L_CORE 0.006452
K_2480 X_NUC_36.L_CORE X_NUC_66.L_CORE 0.006375
K_2481 X_NUC_36.L_CORE X_NUC_67.L_CORE 0.006268
K_2482 X_NUC_36.L_CORE X_NUC_68.L_CORE 0.006316
K_2483 X_NUC_36.L_CORE X_NUC_69.L_CORE 0.003365
K_2484 X_NUC_36.L_CORE X_NUC_70.L_CORE 0.003340
K_2485 X_NUC_36.L_CORE X_NUC_71.L_CORE 0.003313
K_2486 X_NUC_36.L_CORE X_NUC_72.L_CORE 0.003351
K_2487 X_NUC_36.L_CORE X_NUC_73.L_CORE 0.004316
K_2488 X_NUC_36.L_CORE X_NUC_74.L_CORE 0.004310
K_2489 X_NUC_36.L_CORE X_NUC_75.L_CORE 0.004238
K_2490 X_NUC_36.L_CORE X_NUC_76.L_CORE 0.004295
K_2491 X_NUC_36.L_CORE X_NUC_77.L_CORE 0.005185
K_2492 X_NUC_36.L_CORE X_NUC_78.L_CORE 0.003461
K_2493 X_NUC_36.L_CORE X_NUC_79.L_CORE 0.003562
K_2494 X_NUC_36.L_CORE X_NUC_80.L_CORE 0.008487
K_2495 X_NUC_36.L_CORE X_NUC_81.L_CORE 0.002771
K_2496 X_NUC_36.L_CORE X_NUC_82.L_CORE 0.006056
K_2497 X_NUC_36.L_CORE X_NUC_83.L_CORE 0.004005
K_2498 X_NUC_36.L_CORE X_NUC_84.L_CORE 0.002915
K_2499 X_NUC_36.L_CORE X_NUC_85.L_CORE 0.010082
K_2500 X_NUC_36.L_CORE X_NUC_86.L_CORE 0.002993
K_2501 X_NUC_36.L_CORE X_NUC_87.L_CORE 0.003802
K_2502 X_NUC_36.L_CORE X_NUC_88.L_CORE 0.004172
K_2503 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_2504 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_2505 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_2506 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.003204
K_2507 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.003254
K_2508 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.003227
K_2509 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.003226
K_2510 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.004411
K_2511 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.004443
K_2512 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.004460
K_2513 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.004373
K_2514 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.006489
K_2515 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.006640
K_2516 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.006453
K_2517 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.006571
K_2518 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.003066
K_2519 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.003106
K_2520 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.003089
K_2521 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.003068
K_2522 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.007936
K_2523 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.007965
K_2524 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.007904
K_2525 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.007702
K_2526 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.003849
K_2527 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.003914
K_2528 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.003855
K_2529 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.003865
K_2530 X_NUC_37.L_CORE X_NUC_65.L_CORE 0.003683
K_2531 X_NUC_37.L_CORE X_NUC_66.L_CORE 0.003723
K_2532 X_NUC_37.L_CORE X_NUC_67.L_CORE 0.003703
K_2533 X_NUC_37.L_CORE X_NUC_68.L_CORE 0.003661
K_2534 X_NUC_37.L_CORE X_NUC_69.L_CORE 0.006006
K_2535 X_NUC_37.L_CORE X_NUC_70.L_CORE 0.006097
K_2536 X_NUC_37.L_CORE X_NUC_71.L_CORE 0.005948
K_2537 X_NUC_37.L_CORE X_NUC_72.L_CORE 0.005944
K_2538 X_NUC_37.L_CORE X_NUC_73.L_CORE 0.003706
K_2539 X_NUC_37.L_CORE X_NUC_74.L_CORE 0.003757
K_2540 X_NUC_37.L_CORE X_NUC_75.L_CORE 0.003711
K_2541 X_NUC_37.L_CORE X_NUC_76.L_CORE 0.003695
K_2542 X_NUC_37.L_CORE X_NUC_77.L_CORE 0.003328
K_2543 X_NUC_37.L_CORE X_NUC_78.L_CORE 0.006263
K_2544 X_NUC_37.L_CORE X_NUC_79.L_CORE 0.003323
K_2545 X_NUC_37.L_CORE X_NUC_80.L_CORE 0.003489
K_2546 X_NUC_37.L_CORE X_NUC_81.L_CORE 0.008865
K_2547 X_NUC_37.L_CORE X_NUC_82.L_CORE 0.002764
K_2548 X_NUC_37.L_CORE X_NUC_83.L_CORE 0.006059
K_2549 X_NUC_37.L_CORE X_NUC_84.L_CORE 0.004052
K_2550 X_NUC_37.L_CORE X_NUC_85.L_CORE 0.003000
K_2551 X_NUC_37.L_CORE X_NUC_86.L_CORE 0.008517
K_2552 X_NUC_37.L_CORE X_NUC_87.L_CORE 0.003179
K_2553 X_NUC_37.L_CORE X_NUC_88.L_CORE 0.003919
K_2554 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_2555 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_2556 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.003156
K_2557 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.003204
K_2558 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.003178
K_2559 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.003177
K_2560 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.004378
K_2561 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.004411
K_2562 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.004427
K_2563 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.004342
K_2564 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.006341
K_2565 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.006489
K_2566 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.006310
K_2567 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.006421
K_2568 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.003027
K_2569 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.003066
K_2570 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.003049
K_2571 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.003030
K_2572 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.007896
K_2573 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.007936
K_2574 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.007871
K_2575 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.007670
K_2576 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.003786
K_2577 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.003849
K_2578 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.003792
K_2579 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.003802
K_2580 X_NUC_38.L_CORE X_NUC_65.L_CORE 0.003644
K_2581 X_NUC_38.L_CORE X_NUC_66.L_CORE 0.003683
K_2582 X_NUC_38.L_CORE X_NUC_67.L_CORE 0.003664
K_2583 X_NUC_38.L_CORE X_NUC_68.L_CORE 0.003622
K_2584 X_NUC_38.L_CORE X_NUC_69.L_CORE 0.005913
K_2585 X_NUC_38.L_CORE X_NUC_70.L_CORE 0.006006
K_2586 X_NUC_38.L_CORE X_NUC_71.L_CORE 0.005860
K_2587 X_NUC_38.L_CORE X_NUC_72.L_CORE 0.005857
K_2588 X_NUC_38.L_CORE X_NUC_73.L_CORE 0.003655
K_2589 X_NUC_38.L_CORE X_NUC_74.L_CORE 0.003706
K_2590 X_NUC_38.L_CORE X_NUC_75.L_CORE 0.003661
K_2591 X_NUC_38.L_CORE X_NUC_76.L_CORE 0.003646
K_2592 X_NUC_38.L_CORE X_NUC_77.L_CORE 0.003291
K_2593 X_NUC_38.L_CORE X_NUC_78.L_CORE 0.006236
K_2594 X_NUC_38.L_CORE X_NUC_79.L_CORE 0.003275
K_2595 X_NUC_38.L_CORE X_NUC_80.L_CORE 0.003462
K_2596 X_NUC_38.L_CORE X_NUC_81.L_CORE 0.008719
K_2597 X_NUC_38.L_CORE X_NUC_82.L_CORE 0.002730
K_2598 X_NUC_38.L_CORE X_NUC_83.L_CORE 0.006076
K_2599 X_NUC_38.L_CORE X_NUC_84.L_CORE 0.003985
K_2600 X_NUC_38.L_CORE X_NUC_85.L_CORE 0.002970
K_2601 X_NUC_38.L_CORE X_NUC_86.L_CORE 0.008499
K_2602 X_NUC_38.L_CORE X_NUC_87.L_CORE 0.003137
K_2603 X_NUC_38.L_CORE X_NUC_88.L_CORE 0.003885
K_2604 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_2605 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.003181
K_2606 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.003230
K_2607 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.003204
K_2608 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.003203
K_2609 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.004362
K_2610 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.004394
K_2611 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.004411
K_2612 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.004326
K_2613 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.006519
K_2614 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.006676
K_2615 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.006489
K_2616 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.006606
K_2617 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.003043
K_2618 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.003082
K_2619 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.003066
K_2620 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.003046
K_2621 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.007956
K_2622 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.007991
K_2623 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.007936
K_2624 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.007725
K_2625 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.003842
K_2626 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.003907
K_2627 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.003849
K_2628 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.003859
K_2629 X_NUC_39.L_CORE X_NUC_65.L_CORE 0.003663
K_2630 X_NUC_39.L_CORE X_NUC_66.L_CORE 0.003702
K_2631 X_NUC_39.L_CORE X_NUC_67.L_CORE 0.003683
K_2632 X_NUC_39.L_CORE X_NUC_68.L_CORE 0.003641
K_2633 X_NUC_39.L_CORE X_NUC_69.L_CORE 0.006060
K_2634 X_NUC_39.L_CORE X_NUC_70.L_CORE 0.006157
K_2635 X_NUC_39.L_CORE X_NUC_71.L_CORE 0.006006
K_2636 X_NUC_39.L_CORE X_NUC_72.L_CORE 0.006000
K_2637 X_NUC_39.L_CORE X_NUC_73.L_CORE 0.003699
K_2638 X_NUC_39.L_CORE X_NUC_74.L_CORE 0.003751
K_2639 X_NUC_39.L_CORE X_NUC_75.L_CORE 0.003706
K_2640 X_NUC_39.L_CORE X_NUC_76.L_CORE 0.003689
K_2641 X_NUC_39.L_CORE X_NUC_77.L_CORE 0.003277
K_2642 X_NUC_39.L_CORE X_NUC_78.L_CORE 0.006097
K_2643 X_NUC_39.L_CORE X_NUC_79.L_CORE 0.003288
K_2644 X_NUC_39.L_CORE X_NUC_80.L_CORE 0.003440
K_2645 X_NUC_39.L_CORE X_NUC_81.L_CORE 0.008829
K_2646 X_NUC_39.L_CORE X_NUC_82.L_CORE 0.002740
K_2647 X_NUC_39.L_CORE X_NUC_83.L_CORE 0.005994
K_2648 X_NUC_39.L_CORE X_NUC_84.L_CORE 0.004048
K_2649 X_NUC_39.L_CORE X_NUC_85.L_CORE 0.002978
K_2650 X_NUC_39.L_CORE X_NUC_86.L_CORE 0.008757
K_2651 X_NUC_39.L_CORE X_NUC_87.L_CORE 0.003172
K_2652 X_NUC_39.L_CORE X_NUC_88.L_CORE 0.003919
K_2653 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.003182
K_2654 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.003231
K_2655 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.003205
K_2656 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.003204
K_2657 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.004448
K_2658 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.004482
K_2659 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.004499
K_2660 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.004411
K_2661 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.006403
K_2662 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.006552
K_2663 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.006371
K_2664 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.006489
K_2665 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.003063
K_2666 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.003103
K_2667 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.003086
K_2668 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.003066
K_2669 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.008180
K_2670 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.008219
K_2671 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.008152
K_2672 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.007936
K_2673 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.003832
K_2674 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.003896
K_2675 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.003838
K_2676 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.003849
K_2677 X_NUC_40.L_CORE X_NUC_65.L_CORE 0.003706
K_2678 X_NUC_40.L_CORE X_NUC_66.L_CORE 0.003747
K_2679 X_NUC_40.L_CORE X_NUC_67.L_CORE 0.003726
K_2680 X_NUC_40.L_CORE X_NUC_68.L_CORE 0.003683
K_2681 X_NUC_40.L_CORE X_NUC_69.L_CORE 0.006063
K_2682 X_NUC_40.L_CORE X_NUC_70.L_CORE 0.006160
K_2683 X_NUC_40.L_CORE X_NUC_71.L_CORE 0.006006
K_2684 X_NUC_40.L_CORE X_NUC_72.L_CORE 0.006006
K_2685 X_NUC_40.L_CORE X_NUC_73.L_CORE 0.003715
K_2686 X_NUC_40.L_CORE X_NUC_74.L_CORE 0.003767
K_2687 X_NUC_40.L_CORE X_NUC_75.L_CORE 0.003721
K_2688 X_NUC_40.L_CORE X_NUC_76.L_CORE 0.003706
K_2689 X_NUC_40.L_CORE X_NUC_77.L_CORE 0.003297
K_2690 X_NUC_40.L_CORE X_NUC_78.L_CORE 0.006162
K_2691 X_NUC_40.L_CORE X_NUC_79.L_CORE 0.003282
K_2692 X_NUC_40.L_CORE X_NUC_80.L_CORE 0.003488
K_2693 X_NUC_40.L_CORE X_NUC_81.L_CORE 0.008536
K_2694 X_NUC_40.L_CORE X_NUC_82.L_CORE 0.002751
K_2695 X_NUC_40.L_CORE X_NUC_83.L_CORE 0.006170
K_2696 X_NUC_40.L_CORE X_NUC_84.L_CORE 0.004010
K_2697 X_NUC_40.L_CORE X_NUC_85.L_CORE 0.003007
K_2698 X_NUC_40.L_CORE X_NUC_86.L_CORE 0.008765
K_2699 X_NUC_40.L_CORE X_NUC_87.L_CORE 0.003175
K_2700 X_NUC_40.L_CORE X_NUC_88.L_CORE 0.003959
K_2701 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_2702 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_2703 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_2704 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.003241
K_2705 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.003203
K_2706 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.003236
K_2707 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.003203
K_2708 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.004486
K_2709 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.004402
K_2710 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.004412
K_2711 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.004453
K_2712 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.006614
K_2713 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.006571
K_2714 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.006635
K_2715 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.006448
K_2716 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.003164
K_2717 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.003120
K_2718 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.003140
K_2719 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.003128
K_2720 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.007930
K_2721 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.007745
K_2722 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.007643
K_2723 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.007744
K_2724 X_NUC_41.L_CORE X_NUC_65.L_CORE 0.004028
K_2725 X_NUC_41.L_CORE X_NUC_66.L_CORE 0.003982
K_2726 X_NUC_41.L_CORE X_NUC_67.L_CORE 0.004007
K_2727 X_NUC_41.L_CORE X_NUC_68.L_CORE 0.003956
K_2728 X_NUC_41.L_CORE X_NUC_69.L_CORE 0.003919
K_2729 X_NUC_41.L_CORE X_NUC_70.L_CORE 0.003856
K_2730 X_NUC_41.L_CORE X_NUC_71.L_CORE 0.003862
K_2731 X_NUC_41.L_CORE X_NUC_72.L_CORE 0.003863
K_2732 X_NUC_41.L_CORE X_NUC_73.L_CORE 0.005441
K_2733 X_NUC_41.L_CORE X_NUC_74.L_CORE 0.005361
K_2734 X_NUC_41.L_CORE X_NUC_75.L_CORE 0.005346
K_2735 X_NUC_41.L_CORE X_NUC_76.L_CORE 0.005305
K_2736 X_NUC_41.L_CORE X_NUC_77.L_CORE 0.004003
K_2737 X_NUC_41.L_CORE X_NUC_78.L_CORE 0.002964
K_2738 X_NUC_41.L_CORE X_NUC_79.L_CORE 0.006939
K_2739 X_NUC_41.L_CORE X_NUC_80.L_CORE 0.003186
K_2740 X_NUC_41.L_CORE X_NUC_81.L_CORE 0.003394
K_2741 X_NUC_41.L_CORE X_NUC_82.L_CORE 0.009081
K_2742 X_NUC_41.L_CORE X_NUC_83.L_CORE 0.002740
K_2743 X_NUC_41.L_CORE X_NUC_84.L_CORE 0.006052
K_2744 X_NUC_41.L_CORE X_NUC_85.L_CORE 0.004088
K_2745 X_NUC_41.L_CORE X_NUC_86.L_CORE 0.003091
K_2746 X_NUC_41.L_CORE X_NUC_87.L_CORE 0.007246
K_2747 X_NUC_41.L_CORE X_NUC_88.L_CORE 0.003493
K_2748 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_2749 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_2750 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.003279
K_2751 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.003241
K_2752 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.003274
K_2753 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.003241
K_2754 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.004573
K_2755 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.004486
K_2756 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.004496
K_2757 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.004539
K_2758 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.006650
K_2759 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.006614
K_2760 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.006675
K_2761 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.006485
K_2762 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.003210
K_2763 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.003164
K_2764 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.003185
K_2765 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.003173
K_2766 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.008116
K_2767 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.007930
K_2768 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.007815
K_2769 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.007923
K_2770 X_NUC_42.L_CORE X_NUC_65.L_CORE 0.004074
K_2771 X_NUC_42.L_CORE X_NUC_66.L_CORE 0.004028
K_2772 X_NUC_42.L_CORE X_NUC_67.L_CORE 0.004053
K_2773 X_NUC_42.L_CORE X_NUC_68.L_CORE 0.004000
K_2774 X_NUC_42.L_CORE X_NUC_69.L_CORE 0.003985
K_2775 X_NUC_42.L_CORE X_NUC_70.L_CORE 0.003919
K_2776 X_NUC_42.L_CORE X_NUC_71.L_CORE 0.003925
K_2777 X_NUC_42.L_CORE X_NUC_72.L_CORE 0.003926
K_2778 X_NUC_42.L_CORE X_NUC_73.L_CORE 0.005520
K_2779 X_NUC_42.L_CORE X_NUC_74.L_CORE 0.005441
K_2780 X_NUC_42.L_CORE X_NUC_75.L_CORE 0.005423
K_2781 X_NUC_42.L_CORE X_NUC_76.L_CORE 0.005380
K_2782 X_NUC_42.L_CORE X_NUC_77.L_CORE 0.004034
K_2783 X_NUC_42.L_CORE X_NUC_78.L_CORE 0.003000
K_2784 X_NUC_42.L_CORE X_NUC_79.L_CORE 0.006994
K_2785 X_NUC_42.L_CORE X_NUC_80.L_CORE 0.003214
K_2786 X_NUC_42.L_CORE X_NUC_81.L_CORE 0.003445
K_2787 X_NUC_42.L_CORE X_NUC_82.L_CORE 0.008954
K_2788 X_NUC_42.L_CORE X_NUC_83.L_CORE 0.002773
K_2789 X_NUC_42.L_CORE X_NUC_84.L_CORE 0.006160
K_2790 X_NUC_42.L_CORE X_NUC_85.L_CORE 0.004115
K_2791 X_NUC_42.L_CORE X_NUC_86.L_CORE 0.003135
K_2792 X_NUC_42.L_CORE X_NUC_87.L_CORE 0.007308
K_2793 X_NUC_42.L_CORE X_NUC_88.L_CORE 0.003534
K_2794 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_2795 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.003245
K_2796 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.003207
K_2797 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.003241
K_2798 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.003208
K_2799 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.004562
K_2800 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.004474
K_2801 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.004486
K_2802 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.004528
K_2803 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.006586
K_2804 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.006547
K_2805 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.006614
K_2806 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.006426
K_2807 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.003188
K_2808 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.003143
K_2809 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.003164
K_2810 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.003152
K_2811 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.008239
K_2812 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.008039
K_2813 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.007930
K_2814 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.008037
K_2815 X_NUC_43.L_CORE X_NUC_65.L_CORE 0.004047
K_2816 X_NUC_43.L_CORE X_NUC_66.L_CORE 0.004001
K_2817 X_NUC_43.L_CORE X_NUC_67.L_CORE 0.004028
K_2818 X_NUC_43.L_CORE X_NUC_68.L_CORE 0.003975
K_2819 X_NUC_43.L_CORE X_NUC_69.L_CORE 0.003978
K_2820 X_NUC_43.L_CORE X_NUC_70.L_CORE 0.003912
K_2821 X_NUC_43.L_CORE X_NUC_71.L_CORE 0.003919
K_2822 X_NUC_43.L_CORE X_NUC_72.L_CORE 0.003920
K_2823 X_NUC_43.L_CORE X_NUC_73.L_CORE 0.005536
K_2824 X_NUC_43.L_CORE X_NUC_74.L_CORE 0.005454
K_2825 X_NUC_43.L_CORE X_NUC_75.L_CORE 0.005441
K_2826 X_NUC_43.L_CORE X_NUC_76.L_CORE 0.005395
K_2827 X_NUC_43.L_CORE X_NUC_77.L_CORE 0.003958
K_2828 X_NUC_43.L_CORE X_NUC_78.L_CORE 0.002964
K_2829 X_NUC_43.L_CORE X_NUC_79.L_CORE 0.006854
K_2830 X_NUC_43.L_CORE X_NUC_80.L_CORE 0.003171
K_2831 X_NUC_43.L_CORE X_NUC_81.L_CORE 0.003420
K_2832 X_NUC_43.L_CORE X_NUC_82.L_CORE 0.008767
K_2833 X_NUC_43.L_CORE X_NUC_83.L_CORE 0.002748
K_2834 X_NUC_43.L_CORE X_NUC_84.L_CORE 0.006201
K_2835 X_NUC_43.L_CORE X_NUC_85.L_CORE 0.004080
K_2836 X_NUC_43.L_CORE X_NUC_86.L_CORE 0.003123
K_2837 X_NUC_43.L_CORE X_NUC_87.L_CORE 0.007442
K_2838 X_NUC_43.L_CORE X_NUC_88.L_CORE 0.003524
K_2839 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.003278
K_2840 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.003240
K_2841 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.003274
K_2842 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.003241
K_2843 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.004518
K_2844 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.004433
K_2845 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.004444
K_2846 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.004486
K_2847 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.006785
K_2848 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.006742
K_2849 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.006812
K_2850 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.006614
K_2851 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.003201
K_2852 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.003155
K_2853 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.003176
K_2854 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.003164
K_2855 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.008118
K_2856 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.007926
K_2857 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.007816
K_2858 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.007930
K_2859 X_NUC_44.L_CORE X_NUC_65.L_CORE 0.004102
K_2860 X_NUC_44.L_CORE X_NUC_66.L_CORE 0.004054
K_2861 X_NUC_44.L_CORE X_NUC_67.L_CORE 0.004081
K_2862 X_NUC_44.L_CORE X_NUC_68.L_CORE 0.004028
K_2863 X_NUC_44.L_CORE X_NUC_69.L_CORE 0.003977
K_2864 X_NUC_44.L_CORE X_NUC_70.L_CORE 0.003911
K_2865 X_NUC_44.L_CORE X_NUC_71.L_CORE 0.003917
K_2866 X_NUC_44.L_CORE X_NUC_72.L_CORE 0.003919
K_2867 X_NUC_44.L_CORE X_NUC_73.L_CORE 0.005583
K_2868 X_NUC_44.L_CORE X_NUC_74.L_CORE 0.005499
K_2869 X_NUC_44.L_CORE X_NUC_75.L_CORE 0.005483
K_2870 X_NUC_44.L_CORE X_NUC_76.L_CORE 0.005441
K_2871 X_NUC_44.L_CORE X_NUC_77.L_CORE 0.003992
K_2872 X_NUC_44.L_CORE X_NUC_78.L_CORE 0.002970
K_2873 X_NUC_44.L_CORE X_NUC_79.L_CORE 0.006783
K_2874 X_NUC_44.L_CORE X_NUC_80.L_CORE 0.003207
K_2875 X_NUC_44.L_CORE X_NUC_81.L_CORE 0.003401
K_2876 X_NUC_44.L_CORE X_NUC_82.L_CORE 0.009109
K_2877 X_NUC_44.L_CORE X_NUC_83.L_CORE 0.002764
K_2878 X_NUC_44.L_CORE X_NUC_84.L_CORE 0.006062
K_2879 X_NUC_44.L_CORE X_NUC_85.L_CORE 0.004154
K_2880 X_NUC_44.L_CORE X_NUC_86.L_CORE 0.003122
K_2881 X_NUC_44.L_CORE X_NUC_87.L_CORE 0.007467
K_2882 X_NUC_44.L_CORE X_NUC_88.L_CORE 0.003551
K_2883 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_2884 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_2885 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_2886 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.003317
K_2887 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.003323
K_2888 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.003291
K_2889 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.003344
K_2890 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.004620
K_2891 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.004718
K_2892 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.004640
K_2893 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.004671
K_2894 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.006813
K_2895 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.006713
K_2896 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.006620
K_2897 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.006795
K_2898 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.003321
K_2899 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.003348
K_2900 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.003304
K_2901 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.003348
K_2902 X_NUC_45.L_CORE X_NUC_65.L_CORE 0.007871
K_2903 X_NUC_45.L_CORE X_NUC_66.L_CORE 0.008074
K_2904 X_NUC_45.L_CORE X_NUC_67.L_CORE 0.007783
K_2905 X_NUC_45.L_CORE X_NUC_68.L_CORE 0.007858
K_2906 X_NUC_45.L_CORE X_NUC_69.L_CORE 0.004306
K_2907 X_NUC_45.L_CORE X_NUC_70.L_CORE 0.004309
K_2908 X_NUC_45.L_CORE X_NUC_71.L_CORE 0.004240
K_2909 X_NUC_45.L_CORE X_NUC_72.L_CORE 0.004318
K_2910 X_NUC_45.L_CORE X_NUC_73.L_CORE 0.004340
K_2911 X_NUC_45.L_CORE X_NUC_74.L_CORE 0.004391
K_2912 X_NUC_45.L_CORE X_NUC_75.L_CORE 0.004302
K_2913 X_NUC_45.L_CORE X_NUC_76.L_CORE 0.004359
K_2914 X_NUC_45.L_CORE X_NUC_77.L_CORE 0.003751
K_2915 X_NUC_45.L_CORE X_NUC_78.L_CORE 0.004106
K_2916 X_NUC_45.L_CORE X_NUC_79.L_CORE 0.002853
K_2917 X_NUC_45.L_CORE X_NUC_80.L_CORE 0.007647
K_2918 X_NUC_45.L_CORE X_NUC_81.L_CORE 0.003166
K_2919 X_NUC_45.L_CORE X_NUC_82.L_CORE 0.003452
K_2920 X_NUC_45.L_CORE X_NUC_83.L_CORE 0.009127
K_2921 X_NUC_45.L_CORE X_NUC_84.L_CORE 0.002826
K_2922 X_NUC_45.L_CORE X_NUC_85.L_CORE 0.006316
K_2923 X_NUC_45.L_CORE X_NUC_86.L_CORE 0.004255
K_2924 X_NUC_45.L_CORE X_NUC_87.L_CORE 0.003371
K_2925 X_NUC_45.L_CORE X_NUC_88.L_CORE 0.005880
K_2926 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_2927 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_2928 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.003310
K_2929 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.003317
K_2930 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.003286
K_2931 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.003338
K_2932 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.004525
K_2933 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.004620
K_2934 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.004545
K_2935 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.004574
K_2936 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.006909
K_2937 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.006813
K_2938 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.006712
K_2939 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.006894
K_2940 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.003294
K_2941 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.003321
K_2942 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.003277
K_2943 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.003320
K_2944 X_NUC_46.L_CORE X_NUC_65.L_CORE 0.007673
K_2945 X_NUC_46.L_CORE X_NUC_66.L_CORE 0.007871
K_2946 X_NUC_46.L_CORE X_NUC_67.L_CORE 0.007596
K_2947 X_NUC_46.L_CORE X_NUC_68.L_CORE 0.007665
K_2948 X_NUC_46.L_CORE X_NUC_69.L_CORE 0.004302
K_2949 X_NUC_46.L_CORE X_NUC_70.L_CORE 0.004306
K_2950 X_NUC_46.L_CORE X_NUC_71.L_CORE 0.004237
K_2951 X_NUC_46.L_CORE X_NUC_72.L_CORE 0.004315
K_2952 X_NUC_46.L_CORE X_NUC_73.L_CORE 0.004289
K_2953 X_NUC_46.L_CORE X_NUC_74.L_CORE 0.004340
K_2954 X_NUC_46.L_CORE X_NUC_75.L_CORE 0.004253
K_2955 X_NUC_46.L_CORE X_NUC_76.L_CORE 0.004308
K_2956 X_NUC_46.L_CORE X_NUC_77.L_CORE 0.003718
K_2957 X_NUC_46.L_CORE X_NUC_78.L_CORE 0.004124
K_2958 X_NUC_46.L_CORE X_NUC_79.L_CORE 0.002831
K_2959 X_NUC_46.L_CORE X_NUC_80.L_CORE 0.007537
K_2960 X_NUC_46.L_CORE X_NUC_81.L_CORE 0.003171
K_2961 X_NUC_46.L_CORE X_NUC_82.L_CORE 0.003400
K_2962 X_NUC_46.L_CORE X_NUC_83.L_CORE 0.009497
K_2963 X_NUC_46.L_CORE X_NUC_84.L_CORE 0.002811
K_2964 X_NUC_46.L_CORE X_NUC_85.L_CORE 0.006140
K_2965 X_NUC_46.L_CORE X_NUC_86.L_CORE 0.004282
K_2966 X_NUC_46.L_CORE X_NUC_87.L_CORE 0.003335
K_2967 X_NUC_46.L_CORE X_NUC_88.L_CORE 0.005842
K_2968 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_2969 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.003342
K_2970 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.003348
K_2971 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.003317
K_2972 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.003370
K_2973 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.004597
K_2974 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.004696
K_2975 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.004620
K_2976 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.004649
K_2977 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.007015
K_2978 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.006911
K_2979 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.006813
K_2980 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.007000
K_2981 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.003338
K_2982 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.003366
K_2983 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.003321
K_2984 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.003365
K_2985 X_NUC_47.L_CORE X_NUC_65.L_CORE 0.007951
K_2986 X_NUC_47.L_CORE X_NUC_66.L_CORE 0.008166
K_2987 X_NUC_47.L_CORE X_NUC_67.L_CORE 0.007871
K_2988 X_NUC_47.L_CORE X_NUC_68.L_CORE 0.007942
K_2989 X_NUC_47.L_CORE X_NUC_69.L_CORE 0.004374
K_2990 X_NUC_47.L_CORE X_NUC_70.L_CORE 0.004377
K_2991 X_NUC_47.L_CORE X_NUC_71.L_CORE 0.004306
K_2992 X_NUC_47.L_CORE X_NUC_72.L_CORE 0.004387
K_2993 X_NUC_47.L_CORE X_NUC_73.L_CORE 0.004377
K_2994 X_NUC_47.L_CORE X_NUC_74.L_CORE 0.004430
K_2995 X_NUC_47.L_CORE X_NUC_75.L_CORE 0.004340
K_2996 X_NUC_47.L_CORE X_NUC_76.L_CORE 0.004397
K_2997 X_NUC_47.L_CORE X_NUC_77.L_CORE 0.003707
K_2998 X_NUC_47.L_CORE X_NUC_78.L_CORE 0.004097
K_2999 X_NUC_47.L_CORE X_NUC_79.L_CORE 0.002844
K_3000 X_NUC_47.L_CORE X_NUC_80.L_CORE 0.007389
K_3001 X_NUC_47.L_CORE X_NUC_81.L_CORE 0.003183
K_3002 X_NUC_47.L_CORE X_NUC_82.L_CORE 0.003429
K_3003 X_NUC_47.L_CORE X_NUC_83.L_CORE 0.009346
K_3004 X_NUC_47.L_CORE X_NUC_84.L_CORE 0.002837
K_3005 X_NUC_47.L_CORE X_NUC_85.L_CORE 0.006255
K_3006 X_NUC_47.L_CORE X_NUC_86.L_CORE 0.004329
K_3007 X_NUC_47.L_CORE X_NUC_87.L_CORE 0.003385
K_3008 X_NUC_47.L_CORE X_NUC_88.L_CORE 0.006003
K_3009 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.003290
K_3010 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.003296
K_3011 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.003265
K_3012 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.003317
K_3013 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.004568
K_3014 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.004664
K_3015 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.004589
K_3016 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.004620
K_3017 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.006823
K_3018 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.006727
K_3019 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.006633
K_3020 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.006813
K_3021 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.003294
K_3022 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.003321
K_3023 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.003278
K_3024 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.003321
K_3025 X_NUC_48.L_CORE X_NUC_65.L_CORE 0.007874
K_3026 X_NUC_48.L_CORE X_NUC_66.L_CORE 0.008083
K_3027 X_NUC_48.L_CORE X_NUC_67.L_CORE 0.007791
K_3028 X_NUC_48.L_CORE X_NUC_68.L_CORE 0.007871
K_3029 X_NUC_48.L_CORE X_NUC_69.L_CORE 0.004293
K_3030 X_NUC_48.L_CORE X_NUC_70.L_CORE 0.004296
K_3031 X_NUC_48.L_CORE X_NUC_71.L_CORE 0.004228
K_3032 X_NUC_48.L_CORE X_NUC_72.L_CORE 0.004306
K_3033 X_NUC_48.L_CORE X_NUC_73.L_CORE 0.004320
K_3034 X_NUC_48.L_CORE X_NUC_74.L_CORE 0.004371
K_3035 X_NUC_48.L_CORE X_NUC_75.L_CORE 0.004283
K_3036 X_NUC_48.L_CORE X_NUC_76.L_CORE 0.004340
K_3037 X_NUC_48.L_CORE X_NUC_77.L_CORE 0.003686
K_3038 X_NUC_48.L_CORE X_NUC_78.L_CORE 0.004048
K_3039 X_NUC_48.L_CORE X_NUC_79.L_CORE 0.002817
K_3040 X_NUC_48.L_CORE X_NUC_80.L_CORE 0.007455
K_3041 X_NUC_48.L_CORE X_NUC_81.L_CORE 0.003137
K_3042 X_NUC_48.L_CORE X_NUC_82.L_CORE 0.003409
K_3043 X_NUC_48.L_CORE X_NUC_83.L_CORE 0.009168
K_3044 X_NUC_48.L_CORE X_NUC_84.L_CORE 0.002802
K_3045 X_NUC_48.L_CORE X_NUC_85.L_CORE 0.006276
K_3046 X_NUC_48.L_CORE X_NUC_86.L_CORE 0.004251
K_3047 X_NUC_48.L_CORE X_NUC_87.L_CORE 0.003350
K_3048 X_NUC_48.L_CORE X_NUC_88.L_CORE 0.005926
K_3049 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_3050 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_3051 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_3052 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.003443
K_3053 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.003476
K_3054 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.003480
K_3055 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.003433
K_3056 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.004829
K_3057 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.004774
K_3058 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.004835
K_3059 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.004741
K_3060 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.007101
K_3061 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.007313
K_3062 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.007181
K_3063 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.007092
K_3064 X_NUC_49.L_CORE X_NUC_65.L_CORE 0.003567
K_3065 X_NUC_49.L_CORE X_NUC_66.L_CORE 0.003577
K_3066 X_NUC_49.L_CORE X_NUC_67.L_CORE 0.003590
K_3067 X_NUC_49.L_CORE X_NUC_68.L_CORE 0.003532
K_3068 X_NUC_49.L_CORE X_NUC_69.L_CORE 0.007672
K_3069 X_NUC_49.L_CORE X_NUC_70.L_CORE 0.007612
K_3070 X_NUC_49.L_CORE X_NUC_71.L_CORE 0.007605
K_3071 X_NUC_49.L_CORE X_NUC_72.L_CORE 0.007417
K_3072 X_NUC_49.L_CORE X_NUC_73.L_CORE 0.004777
K_3073 X_NUC_49.L_CORE X_NUC_74.L_CORE 0.004827
K_3074 X_NUC_49.L_CORE X_NUC_75.L_CORE 0.004802
K_3075 X_NUC_49.L_CORE X_NUC_76.L_CORE 0.004722
K_3076 X_NUC_49.L_CORE X_NUC_77.L_CORE 0.003055
K_3077 X_NUC_49.L_CORE X_NUC_78.L_CORE 0.003769
K_3078 X_NUC_49.L_CORE X_NUC_79.L_CORE 0.004204
K_3079 X_NUC_49.L_CORE X_NUC_80.L_CORE 0.002789
K_3080 X_NUC_49.L_CORE X_NUC_81.L_CORE 0.008089
K_3081 X_NUC_49.L_CORE X_NUC_82.L_CORE 0.003215
K_3082 X_NUC_49.L_CORE X_NUC_83.L_CORE 0.003482
K_3083 X_NUC_49.L_CORE X_NUC_84.L_CORE 0.009924
K_3084 X_NUC_49.L_CORE X_NUC_85.L_CORE 0.002954
K_3085 X_NUC_49.L_CORE X_NUC_86.L_CORE 0.006359
K_3086 X_NUC_49.L_CORE X_NUC_87.L_CORE 0.004586
K_3087 X_NUC_49.L_CORE X_NUC_88.L_CORE 0.003859
K_3088 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_3089 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_3090 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.003409
K_3091 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.003443
K_3092 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.003446
K_3093 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.003401
K_3094 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.004882
K_3095 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.004829
K_3096 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.004890
K_3097 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.004793
K_3098 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.006898
K_3099 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.007101
K_3100 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.006976
K_3101 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.006894
K_3102 X_NUC_50.L_CORE X_NUC_65.L_CORE 0.003555
K_3103 X_NUC_50.L_CORE X_NUC_66.L_CORE 0.003567
K_3104 X_NUC_50.L_CORE X_NUC_67.L_CORE 0.003579
K_3105 X_NUC_50.L_CORE X_NUC_68.L_CORE 0.003521
K_3106 X_NUC_50.L_CORE X_NUC_69.L_CORE 0.007723
K_3107 X_NUC_50.L_CORE X_NUC_70.L_CORE 0.007672
K_3108 X_NUC_50.L_CORE X_NUC_71.L_CORE 0.007660
K_3109 X_NUC_50.L_CORE X_NUC_72.L_CORE 0.007468
K_3110 X_NUC_50.L_CORE X_NUC_73.L_CORE 0.004727
K_3111 X_NUC_50.L_CORE X_NUC_74.L_CORE 0.004777
K_3112 X_NUC_50.L_CORE X_NUC_75.L_CORE 0.004753
K_3113 X_NUC_50.L_CORE X_NUC_76.L_CORE 0.004675
K_3114 X_NUC_50.L_CORE X_NUC_77.L_CORE 0.003041
K_3115 X_NUC_50.L_CORE X_NUC_78.L_CORE 0.003792
K_3116 X_NUC_50.L_CORE X_NUC_79.L_CORE 0.004147
K_3117 X_NUC_50.L_CORE X_NUC_80.L_CORE 0.002787
K_3118 X_NUC_50.L_CORE X_NUC_81.L_CORE 0.008271
K_3119 X_NUC_50.L_CORE X_NUC_82.L_CORE 0.003178
K_3120 X_NUC_50.L_CORE X_NUC_83.L_CORE 0.003509
K_3121 X_NUC_50.L_CORE X_NUC_84.L_CORE 0.009490
K_3122 X_NUC_50.L_CORE X_NUC_85.L_CORE 0.002939
K_3123 X_NUC_50.L_CORE X_NUC_86.L_CORE 0.006497
K_3124 X_NUC_50.L_CORE X_NUC_87.L_CORE 0.004512
K_3125 X_NUC_50.L_CORE X_NUC_88.L_CORE 0.003858
K_3126 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_3127 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.003405
K_3128 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.003438
K_3129 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.003443
K_3130 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.003397
K_3131 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.004820
K_3132 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.004767
K_3133 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.004829
K_3134 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.004734
K_3135 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.007015
K_3136 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.007224
K_3137 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.007101
K_3138 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.007011
K_3139 X_NUC_51.L_CORE X_NUC_65.L_CORE 0.003543
K_3140 X_NUC_51.L_CORE X_NUC_66.L_CORE 0.003553
K_3141 X_NUC_51.L_CORE X_NUC_67.L_CORE 0.003567
K_3142 X_NUC_51.L_CORE X_NUC_68.L_CORE 0.003509
K_3143 X_NUC_51.L_CORE X_NUC_69.L_CORE 0.007731
K_3144 X_NUC_51.L_CORE X_NUC_70.L_CORE 0.007675
K_3145 X_NUC_51.L_CORE X_NUC_71.L_CORE 0.007672
K_3146 X_NUC_51.L_CORE X_NUC_72.L_CORE 0.007474
K_3147 X_NUC_51.L_CORE X_NUC_73.L_CORE 0.004751
K_3148 X_NUC_51.L_CORE X_NUC_74.L_CORE 0.004800
K_3149 X_NUC_51.L_CORE X_NUC_75.L_CORE 0.004777
K_3150 X_NUC_51.L_CORE X_NUC_76.L_CORE 0.004698
K_3151 X_NUC_51.L_CORE X_NUC_77.L_CORE 0.003012
K_3152 X_NUC_51.L_CORE X_NUC_78.L_CORE 0.003725
K_3153 X_NUC_51.L_CORE X_NUC_79.L_CORE 0.004126
K_3154 X_NUC_51.L_CORE X_NUC_80.L_CORE 0.002761
K_3155 X_NUC_51.L_CORE X_NUC_81.L_CORE 0.007999
K_3156 X_NUC_51.L_CORE X_NUC_82.L_CORE 0.003174
K_3157 X_NUC_51.L_CORE X_NUC_83.L_CORE 0.003465
K_3158 X_NUC_51.L_CORE X_NUC_84.L_CORE 0.009754
K_3159 X_NUC_51.L_CORE X_NUC_85.L_CORE 0.002930
K_3160 X_NUC_51.L_CORE X_NUC_86.L_CORE 0.006425
K_3161 X_NUC_51.L_CORE X_NUC_87.L_CORE 0.004554
K_3162 X_NUC_51.L_CORE X_NUC_88.L_CORE 0.003852
K_3163 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.003451
K_3164 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.003485
K_3165 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.003489
K_3166 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.003443
K_3167 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.004918
K_3168 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.004862
K_3169 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.004927
K_3170 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.004829
K_3171 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.007101
K_3172 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.007318
K_3173 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.007185
K_3174 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.007101
K_3175 X_NUC_52.L_CORE X_NUC_65.L_CORE 0.003601
K_3176 X_NUC_52.L_CORE X_NUC_66.L_CORE 0.003612
K_3177 X_NUC_52.L_CORE X_NUC_67.L_CORE 0.003626
K_3178 X_NUC_52.L_CORE X_NUC_68.L_CORE 0.003567
K_3179 X_NUC_52.L_CORE X_NUC_69.L_CORE 0.007945
K_3180 X_NUC_52.L_CORE X_NUC_70.L_CORE 0.007884
K_3181 X_NUC_52.L_CORE X_NUC_71.L_CORE 0.007876
K_3182 X_NUC_52.L_CORE X_NUC_72.L_CORE 0.007672
K_3183 X_NUC_52.L_CORE X_NUC_73.L_CORE 0.004832
K_3184 X_NUC_52.L_CORE X_NUC_74.L_CORE 0.004884
K_3185 X_NUC_52.L_CORE X_NUC_75.L_CORE 0.004859
K_3186 X_NUC_52.L_CORE X_NUC_76.L_CORE 0.004777
K_3187 X_NUC_52.L_CORE X_NUC_77.L_CORE 0.003040
K_3188 X_NUC_52.L_CORE X_NUC_78.L_CORE 0.003763
K_3189 X_NUC_52.L_CORE X_NUC_79.L_CORE 0.004143
K_3190 X_NUC_52.L_CORE X_NUC_80.L_CORE 0.002795
K_3191 X_NUC_52.L_CORE X_NUC_81.L_CORE 0.007990
K_3192 X_NUC_52.L_CORE X_NUC_82.L_CORE 0.003204
K_3193 X_NUC_52.L_CORE X_NUC_83.L_CORE 0.003516
K_3194 X_NUC_52.L_CORE X_NUC_84.L_CORE 0.009626
K_3195 X_NUC_52.L_CORE X_NUC_85.L_CORE 0.002969
K_3196 X_NUC_52.L_CORE X_NUC_86.L_CORE 0.006545
K_3197 X_NUC_52.L_CORE X_NUC_87.L_CORE 0.004605
K_3198 X_NUC_52.L_CORE X_NUC_88.L_CORE 0.003916
K_3199 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_3200 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_3201 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_3202 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.003635
K_3203 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.003574
K_3204 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.003594
K_3205 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.003607
K_3206 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.005144
K_3207 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.005111
K_3208 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.005052
K_3209 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.005171
K_3210 X_NUC_53.L_CORE X_NUC_65.L_CORE 0.007497
K_3211 X_NUC_53.L_CORE X_NUC_66.L_CORE 0.007263
K_3212 X_NUC_53.L_CORE X_NUC_67.L_CORE 0.007333
K_3213 X_NUC_53.L_CORE X_NUC_68.L_CORE 0.007275
K_3214 X_NUC_53.L_CORE X_NUC_69.L_CORE 0.003973
K_3215 X_NUC_53.L_CORE X_NUC_70.L_CORE 0.003915
K_3216 X_NUC_53.L_CORE X_NUC_71.L_CORE 0.003908
K_3217 X_NUC_53.L_CORE X_NUC_72.L_CORE 0.003950
K_3218 X_NUC_53.L_CORE X_NUC_73.L_CORE 0.007069
K_3219 X_NUC_53.L_CORE X_NUC_74.L_CORE 0.006942
K_3220 X_NUC_53.L_CORE X_NUC_75.L_CORE 0.006838
K_3221 X_NUC_53.L_CORE X_NUC_76.L_CORE 0.006968
K_3222 X_NUC_53.L_CORE X_NUC_77.L_CORE 0.003807
K_3223 X_NUC_53.L_CORE X_NUC_78.L_CORE 0.002847
K_3224 X_NUC_53.L_CORE X_NUC_79.L_CORE 0.003822
K_3225 X_NUC_53.L_CORE X_NUC_80.L_CORE 0.004224
K_3226 X_NUC_53.L_CORE X_NUC_81.L_CORE 0.002783
K_3227 X_NUC_53.L_CORE X_NUC_82.L_CORE 0.008873
K_3228 X_NUC_53.L_CORE X_NUC_83.L_CORE 0.003262
K_3229 X_NUC_53.L_CORE X_NUC_84.L_CORE 0.003632
K_3230 X_NUC_53.L_CORE X_NUC_85.L_CORE 0.010102
K_3231 X_NUC_53.L_CORE X_NUC_86.L_CORE 0.003150
K_3232 X_NUC_53.L_CORE X_NUC_87.L_CORE 0.006675
K_3233 X_NUC_53.L_CORE X_NUC_88.L_CORE 0.004950
K_3234 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_3235 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_3236 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.003698
K_3237 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.003635
K_3238 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.003656
K_3239 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.003669
K_3240 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.005174
K_3241 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.005144
K_3242 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.005082
K_3243 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.005203
K_3244 X_NUC_54.L_CORE X_NUC_65.L_CORE 0.007743
K_3245 X_NUC_54.L_CORE X_NUC_66.L_CORE 0.007497
K_3246 X_NUC_54.L_CORE X_NUC_67.L_CORE 0.007568
K_3247 X_NUC_54.L_CORE X_NUC_68.L_CORE 0.007505
K_3248 X_NUC_54.L_CORE X_NUC_69.L_CORE 0.004033
K_3249 X_NUC_54.L_CORE X_NUC_70.L_CORE 0.003973
K_3250 X_NUC_54.L_CORE X_NUC_71.L_CORE 0.003965
K_3251 X_NUC_54.L_CORE X_NUC_72.L_CORE 0.004009
K_3252 X_NUC_54.L_CORE X_NUC_73.L_CORE 0.007195
K_3253 X_NUC_54.L_CORE X_NUC_74.L_CORE 0.007069
K_3254 X_NUC_54.L_CORE X_NUC_75.L_CORE 0.006956
K_3255 X_NUC_54.L_CORE X_NUC_76.L_CORE 0.007092
K_3256 X_NUC_54.L_CORE X_NUC_77.L_CORE 0.003826
K_3257 X_NUC_54.L_CORE X_NUC_78.L_CORE 0.002876
K_3258 X_NUC_54.L_CORE X_NUC_79.L_CORE 0.003823
K_3259 X_NUC_54.L_CORE X_NUC_80.L_CORE 0.004280
K_3260 X_NUC_54.L_CORE X_NUC_81.L_CORE 0.002808
K_3261 X_NUC_54.L_CORE X_NUC_82.L_CORE 0.008663
K_3262 X_NUC_54.L_CORE X_NUC_83.L_CORE 0.003313
K_3263 X_NUC_54.L_CORE X_NUC_84.L_CORE 0.003648
K_3264 X_NUC_54.L_CORE X_NUC_85.L_CORE 0.010371
K_3265 X_NUC_54.L_CORE X_NUC_86.L_CORE 0.003193
K_3266 X_NUC_54.L_CORE X_NUC_87.L_CORE 0.006682
K_3267 X_NUC_54.L_CORE X_NUC_88.L_CORE 0.005049
K_3268 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_3269 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.003675
K_3270 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.003613
K_3271 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.003635
K_3272 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.003647
K_3273 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.005237
K_3274 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.005204
K_3275 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.005144
K_3276 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.005268
K_3277 X_NUC_55.L_CORE X_NUC_65.L_CORE 0.007662
K_3278 X_NUC_55.L_CORE X_NUC_66.L_CORE 0.007418
K_3279 X_NUC_55.L_CORE X_NUC_67.L_CORE 0.007497
K_3280 X_NUC_55.L_CORE X_NUC_68.L_CORE 0.007430
K_3281 X_NUC_55.L_CORE X_NUC_69.L_CORE 0.004040
K_3282 X_NUC_55.L_CORE X_NUC_70.L_CORE 0.003980
K_3283 X_NUC_55.L_CORE X_NUC_71.L_CORE 0.003973
K_3284 X_NUC_55.L_CORE X_NUC_72.L_CORE 0.004017
K_3285 X_NUC_55.L_CORE X_NUC_73.L_CORE 0.007316
K_3286 X_NUC_55.L_CORE X_NUC_74.L_CORE 0.007180
K_3287 X_NUC_55.L_CORE X_NUC_75.L_CORE 0.007069
K_3288 X_NUC_55.L_CORE X_NUC_76.L_CORE 0.007208
K_3289 X_NUC_55.L_CORE X_NUC_77.L_CORE 0.003773
K_3290 X_NUC_55.L_CORE X_NUC_78.L_CORE 0.002849
K_3291 X_NUC_55.L_CORE X_NUC_79.L_CORE 0.003812
K_3292 X_NUC_55.L_CORE X_NUC_80.L_CORE 0.004195
K_3293 X_NUC_55.L_CORE X_NUC_81.L_CORE 0.002800
K_3294 X_NUC_55.L_CORE X_NUC_82.L_CORE 0.008633
K_3295 X_NUC_55.L_CORE X_NUC_83.L_CORE 0.003279
K_3296 X_NUC_55.L_CORE X_NUC_84.L_CORE 0.003667
K_3297 X_NUC_55.L_CORE X_NUC_85.L_CORE 0.010072
K_3298 X_NUC_55.L_CORE X_NUC_86.L_CORE 0.003187
K_3299 X_NUC_55.L_CORE X_NUC_87.L_CORE 0.006855
K_3300 X_NUC_55.L_CORE X_NUC_88.L_CORE 0.005050
K_3301 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.003662
K_3302 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.003600
K_3303 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.003621
K_3304 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.003635
K_3305 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.005114
K_3306 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.005083
K_3307 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.005025
K_3308 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.005144
K_3309 X_NUC_56.L_CORE X_NUC_65.L_CORE 0.007729
K_3310 X_NUC_56.L_CORE X_NUC_66.L_CORE 0.007479
K_3311 X_NUC_56.L_CORE X_NUC_67.L_CORE 0.007555
K_3312 X_NUC_56.L_CORE X_NUC_68.L_CORE 0.007497
K_3313 X_NUC_56.L_CORE X_NUC_69.L_CORE 0.003996
K_3314 X_NUC_56.L_CORE X_NUC_70.L_CORE 0.003937
K_3315 X_NUC_56.L_CORE X_NUC_71.L_CORE 0.003930
K_3316 X_NUC_56.L_CORE X_NUC_72.L_CORE 0.003973
K_3317 X_NUC_56.L_CORE X_NUC_73.L_CORE 0.007167
K_3318 X_NUC_56.L_CORE X_NUC_74.L_CORE 0.007039
K_3319 X_NUC_56.L_CORE X_NUC_75.L_CORE 0.006930
K_3320 X_NUC_56.L_CORE X_NUC_76.L_CORE 0.007069
K_3321 X_NUC_56.L_CORE X_NUC_77.L_CORE 0.003766
K_3322 X_NUC_56.L_CORE X_NUC_78.L_CORE 0.002839
K_3323 X_NUC_56.L_CORE X_NUC_79.L_CORE 0.003764
K_3324 X_NUC_56.L_CORE X_NUC_80.L_CORE 0.004230
K_3325 X_NUC_56.L_CORE X_NUC_81.L_CORE 0.002775
K_3326 X_NUC_56.L_CORE X_NUC_82.L_CORE 0.008515
K_3327 X_NUC_56.L_CORE X_NUC_83.L_CORE 0.003282
K_3328 X_NUC_56.L_CORE X_NUC_84.L_CORE 0.003606
K_3329 X_NUC_56.L_CORE X_NUC_85.L_CORE 0.010498
K_3330 X_NUC_56.L_CORE X_NUC_86.L_CORE 0.003165
K_3331 X_NUC_56.L_CORE X_NUC_87.L_CORE 0.006667
K_3332 X_NUC_56.L_CORE X_NUC_88.L_CORE 0.005043
K_3333 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.207973
K_3334 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.207973
K_3335 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.207973
K_3336 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.003927
K_3337 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.003992
K_3338 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.003937
K_3339 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.003975
K_3340 X_NUC_57.L_CORE X_NUC_65.L_CORE 0.005628
K_3341 X_NUC_57.L_CORE X_NUC_66.L_CORE 0.005758
K_3342 X_NUC_57.L_CORE X_NUC_67.L_CORE 0.005708
K_3343 X_NUC_57.L_CORE X_NUC_68.L_CORE 0.005630
K_3344 X_NUC_57.L_CORE X_NUC_69.L_CORE 0.008004
K_3345 X_NUC_57.L_CORE X_NUC_70.L_CORE 0.008186
K_3346 X_NUC_57.L_CORE X_NUC_71.L_CORE 0.007894
K_3347 X_NUC_57.L_CORE X_NUC_72.L_CORE 0.008105
K_3348 X_NUC_57.L_CORE X_NUC_73.L_CORE 0.004809
K_3349 X_NUC_57.L_CORE X_NUC_74.L_CORE 0.004915
K_3350 X_NUC_57.L_CORE X_NUC_75.L_CORE 0.004827
K_3351 X_NUC_57.L_CORE X_NUC_76.L_CORE 0.004840
K_3352 X_NUC_57.L_CORE X_NUC_77.L_CORE 0.003007
K_3353 X_NUC_57.L_CORE X_NUC_78.L_CORE 0.004215
K_3354 X_NUC_57.L_CORE X_NUC_79.L_CORE 0.002822
K_3355 X_NUC_57.L_CORE X_NUC_80.L_CORE 0.003909
K_3356 X_NUC_57.L_CORE X_NUC_81.L_CORE 0.004371
K_3357 X_NUC_57.L_CORE X_NUC_82.L_CORE 0.002882
K_3358 X_NUC_57.L_CORE X_NUC_83.L_CORE 0.009327
K_3359 X_NUC_57.L_CORE X_NUC_84.L_CORE 0.003476
K_3360 X_NUC_57.L_CORE X_NUC_85.L_CORE 0.003919
K_3361 X_NUC_57.L_CORE X_NUC_86.L_CORE 0.010908
K_3362 X_NUC_57.L_CORE X_NUC_87.L_CORE 0.003606
K_3363 X_NUC_57.L_CORE X_NUC_88.L_CORE 0.006833
K_3364 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.207973
K_3365 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.207973
K_3366 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.003864
K_3367 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.003927
K_3368 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.003874
K_3369 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.003910
K_3370 X_NUC_58.L_CORE X_NUC_65.L_CORE 0.005501
K_3371 X_NUC_58.L_CORE X_NUC_66.L_CORE 0.005628
K_3372 X_NUC_58.L_CORE X_NUC_67.L_CORE 0.005578
K_3373 X_NUC_58.L_CORE X_NUC_68.L_CORE 0.005506
K_3374 X_NUC_58.L_CORE X_NUC_69.L_CORE 0.007822
K_3375 X_NUC_58.L_CORE X_NUC_70.L_CORE 0.008004
K_3376 X_NUC_58.L_CORE X_NUC_71.L_CORE 0.007725
K_3377 X_NUC_58.L_CORE X_NUC_72.L_CORE 0.007922
K_3378 X_NUC_58.L_CORE X_NUC_73.L_CORE 0.004707
K_3379 X_NUC_58.L_CORE X_NUC_74.L_CORE 0.004809
K_3380 X_NUC_58.L_CORE X_NUC_75.L_CORE 0.004725
K_3381 X_NUC_58.L_CORE X_NUC_76.L_CORE 0.004737
K_3382 X_NUC_58.L_CORE X_NUC_77.L_CORE 0.002982
K_3383 X_NUC_58.L_CORE X_NUC_78.L_CORE 0.004212
K_3384 X_NUC_58.L_CORE X_NUC_79.L_CORE 0.002794
K_3385 X_NUC_58.L_CORE X_NUC_80.L_CORE 0.003876
K_3386 X_NUC_58.L_CORE X_NUC_81.L_CORE 0.004359
K_3387 X_NUC_58.L_CORE X_NUC_82.L_CORE 0.002844
K_3388 X_NUC_58.L_CORE X_NUC_83.L_CORE 0.009449
K_3389 X_NUC_58.L_CORE X_NUC_84.L_CORE 0.003436
K_3390 X_NUC_58.L_CORE X_NUC_85.L_CORE 0.003858
K_3391 X_NUC_58.L_CORE X_NUC_86.L_CORE 0.010960
K_3392 X_NUC_58.L_CORE X_NUC_87.L_CORE 0.003548
K_3393 X_NUC_58.L_CORE X_NUC_88.L_CORE 0.006680
K_3394 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.207973
K_3395 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.003917
K_3396 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.003982
K_3397 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.003927
K_3398 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.003964
K_3399 X_NUC_59.L_CORE X_NUC_65.L_CORE 0.005546
K_3400 X_NUC_59.L_CORE X_NUC_66.L_CORE 0.005674
K_3401 X_NUC_59.L_CORE X_NUC_67.L_CORE 0.005628
K_3402 X_NUC_59.L_CORE X_NUC_68.L_CORE 0.005551
K_3403 X_NUC_59.L_CORE X_NUC_69.L_CORE 0.008107
K_3404 X_NUC_59.L_CORE X_NUC_70.L_CORE 0.008303
K_3405 X_NUC_59.L_CORE X_NUC_71.L_CORE 0.008004
K_3406 X_NUC_59.L_CORE X_NUC_72.L_CORE 0.008218
K_3407 X_NUC_59.L_CORE X_NUC_73.L_CORE 0.004789
K_3408 X_NUC_59.L_CORE X_NUC_74.L_CORE 0.004895
K_3409 X_NUC_59.L_CORE X_NUC_75.L_CORE 0.004809
K_3410 X_NUC_59.L_CORE X_NUC_76.L_CORE 0.004821
K_3411 X_NUC_59.L_CORE X_NUC_77.L_CORE 0.002968
K_3412 X_NUC_59.L_CORE X_NUC_78.L_CORE 0.004160
K_3413 X_NUC_59.L_CORE X_NUC_79.L_CORE 0.002800
K_3414 X_NUC_59.L_CORE X_NUC_80.L_CORE 0.003837
K_3415 X_NUC_59.L_CORE X_NUC_81.L_CORE 0.004362
K_3416 X_NUC_59.L_CORE X_NUC_82.L_CORE 0.002854
K_3417 X_NUC_59.L_CORE X_NUC_83.L_CORE 0.009056
K_3418 X_NUC_59.L_CORE X_NUC_84.L_CORE 0.003471
K_3419 X_NUC_59.L_CORE X_NUC_85.L_CORE 0.003868
K_3420 X_NUC_59.L_CORE X_NUC_86.L_CORE 0.011349
K_3421 X_NUC_59.L_CORE X_NUC_87.L_CORE 0.003594
K_3422 X_NUC_59.L_CORE X_NUC_88.L_CORE 0.006820
K_3423 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.003881
K_3424 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.003944
K_3425 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.003890
K_3426 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.003927
K_3427 X_NUC_60.L_CORE X_NUC_65.L_CORE 0.005620
K_3428 X_NUC_60.L_CORE X_NUC_66.L_CORE 0.005753
K_3429 X_NUC_60.L_CORE X_NUC_67.L_CORE 0.005703
K_3430 X_NUC_60.L_CORE X_NUC_68.L_CORE 0.005628
K_3431 X_NUC_60.L_CORE X_NUC_69.L_CORE 0.007896
K_3432 X_NUC_60.L_CORE X_NUC_70.L_CORE 0.008077
K_3433 X_NUC_60.L_CORE X_NUC_71.L_CORE 0.007795
K_3434 X_NUC_60.L_CORE X_NUC_72.L_CORE 0.008004
K_3435 X_NUC_60.L_CORE X_NUC_73.L_CORE 0.004777
K_3436 X_NUC_60.L_CORE X_NUC_74.L_CORE 0.004882
K_3437 X_NUC_60.L_CORE X_NUC_75.L_CORE 0.004795
K_3438 X_NUC_60.L_CORE X_NUC_76.L_CORE 0.004809
K_3439 X_NUC_60.L_CORE X_NUC_77.L_CORE 0.002972
K_3440 X_NUC_60.L_CORE X_NUC_78.L_CORE 0.004150
K_3441 X_NUC_60.L_CORE X_NUC_79.L_CORE 0.002786
K_3442 X_NUC_60.L_CORE X_NUC_80.L_CORE 0.003880
K_3443 X_NUC_60.L_CORE X_NUC_81.L_CORE 0.004292
K_3444 X_NUC_60.L_CORE X_NUC_82.L_CORE 0.002856
K_3445 X_NUC_60.L_CORE X_NUC_83.L_CORE 0.009333
K_3446 X_NUC_60.L_CORE X_NUC_84.L_CORE 0.003430
K_3447 X_NUC_60.L_CORE X_NUC_85.L_CORE 0.003907
K_3448 X_NUC_60.L_CORE X_NUC_86.L_CORE 0.010787
K_3449 X_NUC_60.L_CORE X_NUC_87.L_CORE 0.003578
K_3450 X_NUC_60.L_CORE X_NUC_88.L_CORE 0.006891
K_3451 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.207973
K_3452 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.207973
K_3453 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.207973
K_3454 X_NUC_61.L_CORE X_NUC_65.L_CORE 0.004395
K_3455 X_NUC_61.L_CORE X_NUC_66.L_CORE 0.004366
K_3456 X_NUC_61.L_CORE X_NUC_67.L_CORE 0.004419
K_3457 X_NUC_61.L_CORE X_NUC_68.L_CORE 0.004332
K_3458 X_NUC_61.L_CORE X_NUC_69.L_CORE 0.006421
K_3459 X_NUC_61.L_CORE X_NUC_70.L_CORE 0.006241
K_3460 X_NUC_61.L_CORE X_NUC_71.L_CORE 0.006323
K_3461 X_NUC_61.L_CORE X_NUC_72.L_CORE 0.006272
K_3462 X_NUC_61.L_CORE X_NUC_73.L_CORE 0.008426
K_3463 X_NUC_61.L_CORE X_NUC_74.L_CORE 0.008347
K_3464 X_NUC_61.L_CORE X_NUC_75.L_CORE 0.008423
K_3465 X_NUC_61.L_CORE X_NUC_76.L_CORE 0.008142
K_3466 X_NUC_61.L_CORE X_NUC_77.L_CORE 0.003048
K_3467 X_NUC_61.L_CORE X_NUC_78.L_CORE 0.002904
K_3468 X_NUC_61.L_CORE X_NUC_79.L_CORE 0.004470
K_3469 X_NUC_61.L_CORE X_NUC_80.L_CORE 0.002825
K_3470 X_NUC_61.L_CORE X_NUC_81.L_CORE 0.003973
K_3471 X_NUC_61.L_CORE X_NUC_82.L_CORE 0.004556
K_3472 X_NUC_61.L_CORE X_NUC_83.L_CORE 0.002985
K_3473 X_NUC_61.L_CORE X_NUC_84.L_CORE 0.010021
K_3474 X_NUC_61.L_CORE X_NUC_85.L_CORE 0.003742
K_3475 X_NUC_61.L_CORE X_NUC_86.L_CORE 0.004268
K_3476 X_NUC_61.L_CORE X_NUC_87.L_CORE 0.011867
K_3477 X_NUC_61.L_CORE X_NUC_88.L_CORE 0.004471
K_3478 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.207973
K_3479 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.207973
K_3480 X_NUC_62.L_CORE X_NUC_65.L_CORE 0.004423
K_3481 X_NUC_62.L_CORE X_NUC_66.L_CORE 0.004395
K_3482 X_NUC_62.L_CORE X_NUC_67.L_CORE 0.004449
K_3483 X_NUC_62.L_CORE X_NUC_68.L_CORE 0.004360
K_3484 X_NUC_62.L_CORE X_NUC_69.L_CORE 0.006612
K_3485 X_NUC_62.L_CORE X_NUC_70.L_CORE 0.006421
K_3486 X_NUC_62.L_CORE X_NUC_71.L_CORE 0.006508
K_3487 X_NUC_62.L_CORE X_NUC_72.L_CORE 0.006453
K_3488 X_NUC_62.L_CORE X_NUC_73.L_CORE 0.008494
K_3489 X_NUC_62.L_CORE X_NUC_74.L_CORE 0.008426
K_3490 X_NUC_62.L_CORE X_NUC_75.L_CORE 0.008498
K_3491 X_NUC_62.L_CORE X_NUC_76.L_CORE 0.008209
K_3492 X_NUC_62.L_CORE X_NUC_77.L_CORE 0.003051
K_3493 X_NUC_62.L_CORE X_NUC_78.L_CORE 0.002929
K_3494 X_NUC_62.L_CORE X_NUC_79.L_CORE 0.004451
K_3495 X_NUC_62.L_CORE X_NUC_80.L_CORE 0.002837
K_3496 X_NUC_62.L_CORE X_NUC_81.L_CORE 0.004032
K_3497 X_NUC_62.L_CORE X_NUC_82.L_CORE 0.004505
K_3498 X_NUC_62.L_CORE X_NUC_83.L_CORE 0.003017
K_3499 X_NUC_62.L_CORE X_NUC_84.L_CORE 0.010126
K_3500 X_NUC_62.L_CORE X_NUC_85.L_CORE 0.003742
K_3501 X_NUC_62.L_CORE X_NUC_86.L_CORE 0.004355
K_3502 X_NUC_62.L_CORE X_NUC_87.L_CORE 0.011529
K_3503 X_NUC_62.L_CORE X_NUC_88.L_CORE 0.004522
K_3504 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.207973
K_3505 X_NUC_63.L_CORE X_NUC_65.L_CORE 0.004370
K_3506 X_NUC_63.L_CORE X_NUC_66.L_CORE 0.004342
K_3507 X_NUC_63.L_CORE X_NUC_67.L_CORE 0.004395
K_3508 X_NUC_63.L_CORE X_NUC_68.L_CORE 0.004309
K_3509 X_NUC_63.L_CORE X_NUC_69.L_CORE 0.006518
K_3510 X_NUC_63.L_CORE X_NUC_70.L_CORE 0.006333
K_3511 X_NUC_63.L_CORE X_NUC_71.L_CORE 0.006421
K_3512 X_NUC_63.L_CORE X_NUC_72.L_CORE 0.006366
K_3513 X_NUC_63.L_CORE X_NUC_73.L_CORE 0.008416
K_3514 X_NUC_63.L_CORE X_NUC_74.L_CORE 0.008343
K_3515 X_NUC_63.L_CORE X_NUC_75.L_CORE 0.008426
K_3516 X_NUC_63.L_CORE X_NUC_76.L_CORE 0.008138
K_3517 X_NUC_63.L_CORE X_NUC_77.L_CORE 0.003012
K_3518 X_NUC_63.L_CORE X_NUC_78.L_CORE 0.002889
K_3519 X_NUC_63.L_CORE X_NUC_79.L_CORE 0.004396
K_3520 X_NUC_63.L_CORE X_NUC_80.L_CORE 0.002802
K_3521 X_NUC_63.L_CORE X_NUC_81.L_CORE 0.003977
K_3522 X_NUC_63.L_CORE X_NUC_82.L_CORE 0.004461
K_3523 X_NUC_63.L_CORE X_NUC_83.L_CORE 0.002980
K_3524 X_NUC_63.L_CORE X_NUC_84.L_CORE 0.010074
K_3525 X_NUC_63.L_CORE X_NUC_85.L_CORE 0.003705
K_3526 X_NUC_63.L_CORE X_NUC_86.L_CORE 0.004306
K_3527 X_NUC_63.L_CORE X_NUC_87.L_CORE 0.011703
K_3528 X_NUC_63.L_CORE X_NUC_88.L_CORE 0.004482
K_3529 X_NUC_64.L_CORE X_NUC_65.L_CORE 0.004459
K_3530 X_NUC_64.L_CORE X_NUC_66.L_CORE 0.004430
K_3531 X_NUC_64.L_CORE X_NUC_67.L_CORE 0.004485
K_3532 X_NUC_64.L_CORE X_NUC_68.L_CORE 0.004395
K_3533 X_NUC_64.L_CORE X_NUC_69.L_CORE 0.006575
K_3534 X_NUC_64.L_CORE X_NUC_70.L_CORE 0.006384
K_3535 X_NUC_64.L_CORE X_NUC_71.L_CORE 0.006472
K_3536 X_NUC_64.L_CORE X_NUC_72.L_CORE 0.006421
K_3537 X_NUC_64.L_CORE X_NUC_73.L_CORE 0.008728
K_3538 X_NUC_64.L_CORE X_NUC_74.L_CORE 0.008647
K_3539 X_NUC_64.L_CORE X_NUC_75.L_CORE 0.008732
K_3540 X_NUC_64.L_CORE X_NUC_76.L_CORE 0.008426
K_3541 X_NUC_64.L_CORE X_NUC_77.L_CORE 0.003033
K_3542 X_NUC_64.L_CORE X_NUC_78.L_CORE 0.002900
K_3543 X_NUC_64.L_CORE X_NUC_79.L_CORE 0.004395
K_3544 X_NUC_64.L_CORE X_NUC_80.L_CORE 0.002832
K_3545 X_NUC_64.L_CORE X_NUC_81.L_CORE 0.003961
K_3546 X_NUC_64.L_CORE X_NUC_82.L_CORE 0.004525
K_3547 X_NUC_64.L_CORE X_NUC_83.L_CORE 0.003006
K_3548 X_NUC_64.L_CORE X_NUC_84.L_CORE 0.009702
K_3549 X_NUC_64.L_CORE X_NUC_85.L_CORE 0.003772
K_3550 X_NUC_64.L_CORE X_NUC_86.L_CORE 0.004321
K_3551 X_NUC_64.L_CORE X_NUC_87.L_CORE 0.012180
K_3552 X_NUC_64.L_CORE X_NUC_88.L_CORE 0.004559
K_3553 X_NUC_65.L_CORE X_NUC_66.L_CORE 0.207973
K_3554 X_NUC_65.L_CORE X_NUC_67.L_CORE 0.207973
K_3555 X_NUC_65.L_CORE X_NUC_68.L_CORE 0.207973
K_3556 X_NUC_65.L_CORE X_NUC_69.L_CORE 0.005239
K_3557 X_NUC_65.L_CORE X_NUC_70.L_CORE 0.005186
K_3558 X_NUC_65.L_CORE X_NUC_71.L_CORE 0.005145
K_3559 X_NUC_65.L_CORE X_NUC_72.L_CORE 0.005263
K_3560 X_NUC_65.L_CORE X_NUC_73.L_CORE 0.007930
K_3561 X_NUC_65.L_CORE X_NUC_74.L_CORE 0.008031
K_3562 X_NUC_65.L_CORE X_NUC_75.L_CORE 0.007786
K_3563 X_NUC_65.L_CORE X_NUC_76.L_CORE 0.008055
K_3564 X_NUC_65.L_CORE X_NUC_77.L_CORE 0.003206
K_3565 X_NUC_65.L_CORE X_NUC_78.L_CORE 0.003047
K_3566 X_NUC_65.L_CORE X_NUC_79.L_CORE 0.002941
K_3567 X_NUC_65.L_CORE X_NUC_80.L_CORE 0.004595
K_3568 X_NUC_65.L_CORE X_NUC_81.L_CORE 0.002920
K_3569 X_NUC_65.L_CORE X_NUC_82.L_CORE 0.004199
K_3570 X_NUC_65.L_CORE X_NUC_83.L_CORE 0.004722
K_3571 X_NUC_65.L_CORE X_NUC_84.L_CORE 0.003246
K_3572 X_NUC_65.L_CORE X_NUC_85.L_CORE 0.011060
K_3573 X_NUC_65.L_CORE X_NUC_86.L_CORE 0.004211
K_3574 X_NUC_65.L_CORE X_NUC_87.L_CORE 0.005135
K_3575 X_NUC_65.L_CORE X_NUC_88.L_CORE 0.011335
K_3576 X_NUC_66.L_CORE X_NUC_67.L_CORE 0.207973
K_3577 X_NUC_66.L_CORE X_NUC_68.L_CORE 0.207973
K_3578 X_NUC_66.L_CORE X_NUC_69.L_CORE 0.005291
K_3579 X_NUC_66.L_CORE X_NUC_70.L_CORE 0.005239
K_3580 X_NUC_66.L_CORE X_NUC_71.L_CORE 0.005195
K_3581 X_NUC_66.L_CORE X_NUC_72.L_CORE 0.005317
K_3582 X_NUC_66.L_CORE X_NUC_73.L_CORE 0.007821
K_3583 X_NUC_66.L_CORE X_NUC_74.L_CORE 0.007930
K_3584 X_NUC_66.L_CORE X_NUC_75.L_CORE 0.007688
K_3585 X_NUC_66.L_CORE X_NUC_76.L_CORE 0.007947
K_3586 X_NUC_66.L_CORE X_NUC_77.L_CORE 0.003199
K_3587 X_NUC_66.L_CORE X_NUC_78.L_CORE 0.003067
K_3588 X_NUC_66.L_CORE X_NUC_79.L_CORE 0.002928
K_3589 X_NUC_66.L_CORE X_NUC_80.L_CORE 0.004610
K_3590 X_NUC_66.L_CORE X_NUC_81.L_CORE 0.002935
K_3591 X_NUC_66.L_CORE X_NUC_82.L_CORE 0.004135
K_3592 X_NUC_66.L_CORE X_NUC_83.L_CORE 0.004816
K_3593 X_NUC_66.L_CORE X_NUC_84.L_CORE 0.003239
K_3594 X_NUC_66.L_CORE X_NUC_85.L_CORE 0.010652
K_3595 X_NUC_66.L_CORE X_NUC_86.L_CORE 0.004269
K_3596 X_NUC_66.L_CORE X_NUC_87.L_CORE 0.005062
K_3597 X_NUC_66.L_CORE X_NUC_88.L_CORE 0.011673
K_3598 X_NUC_67.L_CORE X_NUC_68.L_CORE 0.207973
K_3599 X_NUC_67.L_CORE X_NUC_69.L_CORE 0.005335
K_3600 X_NUC_67.L_CORE X_NUC_70.L_CORE 0.005280
K_3601 X_NUC_67.L_CORE X_NUC_71.L_CORE 0.005239
K_3602 X_NUC_67.L_CORE X_NUC_72.L_CORE 0.005362
K_3603 X_NUC_67.L_CORE X_NUC_73.L_CORE 0.008070
K_3604 X_NUC_67.L_CORE X_NUC_74.L_CORE 0.008183
K_3605 X_NUC_67.L_CORE X_NUC_75.L_CORE 0.007930
K_3606 X_NUC_67.L_CORE X_NUC_76.L_CORE 0.008208
K_3607 X_NUC_67.L_CORE X_NUC_77.L_CORE 0.003173
K_3608 X_NUC_67.L_CORE X_NUC_78.L_CORE 0.003039
K_3609 X_NUC_67.L_CORE X_NUC_79.L_CORE 0.002927
K_3610 X_NUC_67.L_CORE X_NUC_80.L_CORE 0.004521
K_3611 X_NUC_67.L_CORE X_NUC_81.L_CORE 0.002929
K_3612 X_NUC_67.L_CORE X_NUC_82.L_CORE 0.004145
K_3613 X_NUC_67.L_CORE X_NUC_83.L_CORE 0.004733
K_3614 X_NUC_67.L_CORE X_NUC_84.L_CORE 0.003258
K_3615 X_NUC_67.L_CORE X_NUC_85.L_CORE 0.010532
K_3616 X_NUC_67.L_CORE X_NUC_86.L_CORE 0.004270
K_3617 X_NUC_67.L_CORE X_NUC_87.L_CORE 0.005161
K_3618 X_NUC_67.L_CORE X_NUC_88.L_CORE 0.011986
K_3619 X_NUC_68.L_CORE X_NUC_69.L_CORE 0.005212
K_3620 X_NUC_68.L_CORE X_NUC_70.L_CORE 0.005161
K_3621 X_NUC_68.L_CORE X_NUC_71.L_CORE 0.005121
K_3622 X_NUC_68.L_CORE X_NUC_72.L_CORE 0.005239
K_3623 X_NUC_68.L_CORE X_NUC_73.L_CORE 0.007799
K_3624 X_NUC_68.L_CORE X_NUC_74.L_CORE 0.007901
K_3625 X_NUC_68.L_CORE X_NUC_75.L_CORE 0.007667
K_3626 X_NUC_68.L_CORE X_NUC_76.L_CORE 0.007930
K_3627 X_NUC_68.L_CORE X_NUC_77.L_CORE 0.003164
K_3628 X_NUC_68.L_CORE X_NUC_78.L_CORE 0.003023
K_3629 X_NUC_68.L_CORE X_NUC_79.L_CORE 0.002901
K_3630 X_NUC_68.L_CORE X_NUC_80.L_CORE 0.004550
K_3631 X_NUC_68.L_CORE X_NUC_81.L_CORE 0.002897
K_3632 X_NUC_68.L_CORE X_NUC_82.L_CORE 0.004121
K_3633 X_NUC_68.L_CORE X_NUC_83.L_CORE 0.004726
K_3634 X_NUC_68.L_CORE X_NUC_84.L_CORE 0.003210
K_3635 X_NUC_68.L_CORE X_NUC_85.L_CORE 0.010828
K_3636 X_NUC_68.L_CORE X_NUC_86.L_CORE 0.004206
K_3637 X_NUC_68.L_CORE X_NUC_87.L_CORE 0.005060
K_3638 X_NUC_68.L_CORE X_NUC_88.L_CORE 0.011648
K_3639 X_NUC_69.L_CORE X_NUC_70.L_CORE 0.207973
K_3640 X_NUC_69.L_CORE X_NUC_71.L_CORE 0.207973
K_3641 X_NUC_69.L_CORE X_NUC_72.L_CORE 0.207973
K_3642 X_NUC_69.L_CORE X_NUC_73.L_CORE 0.007349
K_3643 X_NUC_69.L_CORE X_NUC_74.L_CORE 0.007584
K_3644 X_NUC_69.L_CORE X_NUC_75.L_CORE 0.007498
K_3645 X_NUC_69.L_CORE X_NUC_76.L_CORE 0.007377
K_3646 X_NUC_69.L_CORE X_NUC_77.L_CORE 0.002760
K_3647 X_NUC_69.L_CORE X_NUC_78.L_CORE 0.003323
K_3648 X_NUC_69.L_CORE X_NUC_79.L_CORE 0.003131
K_3649 X_NUC_69.L_CORE X_NUC_80.L_CORE 0.003036
K_3650 X_NUC_69.L_CORE X_NUC_81.L_CORE 0.004610
K_3651 X_NUC_69.L_CORE X_NUC_82.L_CORE 0.003144
K_3652 X_NUC_69.L_CORE X_NUC_83.L_CORE 0.004380
K_3653 X_NUC_69.L_CORE X_NUC_84.L_CORE 0.005144
K_3654 X_NUC_69.L_CORE X_NUC_85.L_CORE 0.003693
K_3655 X_NUC_69.L_CORE X_NUC_86.L_CORE 0.011382
K_3656 X_NUC_69.L_CORE X_NUC_87.L_CORE 0.005310
K_3657 X_NUC_69.L_CORE X_NUC_88.L_CORE 0.007104
K_3658 X_NUC_70.L_CORE X_NUC_71.L_CORE 0.207973
K_3659 X_NUC_70.L_CORE X_NUC_72.L_CORE 0.207973
K_3660 X_NUC_70.L_CORE X_NUC_73.L_CORE 0.007125
K_3661 X_NUC_70.L_CORE X_NUC_74.L_CORE 0.007349
K_3662 X_NUC_70.L_CORE X_NUC_75.L_CORE 0.007266
K_3663 X_NUC_70.L_CORE X_NUC_76.L_CORE 0.007155
K_3664 X_NUC_70.L_CORE X_NUC_77.L_CORE 0.002747
K_3665 X_NUC_70.L_CORE X_NUC_78.L_CORE 0.003334
K_3666 X_NUC_70.L_CORE X_NUC_79.L_CORE 0.003104
K_3667 X_NUC_70.L_CORE X_NUC_80.L_CORE 0.003030
K_3668 X_NUC_70.L_CORE X_NUC_81.L_CORE 0.004631
K_3669 X_NUC_70.L_CORE X_NUC_82.L_CORE 0.003106
K_3670 X_NUC_70.L_CORE X_NUC_83.L_CORE 0.004423
K_3671 X_NUC_70.L_CORE X_NUC_84.L_CORE 0.005065
K_3672 X_NUC_70.L_CORE X_NUC_85.L_CORE 0.003659
K_3673 X_NUC_70.L_CORE X_NUC_86.L_CORE 0.012013
K_3674 X_NUC_70.L_CORE X_NUC_87.L_CORE 0.005178
K_3675 X_NUC_70.L_CORE X_NUC_88.L_CORE 0.007053
K_3676 X_NUC_71.L_CORE X_NUC_72.L_CORE 0.207973
K_3677 X_NUC_71.L_CORE X_NUC_73.L_CORE 0.007199
K_3678 X_NUC_71.L_CORE X_NUC_74.L_CORE 0.007425
K_3679 X_NUC_71.L_CORE X_NUC_75.L_CORE 0.007349
K_3680 X_NUC_71.L_CORE X_NUC_76.L_CORE 0.007230
K_3681 X_NUC_71.L_CORE X_NUC_77.L_CORE 0.002725
K_3682 X_NUC_71.L_CORE X_NUC_78.L_CORE 0.003288
K_3683 X_NUC_71.L_CORE X_NUC_79.L_CORE 0.003094
K_3684 X_NUC_71.L_CORE X_NUC_80.L_CORE 0.002997
K_3685 X_NUC_71.L_CORE X_NUC_81.L_CORE 0.004580
K_3686 X_NUC_71.L_CORE X_NUC_82.L_CORE 0.003101
K_3687 X_NUC_71.L_CORE X_NUC_83.L_CORE 0.004334
K_3688 X_NUC_71.L_CORE X_NUC_84.L_CORE 0.005101
K_3689 X_NUC_71.L_CORE X_NUC_85.L_CORE 0.003640
K_3690 X_NUC_71.L_CORE X_NUC_86.L_CORE 0.011551
K_3691 X_NUC_71.L_CORE X_NUC_87.L_CORE 0.005241
K_3692 X_NUC_71.L_CORE X_NUC_88.L_CORE 0.007016
K_3693 X_NUC_72.L_CORE X_NUC_73.L_CORE 0.007312
K_3694 X_NUC_72.L_CORE X_NUC_74.L_CORE 0.007549
K_3695 X_NUC_72.L_CORE X_NUC_75.L_CORE 0.007464
K_3696 X_NUC_72.L_CORE X_NUC_76.L_CORE 0.007349
K_3697 X_NUC_72.L_CORE X_NUC_77.L_CORE 0.002737
K_3698 X_NUC_72.L_CORE X_NUC_78.L_CORE 0.003298
K_3699 X_NUC_72.L_CORE X_NUC_79.L_CORE 0.003088
K_3700 X_NUC_72.L_CORE X_NUC_80.L_CORE 0.003028
K_3701 X_NUC_72.L_CORE X_NUC_81.L_CORE 0.004536
K_3702 X_NUC_72.L_CORE X_NUC_82.L_CORE 0.003116
K_3703 X_NUC_72.L_CORE X_NUC_83.L_CORE 0.004398
K_3704 X_NUC_72.L_CORE X_NUC_84.L_CORE 0.005025
K_3705 X_NUC_72.L_CORE X_NUC_85.L_CORE 0.003693
K_3706 X_NUC_72.L_CORE X_NUC_86.L_CORE 0.011547
K_3707 X_NUC_72.L_CORE X_NUC_87.L_CORE 0.005252
K_3708 X_NUC_72.L_CORE X_NUC_88.L_CORE 0.007245
K_3709 X_NUC_73.L_CORE X_NUC_74.L_CORE 0.207973
K_3710 X_NUC_73.L_CORE X_NUC_75.L_CORE 0.207973
K_3711 X_NUC_73.L_CORE X_NUC_76.L_CORE 0.207973
K_3712 X_NUC_73.L_CORE X_NUC_77.L_CORE 0.002912
K_3713 X_NUC_73.L_CORE X_NUC_78.L_CORE 0.002789
K_3714 X_NUC_73.L_CORE X_NUC_79.L_CORE 0.003340
K_3715 X_NUC_73.L_CORE X_NUC_80.L_CORE 0.003233
K_3716 X_NUC_73.L_CORE X_NUC_81.L_CORE 0.003243
K_3717 X_NUC_73.L_CORE X_NUC_82.L_CORE 0.004442
K_3718 X_NUC_73.L_CORE X_NUC_83.L_CORE 0.003512
K_3719 X_NUC_73.L_CORE X_NUC_84.L_CORE 0.004709
K_3720 X_NUC_73.L_CORE X_NUC_85.L_CORE 0.005538
K_3721 X_NUC_73.L_CORE X_NUC_86.L_CORE 0.004590
K_3722 X_NUC_73.L_CORE X_NUC_87.L_CORE 0.012315
K_3723 X_NUC_73.L_CORE X_NUC_88.L_CORE 0.008416
K_3724 X_NUC_74.L_CORE X_NUC_75.L_CORE 0.207973
K_3725 X_NUC_74.L_CORE X_NUC_76.L_CORE 0.207973
K_3726 X_NUC_74.L_CORE X_NUC_77.L_CORE 0.002912
K_3727 X_NUC_74.L_CORE X_NUC_78.L_CORE 0.002809
K_3728 X_NUC_74.L_CORE X_NUC_79.L_CORE 0.003328
K_3729 X_NUC_74.L_CORE X_NUC_80.L_CORE 0.003246
K_3730 X_NUC_74.L_CORE X_NUC_81.L_CORE 0.003271
K_3731 X_NUC_74.L_CORE X_NUC_82.L_CORE 0.004385
K_3732 X_NUC_74.L_CORE X_NUC_83.L_CORE 0.003559
K_3733 X_NUC_74.L_CORE X_NUC_84.L_CORE 0.004707
K_3734 X_NUC_74.L_CORE X_NUC_85.L_CORE 0.005520
K_3735 X_NUC_74.L_CORE X_NUC_86.L_CORE 0.004687
K_3736 X_NUC_74.L_CORE X_NUC_87.L_CORE 0.011733
K_3737 X_NUC_74.L_CORE X_NUC_88.L_CORE 0.008687
K_3738 X_NUC_75.L_CORE X_NUC_76.L_CORE 0.207973
K_3739 X_NUC_75.L_CORE X_NUC_77.L_CORE 0.002881
K_3740 X_NUC_75.L_CORE X_NUC_78.L_CORE 0.002777
K_3741 X_NUC_75.L_CORE X_NUC_79.L_CORE 0.003309
K_3742 X_NUC_75.L_CORE X_NUC_80.L_CORE 0.003198
K_3743 X_NUC_75.L_CORE X_NUC_81.L_CORE 0.003246
K_3744 X_NUC_75.L_CORE X_NUC_82.L_CORE 0.004354
K_3745 X_NUC_75.L_CORE X_NUC_83.L_CORE 0.003504
K_3746 X_NUC_75.L_CORE X_NUC_84.L_CORE 0.004715
K_3747 X_NUC_75.L_CORE X_NUC_85.L_CORE 0.005422
K_3748 X_NUC_75.L_CORE X_NUC_86.L_CORE 0.004638
K_3749 X_NUC_75.L_CORE X_NUC_87.L_CORE 0.012143
K_3750 X_NUC_75.L_CORE X_NUC_88.L_CORE 0.008492
K_3751 X_NUC_76.L_CORE X_NUC_77.L_CORE 0.002887
K_3752 X_NUC_76.L_CORE X_NUC_78.L_CORE 0.002776
K_3753 X_NUC_76.L_CORE X_NUC_79.L_CORE 0.003291
K_3754 X_NUC_76.L_CORE X_NUC_80.L_CORE 0.003226
K_3755 X_NUC_76.L_CORE X_NUC_81.L_CORE 0.003220
K_3756 X_NUC_76.L_CORE X_NUC_82.L_CORE 0.004372
K_3757 X_NUC_76.L_CORE X_NUC_83.L_CORE 0.003524
K_3758 X_NUC_76.L_CORE X_NUC_84.L_CORE 0.004625
K_3759 X_NUC_76.L_CORE X_NUC_85.L_CORE 0.005552
K_3760 X_NUC_76.L_CORE X_NUC_86.L_CORE 0.004608
K_3761 X_NUC_76.L_CORE X_NUC_87.L_CORE 0.011774
K_3762 X_NUC_76.L_CORE X_NUC_88.L_CORE 0.008706
K_3763 X_NUC_77.L_CORE X_NUC_78.L_CORE 0.005008
K_3764 X_NUC_77.L_CORE X_NUC_79.L_CORE 0.005397
K_3765 X_NUC_77.L_CORE X_NUC_80.L_CORE 0.005662
K_3766 X_NUC_77.L_CORE X_NUC_81.L_CORE 0.003324
K_3767 X_NUC_77.L_CORE X_NUC_82.L_CORE 0.004654
K_3768 X_NUC_77.L_CORE X_NUC_83.L_CORE 0.003284
K_3769 X_NUC_77.L_CORE X_NUC_84.L_CORE 0.003007
K_3770 X_NUC_77.L_CORE X_NUC_85.L_CORE 0.003497
K_3771 X_NUC_77.L_CORE X_NUC_86.L_CORE 0.002634
K_3772 X_NUC_77.L_CORE X_NUC_87.L_CORE 0.002842
K_3773 X_NUC_77.L_CORE X_NUC_88.L_CORE 0.002664
K_3774 X_NUC_78.L_CORE X_NUC_79.L_CORE 0.003643
K_3775 X_NUC_78.L_CORE X_NUC_80.L_CORE 0.004477
K_3776 X_NUC_78.L_CORE X_NUC_81.L_CORE 0.005486
K_3777 X_NUC_78.L_CORE X_NUC_82.L_CORE 0.002832
K_3778 X_NUC_78.L_CORE X_NUC_83.L_CORE 0.005013
K_3779 X_NUC_78.L_CORE X_NUC_84.L_CORE 0.003066
K_3780 X_NUC_78.L_CORE X_NUC_85.L_CORE 0.002829
K_3781 X_NUC_78.L_CORE X_NUC_86.L_CORE 0.003693
K_3782 X_NUC_78.L_CORE X_NUC_87.L_CORE 0.002544
K_3783 X_NUC_78.L_CORE X_NUC_88.L_CORE 0.002842
K_3784 X_NUC_79.L_CORE X_NUC_80.L_CORE 0.003127
K_3785 X_NUC_79.L_CORE X_NUC_81.L_CORE 0.004025
K_3786 X_NUC_79.L_CORE X_NUC_82.L_CORE 0.005266
K_3787 X_NUC_79.L_CORE X_NUC_83.L_CORE 0.002626
K_3788 X_NUC_79.L_CORE X_NUC_84.L_CORE 0.005137
K_3789 X_NUC_79.L_CORE X_NUC_85.L_CORE 0.002978
K_3790 X_NUC_79.L_CORE X_NUC_86.L_CORE 0.002782
K_3791 X_NUC_79.L_CORE X_NUC_87.L_CORE 0.003693
K_3792 X_NUC_79.L_CORE X_NUC_88.L_CORE 0.002634
K_3793 X_NUC_80.L_CORE X_NUC_81.L_CORE 0.002870
K_3794 X_NUC_80.L_CORE X_NUC_82.L_CORE 0.003790
K_3795 X_NUC_80.L_CORE X_NUC_83.L_CORE 0.005130
K_3796 X_NUC_80.L_CORE X_NUC_84.L_CORE 0.002541
K_3797 X_NUC_80.L_CORE X_NUC_85.L_CORE 0.005169
K_3798 X_NUC_80.L_CORE X_NUC_86.L_CORE 0.002978
K_3799 X_NUC_80.L_CORE X_NUC_87.L_CORE 0.002829
K_3800 X_NUC_80.L_CORE X_NUC_88.L_CORE 0.003497
K_3801 X_NUC_81.L_CORE X_NUC_82.L_CORE 0.002744
K_3802 X_NUC_81.L_CORE X_NUC_83.L_CORE 0.003686
K_3803 X_NUC_81.L_CORE X_NUC_84.L_CORE 0.005085
K_3804 X_NUC_81.L_CORE X_NUC_85.L_CORE 0.002541
K_3805 X_NUC_81.L_CORE X_NUC_86.L_CORE 0.005137
K_3806 X_NUC_81.L_CORE X_NUC_87.L_CORE 0.003066
K_3807 X_NUC_81.L_CORE X_NUC_88.L_CORE 0.003007
K_3808 X_NUC_82.L_CORE X_NUC_83.L_CORE 0.002705
K_3809 X_NUC_82.L_CORE X_NUC_84.L_CORE 0.003686
K_3810 X_NUC_82.L_CORE X_NUC_85.L_CORE 0.005130
K_3811 X_NUC_82.L_CORE X_NUC_86.L_CORE 0.002626
K_3812 X_NUC_82.L_CORE X_NUC_87.L_CORE 0.005013
K_3813 X_NUC_82.L_CORE X_NUC_88.L_CORE 0.003284
K_3814 X_NUC_83.L_CORE X_NUC_84.L_CORE 0.002744
K_3815 X_NUC_83.L_CORE X_NUC_85.L_CORE 0.003790
K_3816 X_NUC_83.L_CORE X_NUC_86.L_CORE 0.005266
K_3817 X_NUC_83.L_CORE X_NUC_87.L_CORE 0.002832
K_3818 X_NUC_83.L_CORE X_NUC_88.L_CORE 0.004654
K_3819 X_NUC_84.L_CORE X_NUC_85.L_CORE 0.002870
K_3820 X_NUC_84.L_CORE X_NUC_86.L_CORE 0.004025
K_3821 X_NUC_84.L_CORE X_NUC_87.L_CORE 0.005486
K_3822 X_NUC_84.L_CORE X_NUC_88.L_CORE 0.003324
K_3823 X_NUC_85.L_CORE X_NUC_86.L_CORE 0.003127
K_3824 X_NUC_85.L_CORE X_NUC_87.L_CORE 0.004477
K_3825 X_NUC_85.L_CORE X_NUC_88.L_CORE 0.005662
K_3826 X_NUC_86.L_CORE X_NUC_87.L_CORE 0.003643
K_3827 X_NUC_86.L_CORE X_NUC_88.L_CORE 0.005397
K_3828 X_NUC_87.L_CORE X_NUC_88.L_CORE 0.005008

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
