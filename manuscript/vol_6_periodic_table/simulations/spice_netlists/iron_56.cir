* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Iron-56 (Z=26, A=56)
* Auto-generated topological mutual impedance array
* Nodes: 56

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.008885
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.008542
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.008611
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.008720
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.009578
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.009734
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.009360
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.009737
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.010076
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.009851
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.009943
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.009626
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.005879
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.005786
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005727
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.005841
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.008320
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.008545
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.008242
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.008260
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.005815
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.005692
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.005696
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.005672
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.005314
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.005315
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.005203
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.005301
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.006290
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.006305
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.006217
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.006140
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.004622
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.004562
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.004523
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.004555
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.005083
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.005116
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.005001
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.005040
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.004768
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.004732
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.004688
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.004671
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.004334
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.004317
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.004253
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.004281
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.019733
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.005165
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.004892
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.004298
K_56 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_57 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_58 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.009255
K_59 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.008885
K_60 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.008955
K_61 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.009077
K_62 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.009410
K_63 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.009578
K_64 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.009212
K_65 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.009571
K_66 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.010292
K_67 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.010076
K_68 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.010163
K_69 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.009825
K_70 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.005971
K_71 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.005879
K_72 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.005815
K_73 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.005934
K_74 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.008100
K_75 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.008320
K_76 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.008034
K_77 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.008051
K_78 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.005942
K_79 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.005815
K_80 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.005817
K_81 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.005792
K_82 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.005310
K_83 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.005314
K_84 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.005201
K_85 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.005298
K_86 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.006269
K_87 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.006290
K_88 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.006200
K_89 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.006123
K_90 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.004682
K_91 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.004622
K_92 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.004580
K_93 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.004614
K_94 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.005048
K_95 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.005083
K_96 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.004969
K_97 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.005006
K_98 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.004801
K_99 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.004768
K_100 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.004721
K_101 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.004704
K_102 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.004350
K_103 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.004334
K_104 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.004269
K_105 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.004298
K_106 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.018493
K_107 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.005284
K_108 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.004850
K_109 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.004315
K_110 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_111 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.009169
K_112 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.008802
K_113 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.008885
K_114 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.008996
K_115 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.009791
K_116 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.009969
K_117 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.009578
K_118 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.009972
K_119 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.010190
K_120 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.009968
K_121 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.010076
K_122 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.009736
K_123 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.006038
K_124 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.005940
K_125 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.005879
K_126 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.005999
K_127 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.008387
K_128 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.008624
K_129 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.008320
K_130 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.008332
K_131 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.005939
K_132 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.005810
K_133 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.005815
K_134 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.005788
K_135 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.005429
K_136 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.005432
K_137 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.005314
K_138 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.005417
K_139 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.006359
K_140 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.006377
K_141 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.006290
K_142 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.006206
K_143 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.004725
K_144 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.004662
K_145 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.004622
K_146 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.004655
K_147 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.005166
K_148 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.005202
K_149 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.005083
K_150 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.005122
K_151 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.004849
K_152 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.004813
K_153 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.004768
K_154 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.004749
K_155 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.004418
K_156 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.004400
K_157 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.004334
K_158 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.004363
K_159 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.018431
K_160 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.005271
K_161 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.004964
K_162 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.004353
K_163 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.009043
K_164 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.008690
K_165 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.008762
K_166 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.008885
K_167 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.009407
K_168 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.009565
K_169 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.009209
K_170 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.009578
K_171 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.010568
K_172 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.010322
K_173 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.010428
K_174 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.010076
K_175 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.005913
K_176 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.005821
K_177 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.005761
K_178 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.005879
K_179 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.008368
K_180 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.008604
K_181 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.008295
K_182 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.008320
K_183 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.005965
K_184 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.005835
K_185 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.005838
K_186 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.005815
K_187 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.005324
K_188 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.005326
K_189 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.005214
K_190 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.005314
K_191 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.006445
K_192 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006464
K_193 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.006370
K_194 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.006290
K_195 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.004689
K_196 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.004628
K_197 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.004587
K_198 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.004622
K_199 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.005125
K_200 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.005160
K_201 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.005043
K_202 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.005083
K_203 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.004868
K_204 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.004832
K_205 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.004784
K_206 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.004768
K_207 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.004387
K_208 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.004370
K_209 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.004304
K_210 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.004334
K_211 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.019658
K_212 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.005245
K_213 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.004893
K_214 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.004379
K_215 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_216 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_217 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_218 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.006436
K_219 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.006626
K_220 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.006474
K_221 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.006547
K_222 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.007904
K_223 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.008046
K_224 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.008038
K_225 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.007788
K_226 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.009724
K_227 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.009761
K_228 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.009395
K_229 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.009763
K_230 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.004974
K_231 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.005086
K_232 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.005006
K_233 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.004990
K_234 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.008984
K_235 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.008885
K_236 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008821
K_237 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008626
K_238 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.005386
K_239 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.005468
K_240 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.005329
K_241 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.005408
K_242 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.004952
K_243 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.005022
K_244 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.004964
K_245 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.004905
K_246 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006725
K_247 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.006691
K_248 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.006540
K_249 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.006589
K_250 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.004380
K_251 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.004445
K_252 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.004360
K_253 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.004371
K_254 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.005120
K_255 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.005145
K_256 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.005073
K_257 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.005031
K_258 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.004768
K_259 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.004799
K_260 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.004701
K_261 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.004721
K_262 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.006305
K_263 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.011271
K_264 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.004207
K_265 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.004317
K_266 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_267 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_268 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.006256
K_269 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.006436
K_270 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.006294
K_271 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.006361
K_272 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.007759
K_273 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.007904
K_274 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.007891
K_275 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.007654
K_276 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.009666
K_277 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.009724
K_278 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.009352
K_279 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.009715
K_280 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.004866
K_281 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.004974
K_282 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.004898
K_283 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.004882
K_284 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.009069
K_285 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.008984
K_286 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008909
K_287 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008708
K_288 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.005305
K_289 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.005386
K_290 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.005252
K_291 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.005327
K_292 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.004882
K_293 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.004952
K_294 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.004895
K_295 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.004838
K_296 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006752
K_297 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006725
K_298 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.006568
K_299 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.006618
K_300 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.004316
K_301 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.004380
K_302 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.004298
K_303 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.004308
K_304 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.005094
K_305 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.005120
K_306 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.005048
K_307 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.005006
K_308 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.004734
K_309 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.004768
K_310 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.004670
K_311 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.004690
K_312 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.006140
K_313 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.011768
K_314 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.004143
K_315 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.004294
K_316 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_317 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.006393
K_318 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.006582
K_319 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.006436
K_320 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.006505
K_321 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.007765
K_322 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.007905
K_323 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.007904
K_324 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.007660
K_325 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.010067
K_326 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.010120
K_327 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.009724
K_328 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.010122
K_329 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.004940
K_330 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.005051
K_331 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.004974
K_332 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.004956
K_333 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.009139
K_334 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.009043
K_335 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.008984
K_336 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.008770
K_337 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.005441
K_338 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.005527
K_339 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.005386
K_340 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.005466
K_341 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.004937
K_342 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.005008
K_343 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.004952
K_344 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.004891
K_345 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006918
K_346 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006885
K_347 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006725
K_348 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006775
K_349 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.004398
K_350 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.004465
K_351 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.004380
K_352 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.004390
K_353 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.005166
K_354 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.005192
K_355 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.005120
K_356 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.005075
K_357 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.004834
K_358 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.004868
K_359 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.004768
K_360 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.004787
K_361 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.006163
K_362 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.011806
K_363 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.004222
K_364 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.004341
K_365 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.006324
K_366 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.006507
K_367 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.006363
K_368 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.006436
K_369 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.008013
K_370 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.008167
K_371 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.008160
K_372 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.007904
K_373 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.009664
K_374 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.009712
K_375 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.009350
K_376 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.009724
K_377 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.004956
K_378 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.005069
K_379 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.004989
K_380 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.004974
K_381 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.009372
K_382 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.009269
K_383 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.009196
K_384 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.008984
K_385 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.005361
K_386 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.005443
K_387 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.005306
K_388 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.005386
K_389 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.004998
K_390 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.005072
K_391 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.005012
K_392 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.004952
K_393 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006861
K_394 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006829
K_395 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.006669
K_396 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006725
K_397 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.004387
K_398 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.004453
K_399 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.004368
K_400 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.004380
K_401 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.005212
K_402 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.005239
K_403 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.005164
K_404 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.005120
K_405 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.004813
K_406 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.004846
K_407 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.004746
K_408 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.004768
K_409 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.006246
K_410 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.011783
K_411 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.004190
K_412 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.004380
K_413 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_414 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_415 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_416 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.005496
K_417 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.005428
K_418 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.005515
K_419 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.005389
K_420 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.007066
K_421 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.006846
K_422 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.006886
K_423 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.006936
K_424 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.009285
K_425 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.009441
K_426 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.009373
K_427 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.009058
K_428 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.004576
K_429 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.004499
K_430 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.004540
K_431 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.004488
K_432 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.009220
K_433 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.009081
K_434 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008837
K_435 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.009009
K_436 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.005184
K_437 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.005167
K_438 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.005177
K_439 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.005074
K_440 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.004812
K_441 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.004725
K_442 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.004727
K_443 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.004717
K_444 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006840
K_445 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006861
K_446 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006718
K_447 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006678
K_448 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.004380
K_449 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.004337
K_450 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.004338
K_451 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.004290
K_452 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.005083
K_453 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.005031
K_454 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.004984
K_455 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.004975
K_456 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.007544
K_457 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.004474
K_458 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.008333
K_459 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.003932
K_460 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_461 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_462 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.005562
K_463 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.005496
K_464 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.005583
K_465 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.005453
K_466 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.007299
K_467 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.007066
K_468 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.007105
K_469 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.007160
K_470 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.009120
K_471 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.009285
K_472 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.009212
K_473 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.008913
K_474 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.004656
K_475 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.004576
K_476 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.004619
K_477 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.004564
K_478 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.009348
K_479 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.009220
K_480 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.008957
K_481 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.009137
K_482 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.005198
K_483 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.005184
K_484 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.005193
K_485 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.005089
K_486 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.004902
K_487 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.004812
K_488 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.004813
K_489 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.004803
K_490 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006812
K_491 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006840
K_492 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006695
K_493 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.006655
K_494 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.004422
K_495 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.004380
K_496 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.004379
K_497 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.004330
K_498 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.005134
K_499 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.005083
K_500 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.005033
K_501 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.005024
K_502 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.007547
K_503 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.004568
K_504 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.008228
K_505 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.003956
K_506 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_507 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.005473
K_508 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.005408
K_509 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.005496
K_510 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.005370
K_511 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.007251
K_512 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.007019
K_513 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.007066
K_514 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.007116
K_515 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.009182
K_516 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.009342
K_517 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.009285
K_518 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.008971
K_519 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.004611
K_520 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.004533
K_521 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.004576
K_522 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.004522
K_523 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009638
K_524 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.009489
K_525 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.009220
K_526 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.009407
K_527 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.005188
K_528 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.005172
K_529 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.005184
K_530 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.005079
K_531 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.004900
K_532 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.004809
K_533 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.004812
K_534 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.004801
K_535 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006961
K_536 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006987
K_537 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006840
K_538 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006794
K_539 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.004421
K_540 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.004379
K_541 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.004380
K_542 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.004330
K_543 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.005185
K_544 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.005131
K_545 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.005083
K_546 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.005072
K_547 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.007365
K_548 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.004520
K_549 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.008545
K_550 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.003959
K_551 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.005604
K_552 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.005535
K_553 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.005627
K_554 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.005496
K_555 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.007194
K_556 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.006967
K_557 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.007009
K_558 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.007066
K_559 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.009510
K_560 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.009688
K_561 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.009614
K_562 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.009285
K_563 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.004667
K_564 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.004586
K_565 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.004630
K_566 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.004576
K_567 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.009428
K_568 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.009288
K_569 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.009027
K_570 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.009220
K_571 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.005298
K_572 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.005281
K_573 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.005292
K_574 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.005184
K_575 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.004910
K_576 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.004819
K_577 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.004821
K_578 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.004812
K_579 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.007006
K_580 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.007033
K_581 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006879
K_582 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006840
K_583 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.004474
K_584 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.004430
K_585 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.004430
K_586 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.004380
K_587 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.005196
K_588 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.005142
K_589 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.005092
K_590 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.005083
K_591 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.007622
K_592 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.004543
K_593 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.008449
K_594 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.004006
K_595 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_596 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_597 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_598 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.005013
K_599 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.004981
K_600 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.004932
K_601 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.005047
K_602 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.006606
K_603 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.006783
K_604 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.006601
K_605 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.006710
K_606 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.008990
K_607 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.008693
K_608 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.008642
K_609 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.008782
K_610 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.004385
K_611 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.004404
K_612 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.004332
K_613 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.004417
K_614 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.009303
K_615 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.009534
K_616 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.009165
K_617 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.009172
K_618 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.005123
K_619 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.005070
K_620 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.005005
K_621 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.005092
K_622 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.004812
K_623 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.004865
K_624 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.004756
K_625 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.004826
K_626 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006725
K_627 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006691
K_628 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006540
K_629 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006589
K_630 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.004622
K_631 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.004621
K_632 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.004535
K_633 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.004602
K_634 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.009785
K_635 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.005859
K_636 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.004080
K_637 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.006052
K_638 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_639 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_640 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.005042
K_641 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.005013
K_642 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.004961
K_643 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.005078
K_644 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.006436
K_645 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.006606
K_646 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.006434
K_647 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.006535
K_648 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.009301
K_649 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.008990
K_650 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.008925
K_651 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.009080
K_652 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.004365
K_653 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.004385
K_654 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.004313
K_655 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.004397
K_656 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.009070
K_657 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.009303
K_658 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008951
K_659 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.008957
K_660 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.005175
K_661 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.005123
K_662 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.005054
K_663 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.005145
K_664 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.004758
K_665 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.004812
K_666 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.004705
K_667 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.004773
K_668 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006752
K_669 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006725
K_670 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006568
K_671 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006618
K_672 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.004620
K_673 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.004622
K_674 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.004534
K_675 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.004601
K_676 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.009435
K_677 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.005988
K_678 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.004040
K_679 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.006051
K_680 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_681 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.005094
K_682 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.005063
K_683 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.005013
K_684 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.005132
K_685 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.006604
K_686 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.006785
K_687 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.006606
K_688 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.006712
K_689 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.009365
K_690 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.009039
K_691 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.008990
K_692 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.009139
K_693 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.004439
K_694 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.004459
K_695 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.004385
K_696 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.004473
K_697 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.009428
K_698 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.009679
K_699 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.009303
K_700 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.009301
K_701 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.005247
K_702 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.005191
K_703 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.005123
K_704 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.005215
K_705 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.004868
K_706 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.004924
K_707 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.004812
K_708 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.004884
K_709 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006918
K_710 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006885
K_711 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006725
K_712 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.006775
K_713 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.004711
K_714 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.004712
K_715 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.004622
K_716 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.004691
K_717 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.009508
K_718 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.005990
K_719 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.004112
K_720 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.006182
K_721 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.004976
K_722 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.004947
K_723 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.004899
K_724 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.005013
K_725 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.006500
K_726 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.006672
K_727 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.006499
K_728 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.006606
K_729 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.009196
K_730 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.008887
K_731 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.008832
K_732 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.008990
K_733 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.004353
K_734 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.004372
K_735 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.004301
K_736 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.004385
K_737 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.009420
K_738 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.009671
K_739 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.009286
K_740 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.009303
K_741 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.005151
K_742 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.005098
K_743 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.005032
K_744 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.005123
K_745 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.004796
K_746 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.004850
K_747 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.004741
K_748 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.004812
K_749 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006861
K_750 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006829
K_751 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006669
K_752 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006725
K_753 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.004640
K_754 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.004641
K_755 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.004553
K_756 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.004622
K_757 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.009373
K_758 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.005881
K_759 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.004049
K_760 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.006176
K_761 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_762 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_763 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_764 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.004754
K_765 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.004846
K_766 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.004823
K_767 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.004762
K_768 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.006370
K_769 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.006321
K_770 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.006405
K_771 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.006225
K_772 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.008846
K_773 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.009182
K_774 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.008844
K_775 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.008907
K_776 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.004328
K_777 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.004370
K_778 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.004366
K_779 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.004292
K_780 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.009303
K_781 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.009173
K_782 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.009094
K_783 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.008915
K_784 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.005184
K_785 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.005285
K_786 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.005202
K_787 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.005162
K_788 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.004952
K_789 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.004967
K_790 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.004953
K_791 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.004864
K_792 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006290
K_793 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006350
K_794 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.006226
K_795 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.006172
K_796 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.004600
K_797 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.008563
K_798 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.005406
K_799 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.004124
K_800 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_801 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_802 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.004665
K_803 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.004754
K_804 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.004731
K_805 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.004673
K_806 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.006413
K_807 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.006370
K_808 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.006452
K_809 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.006269
K_810 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.008531
K_811 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.008846
K_812 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.008536
K_813 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.008592
K_814 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.004285
K_815 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.004328
K_816 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.004323
K_817 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.004251
K_818 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.009418
K_819 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.009303
K_820 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.009211
K_821 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.009025
K_822 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.005085
K_823 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.005184
K_824 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.005104
K_825 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.005066
K_826 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.004934
K_827 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.004952
K_828 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.004936
K_829 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.004848
K_830 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.006226
K_831 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006290
K_832 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.006167
K_833 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.006114
K_834 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.004540
K_835 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.008810
K_836 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.005280
K_837 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.004107
K_838 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_839 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.004686
K_840 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.004775
K_841 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.004754
K_842 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.004694
K_843 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.006329
K_844 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.006284
K_845 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.006370
K_846 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.006190
K_847 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.008833
K_848 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.009176
K_849 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.008846
K_850 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.008902
K_851 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.004288
K_852 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.004331
K_853 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.004328
K_854 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.004254
K_855 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.009507
K_856 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.009378
K_857 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.009303
K_858 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.009103
K_859 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.005164
K_860 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.005265
K_861 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.005184
K_862 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.005143
K_863 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.004948
K_864 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.004965
K_865 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.004952
K_866 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.004862
K_867 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006349
K_868 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006414
K_869 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006290
K_870 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.006231
K_871 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.004510
K_872 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.008552
K_873 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.005380
K_874 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.004119
K_875 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.004744
K_876 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.004836
K_877 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.004813
K_878 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.004754
K_879 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.006518
K_880 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.006469
K_881 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.006559
K_882 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.006370
K_883 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.008771
K_884 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.009107
K_885 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.008777
K_886 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.008846
K_887 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.004362
K_888 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.004407
K_889 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.004403
K_890 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.004328
K_891 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.009725
K_892 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.009587
K_893 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.009496
K_894 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.009303
K_895 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.005203
K_896 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.005307
K_897 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.005223
K_898 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.005184
K_899 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.005042
K_900 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.005059
K_901 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.005044
K_902 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.004952
K_903 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006408
K_904 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.006475
K_905 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006344
K_906 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006290
K_907 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.004582
K_908 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.008817
K_909 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.005379
K_910 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.004183
K_911 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_912 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_913 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_914 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.004639
K_915 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.004539
K_916 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.004589
K_917 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.004574
K_918 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.006296
K_919 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.006203
K_920 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.006142
K_921 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.006297
K_922 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.008846
K_923 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.008629
K_924 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.008731
K_925 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.008500
K_926 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.004385
K_927 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.004303
K_928 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.004311
K_929 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.004336
K_930 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.009220
K_931 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.009116
K_932 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.008844
K_933 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.009036
K_934 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.005386
K_935 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.005278
K_936 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.005290
K_937 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.005262
K_938 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.005314
K_939 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.005226
K_940 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.005185
K_941 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.005231
K_942 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.009068
K_943 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.003870
K_944 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.007749
K_945 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.005134
K_946 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_947 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_948 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.004743
K_949 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.004639
K_950 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.004691
K_951 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.004675
K_952 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.006388
K_953 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.006296
K_954 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.006230
K_955 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.006392
K_956 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.009064
K_957 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.008846
K_958 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.008948
K_959 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.008700
K_960 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.004471
K_961 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.004385
K_962 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.004393
K_963 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.004419
K_964 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.009310
K_965 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.009220
K_966 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.008931
K_967 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.009129
K_968 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.005497
K_969 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.005386
K_970 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.005398
K_971 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.005367
K_972 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.005404
K_973 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.005314
K_974 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.005269
K_975 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.005318
K_976 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.009227
K_977 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.003942
K_978 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.007756
K_979 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.005217
K_980 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_981 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.004687
K_982 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.004586
K_983 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.004639
K_984 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.004622
K_985 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.006456
K_986 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.006359
K_987 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.006296
K_988 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.006460
K_989 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.008950
K_990 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.008733
K_991 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.008846
K_992 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.008599
K_993 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.004462
K_994 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.004376
K_995 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.004385
K_996 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.004411
K_997 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.009629
K_998 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.009520
K_999 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.009220
K_1000 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.009429
K_1001 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.005483
K_1002 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.005371
K_1003 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.005386
K_1004 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.005354
K_1005 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.005450
K_1006 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.005357
K_1007 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.005314
K_1008 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.005362
K_1009 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.008843
K_1010 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.003906
K_1011 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.007979
K_1012 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.005212
K_1013 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.004704
K_1014 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.004601
K_1015 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.004654
K_1016 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.004639
K_1017 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.006289
K_1018 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.006199
K_1019 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.006139
K_1020 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.006296
K_1021 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.009221
K_1022 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.008984
K_1023 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.009099
K_1024 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.008846
K_1025 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.004435
K_1026 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.004350
K_1027 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.004359
K_1028 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.004385
K_1029 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.009397
K_1030 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.009296
K_1031 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.009008
K_1032 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.009220
K_1033 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.005516
K_1034 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.005402
K_1035 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.005415
K_1036 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.005386
K_1037 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.005398
K_1038 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.005307
K_1039 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.005264
K_1040 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.005314
K_1041 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.008991
K_1042 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.003897
K_1043 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.007710
K_1044 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.005261
K_1045 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_1046 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_1047 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_1048 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.004639
K_1049 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.004704
K_1050 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.004624
K_1051 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.004706
K_1052 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.006370
K_1053 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.006557
K_1054 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.006454
K_1055 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.006401
K_1056 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.008990
K_1057 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.009001
K_1058 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.008703
K_1059 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.009029
K_1060 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.004576
K_1061 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.004663
K_1062 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.004574
K_1063 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.004616
K_1064 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.008984
K_1065 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.009215
K_1066 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.008886
K_1067 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.008860
K_1068 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.005815
K_1069 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.005899
K_1070 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.005738
K_1071 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.005832
K_1072 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.005027
K_1073 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.011754
K_1074 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.003880
K_1075 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.006868
K_1076 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_1077 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_1078 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.004574
K_1079 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.004639
K_1080 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.004561
K_1081 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.004639
K_1082 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.006192
K_1083 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.006370
K_1084 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.006272
K_1085 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.006223
K_1086 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.008963
K_1087 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.008990
K_1088 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.008686
K_1089 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.009010
K_1090 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.004492
K_1091 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.004576
K_1092 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.004491
K_1093 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.004530
K_1094 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.008754
K_1095 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.008984
K_1096 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.008671
K_1097 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.008647
K_1098 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.005731
K_1099 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.005815
K_1100 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.005658
K_1101 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.005748
K_1102 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.004927
K_1103 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.012090
K_1104 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.003822
K_1105 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.006735
K_1106 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_1107 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.004651
K_1108 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.004718
K_1109 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.004639
K_1110 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.004720
K_1111 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.006282
K_1112 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.006465
K_1113 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.006370
K_1114 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.006315
K_1115 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.009289
K_1116 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.009310
K_1117 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.008990
K_1118 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.009341
K_1119 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.004576
K_1120 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.004664
K_1121 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.004576
K_1122 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.004617
K_1123 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.009068
K_1124 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.009315
K_1125 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.008984
K_1126 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.008949
K_1127 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.005892
K_1128 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.005981
K_1129 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.005815
K_1130 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.005911
K_1131 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.004928
K_1132 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.011969
K_1133 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.003878
K_1134 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.006891
K_1135 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.004573
K_1136 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.004636
K_1137 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.004560
K_1138 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.004639
K_1139 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.006333
K_1140 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.006521
K_1141 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.006420
K_1142 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.006370
K_1143 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.008935
K_1144 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.008953
K_1145 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.008660
K_1146 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.008990
K_1147 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.004535
K_1148 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.004621
K_1149 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.004535
K_1150 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.004576
K_1151 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.009096
K_1152 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.009345
K_1153 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.009003
K_1154 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.008984
K_1155 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.005795
K_1156 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.005880
K_1157 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.005720
K_1158 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.005815
K_1159 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.004934
K_1160 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.011473
K_1161 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.003837
K_1162 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.006952
K_1163 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_1164 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_1165 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_1166 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.004754
K_1167 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.004759
K_1168 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.004804
K_1169 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.004696
K_1170 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.006606
K_1171 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.006430
K_1172 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.006528
K_1173 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.006436
K_1174 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.009285
K_1175 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.009480
K_1176 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.009381
K_1177 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.009085
K_1178 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.004974
K_1179 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.004933
K_1180 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.004974
K_1181 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.004874
K_1182 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.008320
K_1183 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.008189
K_1184 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.008171
K_1185 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.008003
K_1186 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.004542
K_1187 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.004697
K_1188 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.013024
K_1189 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.004327
K_1190 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_1191 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_1192 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.004746
K_1193 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.004754
K_1194 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.004798
K_1195 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.004690
K_1196 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.006790
K_1197 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.006606
K_1198 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.006708
K_1199 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.006609
K_1200 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.009085
K_1201 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.009285
K_1202 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.009183
K_1203 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.008906
K_1204 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.005014
K_1205 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.004974
K_1206 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.005016
K_1207 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.004913
K_1208 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.008444
K_1209 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.008320
K_1210 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.008294
K_1211 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.008119
K_1212 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.004526
K_1213 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.004787
K_1214 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.012301
K_1215 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.004345
K_1216 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_1217 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.004703
K_1218 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.004709
K_1219 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.004754
K_1220 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.004648
K_1221 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.006680
K_1222 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.006502
K_1223 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.006606
K_1224 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.006508
K_1225 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.009174
K_1226 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.009371
K_1227 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.009285
K_1228 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.008990
K_1229 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.004971
K_1230 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.004931
K_1231 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.004974
K_1232 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.004872
K_1233 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.008464
K_1234 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.008333
K_1235 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.008320
K_1236 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.008137
K_1237 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.004456
K_1238 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.004696
K_1239 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.012689
K_1240 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.004321
K_1241 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.004811
K_1242 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.004818
K_1243 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.004864
K_1244 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.004754
K_1245 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.006783
K_1246 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.006596
K_1247 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.006701
K_1248 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.006606
K_1249 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.009479
K_1250 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.009696
K_1251 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.009591
K_1252 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.009285
K_1253 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.005078
K_1254 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.005035
K_1255 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.005079
K_1256 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.004974
K_1257 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.008664
K_1258 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.008523
K_1259 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.008502
K_1260 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.008320
K_1261 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.004533
K_1262 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.004748
K_1263 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.012870
K_1264 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.004403
K_1265 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_1266 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_1267 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_1268 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.005013
K_1269 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.004928
K_1270 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.004921
K_1271 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.005003
K_1272 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.007066
K_1273 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.007129
K_1274 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.006944
K_1275 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.007165
K_1276 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.009724
K_1277 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.009376
K_1278 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.009318
K_1279 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.009455
K_1280 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.005879
K_1281 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.005821
K_1282 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.005734
K_1283 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.005869
K_1284 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.006730
K_1285 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.004359
K_1286 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.004991
K_1287 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.010219
K_1288 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_1289 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_1290 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.005099
K_1291 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.005013
K_1292 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.005004
K_1293 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.005090
K_1294 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.006996
K_1295 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.007066
K_1296 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.006882
K_1297 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.007097
K_1298 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.010090
K_1299 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.009724
K_1300 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.009649
K_1301 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.009801
K_1302 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.005934
K_1303 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.005879
K_1304 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.005788
K_1305 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.005926
K_1306 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.006698
K_1307 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.004436
K_1308 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.004954
K_1309 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.010537
K_1310 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_1311 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.005106
K_1312 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.005018
K_1313 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.005013
K_1314 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.005098
K_1315 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.007185
K_1316 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.007256
K_1317 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.007066
K_1318 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.007295
K_1319 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.010163
K_1320 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.009778
K_1321 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.009724
K_1322 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.009868
K_1323 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.006029
K_1324 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.005969
K_1325 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.005879
K_1326 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.006021
K_1327 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.006591
K_1328 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.004398
K_1329 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.005031
K_1330 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.010679
K_1331 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.005019
K_1332 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.004936
K_1333 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.004929
K_1334 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.005013
K_1335 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.006962
K_1336 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.007027
K_1337 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.006849
K_1338 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.007066
K_1339 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.009994
K_1340 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.009627
K_1341 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.009565
K_1342 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.009724
K_1343 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.005884
K_1344 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.005828
K_1345 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.005741
K_1346 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.005879
K_1347 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.006548
K_1348 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.004355
K_1349 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.004917
K_1350 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.010656
K_1351 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_1352 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_1353 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_1354 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.005496
K_1355 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.005644
K_1356 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.005560
K_1357 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.005553
K_1358 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.007904
K_1359 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.008046
K_1360 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.008039
K_1361 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.007788
K_1362 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.010076
K_1363 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.010500
K_1364 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.010075
K_1365 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.010093
K_1366 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.003960
K_1367 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.009387
K_1368 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.004799
K_1369 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.005962
K_1370 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_1371 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_1372 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.005355
K_1373 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.005496
K_1374 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.005417
K_1375 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.005410
K_1376 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.007758
K_1377 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.007904
K_1378 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.007891
K_1379 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.007654
K_1380 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.009678
K_1381 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.010076
K_1382 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.009688
K_1383 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.009703
K_1384 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.003912
K_1385 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.009579
K_1386 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.004694
K_1387 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.005880
K_1388 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_1389 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.005430
K_1390 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.005574
K_1391 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.005496
K_1392 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.005487
K_1393 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.007765
K_1394 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.007905
K_1395 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.007904
K_1396 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.007660
K_1397 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.010054
K_1398 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.010489
K_1399 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.010076
K_1400 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.010082
K_1401 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.003887
K_1402 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.009169
K_1403 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.004753
K_1404 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.005893
K_1405 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.005436
K_1406 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.005581
K_1407 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.005500
K_1408 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.005496
K_1409 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.008013
K_1410 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.008168
K_1411 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.008160
K_1412 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.007904
K_1413 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.010036
K_1414 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.010469
K_1415 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.010047
K_1416 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.010076
K_1417 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.003918
K_1418 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.009294
K_1419 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.004727
K_1420 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.006031
K_1421 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_1422 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_1423 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_1424 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.006436
K_1425 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.006284
K_1426 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.006402
K_1427 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.006283
K_1428 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.009578
K_1429 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.009183
K_1430 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.009248
K_1431 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.009294
K_1432 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.004847
K_1433 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.003927
K_1434 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.013989
K_1435 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.005975
K_1436 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_1437 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_1438 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.006592
K_1439 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.006436
K_1440 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.006559
K_1441 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.006432
K_1442 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.010007
K_1443 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.009578
K_1444 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.009643
K_1445 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.009695
K_1446 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.004856
K_1447 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.003995
K_1448 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.013699
K_1449 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.006079
K_1450 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_1451 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.006464
K_1452 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.006314
K_1453 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.006436
K_1454 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.006312
K_1455 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.009923
K_1456 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.009495
K_1457 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.009578
K_1458 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.009619
K_1459 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.004757
K_1460 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.003934
K_1461 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.013912
K_1462 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.005988
K_1463 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.006594
K_1464 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.006434
K_1465 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.006560
K_1466 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.006436
K_1467 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.009868
K_1468 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.009446
K_1469 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.009518
K_1470 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.009578
K_1471 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.004809
K_1472 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.003941
K_1473 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.013194
K_1474 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.006124
K_1475 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_1476 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_1477 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_1478 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.008885
K_1479 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.008955
K_1480 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.008696
K_1481 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.009062
K_1482 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.004515
K_1483 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.005535
K_1484 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.004615
K_1485 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.023584
K_1486 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_1487 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_1488 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.008801
K_1489 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.008885
K_1490 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.008625
K_1491 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.008981
K_1492 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.004470
K_1493 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.005625
K_1494 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.004549
K_1495 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.022329
K_1496 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_1497 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.009070
K_1498 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.009153
K_1499 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.008885
K_1500 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.009267
K_1501 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.004432
K_1502 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.005536
K_1503 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.004601
K_1504 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.022898
K_1505 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.008704
K_1506 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.008777
K_1507 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.008533
K_1508 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.008885
K_1509 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.004433
K_1510 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.005478
K_1511 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.004529
K_1512 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.024887
K_1513 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_1514 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_1515 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_1516 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.003928
K_1517 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.005056
K_1518 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.006917
K_1519 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.007178
K_1520 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_1521 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_1522 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.003905
K_1523 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.005139
K_1524 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.006733
K_1525 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.007181
K_1526 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_1527 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.003858
K_1528 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.005022
K_1529 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.006784
K_1530 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.007062
K_1531 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.003889
K_1532 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.005045
K_1533 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.006713
K_1534 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.007310
K_1535 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.004257
K_1536 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.004536
K_1537 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.004238
K_1538 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.003644
K_1539 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.004536
K_1540 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.004257

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
