* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Chromium-52 (Z=24, A=52)
* Auto-generated topological mutual impedance array
* Nodes: 52

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.009067
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.008710
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.008780
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.008893
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.009771
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.009931
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.009539
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.009930
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.010251
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.010019
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.010103
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.009783
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.006018
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.005922
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005858
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.005975
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.008426
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.008645
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.008333
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.008354
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.005946
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.005821
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.005818
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.005796
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.005444
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.005443
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.005325
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.005424
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.006331
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.006342
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.006247
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.006179
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.004768
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.004709
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.004664
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.004696
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.005146
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.005169
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.005056
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.005091
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.004824
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.004796
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.004737
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.004733
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.021130
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.005395
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.005149
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.004533
K_52 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_53 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_54 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.009452
K_55 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.009067
K_56 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.009137
K_57 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.009265
K_58 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.009599
K_59 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.009771
K_60 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.009388
K_61 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.009759
K_62 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.010473
K_63 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.010251
K_64 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.010328
K_65 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.009987
K_66 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.006114
K_67 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.006018
K_68 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.005949
K_69 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.006072
K_70 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.008210
K_71 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.008426
K_72 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.008131
K_73 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.008149
K_74 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.006075
K_75 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.005946
K_76 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.005941
K_77 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.005917
K_78 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.005441
K_79 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.005444
K_80 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.005325
K_81 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.005423
K_82 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.006315
K_83 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.006331
K_84 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.006234
K_85 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.006166
K_86 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.004827
K_87 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.004768
K_88 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.004720
K_89 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.004753
K_90 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.005120
K_91 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.005146
K_92 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.005033
K_93 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.005067
K_94 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.004851
K_95 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.004824
K_96 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.004763
K_97 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.004759
K_98 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.019717
K_99 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.005525
K_100 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.005102
K_101 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.004552
K_102 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_103 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.009365
K_104 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.008982
K_105 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.009067
K_106 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.009183
K_107 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.009998
K_108 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.010182
K_109 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.009771
K_110 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.010180
K_111 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.010380
K_112 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.010151
K_113 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.010251
K_114 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.009906
K_115 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.006186
K_116 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.006084
K_117 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.006018
K_118 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.006143
K_119 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.008508
K_120 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.008740
K_121 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.008426
K_122 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.008440
K_123 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.006078
K_124 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.005947
K_125 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.005946
K_126 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.005920
K_127 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.005567
K_128 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.005568
K_129 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.005444
K_130 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.005547
K_131 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.006413
K_132 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.006427
K_133 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.006331
K_134 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.006257
K_135 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.004878
K_136 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.004816
K_137 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.004768
K_138 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.004801
K_139 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.005237
K_140 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.005263
K_141 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.005146
K_142 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.005181
K_143 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.004914
K_144 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.004885
K_145 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.004824
K_146 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.004819
K_147 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.019596
K_148 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.005510
K_149 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.005229
K_150 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.004595
K_151 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.009233
K_152 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.008865
K_153 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.008939
K_154 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.009067
K_155 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.009600
K_156 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.009762
K_157 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.009389
K_158 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.009771
K_159 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.010764
K_160 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.010510
K_161 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.010607
K_162 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.010251
K_163 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.006056
K_164 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.005961
K_165 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.005896
K_166 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.006018
K_167 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.008486
K_168 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.008717
K_169 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.008398
K_170 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.008426
K_171 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.006104
K_172 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.005971
K_173 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.005968
K_174 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.005946
K_175 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.005461
K_176 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.005462
K_177 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.005343
K_178 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.005444
K_179 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.006489
K_180 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006504
K_181 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.006402
K_182 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.006331
K_183 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.004842
K_184 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.004781
K_185 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.004733
K_186 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.004768
K_187 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.005199
K_188 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.005224
K_189 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.005108
K_190 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.005146
K_191 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.004918
K_192 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.004889
K_193 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.004827
K_194 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.004824
K_195 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.020981
K_196 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.005480
K_197 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.005149
K_198 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.004624
K_199 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_200 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_201 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_202 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.006597
K_203 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.006796
K_204 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.006636
K_205 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.006713
K_206 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.008106
K_207 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.008255
K_208 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.008243
K_209 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.007982
K_210 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.009933
K_211 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.009976
K_212 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.009588
K_213 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.009964
K_214 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.005128
K_215 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.005246
K_216 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.005160
K_217 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.005142
K_218 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.009077
K_219 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.008990
K_220 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008905
K_221 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008715
K_222 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.005551
K_223 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.005637
K_224 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.005489
K_225 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.005569
K_226 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.005123
K_227 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.005197
K_228 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.005130
K_229 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.005070
K_230 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006687
K_231 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.006670
K_232 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.006513
K_233 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.006555
K_234 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.004605
K_235 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.004672
K_236 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.004578
K_237 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.004588
K_238 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.005146
K_239 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.005179
K_240 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.005091
K_241 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.005065
K_242 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.006521
K_243 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.012229
K_244 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.004411
K_245 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.004562
K_246 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_247 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_248 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.006408
K_249 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.006597
K_250 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.006447
K_251 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.006517
K_252 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.007952
K_253 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.008106
K_254 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.008088
K_255 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.007841
K_256 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.009867
K_257 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.009933
K_258 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.009539
K_259 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.009909
K_260 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.005014
K_261 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.005128
K_262 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.005045
K_263 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.005029
K_264 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.009149
K_265 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.009077
K_266 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008981
K_267 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008787
K_268 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.005465
K_269 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.005551
K_270 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.005408
K_271 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.005484
K_272 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.005049
K_273 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.005123
K_274 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.005057
K_275 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.005000
K_276 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006698
K_277 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006687
K_278 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.006526
K_279 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.006568
K_280 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.004540
K_281 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.004605
K_282 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.004514
K_283 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.004524
K_284 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.005110
K_285 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.005146
K_286 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.005059
K_287 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.005033
K_288 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.006344
K_289 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.012826
K_290 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.004340
K_291 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.004535
K_292 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_293 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.006552
K_294 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.006751
K_295 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.006597
K_296 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.006669
K_297 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.007963
K_298 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.008111
K_299 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.008106
K_300 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.007851
K_301 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.010292
K_302 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.010353
K_303 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.009933
K_304 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.010339
K_305 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.005093
K_306 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.005211
K_307 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.005128
K_308 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.005109
K_309 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.009241
K_310 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.009158
K_311 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.009077
K_312 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.008868
K_313 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.005611
K_314 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.005702
K_315 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.005551
K_316 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.005631
K_317 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.005112
K_318 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.005188
K_319 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.005123
K_320 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.005062
K_321 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006869
K_322 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006853
K_323 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006687
K_324 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006729
K_325 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.004631
K_326 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.004700
K_327 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.004605
K_328 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.004614
K_329 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.005199
K_330 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.005234
K_331 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.005146
K_332 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.005117
K_333 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.006367
K_334 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.012857
K_335 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.004426
K_336 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.004587
K_337 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.006480
K_338 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.006672
K_339 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.006520
K_340 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.006597
K_341 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.008222
K_342 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.008386
K_343 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.008373
K_344 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.008106
K_345 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.009880
K_346 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.009934
K_347 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.009550
K_348 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.009933
K_349 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.005110
K_350 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.005229
K_351 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.005144
K_352 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.005128
K_353 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.009467
K_354 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.009378
K_355 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.009282
K_356 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.009077
K_357 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.005530
K_358 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.005617
K_359 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.005470
K_360 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.005551
K_361 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.005174
K_362 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.005251
K_363 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.005183
K_364 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.005123
K_365 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006821
K_366 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006806
K_367 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.006640
K_368 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006687
K_369 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.004621
K_370 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.004689
K_371 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.004594
K_372 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.004605
K_373 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.005227
K_374 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.005263
K_375 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.005172
K_376 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.005146
K_377 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.006454
K_378 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.012829
K_379 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.004391
K_380 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.004632
K_381 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_382 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_383 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_384 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.005662
K_385 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.005590
K_386 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.005681
K_387 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.005548
K_388 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.007288
K_389 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.007055
K_390 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.007096
K_391 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.007147
K_392 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.009534
K_393 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.009688
K_394 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.009612
K_395 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.009285
K_396 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.004754
K_397 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.004671
K_398 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.004714
K_399 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.004658
K_400 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.009300
K_401 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.009155
K_402 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008912
K_403 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.009066
K_404 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.005392
K_405 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.005371
K_406 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.005378
K_407 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.005271
K_408 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.005037
K_409 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.004946
K_410 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.004943
K_411 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.004930
K_412 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006687
K_413 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006684
K_414 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006562
K_415 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006519
K_416 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.004768
K_417 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.004722
K_418 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.004710
K_419 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.004662
K_420 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.007755
K_421 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.004662
K_422 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.009079
K_423 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.004147
K_424 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_425 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_426 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.005732
K_427 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.005662
K_428 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.005754
K_429 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.005616
K_430 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.007535
K_431 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.007288
K_432 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.007328
K_433 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.007385
K_434 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.009369
K_435 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.009534
K_436 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.009452
K_437 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.009140
K_438 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.004839
K_439 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.004754
K_440 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.004798
K_441 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.004740
K_442 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.009434
K_443 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.009300
K_444 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.009038
K_445 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.009198
K_446 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.005410
K_447 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.005392
K_448 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.005397
K_449 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.005289
K_450 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.005130
K_451 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.005037
K_452 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.005033
K_453 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.005019
K_454 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006684
K_455 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006687
K_456 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006562
K_457 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.006519
K_458 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.004814
K_459 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.004768
K_460 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.004755
K_461 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.004706
K_462 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.007760
K_463 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.004765
K_464 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.008953
K_465 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.004175
K_466 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_467 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.005638
K_468 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.005570
K_469 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.005662
K_470 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.005528
K_471 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.007487
K_472 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.007240
K_473 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.007288
K_474 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.007339
K_475 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.009439
K_476 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.009598
K_477 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.009534
K_478 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.009205
K_479 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.004793
K_480 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.004709
K_481 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.004754
K_482 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.004696
K_483 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009723
K_484 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.009567
K_485 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.009300
K_486 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.009465
K_487 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.005403
K_488 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.005383
K_489 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.005392
K_490 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.005283
K_491 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.005133
K_492 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.005038
K_493 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.005037
K_494 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.005021
K_495 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006812
K_496 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006812
K_497 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006687
K_498 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006638
K_499 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.004827
K_500 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.004780
K_501 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.004768
K_502 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.004718
K_503 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.007562
K_504 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.004710
K_505 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.009330
K_506 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.004177
K_507 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.005778
K_508 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.005704
K_509 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.005800
K_510 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.005662
K_511 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.007428
K_512 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.007186
K_513 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.007229
K_514 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.007288
K_515 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.009783
K_516 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.009961
K_517 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.009879
K_518 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.009534
K_519 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.004853
K_520 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.004766
K_521 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.004812
K_522 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.004754
K_523 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.009534
K_524 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.009387
K_525 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.009126
K_526 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.009300
K_527 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.005518
K_528 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.005497
K_529 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.005505
K_530 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.005392
K_531 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.005148
K_532 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.005052
K_533 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.005049
K_534 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.005037
K_535 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006862
K_536 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006862
K_537 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006731
K_538 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006687
K_539 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.004879
K_540 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.004831
K_541 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.004818
K_542 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.004768
K_543 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.007831
K_544 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.004736
K_545 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.009215
K_546 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.004230
K_547 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_548 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_549 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_550 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.005196
K_551 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.005163
K_552 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.005110
K_553 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.005233
K_554 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.006861
K_555 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.007051
K_556 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.006852
K_557 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.006971
K_558 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.009288
K_559 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.008981
K_560 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.008912
K_561 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.009066
K_562 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.004601
K_563 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.004621
K_564 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.004540
K_565 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.004633
K_566 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.009358
K_567 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.009573
K_568 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.009191
K_569 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.009222
K_570 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.005392
K_571 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.005339
K_572 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.005261
K_573 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.005356
K_574 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.005123
K_575 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.005174
K_576 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.005051
K_577 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.005129
K_578 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006331
K_579 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006320
K_580 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006168
K_581 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006237
K_582 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.009886
K_583 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.006121
K_584 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.004286
K_585 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.006556
K_586 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_587 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_588 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.005227
K_589 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.005196
K_590 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.005141
K_591 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.005266
K_592 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.006680
K_593 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.006861
K_594 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.006674
K_595 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.006784
K_596 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.009609
K_597 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.009288
K_598 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.009203
K_599 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.009373
K_600 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.004579
K_601 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.004601
K_602 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.004520
K_603 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.004612
K_604 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.009140
K_605 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.009358
K_606 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008992
K_607 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.009022
K_608 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.005443
K_609 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.005392
K_610 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.005310
K_611 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.005408
K_612 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.005070
K_613 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.005123
K_614 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.005001
K_615 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.005077
K_616 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006337
K_617 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006331
K_618 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006176
K_619 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006245
K_620 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.009541
K_621 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.006261
K_622 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.004243
K_623 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.006555
K_624 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_625 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.005284
K_626 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.005251
K_627 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.005196
K_628 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.005325
K_629 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.006863
K_630 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.007057
K_631 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.006861
K_632 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.006977
K_633 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.009696
K_634 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.009357
K_635 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.009288
K_636 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.009454
K_637 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.004661
K_638 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.004683
K_639 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.004601
K_640 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.004696
K_641 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.009515
K_642 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.009751
K_643 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.009358
K_644 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.009382
K_645 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.005530
K_646 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.005475
K_647 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.005392
K_648 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.005493
K_649 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.005195
K_650 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.005250
K_651 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.005123
K_652 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.005203
K_653 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006502
K_654 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006492
K_655 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006331
K_656 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.006403
K_657 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.009599
K_658 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.006259
K_659 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.004321
K_660 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.006709
K_661 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.005157
K_662 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.005126
K_663 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.005074
K_664 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.005196
K_665 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.006750
K_666 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.006933
K_667 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.006744
K_668 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.006861
K_669 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.009508
K_670 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.009188
K_671 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.009114
K_672 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.009288
K_673 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.004567
K_674 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.004588
K_675 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.004509
K_676 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.004601
K_677 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.009480
K_678 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.009714
K_679 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.009316
K_680 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.009358
K_681 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.005425
K_682 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.005373
K_683 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.005293
K_684 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.005392
K_685 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.005113
K_686 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.005166
K_687 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.005043
K_688 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.005123
K_689 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006424
K_690 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006415
K_691 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006257
K_692 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006331
K_693 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.009461
K_694 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.006140
K_695 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.004251
K_696 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.006700
K_697 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_698 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_699 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_700 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.004967
K_701 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.005067
K_702 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.005042
K_703 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.004975
K_704 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.006674
K_705 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.006623
K_706 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.006711
K_707 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.006515
K_708 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.009207
K_709 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.009566
K_710 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.009200
K_711 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.009254
K_712 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.004601
K_713 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.004648
K_714 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.004641
K_715 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.004559
K_716 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.009300
K_717 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.009210
K_718 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.009108
K_719 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.008923
K_720 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.005551
K_721 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.005658
K_722 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.005564
K_723 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.005513
K_724 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.005444
K_725 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.005474
K_726 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.005437
K_727 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.005342
K_728 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.004749
K_729 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.008931
K_730 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.005732
K_731 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.004382
K_732 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_733 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_734 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.004870
K_735 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.004967
K_736 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.004942
K_737 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.004879
K_738 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.006720
K_739 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.006674
K_740 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.006761
K_741 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.006560
K_742 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.008870
K_743 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.009207
K_744 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.008872
K_745 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.008920
K_746 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.004552
K_747 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.004601
K_748 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.004593
K_749 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.004512
K_750 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.009375
K_751 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.009300
K_752 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.009187
K_753 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.008997
K_754 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.005446
K_755 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.005551
K_756 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.005460
K_757 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.005412
K_758 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.005411
K_759 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.005444
K_760 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.005406
K_761 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.005313
K_762 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.004685
K_763 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.009198
K_764 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.005588
K_765 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.004363
K_766 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_767 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.004893
K_768 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.004990
K_769 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.004967
K_770 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.004902
K_771 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.006631
K_772 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.006584
K_773 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.006674
K_774 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.006478
K_775 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.009196
K_776 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.009564
K_777 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.009207
K_778 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.009252
K_779 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.004559
K_780 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.004606
K_781 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.004601
K_782 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.004519
K_783 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.009485
K_784 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.009399
K_785 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.009300
K_786 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.009094
K_787 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.005534
K_788 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.005642
K_789 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.005551
K_790 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.005499
K_791 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.005448
K_792 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.005480
K_793 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.005444
K_794 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.005347
K_795 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.004652
K_796 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.008902
K_797 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.005697
K_798 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.004374
K_799 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.004957
K_800 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.005058
K_801 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.005032
K_802 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.004967
K_803 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.006839
K_804 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.006787
K_805 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.006882
K_806 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.006674
K_807 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.009143
K_808 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.009505
K_809 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.009146
K_810 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.009207
K_811 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.004642
K_812 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.004692
K_813 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.004685
K_814 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.004601
K_815 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.009710
K_816 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.009617
K_817 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.009502
K_818 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.009300
K_819 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.005586
K_820 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.005697
K_821 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.005601
K_822 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.005551
K_823 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.005548
K_824 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.005582
K_825 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.005542
K_826 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.005444
K_827 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.004728
K_828 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.009190
K_829 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.005697
K_830 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.004448
K_831 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_832 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_833 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_834 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.004898
K_835 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.004787
K_836 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.004842
K_837 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.004825
K_838 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.006674
K_839 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.006567
K_840 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.006499
K_841 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.006670
K_842 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.009288
K_843 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.009041
K_844 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.009138
K_845 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.008903
K_846 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.004754
K_847 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.004658
K_848 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.004665
K_849 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.004694
K_850 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.009077
K_851 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.008933
K_852 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.008704
K_853 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.008862
K_854 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.005946
K_855 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.005820
K_856 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.005814
K_857 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.005800
K_858 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.008940
K_859 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.004042
K_860 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.008330
K_861 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.005528
K_862 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_863 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_864 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.005014
K_865 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.004898
K_866 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.004955
K_867 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.004937
K_868 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.006780
K_869 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.006674
K_870 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.006599
K_871 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.006779
K_872 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.009537
K_873 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.009288
K_874 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.009384
K_875 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.009130
K_876 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.004853
K_877 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.004754
K_878 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.004760
K_879 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.004790
K_880 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.009209
K_881 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.009077
K_882 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.008829
K_883 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.008993
K_884 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.006076
K_885 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.005946
K_886 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.005937
K_887 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.005922
K_888 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.009084
K_889 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.004122
K_890 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.008337
K_891 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.005627
K_892 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_893 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.004952
K_894 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.004839
K_895 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.004898
K_896 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.004879
K_897 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.006857
K_898 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.006745
K_899 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.006674
K_900 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.006856
K_901 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.009427
K_902 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.009178
K_903 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.009288
K_904 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.009033
K_905 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.004846
K_906 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.004746
K_907 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.004754
K_908 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.004783
K_909 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.009482
K_910 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.009328
K_911 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.009077
K_912 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.009247
K_913 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.006083
K_914 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.005950
K_915 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.005946
K_916 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.005929
K_917 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.008714
K_918 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.004080
K_919 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.008586
K_920 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.005616
K_921 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.004971
K_922 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.004856
K_923 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.004914
K_924 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.004898
K_925 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.006672
K_926 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.006568
K_927 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.006500
K_928 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.006674
K_929 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.009707
K_930 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.009435
K_931 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.009546
K_932 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.009288
K_933 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.004815
K_934 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.004716
K_935 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.004723
K_936 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.004754
K_937 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.009289
K_938 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.009145
K_939 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.008899
K_940 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.009077
K_941 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.006100
K_942 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.005966
K_943 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.005959
K_944 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.005946
K_945 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.008850
K_946 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.004071
K_947 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.008267
K_948 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.005675
K_949 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_950 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_951 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_952 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.004967
K_953 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.005042
K_954 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.004950
K_955 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.005043
K_956 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.006861
K_957 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.007080
K_958 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.006953
K_959 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.006896
K_960 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.009534
K_961 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.009576
K_962 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.009220
K_963 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.009574
K_964 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.005128
K_965 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.005235
K_966 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.005120
K_967 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.005172
K_968 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.008426
K_969 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.008641
K_970 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.008320
K_971 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.008364
K_972 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.005155
K_973 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.011678
K_974 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.004108
K_975 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.007596
K_976 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_977 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_978 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.004893
K_979 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.004967
K_980 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.004878
K_981 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.004967
K_982 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.006655
K_983 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.006861
K_984 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.006743
K_985 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.006690
K_986 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.009473
K_987 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.009534
K_988 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.009174
K_989 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.009522
K_990 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.005024
K_991 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.005128
K_992 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.005018
K_993 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.005067
K_994 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.008214
K_995 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.008426
K_996 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.008121
K_997 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.008162
K_998 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.005053
K_999 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.012005
K_1000 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.004044
K_1001 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.007429
K_1002 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_1003 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.004982
K_1004 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.005059
K_1005 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.004967
K_1006 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.005060
K_1007 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.006766
K_1008 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.006979
K_1009 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.006861
K_1010 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.006803
K_1011 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.009860
K_1012 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.009918
K_1013 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.009534
K_1014 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.009915
K_1015 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.005133
K_1016 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.005242
K_1017 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.005128
K_1018 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.005178
K_1019 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.008522
K_1020 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.008752
K_1021 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.008426
K_1022 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.008464
K_1023 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.005049
K_1024 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.011830
K_1025 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.004105
K_1026 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.007613
K_1027 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.004892
K_1028 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.004965
K_1029 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.004877
K_1030 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.004967
K_1031 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.006820
K_1032 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.007038
K_1033 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.006914
K_1034 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.006861
K_1035 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.009476
K_1036 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.009527
K_1037 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.009176
K_1038 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.009534
K_1039 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.005082
K_1040 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.005188
K_1041 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.005076
K_1042 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.005128
K_1043 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.008476
K_1044 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.008702
K_1045 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.008374
K_1046 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.008426
K_1047 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.005056
K_1048 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.011377
K_1049 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.004058
K_1050 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.007694
K_1051 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_1052 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_1053 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_1054 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.005196
K_1055 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.005202
K_1056 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.005255
K_1057 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.005126
K_1058 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.007288
K_1059 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.007080
K_1060 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.007193
K_1061 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.007076
K_1062 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.009933
K_1063 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.010095
K_1064 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.010005
K_1065 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.009656
K_1066 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.006018
K_1067 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.005961
K_1068 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.006007
K_1069 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.005867
K_1070 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.004672
K_1071 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.004903
K_1072 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.013978
K_1073 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.004679
K_1074 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_1075 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_1076 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.005188
K_1077 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.005196
K_1078 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.005248
K_1079 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.005120
K_1080 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.007505
K_1081 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.007288
K_1082 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.007407
K_1083 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.007279
K_1084 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.009756
K_1085 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.009933
K_1086 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.009835
K_1087 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.009503
K_1088 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.006071
K_1089 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.006018
K_1090 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.006062
K_1091 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.005918
K_1092 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.004656
K_1093 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.005001
K_1094 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.013120
K_1095 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.004700
K_1096 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_1097 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.005137
K_1098 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.005143
K_1099 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.005196
K_1100 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.005070
K_1101 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.007377
K_1102 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.007166
K_1103 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.007288
K_1104 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.007162
K_1105 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.009840
K_1106 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.010010
K_1107 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.009933
K_1108 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.009581
K_1109 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.006024
K_1110 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.005969
K_1111 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.006018
K_1112 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.005874
K_1113 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.004580
K_1114 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.004899
K_1115 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.013510
K_1116 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.004669
K_1117 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.005266
K_1118 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.005273
K_1119 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.005329
K_1120 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.005196
K_1121 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.007510
K_1122 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.007288
K_1123 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.007411
K_1124 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.007288
K_1125 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.010210
K_1126 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.010400
K_1127 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.010301
K_1128 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.009933
K_1129 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.006176
K_1130 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.006118
K_1131 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.006167
K_1132 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.006018
K_1133 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.004659
K_1134 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.004954
K_1135 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.013678
K_1136 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.004766
K_1137 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_1138 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_1139 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_1140 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.005662
K_1141 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.005554
K_1142 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.005544
K_1143 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.005649
K_1144 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.008106
K_1145 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.008167
K_1146 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.007926
K_1147 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.008216
K_1148 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.010251
K_1149 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.009932
K_1150 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.009778
K_1151 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.010018
K_1152 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.006558
K_1153 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.004572
K_1154 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.005338
K_1155 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.012010
K_1156 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_1157 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_1158 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.005771
K_1159 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.005662
K_1160 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.005648
K_1161 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.005759
K_1162 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.008034
K_1163 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.008106
K_1164 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.007864
K_1165 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.008147
K_1166 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.010575
K_1167 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.010251
K_1168 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.010070
K_1169 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.010333
K_1170 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.006526
K_1171 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.004656
K_1172 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.005293
K_1173 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.012487
K_1174 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_1175 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.005783
K_1176 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.005671
K_1177 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.005662
K_1178 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.005771
K_1179 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.008285
K_1180 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.008357
K_1181 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.008106
K_1182 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.008410
K_1183 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.010770
K_1184 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.010415
K_1185 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.010251
K_1186 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.010515
K_1187 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.006419
K_1188 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.004609
K_1189 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.005375
K_1190 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.012622
K_1191 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.005671
K_1192 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.005565
K_1193 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.005554
K_1194 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.005662
K_1195 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.007988
K_1196 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.008052
K_1197 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.007821
K_1198 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.008106
K_1199 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.010474
K_1200 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.010146
K_1201 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.009983
K_1202 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.010251
K_1203 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.006388
K_1204 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.004565
K_1205 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.005247
K_1206 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.012638
K_1207 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_1208 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_1209 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_1210 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.006597
K_1211 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.006811
K_1212 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.006688
K_1213 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.006674
K_1214 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.009771
K_1215 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.010050
K_1216 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.009952
K_1217 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.009624
K_1218 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.004118
K_1219 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.008654
K_1220 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.005180
K_1221 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.006700
K_1222 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_1223 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_1224 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.006396
K_1225 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.006597
K_1226 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.006481
K_1227 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.006469
K_1228 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.009495
K_1229 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.009771
K_1230 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.009671
K_1231 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.009369
K_1232 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.004069
K_1233 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.008825
K_1234 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.005060
K_1235 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.006601
K_1236 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_1237 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.006503
K_1238 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.006711
K_1239 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.006597
K_1240 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.006580
K_1241 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.009580
K_1242 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.009853
K_1243 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.009771
K_1244 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.009450
K_1245 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.004038
K_1246 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.008481
K_1247 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.005123
K_1248 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.006602
K_1249 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.006516
K_1250 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.006725
K_1251 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.006606
K_1252 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.006597
K_1253 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.009904
K_1254 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.010206
K_1255 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.010104
K_1256 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.009771
K_1257 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.004070
K_1258 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.008565
K_1259 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.005089
K_1260 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.006784
K_1261 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_1262 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_1263 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_1264 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.009067
K_1265 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.008758
K_1266 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.008969
K_1267 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.008757
K_1268 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.004847
K_1269 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.004222
K_1270 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.011883
K_1271 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.006899
K_1272 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_1273 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_1274 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.009392
K_1275 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.009067
K_1276 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.009292
K_1277 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.009057
K_1278 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.004849
K_1279 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.004297
K_1280 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.011604
K_1281 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.007029
K_1282 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_1283 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.009150
K_1284 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.008841
K_1285 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.009067
K_1286 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.008840
K_1287 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.004754
K_1288 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.004225
K_1289 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.011725
K_1290 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.006896
K_1291 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.009394
K_1292 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.009060
K_1293 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.009294
K_1294 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.009067
K_1295 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.004801
K_1296 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.004232
K_1297 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.011269
K_1298 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.007087
K_1299 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_1300 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_1301 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_1302 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.004510
K_1303 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.005447
K_1304 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.005365
K_1305 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.018599
K_1306 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_1307 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_1308 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.004473
K_1309 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.005538
K_1310 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.005275
K_1311 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.018352
K_1312 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_1313 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.004424
K_1314 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.005434
K_1315 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.005332
K_1316 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.017808
K_1317 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.004435
K_1318 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.005400
K_1319 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.005242
K_1320 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.019452
K_1321 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.004454
K_1322 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.004745
K_1323 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.004434
K_1324 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.003812
K_1325 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.004745
K_1326 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.004454

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
