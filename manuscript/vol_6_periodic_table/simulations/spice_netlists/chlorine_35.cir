* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Chlorine-35 (Z=17, A=35)
* Auto-generated topological mutual impedance array
* Nodes: 35

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.010077
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.009642
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.009713
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.009851
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.010838
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.011012
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.010518
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.010977
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.011144
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.010880
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.010894
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.010581
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.006853
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.006737
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.006639
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.006776
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.008847
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.008996
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.008661
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.008698
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.006721
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.006599
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.006540
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.006535
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.006298
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.006276
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.006131
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.006205
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.023474
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.006093
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.005779
K_35 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_36 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_37 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.010550
K_38 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.010077
K_39 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.010145
K_40 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.010304
K_41 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.010644
K_42 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.010838
K_43 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.010353
K_44 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.010789
K_45 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.011394
K_46 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.011144
K_47 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.011143
K_48 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.010808
K_49 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.006968
K_50 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.006853
K_51 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.006747
K_52 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.006891
K_53 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.008690
K_54 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.008847
K_55 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.008521
K_56 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.008555
K_57 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.006843
K_58 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.006721
K_59 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.006656
K_60 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.006650
K_61 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.006314
K_62 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.006298
K_63 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.006149
K_64 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.006224
K_65 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.021741
K_66 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.006252
K_67 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.005746
K_68 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_69 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.010460
K_70 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.009988
K_71 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.010077
K_72 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.010220
K_73 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.011158
K_74 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.011365
K_75 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.010838
K_76 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.011326
K_77 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.011379
K_78 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.011114
K_79 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.011144
K_80 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.010795
K_81 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.007081
K_82 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.006957
K_83 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.006853
K_84 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.007001
K_85 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.009028
K_86 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.009196
K_87 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.008847
K_88 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.008878
K_89 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.006911
K_90 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.006782
K_91 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.006721
K_92 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.006712
K_93 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.006473
K_94 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.006452
K_95 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.006298
K_96 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.006376
K_97 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.021627
K_98 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.006248
K_99 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.005901
K_100 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.010294
K_101 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.009843
K_102 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.009917
K_103 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.010077
K_104 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.010677
K_105 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.010858
K_106 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.010383
K_107 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.010838
K_108 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.011771
K_109 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.011478
K_110 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.011494
K_111 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.011144
K_112 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.006925
K_113 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.006808
K_114 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.006707
K_115 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.006853
K_116 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.008988
K_117 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.009153
K_118 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.008801
K_119 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.008847
K_120 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.006917
K_121 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.006788
K_122 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.006724
K_123 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.006721
K_124 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.006389
K_125 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.006369
K_126 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.006217
K_127 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.006298
K_128 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.023330
K_129 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006210
K_130 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.005821
K_131 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_132 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_133 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_134 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.007563
K_135 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.007825
K_136 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.007607
K_137 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.007707
K_138 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.009328
K_139 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.009533
K_140 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.009475
K_141 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.009151
K_142 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.011066
K_143 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.011164
K_144 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.010641
K_145 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.011031
K_146 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.006178
K_147 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.006338
K_148 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.006199
K_149 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.006177
K_150 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.009208
K_151 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.009231
K_152 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.009014
K_153 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008894
K_154 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.006721
K_155 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.006831
K_156 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.006623
K_157 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.006672
K_158 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.007259
K_159 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.013601
K_160 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.005356
K_161 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_162 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_163 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.007316
K_164 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.007563
K_165 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.007361
K_166 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.007451
K_167 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.009117
K_168 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.009328
K_169 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.009265
K_170 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.008961
K_171 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.010939
K_172 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.011066
K_173 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.010542
K_174 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.010921
K_175 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.006025
K_176 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.006178
K_177 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.006047
K_178 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.006026
K_179 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.009168
K_180 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.009208
K_181 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008985
K_182 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008866
K_183 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.006610
K_184 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.006721
K_185 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.006519
K_186 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.006567
K_187 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.007043
K_188 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.014229
K_189 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.005264
K_190 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_191 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.007510
K_192 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.007772
K_193 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.007563
K_194 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.007656
K_195 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.009169
K_196 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.009373
K_197 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.009328
K_198 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.009009
K_199 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.011511
K_200 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.011640
K_201 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.011066
K_202 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.011490
K_203 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.006152
K_204 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.006313
K_205 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.006178
K_206 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.006154
K_207 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.009396
K_208 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.009430
K_209 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.009208
K_210 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.009072
K_211 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.006817
K_212 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.006936
K_213 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.006721
K_214 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.006770
K_215 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.007066
K_216 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.014413
K_217 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.005394
K_218 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.007417
K_219 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.007670
K_220 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.007464
K_221 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.007563
K_222 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.009495
K_223 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.009722
K_224 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.009661
K_225 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.009328
K_226 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.011069
K_227 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.011184
K_228 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.010658
K_229 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.011066
K_230 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.006174
K_231 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.006336
K_232 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.006197
K_233 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.006178
K_234 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.009537
K_235 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.009573
K_236 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.009332
K_237 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.009208
K_238 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.006764
K_239 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.006880
K_240 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.006667
K_241 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.006721
K_242 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.007174
K_243 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.014383
K_244 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.005356
K_245 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_246 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_247 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_248 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.006749
K_249 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.006646
K_250 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.006769
K_251 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.006584
K_252 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.008769
K_253 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.008440
K_254 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.008483
K_255 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.008536
K_256 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.010968
K_257 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.011055
K_258 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.010935
K_259 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.010546
K_260 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.006178
K_261 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.006051
K_262 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.006093
K_263 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.006007
K_264 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.008847
K_265 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.008689
K_266 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008554
K_267 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.008521
K_268 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.008597
K_269 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.005507
K_270 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.009283
K_271 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_272 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_273 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.006850
K_274 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.006749
K_275 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.006875
K_276 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.006681
K_277 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.009121
K_278 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.008769
K_279 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.008809
K_280 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.008868
K_281 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.010853
K_282 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.010968
K_283 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.010836
K_284 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.010457
K_285 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.006308
K_286 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.006178
K_287 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.006220
K_288 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.006129
K_289 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.008997
K_290 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.008847
K_291 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.008697
K_292 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.008662
K_293 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.008594
K_294 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.005649
K_295 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.009260
K_296 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_297 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.006723
K_298 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.006624
K_299 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.006749
K_300 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.006562
K_301 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.009069
K_302 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.008714
K_303 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.008769
K_304 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.008819
K_305 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.010971
K_306 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.011074
K_307 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.010968
K_308 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.010562
K_309 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.006262
K_310 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.006131
K_311 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.006178
K_312 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.006086
K_313 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009155
K_314 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.008988
K_315 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.008847
K_316 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.008803
K_317 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.008346
K_318 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.005576
K_319 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.009583
K_320 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.006920
K_321 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.006813
K_322 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.006946
K_323 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.006749
K_324 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.009006
K_325 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.008658
K_326 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.008704
K_327 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.008769
K_328 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.011411
K_329 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.011527
K_330 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.011391
K_331 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.010968
K_332 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.006359
K_333 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.006223
K_334 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.006269
K_335 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.006178
K_336 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.009195
K_337 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.009027
K_338 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.008876
K_339 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.008847
K_340 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.008666
K_341 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.005613
K_342 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.009561
K_343 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_344 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_345 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_346 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.006533
K_347 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.006482
K_348 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.006392
K_349 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.006585
K_350 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.008769
K_351 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.009049
K_352 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.008701
K_353 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.008912
K_354 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.011066
K_355 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.010770
K_356 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.010507
K_357 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.010790
K_358 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.006853
K_359 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.006885
K_360 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.006691
K_361 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.006869
K_362 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.010534
K_363 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.007384
K_364 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.005683
K_365 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_366 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_367 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.006578
K_368 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.006533
K_369 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.006437
K_370 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.006635
K_371 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.008499
K_372 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.008769
K_373 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.008444
K_374 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.008637
K_375 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.011353
K_376 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.011066
K_377 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.010767
K_378 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.011071
K_379 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.006815
K_380 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.006853
K_381 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.006659
K_382 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.006834
K_383 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.010162
K_384 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.007589
K_385 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.005618
K_386 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_387 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.006676
K_388 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.006625
K_389 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.006533
K_390 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.006736
K_391 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.008822
K_392 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.009116
K_393 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.008769
K_394 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.008976
K_395 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.011687
K_396 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.011357
K_397 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.011066
K_398 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.011380
K_399 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.007019
K_400 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.007057
K_401 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.006853
K_402 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.007040
K_403 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.010161
K_404 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.007587
K_405 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.005764
K_406 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.006475
K_407 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.006428
K_408 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.006341
K_409 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.006533
K_410 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.008618
K_411 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.008891
K_412 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.008561
K_413 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.008769
K_414 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.011330
K_415 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.011029
K_416 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.010747
K_417 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.011066
K_418 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.006830
K_419 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.006865
K_420 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.006673
K_421 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.006853
K_422 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.010055
K_423 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.007413
K_424 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.005644
K_425 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_426 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_427 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_428 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.006749
K_429 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.006932
K_430 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.006879
K_431 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.006752
K_432 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.009328
K_433 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.009284
K_434 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.009381
K_435 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.009012
K_436 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.011144
K_437 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.011538
K_438 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.011130
K_439 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.010943
K_440 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.005454
K_441 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.010815
K_442 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.007815
K_443 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_444 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_445 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.006574
K_446 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.006749
K_447 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.006697
K_448 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.006580
K_449 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.009353
K_450 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.009328
K_451 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.009416
K_452 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.009043
K_453 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.010759
K_454 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.011144
K_455 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.010760
K_456 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.010592
K_457 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.005373
K_458 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.011239
K_459 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.007572
K_460 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_461 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.006620
K_462 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.006796
K_463 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.006749
K_464 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.006626
K_465 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.009257
K_466 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.009223
K_467 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.009328
K_468 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.008957
K_469 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.011127
K_470 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.011537
K_471 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.011144
K_472 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.010942
K_473 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.005322
K_474 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.010784
K_475 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.007778
K_476 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.006740
K_477 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.006925
K_478 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.006872
K_479 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.006749
K_480 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.009658
K_481 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.009620
K_482 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.009727
K_483 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.009328
K_484 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.011323
K_485 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.011756
K_486 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.011324
K_487 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.011144
K_488 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.005415
K_489 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.011176
K_490 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.007807
K_491 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_492 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_493 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_494 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.007563
K_495 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.007302
K_496 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.007414
K_497 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.007383
K_498 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.010838
K_499 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.010463
K_500 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.010328
K_501 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.010628
K_502 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.008777
K_503 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.005193
K_504 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.011758
K_505 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_506 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_507 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.007843
K_508 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.007563
K_509 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.007682
K_510 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.007648
K_511 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.011224
K_512 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.010838
K_513 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.010674
K_514 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.011007
K_515 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.008826
K_516 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.005324
K_517 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.011836
K_518 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_519 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.007711
K_520 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.007440
K_521 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.007563
K_522 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.007526
K_523 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.011399
K_524 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.010980
K_525 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.010838
K_526 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.011171
K_527 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.008502
K_528 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.005249
K_529 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.012361
K_530 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.007746
K_531 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.007471
K_532 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.007590
K_533 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.007563
K_534 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.011030
K_535 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.010649
K_536 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.010507
K_537 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.010838
K_538 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.008631
K_539 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.005235
K_540 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.011767
K_541 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_542 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_543 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_544 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.010077
K_545 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.010414
K_546 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.009989
K_547 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.010342
K_548 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.005879
K_549 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.011663
K_550 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.006771
K_551 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_552 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_553 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.009750
K_554 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.010077
K_555 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.009681
K_556 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.010001
K_557 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.005770
K_558 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.012124
K_559 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.006599
K_560 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_561 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.010143
K_562 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.010500
K_563 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.010077
K_564 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.010426
K_565 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.005729
K_566 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.011746
K_567 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.006771
K_568 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.009810
K_569 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.010131
K_570 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.009740
K_571 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.010077
K_572 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.005754
K_573 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.011468
K_574 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.006646
K_575 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_576 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_577 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_578 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.005543
K_579 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.006727
K_580 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.018974
K_581 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_582 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_583 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.005505
K_584 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.006917
K_585 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.017458
K_586 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_587 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.005404
K_588 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.006720
K_589 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.018476
K_590 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.005480
K_591 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.006768
K_592 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.018007
K_593 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.005044
K_594 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.005314
K_595 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.005044

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
