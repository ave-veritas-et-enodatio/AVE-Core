* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Calcium-40 (Z=20, A=40)
* Auto-generated topological mutual impedance array
* Nodes: 40

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.010136
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.009693
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.009773
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.009914
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.010915
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.011105
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.010610
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.011088
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.011363
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.011082
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.011148
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.010784
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.006787
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.006668
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.006581
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.006724
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.009223
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.009447
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.009074
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.009104
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.006686
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.006540
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.006516
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.006496
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.006158
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.006151
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.006002
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.006111
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.006786
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.006781
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.006655
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.006612
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.005569
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.005515
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.005433
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.005466
K_40 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_41 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_42 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.010617
K_43 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.010136
K_44 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.010215
K_45 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.010375
K_46 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.010706
K_47 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.010915
K_48 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.010431
K_49 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.010884
K_50 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.011631
K_51 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.011363
K_52 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.011417
K_53 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.011027
K_54 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.006905
K_55 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.006787
K_56 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.006692
K_57 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.006843
K_58 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.008997
K_59 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.009223
K_60 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.008867
K_61 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.008895
K_62 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.006834
K_63 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.006686
K_64 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.006657
K_65 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.006635
K_66 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.006160
K_67 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.006158
K_68 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.006006
K_69 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.006116
K_70 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.006783
K_71 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.006786
K_72 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.006656
K_73 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.006613
K_74 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.005621
K_75 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.005569
K_76 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.005483
K_77 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.005517
K_78 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_79 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.010515
K_80 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.010035
K_81 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.010136
K_82 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.010280
K_83 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.011214
K_84 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.011438
K_85 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.010915
K_86 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.011420
K_87 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.011556
K_88 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.011277
K_89 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.011363
K_90 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.010963
K_91 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.007006
K_92 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.006878
K_93 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.006787
K_94 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.006941
K_95 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.009360
K_96 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.009605
K_97 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.009223
K_98 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.009245
K_99 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.006861
K_100 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.006708
K_101 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.006686
K_102 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.006661
K_103 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.006322
K_104 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.006317
K_105 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.006158
K_106 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.006274
K_107 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.006916
K_108 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.006915
K_109 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.006786
K_110 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.006737
K_111 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.005712
K_112 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.005656
K_113 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.005569
K_114 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.005603
K_115 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.010348
K_116 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.009890
K_117 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.009974
K_118 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.010136
K_119 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.010721
K_120 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.010916
K_121 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.010445
K_122 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.010915
K_123 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.012007
K_124 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.011695
K_125 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.011773
K_126 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.011363
K_127 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.006844
K_128 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.006725
K_129 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.006636
K_130 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.006787
K_131 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.009328
K_132 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.009570
K_133 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.009183
K_134 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.009223
K_135 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.006885
K_136 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.006730
K_137 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.006704
K_138 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.006686
K_139 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.006201
K_140 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.006196
K_141 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.006044
K_142 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.006158
K_143 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.006966
K_144 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006965
K_145 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.006828
K_146 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.006786
K_147 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.005674
K_148 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.005619
K_149 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.005532
K_150 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.005569
K_151 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_152 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_153 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_154 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.007462
K_155 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.007718
K_156 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.007509
K_157 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.007607
K_158 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.009183
K_159 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.009377
K_160 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.009346
K_161 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.009018
K_162 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.011125
K_163 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.011195
K_164 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.010691
K_165 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.011132
K_166 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.005899
K_167 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.006053
K_168 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.005933
K_169 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.005911
K_170 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.009847
K_171 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.009790
K_172 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.009632
K_173 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.009442
K_174 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.006385
K_175 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.006495
K_176 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.006299
K_177 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.006387
K_178 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.005975
K_179 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.006069
K_180 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.005960
K_181 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.005898
K_182 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006786
K_183 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.006825
K_184 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.006645
K_185 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.006663
K_186 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_187 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_188 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.007222
K_189 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.007462
K_190 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.007269
K_191 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.007358
K_192 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.008983
K_193 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.009183
K_194 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.009144
K_195 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.008837
K_196 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.011025
K_197 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.011125
K_198 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.010616
K_199 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.011048
K_200 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.005753
K_201 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.005899
K_202 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.005786
K_203 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.005766
K_204 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.009883
K_205 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.009847
K_206 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.009676
K_207 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.009483
K_208 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.006275
K_209 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.006385
K_210 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.006196
K_211 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.006279
K_212 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.005881
K_213 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.005975
K_214 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.005869
K_215 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.005810
K_216 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006740
K_217 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006786
K_218 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.006606
K_219 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.006623
K_220 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_221 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.007407
K_222 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.007662
K_223 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.007462
K_224 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.007554
K_225 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.009011
K_226 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.009203
K_227 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.009183
K_228 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.008863
K_229 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.011580
K_230 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.011677
K_231 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.011125
K_232 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.011606
K_233 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.005862
K_234 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.006015
K_235 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.005899
K_236 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.005875
K_237 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.010053
K_238 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.010004
K_239 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.009847
K_240 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.009633
K_241 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.006470
K_242 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.006587
K_243 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.006385
K_244 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.006474
K_245 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.005986
K_246 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.006083
K_247 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.005975
K_248 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.005911
K_249 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006928
K_250 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006973
K_251 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006786
K_252 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006801
K_253 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.007316
K_254 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.007562
K_255 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.007365
K_256 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.007462
K_257 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.009338
K_258 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.009552
K_259 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.009519
K_260 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.009183
K_261 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.011086
K_262 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.011171
K_263 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.010671
K_264 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.011125
K_265 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.005884
K_266 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.006038
K_267 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.005919
K_268 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.005899
K_269 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.010284
K_270 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.010232
K_271 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.010052
K_272 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.009847
K_273 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.006378
K_274 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.006491
K_275 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.006295
K_276 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.006385
K_277 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.006050
K_278 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.006150
K_279 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.006036
K_280 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.005975
K_281 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006908
K_282 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006953
K_283 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.006764
K_284 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006786
K_285 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_286 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_287 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_288 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.006497
K_289 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.006402
K_290 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.006519
K_291 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.006346
K_292 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.008391
K_293 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.008086
K_294 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.008134
K_295 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.008195
K_296 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.010824
K_297 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.010982
K_298 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.010873
K_299 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.010467
K_300 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.005601
K_301 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.005489
K_302 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.005539
K_303 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.005465
K_304 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.009990
K_305 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.009809
K_306 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.009558
K_307 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.009661
K_308 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.006385
K_309 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.006342
K_310 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.006335
K_311 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.006206
K_312 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.006158
K_313 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.006051
K_314 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.006026
K_315 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.005989
K_316 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_317 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_318 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.006589
K_319 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.006497
K_320 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.006616
K_321 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.006435
K_322 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.008719
K_323 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.008391
K_324 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.008437
K_325 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.008506
K_326 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.010645
K_327 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.010824
K_328 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.010706
K_329 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.010317
K_330 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.005716
K_331 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.005601
K_332 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.005652
K_333 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.005573
K_334 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.010156
K_335 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.009990
K_336 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.009713
K_337 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.009822
K_338 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.006424
K_339 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.006385
K_340 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.006375
K_341 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.006244
K_342 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.006266
K_343 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.006158
K_344 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.006129
K_345 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.006091
K_346 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_347 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.006468
K_348 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.006378
K_349 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.006497
K_350 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.006323
K_351 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.008661
K_352 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.008333
K_353 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.008391
K_354 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.008452
K_355 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.010746
K_356 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.010916
K_357 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.010824
K_358 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.010410
K_359 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.005660
K_360 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.005547
K_361 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.005601
K_362 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.005522
K_363 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.010460
K_364 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.010266
K_365 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.009990
K_366 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.010096
K_367 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.006431
K_368 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.006390
K_369 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.006385
K_370 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.006251
K_371 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.006295
K_372 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.006182
K_373 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.006158
K_374 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.006117
K_375 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.006652
K_376 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.006554
K_377 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.006680
K_378 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.006497
K_379 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.008589
K_380 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.008269
K_381 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.008319
K_382 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.008391
K_383 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.011188
K_384 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.011379
K_385 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.011258
K_386 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.010824
K_387 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.005743
K_388 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.005624
K_389 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.005679
K_390 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.005601
K_391 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.010329
K_392 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.010142
K_393 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.009864
K_394 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.009990
K_395 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.006575
K_396 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.006530
K_397 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.006523
K_398 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.006385
K_399 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.006337
K_400 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.006223
K_401 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.006195
K_402 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.006158
K_403 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_404 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_405 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_406 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.006073
K_407 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.006028
K_408 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.005953
K_409 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.006121
K_410 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.008065
K_411 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.008319
K_412 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.008036
K_413 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.008205
K_414 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.010716
K_415 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.010348
K_416 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.010203
K_417 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.010426
K_418 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.005601
K_419 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.005628
K_420 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.005505
K_421 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.005638
K_422 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.009847
K_423 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.010017
K_424 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.009581
K_425 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.009697
K_426 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.006686
K_427 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.006647
K_428 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.006491
K_429 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.006627
K_430 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_431 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_432 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.006114
K_433 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.006073
K_434 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.005995
K_435 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.006166
K_436 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.007821
K_437 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.008065
K_438 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.007800
K_439 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.007955
K_440 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.011095
K_441 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.010716
K_442 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.010542
K_443 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.010789
K_444 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.005570
K_445 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.005601
K_446 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.005478
K_447 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.005608
K_448 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.009665
K_449 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.009847
K_450 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.009423
K_451 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.009533
K_452 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.006718
K_453 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.006686
K_454 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.006524
K_455 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.006662
K_456 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_457 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.006195
K_458 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.006150
K_459 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.006073
K_460 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.006249
K_461 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.008081
K_462 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.008344
K_463 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.008065
K_464 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.008229
K_465 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.011282
K_466 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.010870
K_467 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.010716
K_468 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.010961
K_469 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.005697
K_470 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.005728
K_471 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.005601
K_472 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.005738
K_473 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.010112
K_474 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.010309
K_475 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.009847
K_476 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.009961
K_477 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.006891
K_478 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.006852
K_479 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.006686
K_480 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.006831
K_481 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.006021
K_482 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.005979
K_483 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.005907
K_484 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.006073
K_485 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.007919
K_486 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.008166
K_487 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.007898
K_488 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.008065
K_489 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.011001
K_490 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.010618
K_491 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.010461
K_492 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.010716
K_493 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.005560
K_494 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.005589
K_495 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.005469
K_496 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.005601
K_497 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.009981
K_498 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.010170
K_499 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.009715
K_500 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.009847
K_501 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.006739
K_502 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.006702
K_503 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.006543
K_504 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.006686
K_505 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_506 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_507 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_508 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.005950
K_509 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.006093
K_510 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.006054
K_511 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.005958
K_512 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.008065
K_513 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.008001
K_514 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.008112
K_515 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.007829
K_516 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.010824
K_517 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.011295
K_518 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.010802
K_519 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.010807
K_520 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.005899
K_521 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.005976
K_522 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.005951
K_523 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.005822
K_524 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.009223
K_525 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.009271
K_526 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.009114
K_527 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.008909
K_528 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_529 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_530 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.005811
K_531 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.005950
K_532 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.005911
K_533 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.005821
K_534 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.008117
K_535 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.008065
K_536 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.008172
K_537 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.007883
K_538 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.010381
K_539 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.010824
K_540 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.010375
K_541 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.010380
K_542 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.005821
K_543 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.005899
K_544 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.005873
K_545 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.005749
K_546 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.009158
K_547 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.009223
K_548 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.009060
K_549 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.008858
K_550 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_551 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.005845
K_552 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.005984
K_553 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.005950
K_554 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.005855
K_555 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.008006
K_556 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.007949
K_557 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.008065
K_558 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.007781
K_559 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.010817
K_560 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.011304
K_561 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.010824
K_562 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.010815
K_563 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.005844
K_564 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.005921
K_565 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.005899
K_566 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.005771
K_567 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.009317
K_568 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.009376
K_569 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.009223
K_570 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.009002
K_571 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.005937
K_572 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.006082
K_573 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.006043
K_574 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.005950
K_575 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.008309
K_576 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.008246
K_577 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.008368
K_578 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.008065
K_579 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.010811
K_580 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.011297
K_581 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.010804
K_582 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.010824
K_583 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.005975
K_584 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.006057
K_585 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.006031
K_586 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.005899
K_587 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.009553
K_588 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.009617
K_589 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.009442
K_590 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.009223
K_591 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_592 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_593 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_594 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.006073
K_595 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.005904
K_596 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.005984
K_597 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.005960
K_598 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.008391
K_599 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.008209
K_600 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.008104
K_601 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.008355
K_602 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.011125
K_603 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.010731
K_604 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.010799
K_605 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.010571
K_606 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.006787
K_607 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.006605
K_608 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.006596
K_609 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.006644
K_610 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_611 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_612 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.006253
K_613 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.006073
K_614 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.006159
K_615 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.006132
K_616 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.008572
K_617 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.008391
K_618 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.008272
K_619 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.008540
K_620 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.011530
K_621 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.011125
K_622 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.011185
K_623 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.010932
K_624 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.006977
K_625 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.006787
K_626 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.006774
K_627 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.006826
K_628 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_629 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.006161
K_630 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.005986
K_631 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.006073
K_632 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.006046
K_633 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.008697
K_634 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.008502
K_635 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.008391
K_636 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.008664
K_637 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.011447
K_638 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.011034
K_639 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.011125
K_640 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.010861
K_641 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.006988
K_642 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.006793
K_643 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.006787
K_644 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.006836
K_645 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.006187
K_646 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.006011
K_647 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.006096
K_648 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.006073
K_649 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.008415
K_650 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.008237
K_651 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.008131
K_652 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.008391
K_653 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.011738
K_654 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.011295
K_655 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.011374
K_656 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.011125
K_657 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.006932
K_658 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.006742
K_659 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.006732
K_660 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.006787
K_661 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_662 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_663 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_664 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.006497
K_665 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.006627
K_666 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.006464
K_667 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.006622
K_668 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.009183
K_669 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.009576
K_670 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.009299
K_671 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.009240
K_672 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.011363
K_673 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.011624
K_674 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.011023
K_675 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.011416
K_676 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_677 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_678 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.006368
K_679 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.006497
K_680 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.006341
K_681 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.006490
K_682 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.008818
K_683 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.009183
K_684 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.008929
K_685 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.008877
K_686 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.011087
K_687 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.011363
K_688 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.010785
K_689 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.011152
K_690 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_691 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.006523
K_692 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.006658
K_693 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.006497
K_694 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.006654
K_695 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.009053
K_696 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.009439
K_697 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.009183
K_698 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.009117
K_699 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.011700
K_700 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.012006
K_701 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.011363
K_702 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.011777
K_703 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.006372
K_704 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.006498
K_705 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.006345
K_706 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.006497
K_707 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.009109
K_708 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.009502
K_709 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.009232
K_710 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.009183
K_711 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.011278
K_712 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.011551
K_713 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.010960
K_714 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.011363
K_715 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_716 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_717 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_718 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.007462
K_719 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.007465
K_720 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.007571
K_721 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.007308
K_722 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.010915
K_723 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.010546
K_724 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.010743
K_725 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.010406
K_726 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_727 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_728 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.007450
K_729 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.007462
K_730 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.007563
K_731 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.007301
K_732 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.011292
K_733 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.010915
K_734 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.011118
K_735 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.010746
K_736 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_737 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.007349
K_738 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.007356
K_739 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.007462
K_740 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.007206
K_741 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.011064
K_742 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.010694
K_743 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.010915
K_744 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.010548
K_745 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.007617
K_746 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.007624
K_747 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.007737
K_748 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.007462
K_749 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.011471
K_750 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.011060
K_751 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.011289
K_752 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.010915
K_753 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_754 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_755 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_756 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.010136
K_757 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.009821
K_758 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.009742
K_759 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.010085
K_760 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_761 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_762 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.010456
K_763 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.010136
K_764 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.010036
K_765 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.010413
K_766 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_767 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.010555
K_768 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.010213
K_769 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.010136
K_770 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.010511
K_771 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.010162
K_772 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.009857
K_773 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.009776
K_774 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.010136
K_775 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_776 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_777 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_778 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_779 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_780 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
