* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Krypton-84 (Z=36, A=84)
* Auto-generated topological mutual impedance array
* Nodes: 84

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON
X_NUC_65 NODE_65 0 NUCLEON
X_NUC_66 NODE_66 0 NUCLEON
X_NUC_67 NODE_67 0 NUCLEON
X_NUC_68 NODE_68 0 NUCLEON
X_NUC_69 NODE_69 0 NUCLEON
X_NUC_70 NODE_70 0 NUCLEON
X_NUC_71 NODE_71 0 NUCLEON
X_NUC_72 NODE_72 0 NUCLEON
X_NUC_73 NODE_73 0 NUCLEON
X_NUC_74 NODE_74 0 NUCLEON
X_NUC_75 NODE_75 0 NUCLEON
X_NUC_76 NODE_76 0 NUCLEON
X_NUC_77 NODE_77 0 NUCLEON
X_NUC_78 NODE_78 0 NUCLEON
X_NUC_79 NODE_79 0 NUCLEON
X_NUC_80 NODE_80 0 NUCLEON
X_NUC_81 NODE_81 0 NUCLEON
X_NUC_82 NODE_82 0 NUCLEON
X_NUC_83 NODE_83 0 NUCLEON
X_NUC_84 NODE_84 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.007449
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.007206
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.007260
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.007337
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.008037
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.008153
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.007895
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.008167
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.008530
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.008367
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.008463
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.008215
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.004881
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.004815
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.004779
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.004861
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.007144
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.007335
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.007118
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.007127
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.004846
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.004754
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.004769
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.004749
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.004405
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.004409
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.004333
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.004409
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.005488
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.005510
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.005461
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.005378
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.003768
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.003721
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.003703
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.003728
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.004344
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.004388
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.004298
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.004334
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.004060
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.004025
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.004014
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.003983
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.003437
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.003422
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.003384
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.003418
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.004015
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.004039
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.003982
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.003970
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.003339
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.003310
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.003292
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.003294
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.003354
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.003359
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.003311
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.003333
K_64 X_NUC_1.L_CORE X_NUC_65.L_CORE 0.003418
K_65 X_NUC_1.L_CORE X_NUC_66.L_CORE 0.003412
K_66 X_NUC_1.L_CORE X_NUC_67.L_CORE 0.003381
K_67 X_NUC_1.L_CORE X_NUC_68.L_CORE 0.003372
K_68 X_NUC_1.L_CORE X_NUC_69.L_CORE 0.003103
K_69 X_NUC_1.L_CORE X_NUC_70.L_CORE 0.003091
K_70 X_NUC_1.L_CORE X_NUC_71.L_CORE 0.003061
K_71 X_NUC_1.L_CORE X_NUC_72.L_CORE 0.003072
K_72 X_NUC_1.L_CORE X_NUC_73.L_CORE 0.032209
K_73 X_NUC_1.L_CORE X_NUC_74.L_CORE 0.005803
K_74 X_NUC_1.L_CORE X_NUC_75.L_CORE 0.006086
K_75 X_NUC_1.L_CORE X_NUC_76.L_CORE 0.006005
K_76 X_NUC_1.L_CORE X_NUC_77.L_CORE 0.003819
K_77 X_NUC_1.L_CORE X_NUC_78.L_CORE 0.004966
K_78 X_NUC_1.L_CORE X_NUC_79.L_CORE 0.003666
K_79 X_NUC_1.L_CORE X_NUC_80.L_CORE 0.003390
K_80 X_NUC_1.L_CORE X_NUC_81.L_CORE 0.003770
K_81 X_NUC_1.L_CORE X_NUC_82.L_CORE 0.002964
K_82 X_NUC_1.L_CORE X_NUC_83.L_CORE 0.003140
K_83 X_NUC_1.L_CORE X_NUC_84.L_CORE 0.002945
K_84 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_85 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_86 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.007709
K_87 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.007449
K_88 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.007504
K_89 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.007590
K_90 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.007914
K_91 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.008037
K_92 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.007784
K_93 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.008044
K_94 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.008689
K_95 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.008530
K_96 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.008625
K_97 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.008363
K_98 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.004947
K_99 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.004881
K_100 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.004842
K_101 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.004927
K_102 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.006959
K_103 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.007144
K_104 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.006939
K_105 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.006947
K_106 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.004942
K_107 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.004846
K_108 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.004861
K_109 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.004840
K_110 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.004400
K_111 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.004405
K_112 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.004329
K_113 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.004405
K_114 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.005462
K_115 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.005488
K_116 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.005437
K_117 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.005355
K_118 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.003816
K_119 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.003768
K_120 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.003750
K_121 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.003775
K_122 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.004300
K_123 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.004344
K_124 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.004256
K_125 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.004290
K_126 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.004095
K_127 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.004060
K_128 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.004048
K_129 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.004017
K_130 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.003452
K_131 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.003437
K_132 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.003398
K_133 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.003432
K_134 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.003990
K_135 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.004015
K_136 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.003958
K_137 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.003946
K_138 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.003368
K_139 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.003339
K_140 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.003320
K_141 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.003323
K_142 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.003348
K_143 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.003354
K_144 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.003306
K_145 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.003328
K_146 X_NUC_2.L_CORE X_NUC_65.L_CORE 0.003423
K_147 X_NUC_2.L_CORE X_NUC_66.L_CORE 0.003418
K_148 X_NUC_2.L_CORE X_NUC_67.L_CORE 0.003387
K_149 X_NUC_2.L_CORE X_NUC_68.L_CORE 0.003377
K_150 X_NUC_2.L_CORE X_NUC_69.L_CORE 0.003113
K_151 X_NUC_2.L_CORE X_NUC_70.L_CORE 0.003103
K_152 X_NUC_2.L_CORE X_NUC_71.L_CORE 0.003072
K_153 X_NUC_2.L_CORE X_NUC_72.L_CORE 0.003082
K_154 X_NUC_2.L_CORE X_NUC_73.L_CORE 0.029815
K_155 X_NUC_2.L_CORE X_NUC_74.L_CORE 0.005963
K_156 X_NUC_2.L_CORE X_NUC_75.L_CORE 0.005999
K_157 X_NUC_2.L_CORE X_NUC_76.L_CORE 0.006069
K_158 X_NUC_2.L_CORE X_NUC_77.L_CORE 0.003858
K_159 X_NUC_2.L_CORE X_NUC_78.L_CORE 0.004880
K_160 X_NUC_2.L_CORE X_NUC_79.L_CORE 0.003715
K_161 X_NUC_2.L_CORE X_NUC_80.L_CORE 0.003387
K_162 X_NUC_2.L_CORE X_NUC_81.L_CORE 0.003761
K_163 X_NUC_2.L_CORE X_NUC_82.L_CORE 0.002987
K_164 X_NUC_2.L_CORE X_NUC_83.L_CORE 0.003127
K_165 X_NUC_2.L_CORE X_NUC_84.L_CORE 0.002954
K_166 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_167 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.007644
K_168 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.007386
K_169 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.007449
K_170 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.007528
K_171 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.008174
K_172 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.008303
K_173 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.008037
K_174 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.008317
K_175 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.008585
K_176 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.008425
K_177 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.008530
K_178 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.008270
K_179 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.004987
K_180 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.004918
K_181 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.004881
K_182 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.004967
K_183 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.007161
K_184 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.007359
K_185 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.007144
K_186 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.007149
K_187 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.004925
K_188 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.004829
K_189 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.004846
K_190 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.004823
K_191 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.004479
K_192 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.004484
K_193 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.004405
K_194 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.004484
K_195 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.005511
K_196 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.005536
K_197 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.005488
K_198 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.005402
K_199 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.003835
K_200 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.003786
K_201 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.003768
K_202 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.003793
K_203 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.004390
K_204 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.004436
K_205 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.004344
K_206 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.004380
K_207 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.004106
K_208 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.004071
K_209 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.004060
K_210 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.004028
K_211 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.003493
K_212 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.003478
K_213 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.003437
K_214 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.003473
K_215 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.004048
K_216 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.004073
K_217 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.004015
K_218 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.004003
K_219 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.003387
K_220 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.003357
K_221 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.003339
K_222 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.003341
K_223 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.003397
K_224 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.003403
K_225 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.003354
K_226 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.003377
K_227 X_NUC_3.L_CORE X_NUC_65.L_CORE 0.003455
K_228 X_NUC_3.L_CORE X_NUC_66.L_CORE 0.003449
K_229 X_NUC_3.L_CORE X_NUC_67.L_CORE 0.003418
K_230 X_NUC_3.L_CORE X_NUC_68.L_CORE 0.003407
K_231 X_NUC_3.L_CORE X_NUC_69.L_CORE 0.003145
K_232 X_NUC_3.L_CORE X_NUC_70.L_CORE 0.003133
K_233 X_NUC_3.L_CORE X_NUC_71.L_CORE 0.003103
K_234 X_NUC_3.L_CORE X_NUC_72.L_CORE 0.003113
K_235 X_NUC_3.L_CORE X_NUC_73.L_CORE 0.027894
K_236 X_NUC_3.L_CORE X_NUC_74.L_CORE 0.005908
K_237 X_NUC_3.L_CORE X_NUC_75.L_CORE 0.006148
K_238 X_NUC_3.L_CORE X_NUC_76.L_CORE 0.006019
K_239 X_NUC_3.L_CORE X_NUC_77.L_CORE 0.003885
K_240 X_NUC_3.L_CORE X_NUC_78.L_CORE 0.004977
K_241 X_NUC_3.L_CORE X_NUC_79.L_CORE 0.003712
K_242 X_NUC_3.L_CORE X_NUC_80.L_CORE 0.003436
K_243 X_NUC_3.L_CORE X_NUC_81.L_CORE 0.003793
K_244 X_NUC_3.L_CORE X_NUC_82.L_CORE 0.003006
K_245 X_NUC_3.L_CORE X_NUC_83.L_CORE 0.003171
K_246 X_NUC_3.L_CORE X_NUC_84.L_CORE 0.002977
K_247 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.007556
K_248 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.007307
K_249 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.007364
K_250 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.007449
K_251 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.007902
K_252 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.008018
K_253 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.007772
K_254 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.008037
K_255 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.008870
K_256 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.008693
K_257 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.008801
K_258 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.008530
K_259 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.004898
K_260 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.004833
K_261 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.004797
K_262 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.004881
K_263 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.007152
K_264 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.007349
K_265 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.007130
K_266 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.007144
K_267 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.004948
K_268 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.004851
K_269 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.004867
K_270 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.004846
K_271 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.004400
K_272 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.004404
K_273 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.004329
K_274 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.004405
K_275 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.005601
K_276 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.005626
K_277 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.005574
K_278 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.005488
K_279 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.003809
K_280 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.003760
K_281 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.003742
K_282 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.003768
K_283 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.004353
K_284 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.004398
K_285 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.004308
K_286 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.004344
K_287 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.004140
K_288 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.004103
K_289 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.004092
K_290 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.004060
K_291 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.003456
K_292 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.003442
K_293 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.003402
K_294 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.003437
K_295 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.004060
K_296 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.004086
K_297 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.004026
K_298 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.004015
K_299 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.003384
K_300 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.003354
K_301 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.003336
K_302 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.003339
K_303 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.003374
K_304 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.003380
K_305 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.003331
K_306 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.003354
K_307 X_NUC_4.L_CORE X_NUC_65.L_CORE 0.003465
K_308 X_NUC_4.L_CORE X_NUC_66.L_CORE 0.003459
K_309 X_NUC_4.L_CORE X_NUC_67.L_CORE 0.003427
K_310 X_NUC_4.L_CORE X_NUC_68.L_CORE 0.003418
K_311 X_NUC_4.L_CORE X_NUC_69.L_CORE 0.003134
K_312 X_NUC_4.L_CORE X_NUC_70.L_CORE 0.003123
K_313 X_NUC_4.L_CORE X_NUC_71.L_CORE 0.003092
K_314 X_NUC_4.L_CORE X_NUC_72.L_CORE 0.003103
K_315 X_NUC_4.L_CORE X_NUC_73.L_CORE 0.029824
K_316 X_NUC_4.L_CORE X_NUC_74.L_CORE 0.005866
K_317 X_NUC_4.L_CORE X_NUC_75.L_CORE 0.005999
K_318 X_NUC_4.L_CORE X_NUC_76.L_CORE 0.006167
K_319 X_NUC_4.L_CORE X_NUC_77.L_CORE 0.003832
K_320 X_NUC_4.L_CORE X_NUC_78.L_CORE 0.004980
K_321 X_NUC_4.L_CORE X_NUC_79.L_CORE 0.003726
K_322 X_NUC_4.L_CORE X_NUC_80.L_CORE 0.003395
K_323 X_NUC_4.L_CORE X_NUC_81.L_CORE 0.003825
K_324 X_NUC_4.L_CORE X_NUC_82.L_CORE 0.002993
K_325 X_NUC_4.L_CORE X_NUC_83.L_CORE 0.003159
K_326 X_NUC_4.L_CORE X_NUC_84.L_CORE 0.002980
K_327 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_328 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_329 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_330 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.005320
K_331 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.005450
K_332 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.005348
K_333 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.005399
K_334 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.006523
K_335 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.006618
K_336 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.006623
K_337 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.006448
K_338 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.008119
K_339 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.008136
K_340 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.007894
K_341 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.008169
K_342 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.004044
K_343 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.004119
K_344 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.004070
K_345 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.004058
K_346 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.007751
K_347 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.007646
K_348 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.007646
K_349 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.007477
K_350 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.004382
K_351 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.004437
K_352 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.004348
K_353 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.004408
K_354 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.003992
K_355 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.004040
K_356 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.004011
K_357 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.003965
K_358 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006039
K_359 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.005974
K_360 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.005874
K_361 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.005931
K_362 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.003423
K_363 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.003470
K_364 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.003419
K_365 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.003429
K_366 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.004374
K_367 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.004380
K_368 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.004354
K_369 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.004299
K_370 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.004053
K_371 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.004069
K_372 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.003995
K_373 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.004039
K_374 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.003243
K_375 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.003277
K_376 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.003241
K_377 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.003228
K_378 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.004218
K_379 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.004204
K_380 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.004157
K_381 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.004148
K_382 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.003251
K_383 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.003277
K_384 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.003227
K_385 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.003241
K_386 X_NUC_5.L_CORE X_NUC_65.L_CORE 0.003332
K_387 X_NUC_5.L_CORE X_NUC_66.L_CORE 0.003349
K_388 X_NUC_5.L_CORE X_NUC_67.L_CORE 0.003315
K_389 X_NUC_5.L_CORE X_NUC_68.L_CORE 0.003299
K_390 X_NUC_5.L_CORE X_NUC_69.L_CORE 0.003418
K_391 X_NUC_5.L_CORE X_NUC_70.L_CORE 0.003427
K_392 X_NUC_5.L_CORE X_NUC_71.L_CORE 0.003381
K_393 X_NUC_5.L_CORE X_NUC_72.L_CORE 0.003387
K_394 X_NUC_5.L_CORE X_NUC_73.L_CORE 0.006353
K_395 X_NUC_5.L_CORE X_NUC_74.L_CORE 0.024444
K_396 X_NUC_5.L_CORE X_NUC_75.L_CORE 0.004375
K_397 X_NUC_5.L_CORE X_NUC_76.L_CORE 0.005100
K_398 X_NUC_5.L_CORE X_NUC_77.L_CORE 0.005761
K_399 X_NUC_5.L_CORE X_NUC_78.L_CORE 0.003314
K_400 X_NUC_5.L_CORE X_NUC_79.L_CORE 0.005051
K_401 X_NUC_5.L_CORE X_NUC_80.L_CORE 0.003447
K_402 X_NUC_5.L_CORE X_NUC_81.L_CORE 0.003187
K_403 X_NUC_5.L_CORE X_NUC_82.L_CORE 0.003840
K_404 X_NUC_5.L_CORE X_NUC_83.L_CORE 0.002860
K_405 X_NUC_5.L_CORE X_NUC_84.L_CORE 0.003086
K_406 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_407 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_408 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.005197
K_409 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.005320
K_410 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.005225
K_411 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.005272
K_412 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.006425
K_413 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.006523
K_414 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.006524
K_415 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.006357
K_416 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.008090
K_417 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.008119
K_418 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.007873
K_419 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.008145
K_420 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.003970
K_421 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.004044
K_422 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.003996
K_423 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.003985
K_424 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.007848
K_425 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.007751
K_426 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.007745
K_427 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.007570
K_428 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.004327
K_429 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.004382
K_430 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.004295
K_431 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.004353
K_432 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.003944
K_433 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.003992
K_434 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.003963
K_435 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.003919
K_436 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006100
K_437 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006039
K_438 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.005933
K_439 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.005992
K_440 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.003378
K_441 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.003423
K_442 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.003374
K_443 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.003383
K_444 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.004366
K_445 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.004374
K_446 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.004347
K_447 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.004292
K_448 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.004037
K_449 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.004053
K_450 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.003980
K_451 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.004023
K_452 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.003209
K_453 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.003243
K_454 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.003207
K_455 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.003195
K_456 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.004231
K_457 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.004218
K_458 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.004170
K_459 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.004161
K_460 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.003225
K_461 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.003251
K_462 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.003202
K_463 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.003216
K_464 X_NUC_6.L_CORE X_NUC_65.L_CORE 0.003315
K_465 X_NUC_6.L_CORE X_NUC_66.L_CORE 0.003332
K_466 X_NUC_6.L_CORE X_NUC_67.L_CORE 0.003298
K_467 X_NUC_6.L_CORE X_NUC_68.L_CORE 0.003282
K_468 X_NUC_6.L_CORE X_NUC_69.L_CORE 0.003408
K_469 X_NUC_6.L_CORE X_NUC_70.L_CORE 0.003418
K_470 X_NUC_6.L_CORE X_NUC_71.L_CORE 0.003371
K_471 X_NUC_6.L_CORE X_NUC_72.L_CORE 0.003377
K_472 X_NUC_6.L_CORE X_NUC_73.L_CORE 0.006183
K_473 X_NUC_6.L_CORE X_NUC_74.L_CORE 0.027620
K_474 X_NUC_6.L_CORE X_NUC_75.L_CORE 0.004293
K_475 X_NUC_6.L_CORE X_NUC_76.L_CORE 0.005059
K_476 X_NUC_6.L_CORE X_NUC_77.L_CORE 0.005777
K_477 X_NUC_6.L_CORE X_NUC_78.L_CORE 0.003267
K_478 X_NUC_6.L_CORE X_NUC_79.L_CORE 0.005099
K_479 X_NUC_6.L_CORE X_NUC_80.L_CORE 0.003419
K_480 X_NUC_6.L_CORE X_NUC_81.L_CORE 0.003162
K_481 X_NUC_6.L_CORE X_NUC_82.L_CORE 0.003855
K_482 X_NUC_6.L_CORE X_NUC_83.L_CORE 0.002837
K_483 X_NUC_6.L_CORE X_NUC_84.L_CORE 0.003079
K_484 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_485 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.005290
K_486 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.005418
K_487 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.005320
K_488 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.005368
K_489 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.006420
K_490 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.006515
K_491 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.006523
K_492 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.006352
K_493 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.008350
K_494 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.008376
K_495 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.008119
K_496 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.008412
K_497 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.004016
K_498 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.004091
K_499 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.004044
K_500 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.004031
K_501 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.007848
K_502 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.007746
K_503 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.007751
K_504 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.007570
K_505 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.004414
K_506 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.004472
K_507 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.004382
K_508 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.004442
K_509 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.003972
K_510 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.004020
K_511 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.003992
K_512 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.003946
K_513 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006213
K_514 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006146
K_515 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006039
K_516 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006099
K_517 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.003427
K_518 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.003474
K_519 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.003423
K_520 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.003433
K_521 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.004392
K_522 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.004399
K_523 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.004374
K_524 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.004317
K_525 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.004113
K_526 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.004130
K_527 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.004053
K_528 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.004098
K_529 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.003244
K_530 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.003278
K_531 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.003243
K_532 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.003229
K_533 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.004280
K_534 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.004266
K_535 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.004218
K_536 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.004208
K_537 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.003274
K_538 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.003301
K_539 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.003251
K_540 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.003264
K_541 X_NUC_7.L_CORE X_NUC_65.L_CORE 0.003349
K_542 X_NUC_7.L_CORE X_NUC_66.L_CORE 0.003366
K_543 X_NUC_7.L_CORE X_NUC_67.L_CORE 0.003332
K_544 X_NUC_7.L_CORE X_NUC_68.L_CORE 0.003315
K_545 X_NUC_7.L_CORE X_NUC_69.L_CORE 0.003455
K_546 X_NUC_7.L_CORE X_NUC_70.L_CORE 0.003465
K_547 X_NUC_7.L_CORE X_NUC_71.L_CORE 0.003418
K_548 X_NUC_7.L_CORE X_NUC_72.L_CORE 0.003423
K_549 X_NUC_7.L_CORE X_NUC_73.L_CORE 0.006198
K_550 X_NUC_7.L_CORE X_NUC_74.L_CORE 0.025408
K_551 X_NUC_7.L_CORE X_NUC_75.L_CORE 0.004359
K_552 X_NUC_7.L_CORE X_NUC_76.L_CORE 0.005048
K_553 X_NUC_7.L_CORE X_NUC_77.L_CORE 0.005898
K_554 X_NUC_7.L_CORE X_NUC_78.L_CORE 0.003300
K_555 X_NUC_7.L_CORE X_NUC_79.L_CORE 0.005111
K_556 X_NUC_7.L_CORE X_NUC_80.L_CORE 0.003476
K_557 X_NUC_7.L_CORE X_NUC_81.L_CORE 0.003185
K_558 X_NUC_7.L_CORE X_NUC_82.L_CORE 0.003904
K_559 X_NUC_7.L_CORE X_NUC_83.L_CORE 0.002873
K_560 X_NUC_7.L_CORE X_NUC_84.L_CORE 0.003109
K_561 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.005242
K_562 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.005367
K_563 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.005270
K_564 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.005320
K_565 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.006593
K_566 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.006695
K_567 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.006700
K_568 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.006523
K_569 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.008057
K_570 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.008080
K_571 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.007843
K_572 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.008119
K_573 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.004028
K_574 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.004103
K_575 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.004054
K_576 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.004044
K_577 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.008044
K_578 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.007934
K_579 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.007933
K_580 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.007751
K_581 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.004354
K_582 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.004410
K_583 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.004322
K_584 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.004382
K_585 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.004017
K_586 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.004067
K_587 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.004038
K_588 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.003992
K_589 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006147
K_590 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006082
K_591 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.005976
K_592 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006039
K_593 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.003417
K_594 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.003464
K_595 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.003413
K_596 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.003423
K_597 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.004450
K_598 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.004458
K_599 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.004430
K_600 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.004374
K_601 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.004067
K_602 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.004083
K_603 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.004009
K_604 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.004053
K_605 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.003257
K_606 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.003292
K_607 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.003255
K_608 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.003243
K_609 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.004290
K_610 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.004276
K_611 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.004227
K_612 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.004218
K_613 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.003260
K_614 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.003286
K_615 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.003237
K_616 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.003251
K_617 X_NUC_8.L_CORE X_NUC_65.L_CORE 0.003366
K_618 X_NUC_8.L_CORE X_NUC_66.L_CORE 0.003384
K_619 X_NUC_8.L_CORE X_NUC_67.L_CORE 0.003348
K_620 X_NUC_8.L_CORE X_NUC_68.L_CORE 0.003332
K_621 X_NUC_8.L_CORE X_NUC_69.L_CORE 0.003449
K_622 X_NUC_8.L_CORE X_NUC_70.L_CORE 0.003459
K_623 X_NUC_8.L_CORE X_NUC_71.L_CORE 0.003411
K_624 X_NUC_8.L_CORE X_NUC_72.L_CORE 0.003418
K_625 X_NUC_8.L_CORE X_NUC_73.L_CORE 0.006266
K_626 X_NUC_8.L_CORE X_NUC_74.L_CORE 0.025279
K_627 X_NUC_8.L_CORE X_NUC_75.L_CORE 0.004321
K_628 X_NUC_8.L_CORE X_NUC_76.L_CORE 0.005161
K_629 X_NUC_8.L_CORE X_NUC_77.L_CORE 0.005757
K_630 X_NUC_8.L_CORE X_NUC_78.L_CORE 0.003308
K_631 X_NUC_8.L_CORE X_NUC_79.L_CORE 0.005176
K_632 X_NUC_8.L_CORE X_NUC_80.L_CORE 0.003442
K_633 X_NUC_8.L_CORE X_NUC_81.L_CORE 0.003210
K_634 X_NUC_8.L_CORE X_NUC_82.L_CORE 0.003888
K_635 X_NUC_8.L_CORE X_NUC_83.L_CORE 0.002869
K_636 X_NUC_8.L_CORE X_NUC_84.L_CORE 0.003119
K_637 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_638 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_639 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_640 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.004473
K_641 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.004428
K_642 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.004487
K_643 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.004403
K_644 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.005729
K_645 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.005583
K_646 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.005614
K_647 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.005650
K_648 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.007621
K_649 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.007746
K_650 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.007711
K_651 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.007492
K_652 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.003639
K_653 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.003589
K_654 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.003619
K_655 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.003585
K_656 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.007955
K_657 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.007860
K_658 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.007670
K_659 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.007850
K_660 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.004111
K_661 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.004104
K_662 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.004118
K_663 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.004047
K_664 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.003765
K_665 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.003705
K_666 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.003713
K_667 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.003711
K_668 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006335
K_669 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006411
K_670 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006259
K_671 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006238
K_672 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.003257
K_673 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.003231
K_674 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.003242
K_675 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.003208
K_676 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.004364
K_677 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.004315
K_678 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.004276
K_679 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.004304
K_680 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.004036
K_681 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.004045
K_682 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.004020
K_683 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.003974
K_684 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.003171
K_685 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.003138
K_686 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.003138
K_687 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.003125
K_688 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.004273
K_689 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.004266
K_690 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.004206
K_691 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.004212
K_692 X_NUC_9.L_CORE X_NUC_65.L_CORE 0.003251
K_693 X_NUC_9.L_CORE X_NUC_66.L_CORE 0.003238
K_694 X_NUC_9.L_CORE X_NUC_67.L_CORE 0.003228
K_695 X_NUC_9.L_CORE X_NUC_68.L_CORE 0.003203
K_696 X_NUC_9.L_CORE X_NUC_69.L_CORE 0.003354
K_697 X_NUC_9.L_CORE X_NUC_70.L_CORE 0.003331
K_698 X_NUC_9.L_CORE X_NUC_71.L_CORE 0.003312
K_699 X_NUC_9.L_CORE X_NUC_72.L_CORE 0.003306
K_700 X_NUC_9.L_CORE X_NUC_73.L_CORE 0.007021
K_701 X_NUC_9.L_CORE X_NUC_74.L_CORE 0.004426
K_702 X_NUC_9.L_CORE X_NUC_75.L_CORE 0.023296
K_703 X_NUC_9.L_CORE X_NUC_76.L_CORE 0.003690
K_704 X_NUC_9.L_CORE X_NUC_77.L_CORE 0.004512
K_705 X_NUC_9.L_CORE X_NUC_78.L_CORE 0.005507
K_706 X_NUC_9.L_CORE X_NUC_79.L_CORE 0.003014
K_707 X_NUC_9.L_CORE X_NUC_80.L_CORE 0.005020
K_708 X_NUC_9.L_CORE X_NUC_81.L_CORE 0.003294
K_709 X_NUC_9.L_CORE X_NUC_82.L_CORE 0.003062
K_710 X_NUC_9.L_CORE X_NUC_83.L_CORE 0.003769
K_711 X_NUC_9.L_CORE X_NUC_84.L_CORE 0.002874
K_712 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_713 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_714 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.004516
K_715 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.004473
K_716 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.004532
K_717 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.004446
K_718 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.005882
K_719 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.005729
K_720 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.005760
K_721 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.005799
K_722 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.007493
K_723 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.007621
K_724 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.007583
K_725 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.007374
K_726 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.003690
K_727 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.003639
K_728 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.003670
K_729 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.003635
K_730 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.008041
K_731 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.007955
K_732 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.007753
K_733 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.007938
K_734 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.004116
K_735 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.004111
K_736 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.004124
K_737 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.004053
K_738 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.003825
K_739 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.003765
K_740 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.003772
K_741 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.003770
K_742 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006255
K_743 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006335
K_744 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006185
K_745 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.006165
K_746 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.003283
K_747 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.003257
K_748 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.003268
K_749 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.003234
K_750 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.004413
K_751 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.004364
K_752 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.004323
K_753 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.004352
K_754 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.004025
K_755 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.004036
K_756 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.004010
K_757 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.003965
K_758 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.003203
K_759 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.003171
K_760 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.003170
K_761 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.003156
K_762 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.004279
K_763 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.004273
K_764 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.004212
K_765 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.004218
K_766 X_NUC_10.L_CORE X_NUC_65.L_CORE 0.003263
K_767 X_NUC_10.L_CORE X_NUC_66.L_CORE 0.003251
K_768 X_NUC_10.L_CORE X_NUC_67.L_CORE 0.003241
K_769 X_NUC_10.L_CORE X_NUC_68.L_CORE 0.003215
K_770 X_NUC_10.L_CORE X_NUC_69.L_CORE 0.003376
K_771 X_NUC_10.L_CORE X_NUC_70.L_CORE 0.003354
K_772 X_NUC_10.L_CORE X_NUC_71.L_CORE 0.003334
K_773 X_NUC_10.L_CORE X_NUC_72.L_CORE 0.003327
K_774 X_NUC_10.L_CORE X_NUC_73.L_CORE 0.007073
K_775 X_NUC_10.L_CORE X_NUC_74.L_CORE 0.004517
K_776 X_NUC_10.L_CORE X_NUC_75.L_CORE 0.021472
K_777 X_NUC_10.L_CORE X_NUC_76.L_CORE 0.003716
K_778 X_NUC_10.L_CORE X_NUC_77.L_CORE 0.004599
K_779 X_NUC_10.L_CORE X_NUC_78.L_CORE 0.005428
K_780 X_NUC_10.L_CORE X_NUC_79.L_CORE 0.003048
K_781 X_NUC_10.L_CORE X_NUC_80.L_CORE 0.005038
K_782 X_NUC_10.L_CORE X_NUC_81.L_CORE 0.003296
K_783 X_NUC_10.L_CORE X_NUC_82.L_CORE 0.003094
K_784 X_NUC_10.L_CORE X_NUC_83.L_CORE 0.003760
K_785 X_NUC_10.L_CORE X_NUC_84.L_CORE 0.002888
K_786 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_787 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.004456
K_788 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.004414
K_789 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.004473
K_790 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.004389
K_791 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.005847
K_792 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.005695
K_793 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.005729
K_794 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.005766
K_795 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.007525
K_796 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.007650
K_797 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.007621
K_798 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.007405
K_799 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.003659
K_800 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.003608
K_801 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.003639
K_802 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.003605
K_803 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.008261
K_804 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.008162
K_805 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.007955
K_806 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.008150
K_807 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.004102
K_808 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.004096
K_809 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.004111
K_810 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.004039
K_811 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.003816
K_812 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.003755
K_813 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.003765
K_814 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.003761
K_815 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006407
K_816 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006489
K_817 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006335
K_818 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006310
K_819 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.003271
K_820 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.003245
K_821 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.003257
K_822 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.003222
K_823 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.004456
K_824 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.004404
K_825 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.004364
K_826 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.004392
K_827 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.004051
K_828 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.004061
K_829 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.004036
K_830 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.003990
K_831 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.003203
K_832 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.003170
K_833 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.003171
K_834 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.003156
K_835 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.004342
K_836 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.004335
K_837 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.004273
K_838 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.004278
K_839 X_NUC_11.L_CORE X_NUC_65.L_CORE 0.003273
K_840 X_NUC_11.L_CORE X_NUC_66.L_CORE 0.003260
K_841 X_NUC_11.L_CORE X_NUC_67.L_CORE 0.003251
K_842 X_NUC_11.L_CORE X_NUC_68.L_CORE 0.003224
K_843 X_NUC_11.L_CORE X_NUC_69.L_CORE 0.003397
K_844 X_NUC_11.L_CORE X_NUC_70.L_CORE 0.003374
K_845 X_NUC_11.L_CORE X_NUC_71.L_CORE 0.003354
K_846 X_NUC_11.L_CORE X_NUC_72.L_CORE 0.003347
K_847 X_NUC_11.L_CORE X_NUC_73.L_CORE 0.006877
K_848 X_NUC_11.L_CORE X_NUC_74.L_CORE 0.004448
K_849 X_NUC_11.L_CORE X_NUC_75.L_CORE 0.023324
K_850 X_NUC_11.L_CORE X_NUC_76.L_CORE 0.003680
K_851 X_NUC_11.L_CORE X_NUC_77.L_CORE 0.004595
K_852 X_NUC_11.L_CORE X_NUC_78.L_CORE 0.005479
K_853 X_NUC_11.L_CORE X_NUC_79.L_CORE 0.003032
K_854 X_NUC_11.L_CORE X_NUC_80.L_CORE 0.005135
K_855 X_NUC_11.L_CORE X_NUC_81.L_CORE 0.003299
K_856 X_NUC_11.L_CORE X_NUC_82.L_CORE 0.003100
K_857 X_NUC_11.L_CORE X_NUC_83.L_CORE 0.003809
K_858 X_NUC_11.L_CORE X_NUC_84.L_CORE 0.002897
K_859 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.004543
K_860 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.004498
K_861 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.004559
K_862 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.004473
K_863 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.005807
K_864 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.005657
K_865 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.005689
K_866 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.005729
K_867 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.007747
K_868 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.007884
K_869 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.007847
K_870 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.007621
K_871 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.003694
K_872 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.003642
K_873 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.003674
K_874 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.003639
K_875 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.008053
K_876 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.007961
K_877 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.007763
K_878 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.007955
K_879 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.004176
K_880 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.004170
K_881 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.004185
K_882 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.004111
K_883 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.003819
K_884 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.003758
K_885 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.003766
K_886 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.003765
K_887 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006429
K_888 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006512
K_889 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006353
K_890 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006335
K_891 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.003307
K_892 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.003280
K_893 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.003292
K_894 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.003257
K_895 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.004425
K_896 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.004375
K_897 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.004335
K_898 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.004364
K_899 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.004099
K_900 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.004109
K_901 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.004082
K_902 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.004036
K_903 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.003218
K_904 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.003185
K_905 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.003185
K_906 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.003171
K_907 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.004335
K_908 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.004329
K_909 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.004266
K_910 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.004273
K_911 X_NUC_12.L_CORE X_NUC_65.L_CORE 0.003300
K_912 X_NUC_12.L_CORE X_NUC_66.L_CORE 0.003287
K_913 X_NUC_12.L_CORE X_NUC_67.L_CORE 0.003277
K_914 X_NUC_12.L_CORE X_NUC_68.L_CORE 0.003251
K_915 X_NUC_12.L_CORE X_NUC_69.L_CORE 0.003404
K_916 X_NUC_12.L_CORE X_NUC_70.L_CORE 0.003380
K_917 X_NUC_12.L_CORE X_NUC_71.L_CORE 0.003360
K_918 X_NUC_12.L_CORE X_NUC_72.L_CORE 0.003354
K_919 X_NUC_12.L_CORE X_NUC_73.L_CORE 0.007082
K_920 X_NUC_12.L_CORE X_NUC_74.L_CORE 0.004477
K_921 X_NUC_12.L_CORE X_NUC_75.L_CORE 0.021760
K_922 X_NUC_12.L_CORE X_NUC_76.L_CORE 0.003740
K_923 X_NUC_12.L_CORE X_NUC_77.L_CORE 0.004558
K_924 X_NUC_12.L_CORE X_NUC_78.L_CORE 0.005570
K_925 X_NUC_12.L_CORE X_NUC_79.L_CORE 0.003055
K_926 X_NUC_12.L_CORE X_NUC_80.L_CORE 0.005068
K_927 X_NUC_12.L_CORE X_NUC_81.L_CORE 0.003339
K_928 X_NUC_12.L_CORE X_NUC_82.L_CORE 0.003101
K_929 X_NUC_12.L_CORE X_NUC_83.L_CORE 0.003817
K_930 X_NUC_12.L_CORE X_NUC_84.L_CORE 0.002914
K_931 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_932 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_933 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_934 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.004005
K_935 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.003985
K_936 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.003955
K_937 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.004028
K_938 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.005249
K_939 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.005364
K_940 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.005254
K_941 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.005321
K_942 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.007237
K_943 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.007028
K_944 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.007021
K_945 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.007105
K_946 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.003399
K_947 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.003410
K_948 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.003369
K_949 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.003421
K_950 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.008021
K_951 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.008233
K_952 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.007987
K_953 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.007940
K_954 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.003942
K_955 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.003903
K_956 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.003873
K_957 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.003927
K_958 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.003629
K_959 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.003667
K_960 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.003607
K_961 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.003648
K_962 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006501
K_963 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006427
K_964 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006341
K_965 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006328
K_966 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.003173
K_967 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.003170
K_968 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.003134
K_969 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.003175
K_970 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.004355
K_971 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.004408
K_972 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.004321
K_973 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.004341
K_974 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.004029
K_975 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.003994
K_976 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.003953
K_977 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.003984
K_978 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.003171
K_979 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.003183
K_980 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.003137
K_981 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.003170
K_982 X_NUC_13.L_CORE X_NUC_65.L_CORE 0.004218
K_983 X_NUC_13.L_CORE X_NUC_66.L_CORE 0.004226
K_984 X_NUC_13.L_CORE X_NUC_67.L_CORE 0.004157
K_985 X_NUC_13.L_CORE X_NUC_68.L_CORE 0.004170
K_986 X_NUC_13.L_CORE X_NUC_69.L_CORE 0.003339
K_987 X_NUC_13.L_CORE X_NUC_70.L_CORE 0.003335
K_988 X_NUC_13.L_CORE X_NUC_71.L_CORE 0.003291
K_989 X_NUC_13.L_CORE X_NUC_72.L_CORE 0.003319
K_990 X_NUC_13.L_CORE X_NUC_73.L_CORE 0.007999
K_991 X_NUC_13.L_CORE X_NUC_74.L_CORE 0.005593
K_992 X_NUC_13.L_CORE X_NUC_75.L_CORE 0.003798
K_993 X_NUC_13.L_CORE X_NUC_76.L_CORE 0.019489
K_994 X_NUC_13.L_CORE X_NUC_77.L_CORE 0.003355
K_995 X_NUC_13.L_CORE X_NUC_78.L_CORE 0.004278
K_996 X_NUC_13.L_CORE X_NUC_79.L_CORE 0.005175
K_997 X_NUC_13.L_CORE X_NUC_80.L_CORE 0.002899
K_998 X_NUC_13.L_CORE X_NUC_81.L_CORE 0.004930
K_999 X_NUC_13.L_CORE X_NUC_82.L_CORE 0.003220
K_1000 X_NUC_13.L_CORE X_NUC_83.L_CORE 0.003069
K_1001 X_NUC_13.L_CORE X_NUC_84.L_CORE 0.003535
K_1002 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_1003 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_1004 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.004024
K_1005 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.004005
K_1006 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.003974
K_1007 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.004048
K_1008 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.005139
K_1009 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.005249
K_1010 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.005144
K_1011 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.005207
K_1012 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.007456
K_1013 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.007237
K_1014 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.007225
K_1015 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.007316
K_1016 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.003386
K_1017 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.003399
K_1018 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.003357
K_1019 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.003409
K_1020 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.007814
K_1021 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.008021
K_1022 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.007788
K_1023 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.007744
K_1024 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.003980
K_1025 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.003942
K_1026 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.003911
K_1027 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.003966
K_1028 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.003591
K_1029 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.003629
K_1030 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.003570
K_1031 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.003610
K_1032 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006572
K_1033 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006501
K_1034 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006409
K_1035 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006396
K_1036 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.003176
K_1037 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.003173
K_1038 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.003137
K_1039 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.003178
K_1040 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.004302
K_1041 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.004355
K_1042 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.004270
K_1043 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.004289
K_1044 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.004063
K_1045 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.004029
K_1046 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.003986
K_1047 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.004018
K_1048 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.003157
K_1049 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.003171
K_1050 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.003125
K_1051 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.003157
K_1052 X_NUC_14.L_CORE X_NUC_65.L_CORE 0.004209
K_1053 X_NUC_14.L_CORE X_NUC_66.L_CORE 0.004218
K_1054 X_NUC_14.L_CORE X_NUC_67.L_CORE 0.004149
K_1055 X_NUC_14.L_CORE X_NUC_68.L_CORE 0.004162
K_1056 X_NUC_14.L_CORE X_NUC_69.L_CORE 0.003343
K_1057 X_NUC_14.L_CORE X_NUC_70.L_CORE 0.003339
K_1058 X_NUC_14.L_CORE X_NUC_71.L_CORE 0.003295
K_1059 X_NUC_14.L_CORE X_NUC_72.L_CORE 0.003323
K_1060 X_NUC_14.L_CORE X_NUC_73.L_CORE 0.007830
K_1061 X_NUC_14.L_CORE X_NUC_74.L_CORE 0.005688
K_1062 X_NUC_14.L_CORE X_NUC_75.L_CORE 0.003763
K_1063 X_NUC_14.L_CORE X_NUC_76.L_CORE 0.019710
K_1064 X_NUC_14.L_CORE X_NUC_77.L_CORE 0.003371
K_1065 X_NUC_14.L_CORE X_NUC_78.L_CORE 0.004203
K_1066 X_NUC_14.L_CORE X_NUC_79.L_CORE 0.005277
K_1067 X_NUC_14.L_CORE X_NUC_80.L_CORE 0.002890
K_1068 X_NUC_14.L_CORE X_NUC_81.L_CORE 0.004879
K_1069 X_NUC_14.L_CORE X_NUC_82.L_CORE 0.003241
K_1070 X_NUC_14.L_CORE X_NUC_83.L_CORE 0.003050
K_1071 X_NUC_14.L_CORE X_NUC_84.L_CORE 0.003539
K_1072 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_1073 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.004057
K_1074 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.004036
K_1075 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.004005
K_1076 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.004081
K_1077 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.005242
K_1078 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.005358
K_1079 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.005249
K_1080 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.005315
K_1081 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.007464
K_1082 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.007239
K_1083 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.007237
K_1084 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.007324
K_1085 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.003428
K_1086 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.003441
K_1087 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.003399
K_1088 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.003452
K_1089 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.008043
K_1090 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.008264
K_1091 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.008021
K_1092 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.007968
K_1093 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.004012
K_1094 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.003972
K_1095 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.003942
K_1096 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.003997
K_1097 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.003651
K_1098 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.003690
K_1099 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.003629
K_1100 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.003671
K_1101 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006667
K_1102 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006590
K_1103 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006501
K_1104 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.006484
K_1105 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.003214
K_1106 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.003210
K_1107 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.003173
K_1108 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.003215
K_1109 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.004388
K_1110 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.004444
K_1111 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.004355
K_1112 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.004375
K_1113 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.004108
K_1114 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.004072
K_1115 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.004029
K_1116 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.004062
K_1117 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.003204
K_1118 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.003217
K_1119 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.003171
K_1120 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.003204
K_1121 X_NUC_15.L_CORE X_NUC_65.L_CORE 0.004281
K_1122 X_NUC_15.L_CORE X_NUC_66.L_CORE 0.004290
K_1123 X_NUC_15.L_CORE X_NUC_67.L_CORE 0.004218
K_1124 X_NUC_15.L_CORE X_NUC_68.L_CORE 0.004231
K_1125 X_NUC_15.L_CORE X_NUC_69.L_CORE 0.003388
K_1126 X_NUC_15.L_CORE X_NUC_70.L_CORE 0.003384
K_1127 X_NUC_15.L_CORE X_NUC_71.L_CORE 0.003339
K_1128 X_NUC_15.L_CORE X_NUC_72.L_CORE 0.003368
K_1129 X_NUC_15.L_CORE X_NUC_73.L_CORE 0.007869
K_1130 X_NUC_15.L_CORE X_NUC_74.L_CORE 0.005669
K_1131 X_NUC_15.L_CORE X_NUC_75.L_CORE 0.003808
K_1132 X_NUC_15.L_CORE X_NUC_76.L_CORE 0.019245
K_1133 X_NUC_15.L_CORE X_NUC_77.L_CORE 0.003396
K_1134 X_NUC_15.L_CORE X_NUC_78.L_CORE 0.004277
K_1135 X_NUC_15.L_CORE X_NUC_79.L_CORE 0.005293
K_1136 X_NUC_15.L_CORE X_NUC_80.L_CORE 0.002925
K_1137 X_NUC_15.L_CORE X_NUC_81.L_CORE 0.004968
K_1138 X_NUC_15.L_CORE X_NUC_82.L_CORE 0.003270
K_1139 X_NUC_15.L_CORE X_NUC_83.L_CORE 0.003096
K_1140 X_NUC_15.L_CORE X_NUC_84.L_CORE 0.003585
K_1141 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.003981
K_1142 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.003962
K_1143 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.003932
K_1144 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.004005
K_1145 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.005178
K_1146 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.005289
K_1147 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.005184
K_1148 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.005249
K_1149 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.007367
K_1150 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.007151
K_1151 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.007145
K_1152 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.007237
K_1153 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.003376
K_1154 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.003388
K_1155 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.003347
K_1156 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.003399
K_1157 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.008092
K_1158 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.008317
K_1159 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.008064
K_1160 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.008021
K_1161 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.003955
K_1162 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.003916
K_1163 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.003887
K_1164 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.003942
K_1165 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.003609
K_1166 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.003648
K_1167 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.003588
K_1168 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.003629
K_1169 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006682
K_1170 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006605
K_1171 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006512
K_1172 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006501
K_1173 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.003171
K_1174 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.003168
K_1175 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.003132
K_1176 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.003173
K_1177 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.004368
K_1178 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.004422
K_1179 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.004334
K_1180 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.004355
K_1181 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.004073
K_1182 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.004038
K_1183 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.003996
K_1184 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.004029
K_1185 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.003171
K_1186 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.003184
K_1187 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.003138
K_1188 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.003171
K_1189 X_NUC_16.L_CORE X_NUC_65.L_CORE 0.004266
K_1190 X_NUC_16.L_CORE X_NUC_66.L_CORE 0.004275
K_1191 X_NUC_16.L_CORE X_NUC_67.L_CORE 0.004204
K_1192 X_NUC_16.L_CORE X_NUC_68.L_CORE 0.004218
K_1193 X_NUC_16.L_CORE X_NUC_69.L_CORE 0.003358
K_1194 X_NUC_16.L_CORE X_NUC_70.L_CORE 0.003354
K_1195 X_NUC_16.L_CORE X_NUC_71.L_CORE 0.003310
K_1196 X_NUC_16.L_CORE X_NUC_72.L_CORE 0.003339
K_1197 X_NUC_16.L_CORE X_NUC_73.L_CORE 0.007705
K_1198 X_NUC_16.L_CORE X_NUC_74.L_CORE 0.005557
K_1199 X_NUC_16.L_CORE X_NUC_75.L_CORE 0.003749
K_1200 X_NUC_16.L_CORE X_NUC_76.L_CORE 0.021062
K_1201 X_NUC_16.L_CORE X_NUC_77.L_CORE 0.003344
K_1202 X_NUC_16.L_CORE X_NUC_78.L_CORE 0.004246
K_1203 X_NUC_16.L_CORE X_NUC_79.L_CORE 0.005271
K_1204 X_NUC_16.L_CORE X_NUC_80.L_CORE 0.002889
K_1205 X_NUC_16.L_CORE X_NUC_81.L_CORE 0.004987
K_1206 X_NUC_16.L_CORE X_NUC_82.L_CORE 0.003240
K_1207 X_NUC_16.L_CORE X_NUC_83.L_CORE 0.003072
K_1208 X_NUC_16.L_CORE X_NUC_84.L_CORE 0.003572
K_1209 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_1210 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_1211 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_1212 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.003716
K_1213 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.003773
K_1214 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.003759
K_1215 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.003722
K_1216 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.004942
K_1217 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.004909
K_1218 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.004966
K_1219 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.004856
K_1220 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.006963
K_1221 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.007176
K_1222 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.006971
K_1223 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.007032
K_1224 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.003249
K_1225 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.003273
K_1226 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.003274
K_1227 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.003231
K_1228 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.008035
K_1229 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.007863
K_1230 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.007857
K_1231 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.007737
K_1232 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.003841
K_1233 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.003904
K_1234 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.003859
K_1235 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.003842
K_1236 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.003556
K_1237 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.003557
K_1238 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.003565
K_1239 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.003511
K_1240 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006577
K_1241 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006632
K_1242 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.006448
K_1243 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.006486
K_1244 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.003147
K_1245 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.003177
K_1246 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.003159
K_1247 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.003131
K_1248 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.004355
K_1249 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.004336
K_1250 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.004322
K_1251 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.004270
K_1252 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.004036
K_1253 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.004083
K_1254 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.004019
K_1255 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.004011
K_1256 X_NUC_17.L_CORE X_NUC_65.L_CORE 0.003243
K_1257 X_NUC_17.L_CORE X_NUC_66.L_CORE 0.003257
K_1258 X_NUC_17.L_CORE X_NUC_67.L_CORE 0.003241
K_1259 X_NUC_17.L_CORE X_NUC_68.L_CORE 0.003208
K_1260 X_NUC_17.L_CORE X_NUC_69.L_CORE 0.004015
K_1261 X_NUC_17.L_CORE X_NUC_70.L_CORE 0.004027
K_1262 X_NUC_17.L_CORE X_NUC_71.L_CORE 0.003982
K_1263 X_NUC_17.L_CORE X_NUC_72.L_CORE 0.003958
K_1264 X_NUC_17.L_CORE X_NUC_73.L_CORE 0.004283
K_1265 X_NUC_17.L_CORE X_NUC_74.L_CORE 0.007445
K_1266 X_NUC_17.L_CORE X_NUC_75.L_CORE 0.005009
K_1267 X_NUC_17.L_CORE X_NUC_76.L_CORE 0.003420
K_1268 X_NUC_17.L_CORE X_NUC_77.L_CORE 0.017056
K_1269 X_NUC_17.L_CORE X_NUC_78.L_CORE 0.003187
K_1270 X_NUC_17.L_CORE X_NUC_79.L_CORE 0.004036
K_1271 X_NUC_17.L_CORE X_NUC_80.L_CORE 0.005081
K_1272 X_NUC_17.L_CORE X_NUC_81.L_CORE 0.002847
K_1273 X_NUC_17.L_CORE X_NUC_82.L_CORE 0.004711
K_1274 X_NUC_17.L_CORE X_NUC_83.L_CORE 0.003246
K_1275 X_NUC_17.L_CORE X_NUC_84.L_CORE 0.003137
K_1276 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_1277 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_1278 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.003661
K_1279 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.003716
K_1280 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.003703
K_1281 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.003668
K_1282 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.004972
K_1283 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.004942
K_1284 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.004998
K_1285 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.004886
K_1286 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.006760
K_1287 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.006963
K_1288 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.006771
K_1289 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.006827
K_1290 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.003225
K_1291 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.003249
K_1292 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.003250
K_1293 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.003207
K_1294 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.008205
K_1295 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.008035
K_1296 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.008022
K_1297 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.007895
K_1298 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.003779
K_1299 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.003841
K_1300 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.003797
K_1301 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.003781
K_1302 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.003554
K_1303 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.003556
K_1304 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.003563
K_1305 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.003509
K_1306 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.006518
K_1307 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006577
K_1308 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.006395
K_1309 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.006432
K_1310 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.003118
K_1311 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.003147
K_1312 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.003130
K_1313 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.003102
K_1314 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.004372
K_1315 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.004355
K_1316 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.004340
K_1317 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.004287
K_1318 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.003989
K_1319 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.004036
K_1320 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.003973
K_1321 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.003966
K_1322 X_NUC_18.L_CORE X_NUC_65.L_CORE 0.003228
K_1323 X_NUC_18.L_CORE X_NUC_66.L_CORE 0.003243
K_1324 X_NUC_18.L_CORE X_NUC_67.L_CORE 0.003227
K_1325 X_NUC_18.L_CORE X_NUC_68.L_CORE 0.003195
K_1326 X_NUC_18.L_CORE X_NUC_69.L_CORE 0.004002
K_1327 X_NUC_18.L_CORE X_NUC_70.L_CORE 0.004015
K_1328 X_NUC_18.L_CORE X_NUC_71.L_CORE 0.003970
K_1329 X_NUC_18.L_CORE X_NUC_72.L_CORE 0.003946
K_1330 X_NUC_18.L_CORE X_NUC_73.L_CORE 0.004233
K_1331 X_NUC_18.L_CORE X_NUC_74.L_CORE 0.007539
K_1332 X_NUC_18.L_CORE X_NUC_75.L_CORE 0.004893
K_1333 X_NUC_18.L_CORE X_NUC_76.L_CORE 0.003409
K_1334 X_NUC_18.L_CORE X_NUC_77.L_CORE 0.017724
K_1335 X_NUC_18.L_CORE X_NUC_78.L_CORE 0.003146
K_1336 X_NUC_18.L_CORE X_NUC_79.L_CORE 0.004063
K_1337 X_NUC_18.L_CORE X_NUC_80.L_CORE 0.004998
K_1338 X_NUC_18.L_CORE X_NUC_81.L_CORE 0.002830
K_1339 X_NUC_18.L_CORE X_NUC_82.L_CORE 0.004743
K_1340 X_NUC_18.L_CORE X_NUC_83.L_CORE 0.003213
K_1341 X_NUC_18.L_CORE X_NUC_84.L_CORE 0.003131
K_1342 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_1343 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.003674
K_1344 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.003729
K_1345 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.003716
K_1346 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.003680
K_1347 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.004915
K_1348 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.004885
K_1349 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.004942
K_1350 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.004833
K_1351 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.006947
K_1352 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.007163
K_1353 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.006963
K_1354 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.007020
K_1355 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.003224
K_1356 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.003248
K_1357 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.003249
K_1358 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.003207
K_1359 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.008212
K_1360 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.008036
K_1361 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.008035
K_1362 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.007901
K_1363 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.003822
K_1364 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.003885
K_1365 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.003841
K_1366 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.003824
K_1367 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.003547
K_1368 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.003548
K_1369 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.003556
K_1370 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.003502
K_1371 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006708
K_1372 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006769
K_1373 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006577
K_1374 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.006614
K_1375 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.003135
K_1376 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.003165
K_1377 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.003147
K_1378 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.003119
K_1379 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.004387
K_1380 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.004368
K_1381 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.004355
K_1382 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.004301
K_1383 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.004052
K_1384 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.004100
K_1385 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.004036
K_1386 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.004027
K_1387 X_NUC_19.L_CORE X_NUC_65.L_CORE 0.003243
K_1388 X_NUC_19.L_CORE X_NUC_66.L_CORE 0.003258
K_1389 X_NUC_19.L_CORE X_NUC_67.L_CORE 0.003243
K_1390 X_NUC_19.L_CORE X_NUC_68.L_CORE 0.003209
K_1391 X_NUC_19.L_CORE X_NUC_69.L_CORE 0.004047
K_1392 X_NUC_19.L_CORE X_NUC_70.L_CORE 0.004060
K_1393 X_NUC_19.L_CORE X_NUC_71.L_CORE 0.004015
K_1394 X_NUC_19.L_CORE X_NUC_72.L_CORE 0.003990
K_1395 X_NUC_19.L_CORE X_NUC_73.L_CORE 0.004202
K_1396 X_NUC_19.L_CORE X_NUC_74.L_CORE 0.007299
K_1397 X_NUC_19.L_CORE X_NUC_75.L_CORE 0.004933
K_1398 X_NUC_19.L_CORE X_NUC_76.L_CORE 0.003388
K_1399 X_NUC_19.L_CORE X_NUC_77.L_CORE 0.018548
K_1400 X_NUC_19.L_CORE X_NUC_78.L_CORE 0.003162
K_1401 X_NUC_19.L_CORE X_NUC_79.L_CORE 0.004037
K_1402 X_NUC_19.L_CORE X_NUC_80.L_CORE 0.005116
K_1403 X_NUC_19.L_CORE X_NUC_81.L_CORE 0.002836
K_1404 X_NUC_19.L_CORE X_NUC_82.L_CORE 0.004783
K_1405 X_NUC_19.L_CORE X_NUC_83.L_CORE 0.003250
K_1406 X_NUC_19.L_CORE X_NUC_84.L_CORE 0.003147
K_1407 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.003709
K_1408 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.003766
K_1409 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.003752
K_1410 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.003716
K_1411 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.005028
K_1412 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.004996
K_1413 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.005055
K_1414 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.004942
K_1415 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.006888
K_1416 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.007098
K_1417 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.006899
K_1418 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.006963
K_1419 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.003266
K_1420 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.003291
K_1421 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.003292
K_1422 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.003249
K_1423 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.008356
K_1424 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.008170
K_1425 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.008163
K_1426 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.008035
K_1427 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.003838
K_1428 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.003902
K_1429 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.003857
K_1430 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.003841
K_1431 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.003602
K_1432 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.003604
K_1433 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.003611
K_1434 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.003556
K_1435 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006666
K_1436 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.006726
K_1437 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006535
K_1438 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006577
K_1439 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.003164
K_1440 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.003194
K_1441 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.003176
K_1442 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.003147
K_1443 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.004443
K_1444 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.004424
K_1445 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.004409
K_1446 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.004355
K_1447 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.004060
K_1448 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.004109
K_1449 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.004043
K_1450 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.004036
K_1451 X_NUC_20.L_CORE X_NUC_65.L_CORE 0.003277
K_1452 X_NUC_20.L_CORE X_NUC_66.L_CORE 0.003292
K_1453 X_NUC_20.L_CORE X_NUC_67.L_CORE 0.003276
K_1454 X_NUC_20.L_CORE X_NUC_68.L_CORE 0.003243
K_1455 X_NUC_20.L_CORE X_NUC_69.L_CORE 0.004073
K_1456 X_NUC_20.L_CORE X_NUC_70.L_CORE 0.004086
K_1457 X_NUC_20.L_CORE X_NUC_71.L_CORE 0.004039
K_1458 X_NUC_20.L_CORE X_NUC_72.L_CORE 0.004015
K_1459 X_NUC_20.L_CORE X_NUC_73.L_CORE 0.004264
K_1460 X_NUC_20.L_CORE X_NUC_74.L_CORE 0.007511
K_1461 X_NUC_20.L_CORE X_NUC_75.L_CORE 0.004941
K_1462 X_NUC_20.L_CORE X_NUC_76.L_CORE 0.003443
K_1463 X_NUC_20.L_CORE X_NUC_77.L_CORE 0.017487
K_1464 X_NUC_20.L_CORE X_NUC_78.L_CORE 0.003186
K_1465 X_NUC_20.L_CORE X_NUC_79.L_CORE 0.004106
K_1466 X_NUC_20.L_CORE X_NUC_80.L_CORE 0.005076
K_1467 X_NUC_20.L_CORE X_NUC_81.L_CORE 0.002867
K_1468 X_NUC_20.L_CORE X_NUC_82.L_CORE 0.004812
K_1469 X_NUC_20.L_CORE X_NUC_83.L_CORE 0.003261
K_1470 X_NUC_20.L_CORE X_NUC_84.L_CORE 0.003175
K_1471 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_1472 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_1473 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_1474 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.003530
K_1475 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.003472
K_1476 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.003503
K_1477 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.003494
K_1478 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.004743
K_1479 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.004693
K_1480 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.004659
K_1481 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.004751
K_1482 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.006781
K_1483 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.006664
K_1484 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.006748
K_1485 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.006586
K_1486 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.003160
K_1487 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.003116
K_1488 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.003124
K_1489 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.003137
K_1490 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.008033
K_1491 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.008038
K_1492 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.007779
K_1493 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.007983
K_1494 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.003793
K_1495 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.003737
K_1496 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.003759
K_1497 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.003732
K_1498 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.003533
K_1499 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.003494
K_1500 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.003477
K_1501 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.003513
K_1502 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.006577
K_1503 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.006537
K_1504 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.006450
K_1505 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.006395
K_1506 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.003173
K_1507 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.003132
K_1508 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.003135
K_1509 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.003136
K_1510 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.004364
K_1511 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.004333
K_1512 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.004276
K_1513 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.004322
K_1514 X_NUC_21.L_CORE X_NUC_65.L_CORE 0.004053
K_1515 X_NUC_21.L_CORE X_NUC_66.L_CORE 0.004009
K_1516 X_NUC_21.L_CORE X_NUC_67.L_CORE 0.003996
K_1517 X_NUC_21.L_CORE X_NUC_68.L_CORE 0.003979
K_1518 X_NUC_21.L_CORE X_NUC_69.L_CORE 0.003437
K_1519 X_NUC_21.L_CORE X_NUC_70.L_CORE 0.003402
K_1520 X_NUC_21.L_CORE X_NUC_71.L_CORE 0.003384
K_1521 X_NUC_21.L_CORE X_NUC_72.L_CORE 0.003397
K_1522 X_NUC_21.L_CORE X_NUC_73.L_CORE 0.006809
K_1523 X_NUC_21.L_CORE X_NUC_74.L_CORE 0.003474
K_1524 X_NUC_21.L_CORE X_NUC_75.L_CORE 0.006976
K_1525 X_NUC_21.L_CORE X_NUC_76.L_CORE 0.004519
K_1526 X_NUC_21.L_CORE X_NUC_77.L_CORE 0.003184
K_1527 X_NUC_21.L_CORE X_NUC_78.L_CORE 0.015883
K_1528 X_NUC_21.L_CORE X_NUC_79.L_CORE 0.003038
K_1529 X_NUC_21.L_CORE X_NUC_80.L_CORE 0.003930
K_1530 X_NUC_21.L_CORE X_NUC_81.L_CORE 0.004874
K_1531 X_NUC_21.L_CORE X_NUC_82.L_CORE 0.002836
K_1532 X_NUC_21.L_CORE X_NUC_83.L_CORE 0.004480
K_1533 X_NUC_21.L_CORE X_NUC_84.L_CORE 0.003290
K_1534 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_1535 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_1536 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.003590
K_1537 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.003530
K_1538 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.003562
K_1539 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.003552
K_1540 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.004792
K_1541 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.004743
K_1542 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.004707
K_1543 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.004802
K_1544 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.006895
K_1545 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.006781
K_1546 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.006865
K_1547 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.006694
K_1548 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.003206
K_1549 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.003160
K_1550 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.003168
K_1551 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.003182
K_1552 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.008016
K_1553 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.008033
K_1554 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.007769
K_1555 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.007972
K_1556 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.003851
K_1557 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.003793
K_1558 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.003815
K_1559 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.003788
K_1560 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.003572
K_1561 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.003533
K_1562 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.003514
K_1563 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.003552
K_1564 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.006612
K_1565 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.006577
K_1566 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.006485
K_1567 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.006430
K_1568 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.003215
K_1569 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.003173
K_1570 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.003175
K_1571 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.003177
K_1572 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.004394
K_1573 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.004364
K_1574 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.004305
K_1575 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.004352
K_1576 X_NUC_22.L_CORE X_NUC_65.L_CORE 0.004097
K_1577 X_NUC_22.L_CORE X_NUC_66.L_CORE 0.004053
K_1578 X_NUC_22.L_CORE X_NUC_67.L_CORE 0.004039
K_1579 X_NUC_22.L_CORE X_NUC_68.L_CORE 0.004021
K_1580 X_NUC_22.L_CORE X_NUC_69.L_CORE 0.003473
K_1581 X_NUC_22.L_CORE X_NUC_70.L_CORE 0.003437
K_1582 X_NUC_22.L_CORE X_NUC_71.L_CORE 0.003419
K_1583 X_NUC_22.L_CORE X_NUC_72.L_CORE 0.003432
K_1584 X_NUC_22.L_CORE X_NUC_73.L_CORE 0.006951
K_1585 X_NUC_22.L_CORE X_NUC_74.L_CORE 0.003530
K_1586 X_NUC_22.L_CORE X_NUC_75.L_CORE 0.007018
K_1587 X_NUC_22.L_CORE X_NUC_76.L_CORE 0.004596
K_1588 X_NUC_22.L_CORE X_NUC_77.L_CORE 0.003223
K_1589 X_NUC_22.L_CORE X_NUC_78.L_CORE 0.015137
K_1590 X_NUC_22.L_CORE X_NUC_79.L_CORE 0.003081
K_1591 X_NUC_22.L_CORE X_NUC_80.L_CORE 0.003956
K_1592 X_NUC_22.L_CORE X_NUC_81.L_CORE 0.004914
K_1593 X_NUC_22.L_CORE X_NUC_82.L_CORE 0.002869
K_1594 X_NUC_22.L_CORE X_NUC_83.L_CORE 0.004491
K_1595 X_NUC_22.L_CORE X_NUC_84.L_CORE 0.003322
K_1596 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_1597 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.003558
K_1598 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.003499
K_1599 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.003530
K_1600 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.003520
K_1601 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.004829
K_1602 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.004777
K_1603 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.004743
K_1604 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.004839
K_1605 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.006807
K_1606 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.006693
K_1607 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.006781
K_1608 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.006613
K_1609 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.003198
K_1610 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.003153
K_1611 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.003160
K_1612 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.003174
K_1613 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.008299
K_1614 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.008312
K_1615 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.008033
K_1616 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.008251
K_1617 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.003828
K_1618 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.003771
K_1619 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.003793
K_1620 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.003766
K_1621 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.003591
K_1622 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.003550
K_1623 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.003533
K_1624 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.003570
K_1625 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.006706
K_1626 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.006666
K_1627 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.006577
K_1628 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.006516
K_1629 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.003213
K_1630 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.003170
K_1631 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.003173
K_1632 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.003175
K_1633 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.004456
K_1634 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.004424
K_1635 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.004364
K_1636 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.004412
K_1637 X_NUC_23.L_CORE X_NUC_65.L_CORE 0.004111
K_1638 X_NUC_23.L_CORE X_NUC_66.L_CORE 0.004066
K_1639 X_NUC_23.L_CORE X_NUC_67.L_CORE 0.004053
K_1640 X_NUC_23.L_CORE X_NUC_68.L_CORE 0.004035
K_1641 X_NUC_23.L_CORE X_NUC_69.L_CORE 0.003493
K_1642 X_NUC_23.L_CORE X_NUC_70.L_CORE 0.003455
K_1643 X_NUC_23.L_CORE X_NUC_71.L_CORE 0.003437
K_1644 X_NUC_23.L_CORE X_NUC_72.L_CORE 0.003450
K_1645 X_NUC_23.L_CORE X_NUC_73.L_CORE 0.006741
K_1646 X_NUC_23.L_CORE X_NUC_74.L_CORE 0.003494
K_1647 X_NUC_23.L_CORE X_NUC_75.L_CORE 0.007050
K_1648 X_NUC_23.L_CORE X_NUC_76.L_CORE 0.004520
K_1649 X_NUC_23.L_CORE X_NUC_77.L_CORE 0.003220
K_1650 X_NUC_23.L_CORE X_NUC_78.L_CORE 0.016031
K_1651 X_NUC_23.L_CORE X_NUC_79.L_CORE 0.003062
K_1652 X_NUC_23.L_CORE X_NUC_80.L_CORE 0.003998
K_1653 X_NUC_23.L_CORE X_NUC_81.L_CORE 0.004915
K_1654 X_NUC_23.L_CORE X_NUC_82.L_CORE 0.002871
K_1655 X_NUC_23.L_CORE X_NUC_83.L_CORE 0.004567
K_1656 X_NUC_23.L_CORE X_NUC_84.L_CORE 0.003332
K_1657 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.003567
K_1658 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.003508
K_1659 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.003539
K_1660 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.003530
K_1661 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.004733
K_1662 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.004684
K_1663 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.004650
K_1664 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.004743
K_1665 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.006986
K_1666 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.006863
K_1667 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.006954
K_1668 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.006781
K_1669 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.003183
K_1670 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.003139
K_1671 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.003146
K_1672 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.003160
K_1673 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.008072
K_1674 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.008083
K_1675 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.007820
K_1676 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.008033
K_1677 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.003857
K_1678 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.003798
K_1679 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.003821
K_1680 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.003793
K_1681 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.003552
K_1682 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.003513
K_1683 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.003496
K_1684 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.003533
K_1685 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.006769
K_1686 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.006728
K_1687 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.006633
K_1688 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.006577
K_1689 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.003211
K_1690 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.003169
K_1691 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.003171
K_1692 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.003173
K_1693 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.004406
K_1694 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.004374
K_1695 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.004316
K_1696 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.004364
K_1697 X_NUC_24.L_CORE X_NUC_65.L_CORE 0.004130
K_1698 X_NUC_24.L_CORE X_NUC_66.L_CORE 0.004085
K_1699 X_NUC_24.L_CORE X_NUC_67.L_CORE 0.004071
K_1700 X_NUC_24.L_CORE X_NUC_68.L_CORE 0.004053
K_1701 X_NUC_24.L_CORE X_NUC_69.L_CORE 0.003479
K_1702 X_NUC_24.L_CORE X_NUC_70.L_CORE 0.003442
K_1703 X_NUC_24.L_CORE X_NUC_71.L_CORE 0.003424
K_1704 X_NUC_24.L_CORE X_NUC_72.L_CORE 0.003437
K_1705 X_NUC_24.L_CORE X_NUC_73.L_CORE 0.006773
K_1706 X_NUC_24.L_CORE X_NUC_74.L_CORE 0.003486
K_1707 X_NUC_24.L_CORE X_NUC_75.L_CORE 0.006837
K_1708 X_NUC_24.L_CORE X_NUC_76.L_CORE 0.004584
K_1709 X_NUC_24.L_CORE X_NUC_77.L_CORE 0.003191
K_1710 X_NUC_24.L_CORE X_NUC_78.L_CORE 0.016218
K_1711 X_NUC_24.L_CORE X_NUC_79.L_CORE 0.003071
K_1712 X_NUC_24.L_CORE X_NUC_80.L_CORE 0.003935
K_1713 X_NUC_24.L_CORE X_NUC_81.L_CORE 0.004989
K_1714 X_NUC_24.L_CORE X_NUC_82.L_CORE 0.002861
K_1715 X_NUC_24.L_CORE X_NUC_83.L_CORE 0.004533
K_1716 X_NUC_24.L_CORE X_NUC_84.L_CORE 0.003339
K_1717 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_1718 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_1719 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_1720 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.003414
K_1721 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.003448
K_1722 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.003406
K_1723 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.003451
K_1724 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.004623
K_1725 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.004721
K_1726 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.004675
K_1727 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.004642
K_1728 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.006677
K_1729 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.006653
K_1730 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.006515
K_1731 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.006708
K_1732 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.003119
K_1733 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.003161
K_1734 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.003122
K_1735 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.003142
K_1736 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.008031
K_1737 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.008184
K_1738 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.008019
K_1739 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.007875
K_1740 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.003793
K_1741 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.003818
K_1742 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.003757
K_1743 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.003815
K_1744 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.003556
K_1745 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.003611
K_1746 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.003563
K_1747 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.003564
K_1748 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.006501
K_1749 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.006509
K_1750 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.006339
K_1751 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.006408
K_1752 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.003257
K_1753 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.003291
K_1754 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.003241
K_1755 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.003268
K_1756 X_NUC_25.L_CORE X_NUC_65.L_CORE 0.004374
K_1757 X_NUC_25.L_CORE X_NUC_66.L_CORE 0.004431
K_1758 X_NUC_25.L_CORE X_NUC_67.L_CORE 0.004353
K_1759 X_NUC_25.L_CORE X_NUC_68.L_CORE 0.004348
K_1760 X_NUC_25.L_CORE X_NUC_69.L_CORE 0.004060
K_1761 X_NUC_25.L_CORE X_NUC_70.L_CORE 0.004090
K_1762 X_NUC_25.L_CORE X_NUC_71.L_CORE 0.004012
K_1763 X_NUC_25.L_CORE X_NUC_72.L_CORE 0.004048
K_1764 X_NUC_25.L_CORE X_NUC_73.L_CORE 0.004393
K_1765 X_NUC_25.L_CORE X_NUC_74.L_CORE 0.007817
K_1766 X_NUC_25.L_CORE X_NUC_75.L_CORE 0.003182
K_1767 X_NUC_25.L_CORE X_NUC_76.L_CORE 0.006726
K_1768 X_NUC_25.L_CORE X_NUC_77.L_CORE 0.004332
K_1769 X_NUC_25.L_CORE X_NUC_78.L_CORE 0.003108
K_1770 X_NUC_25.L_CORE X_NUC_79.L_CORE 0.013643
K_1771 X_NUC_25.L_CORE X_NUC_80.L_CORE 0.003031
K_1772 X_NUC_25.L_CORE X_NUC_81.L_CORE 0.003934
K_1773 X_NUC_25.L_CORE X_NUC_82.L_CORE 0.004767
K_1774 X_NUC_25.L_CORE X_NUC_83.L_CORE 0.002965
K_1775 X_NUC_25.L_CORE X_NUC_84.L_CORE 0.004126
K_1776 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_1777 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_1778 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.003379
K_1779 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.003414
K_1780 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.003372
K_1781 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.003415
K_1782 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.004529
K_1783 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.004623
K_1784 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.004579
K_1785 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.004548
K_1786 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.006694
K_1787 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.006677
K_1788 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.006534
K_1789 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.006729
K_1790 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.003078
K_1791 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.003119
K_1792 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.003082
K_1793 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.003100
K_1794 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.007874
K_1795 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.008031
K_1796 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.007869
K_1797 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.007732
K_1798 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.003768
K_1799 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.003793
K_1800 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.003733
K_1801 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.003789
K_1802 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.003502
K_1803 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.003556
K_1804 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.003510
K_1805 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.003510
K_1806 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.006487
K_1807 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.006501
K_1808 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.006329
K_1809 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.006398
K_1810 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.003224
K_1811 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.003257
K_1812 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.003208
K_1813 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.003235
K_1814 X_NUC_26.L_CORE X_NUC_65.L_CORE 0.004317
K_1815 X_NUC_26.L_CORE X_NUC_66.L_CORE 0.004374
K_1816 X_NUC_26.L_CORE X_NUC_67.L_CORE 0.004298
K_1817 X_NUC_26.L_CORE X_NUC_68.L_CORE 0.004293
K_1818 X_NUC_26.L_CORE X_NUC_69.L_CORE 0.004029
K_1819 X_NUC_26.L_CORE X_NUC_70.L_CORE 0.004060
K_1820 X_NUC_26.L_CORE X_NUC_71.L_CORE 0.003983
K_1821 X_NUC_26.L_CORE X_NUC_72.L_CORE 0.004018
K_1822 X_NUC_26.L_CORE X_NUC_73.L_CORE 0.004318
K_1823 X_NUC_26.L_CORE X_NUC_74.L_CORE 0.007800
K_1824 X_NUC_26.L_CORE X_NUC_75.L_CORE 0.003143
K_1825 X_NUC_26.L_CORE X_NUC_76.L_CORE 0.006569
K_1826 X_NUC_26.L_CORE X_NUC_77.L_CORE 0.004321
K_1827 X_NUC_26.L_CORE X_NUC_78.L_CORE 0.003063
K_1828 X_NUC_26.L_CORE X_NUC_79.L_CORE 0.014044
K_1829 X_NUC_26.L_CORE X_NUC_80.L_CORE 0.003006
K_1830 X_NUC_26.L_CORE X_NUC_81.L_CORE 0.003875
K_1831 X_NUC_26.L_CORE X_NUC_82.L_CORE 0.004772
K_1832 X_NUC_26.L_CORE X_NUC_83.L_CORE 0.002934
K_1833 X_NUC_26.L_CORE X_NUC_84.L_CORE 0.004093
K_1834 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_1835 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.003420
K_1836 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.003456
K_1837 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.003414
K_1838 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.003458
K_1839 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.004571
K_1840 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.004666
K_1841 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.004623
K_1842 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.004590
K_1843 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.006844
K_1844 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.006821
K_1845 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.006677
K_1846 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.006881
K_1847 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.003115
K_1848 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.003157
K_1849 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.003119
K_1850 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.003138
K_1851 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.008030
K_1852 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.008190
K_1853 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.008031
K_1854 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.007880
K_1855 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.003830
K_1856 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.003856
K_1857 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.003793
K_1858 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.003852
K_1859 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.003548
K_1860 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.003603
K_1861 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.003556
K_1862 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.003556
K_1863 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.006669
K_1864 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.006681
K_1865 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.006501
K_1866 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.006572
K_1867 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.003273
K_1868 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.003307
K_1869 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.003257
K_1870 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.003284
K_1871 X_NUC_27.L_CORE X_NUC_65.L_CORE 0.004393
K_1872 X_NUC_27.L_CORE X_NUC_66.L_CORE 0.004452
K_1873 X_NUC_27.L_CORE X_NUC_67.L_CORE 0.004374
K_1874 X_NUC_27.L_CORE X_NUC_68.L_CORE 0.004368
K_1875 X_NUC_27.L_CORE X_NUC_69.L_CORE 0.004108
K_1876 X_NUC_27.L_CORE X_NUC_70.L_CORE 0.004140
K_1877 X_NUC_27.L_CORE X_NUC_71.L_CORE 0.004060
K_1878 X_NUC_27.L_CORE X_NUC_72.L_CORE 0.004096
K_1879 X_NUC_27.L_CORE X_NUC_73.L_CORE 0.004323
K_1880 X_NUC_27.L_CORE X_NUC_74.L_CORE 0.007743
K_1881 X_NUC_27.L_CORE X_NUC_75.L_CORE 0.003169
K_1882 X_NUC_27.L_CORE X_NUC_76.L_CORE 0.006546
K_1883 X_NUC_27.L_CORE X_NUC_77.L_CORE 0.004371
K_1884 X_NUC_27.L_CORE X_NUC_78.L_CORE 0.003091
K_1885 X_NUC_27.L_CORE X_NUC_79.L_CORE 0.014293
K_1886 X_NUC_27.L_CORE X_NUC_80.L_CORE 0.003044
K_1887 X_NUC_27.L_CORE X_NUC_81.L_CORE 0.003918
K_1888 X_NUC_27.L_CORE X_NUC_82.L_CORE 0.004866
K_1889 X_NUC_27.L_CORE X_NUC_83.L_CORE 0.002974
K_1890 X_NUC_27.L_CORE X_NUC_84.L_CORE 0.004164
K_1891 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.003377
K_1892 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.003411
K_1893 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.003370
K_1894 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.003414
K_1895 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.004602
K_1896 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.004700
K_1897 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.004655
K_1898 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.004623
K_1899 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.006639
K_1900 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.006619
K_1901 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.006483
K_1902 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.006677
K_1903 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.003096
K_1904 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.003137
K_1905 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.003100
K_1906 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.003119
K_1907 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.008183
K_1908 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.008353
K_1909 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.008178
K_1910 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.008031
K_1911 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.003771
K_1912 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.003796
K_1913 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.003736
K_1914 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.003793
K_1915 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.003547
K_1916 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.003603
K_1917 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.003555
K_1918 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.003556
K_1919 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.006591
K_1920 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.006603
K_1921 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.006426
K_1922 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.006501
K_1923 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.003245
K_1924 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.003279
K_1925 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.003229
K_1926 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.003257
K_1927 X_NUC_28.L_CORE X_NUC_65.L_CORE 0.004398
K_1928 X_NUC_28.L_CORE X_NUC_66.L_CORE 0.004457
K_1929 X_NUC_28.L_CORE X_NUC_67.L_CORE 0.004377
K_1930 X_NUC_28.L_CORE X_NUC_68.L_CORE 0.004374
K_1931 X_NUC_28.L_CORE X_NUC_69.L_CORE 0.004071
K_1932 X_NUC_28.L_CORE X_NUC_70.L_CORE 0.004102
K_1933 X_NUC_28.L_CORE X_NUC_71.L_CORE 0.004023
K_1934 X_NUC_28.L_CORE X_NUC_72.L_CORE 0.004060
K_1935 X_NUC_28.L_CORE X_NUC_73.L_CORE 0.004314
K_1936 X_NUC_28.L_CORE X_NUC_74.L_CORE 0.007565
K_1937 X_NUC_28.L_CORE X_NUC_75.L_CORE 0.003142
K_1938 X_NUC_28.L_CORE X_NUC_76.L_CORE 0.006679
K_1939 X_NUC_28.L_CORE X_NUC_77.L_CORE 0.004282
K_1940 X_NUC_28.L_CORE X_NUC_78.L_CORE 0.003086
K_1941 X_NUC_28.L_CORE X_NUC_79.L_CORE 0.014554
K_1942 X_NUC_28.L_CORE X_NUC_80.L_CORE 0.003010
K_1943 X_NUC_28.L_CORE X_NUC_81.L_CORE 0.003941
K_1944 X_NUC_28.L_CORE X_NUC_82.L_CORE 0.004792
K_1945 X_NUC_28.L_CORE X_NUC_83.L_CORE 0.002959
K_1946 X_NUC_28.L_CORE X_NUC_84.L_CORE 0.004161
K_1947 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_1948 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_1949 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_1950 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.003349
K_1951 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.003352
K_1952 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.003375
K_1953 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.003321
K_1954 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.004566
K_1955 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.004478
K_1956 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.004530
K_1957 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.004490
K_1958 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.006643
K_1959 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.006787
K_1960 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.006728
K_1961 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.006590
K_1962 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.003119
K_1963 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.003101
K_1964 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.003124
K_1965 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.003082
K_1966 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.008033
K_1967 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.007821
K_1968 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.007784
K_1969 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.007766
K_1970 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.003841
K_1971 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.003859
K_1972 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.003860
K_1973 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.003799
K_1974 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.003629
K_1975 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.003589
K_1976 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.003608
K_1977 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.003570
K_1978 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.006335
K_1979 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.006356
K_1980 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.006260
K_1981 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.006187
K_1982 X_NUC_29.L_CORE X_NUC_65.L_CORE 0.003423
K_1983 X_NUC_29.L_CORE X_NUC_66.L_CORE 0.003415
K_1984 X_NUC_29.L_CORE X_NUC_67.L_CORE 0.003420
K_1985 X_NUC_29.L_CORE X_NUC_68.L_CORE 0.003375
K_1986 X_NUC_29.L_CORE X_NUC_69.L_CORE 0.004344
K_1987 X_NUC_29.L_CORE X_NUC_70.L_CORE 0.004309
K_1988 X_NUC_29.L_CORE X_NUC_71.L_CORE 0.004300
K_1989 X_NUC_29.L_CORE X_NUC_72.L_CORE 0.004256
K_1990 X_NUC_29.L_CORE X_NUC_73.L_CORE 0.003953
K_1991 X_NUC_29.L_CORE X_NUC_74.L_CORE 0.003894
K_1992 X_NUC_29.L_CORE X_NUC_75.L_CORE 0.008349
K_1993 X_NUC_29.L_CORE X_NUC_76.L_CORE 0.002973
K_1994 X_NUC_29.L_CORE X_NUC_77.L_CORE 0.006331
K_1995 X_NUC_29.L_CORE X_NUC_78.L_CORE 0.004227
K_1996 X_NUC_29.L_CORE X_NUC_79.L_CORE 0.003021
K_1997 X_NUC_29.L_CORE X_NUC_80.L_CORE 0.012370
K_1998 X_NUC_29.L_CORE X_NUC_81.L_CORE 0.003041
K_1999 X_NUC_29.L_CORE X_NUC_82.L_CORE 0.003898
K_2000 X_NUC_29.L_CORE X_NUC_83.L_CORE 0.004653
K_2001 X_NUC_29.L_CORE X_NUC_84.L_CORE 0.003206
K_2002 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_2003 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_2004 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.003345
K_2005 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.003349
K_2006 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.003371
K_2007 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.003318
K_2008 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.004658
K_2009 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.004566
K_2010 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.004620
K_2011 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.004578
K_2012 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.006501
K_2013 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.006643
K_2014 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.006584
K_2015 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.006454
K_2016 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.003136
K_2017 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.003119
K_2018 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.003141
K_2019 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.003099
K_2020 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.008250
K_2021 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.008033
K_2022 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.007987
K_2023 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.007967
K_2024 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.003821
K_2025 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.003841
K_2026 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.003841
K_2027 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.003781
K_2028 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.003669
K_2029 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.003629
K_2030 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.003648
K_2031 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.003609
K_2032 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.006307
K_2033 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.006335
K_2034 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.006236
K_2035 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.006164
K_2036 X_NUC_30.L_CORE X_NUC_65.L_CORE 0.003431
K_2037 X_NUC_30.L_CORE X_NUC_66.L_CORE 0.003423
K_2038 X_NUC_30.L_CORE X_NUC_67.L_CORE 0.003428
K_2039 X_NUC_30.L_CORE X_NUC_68.L_CORE 0.003382
K_2040 X_NUC_30.L_CORE X_NUC_69.L_CORE 0.004378
K_2041 X_NUC_30.L_CORE X_NUC_70.L_CORE 0.004344
K_2042 X_NUC_30.L_CORE X_NUC_71.L_CORE 0.004333
K_2043 X_NUC_30.L_CORE X_NUC_72.L_CORE 0.004289
K_2044 X_NUC_30.L_CORE X_NUC_73.L_CORE 0.003951
K_2045 X_NUC_30.L_CORE X_NUC_74.L_CORE 0.003945
K_2046 X_NUC_30.L_CORE X_NUC_75.L_CORE 0.008156
K_2047 X_NUC_30.L_CORE X_NUC_76.L_CORE 0.002981
K_2048 X_NUC_30.L_CORE X_NUC_77.L_CORE 0.006529
K_2049 X_NUC_30.L_CORE X_NUC_78.L_CORE 0.004178
K_2050 X_NUC_30.L_CORE X_NUC_79.L_CORE 0.003050
K_2051 X_NUC_30.L_CORE X_NUC_80.L_CORE 0.012297
K_2052 X_NUC_30.L_CORE X_NUC_81.L_CORE 0.003038
K_2053 X_NUC_30.L_CORE X_NUC_82.L_CORE 0.003953
K_2054 X_NUC_30.L_CORE X_NUC_83.L_CORE 0.004619
K_2055 X_NUC_30.L_CORE X_NUC_84.L_CORE 0.003220
K_2056 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_2057 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.003322
K_2058 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.003326
K_2059 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.003349
K_2060 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.003296
K_2061 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.004602
K_2062 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.004512
K_2063 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.004566
K_2064 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.004525
K_2065 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.006555
K_2066 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.006697
K_2067 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.006643
K_2068 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.006507
K_2069 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.003114
K_2070 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.003096
K_2071 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.003119
K_2072 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.003077
K_2073 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.008294
K_2074 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.008067
K_2075 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.008033
K_2076 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.008007
K_2077 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.003821
K_2078 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.003839
K_2079 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.003841
K_2080 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.003780
K_2081 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.003649
K_2082 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.003609
K_2083 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.003629
K_2084 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.003589
K_2085 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.006406
K_2086 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.006431
K_2087 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.006335
K_2088 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.006256
K_2089 X_NUC_31.L_CORE X_NUC_65.L_CORE 0.003426
K_2090 X_NUC_31.L_CORE X_NUC_66.L_CORE 0.003418
K_2091 X_NUC_31.L_CORE X_NUC_67.L_CORE 0.003423
K_2092 X_NUC_31.L_CORE X_NUC_68.L_CORE 0.003377
K_2093 X_NUC_31.L_CORE X_NUC_69.L_CORE 0.004388
K_2094 X_NUC_31.L_CORE X_NUC_70.L_CORE 0.004353
K_2095 X_NUC_31.L_CORE X_NUC_71.L_CORE 0.004344
K_2096 X_NUC_31.L_CORE X_NUC_72.L_CORE 0.004298
K_2097 X_NUC_31.L_CORE X_NUC_73.L_CORE 0.003892
K_2098 X_NUC_31.L_CORE X_NUC_74.L_CORE 0.003875
K_2099 X_NUC_31.L_CORE X_NUC_75.L_CORE 0.008029
K_2100 X_NUC_31.L_CORE X_NUC_76.L_CORE 0.002952
K_2101 X_NUC_31.L_CORE X_NUC_77.L_CORE 0.006409
K_2102 X_NUC_31.L_CORE X_NUC_78.L_CORE 0.004171
K_2103 X_NUC_31.L_CORE X_NUC_79.L_CORE 0.003023
K_2104 X_NUC_31.L_CORE X_NUC_80.L_CORE 0.012972
K_2105 X_NUC_31.L_CORE X_NUC_81.L_CORE 0.003029
K_2106 X_NUC_31.L_CORE X_NUC_82.L_CORE 0.003940
K_2107 X_NUC_31.L_CORE X_NUC_83.L_CORE 0.004668
K_2108 X_NUC_31.L_CORE X_NUC_84.L_CORE 0.003218
K_2109 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.003376
K_2110 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.003380
K_2111 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.003403
K_2112 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.003349
K_2113 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.004644
K_2114 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.004553
K_2115 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.004607
K_2116 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.004566
K_2117 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.006691
K_2118 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.006842
K_2119 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.006781
K_2120 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.006643
K_2121 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.003156
K_2122 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.003138
K_2123 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.003162
K_2124 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.003119
K_2125 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.008316
K_2126 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.008088
K_2127 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.008047
K_2128 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.008033
K_2129 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.003883
K_2130 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.003903
K_2131 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.003903
K_2132 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.003841
K_2133 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.003690
K_2134 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.003649
K_2135 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.003669
K_2136 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.003629
K_2137 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.006487
K_2138 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.006514
K_2139 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.006410
K_2140 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.006335
K_2141 X_NUC_32.L_CORE X_NUC_65.L_CORE 0.003473
K_2142 X_NUC_32.L_CORE X_NUC_66.L_CORE 0.003465
K_2143 X_NUC_32.L_CORE X_NUC_67.L_CORE 0.003470
K_2144 X_NUC_32.L_CORE X_NUC_68.L_CORE 0.003423
K_2145 X_NUC_32.L_CORE X_NUC_69.L_CORE 0.004436
K_2146 X_NUC_32.L_CORE X_NUC_70.L_CORE 0.004400
K_2147 X_NUC_32.L_CORE X_NUC_71.L_CORE 0.004390
K_2148 X_NUC_32.L_CORE X_NUC_72.L_CORE 0.004344
K_2149 X_NUC_32.L_CORE X_NUC_73.L_CORE 0.003951
K_2150 X_NUC_32.L_CORE X_NUC_74.L_CORE 0.003917
K_2151 X_NUC_32.L_CORE X_NUC_75.L_CORE 0.008160
K_2152 X_NUC_32.L_CORE X_NUC_76.L_CORE 0.002993
K_2153 X_NUC_32.L_CORE X_NUC_77.L_CORE 0.006408
K_2154 X_NUC_32.L_CORE X_NUC_78.L_CORE 0.004240
K_2155 X_NUC_32.L_CORE X_NUC_79.L_CORE 0.003056
K_2156 X_NUC_32.L_CORE X_NUC_80.L_CORE 0.012712
K_2157 X_NUC_32.L_CORE X_NUC_81.L_CORE 0.003071
K_2158 X_NUC_32.L_CORE X_NUC_82.L_CORE 0.003968
K_2159 X_NUC_32.L_CORE X_NUC_83.L_CORE 0.004722
K_2160 X_NUC_32.L_CORE X_NUC_84.L_CORE 0.003254
K_2161 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_2162 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_2163 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_2164 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.003328
K_2165 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.003290
K_2166 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.003288
K_2167 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.003325
K_2168 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.004566
K_2169 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.004603
K_2170 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.004527
K_2171 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.004619
K_2172 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.006677
K_2173 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.006482
K_2174 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.006519
K_2175 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.006530
K_2176 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.003160
K_2177 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.003144
K_2178 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.003123
K_2179 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.003166
K_2180 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.008035
K_2181 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.008156
K_2182 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.007851
K_2183 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.008021
K_2184 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.003942
K_2185 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.003885
K_2186 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.003874
K_2187 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.003909
K_2188 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.003765
K_2189 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.003764
K_2190 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.003712
K_2191 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.003771
K_2192 X_NUC_33.L_CORE X_NUC_65.L_CORE 0.006039
K_2193 X_NUC_33.L_CORE X_NUC_66.L_CORE 0.005974
K_2194 X_NUC_33.L_CORE X_NUC_67.L_CORE 0.005874
K_2195 X_NUC_33.L_CORE X_NUC_68.L_CORE 0.005931
K_2196 X_NUC_33.L_CORE X_NUC_69.L_CORE 0.003768
K_2197 X_NUC_33.L_CORE X_NUC_70.L_CORE 0.003740
K_2198 X_NUC_33.L_CORE X_NUC_71.L_CORE 0.003703
K_2199 X_NUC_33.L_CORE X_NUC_72.L_CORE 0.003748
K_2200 X_NUC_33.L_CORE X_NUC_73.L_CORE 0.005275
K_2201 X_NUC_33.L_CORE X_NUC_74.L_CORE 0.003547
K_2202 X_NUC_33.L_CORE X_NUC_75.L_CORE 0.003697
K_2203 X_NUC_33.L_CORE X_NUC_76.L_CORE 0.008397
K_2204 X_NUC_33.L_CORE X_NUC_77.L_CORE 0.002870
K_2205 X_NUC_33.L_CORE X_NUC_78.L_CORE 0.006395
K_2206 X_NUC_33.L_CORE X_NUC_79.L_CORE 0.004121
K_2207 X_NUC_33.L_CORE X_NUC_80.L_CORE 0.003044
K_2208 X_NUC_33.L_CORE X_NUC_81.L_CORE 0.010938
K_2209 X_NUC_33.L_CORE X_NUC_82.L_CORE 0.003114
K_2210 X_NUC_33.L_CORE X_NUC_83.L_CORE 0.004015
K_2211 X_NUC_33.L_CORE X_NUC_84.L_CORE 0.004384
K_2212 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_2213 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_2214 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.003367
K_2215 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.003328
K_2216 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.003326
K_2217 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.003363
K_2218 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.004529
K_2219 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.004566
K_2220 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.004491
K_2221 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.004581
K_2222 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.006882
K_2223 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.006677
K_2224 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.006713
K_2225 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.006726
K_2226 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.003176
K_2227 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.003160
K_2228 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.003139
K_2229 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.003183
K_2230 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.007908
K_2231 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.008035
K_2232 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.007738
K_2233 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.007901
K_2234 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.003999
K_2235 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.003942
K_2236 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.003929
K_2237 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.003965
K_2238 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.003764
K_2239 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.003765
K_2240 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.003712
K_2241 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.003771
K_2242 X_NUC_34.L_CORE X_NUC_65.L_CORE 0.006101
K_2243 X_NUC_34.L_CORE X_NUC_66.L_CORE 0.006039
K_2244 X_NUC_34.L_CORE X_NUC_67.L_CORE 0.005934
K_2245 X_NUC_34.L_CORE X_NUC_68.L_CORE 0.005992
K_2246 X_NUC_34.L_CORE X_NUC_69.L_CORE 0.003795
K_2247 X_NUC_34.L_CORE X_NUC_70.L_CORE 0.003768
K_2248 X_NUC_34.L_CORE X_NUC_71.L_CORE 0.003729
K_2249 X_NUC_34.L_CORE X_NUC_72.L_CORE 0.003775
K_2250 X_NUC_34.L_CORE X_NUC_73.L_CORE 0.005285
K_2251 X_NUC_34.L_CORE X_NUC_74.L_CORE 0.003590
K_2252 X_NUC_34.L_CORE X_NUC_75.L_CORE 0.003685
K_2253 X_NUC_34.L_CORE X_NUC_76.L_CORE 0.008668
K_2254 X_NUC_34.L_CORE X_NUC_77.L_CORE 0.002890
K_2255 X_NUC_34.L_CORE X_NUC_78.L_CORE 0.006250
K_2256 X_NUC_34.L_CORE X_NUC_79.L_CORE 0.004202
K_2257 X_NUC_34.L_CORE X_NUC_80.L_CORE 0.003046
K_2258 X_NUC_34.L_CORE X_NUC_81.L_CORE 0.010903
K_2259 X_NUC_34.L_CORE X_NUC_82.L_CORE 0.003145
K_2260 X_NUC_34.L_CORE X_NUC_83.L_CORE 0.003999
K_2261 X_NUC_34.L_CORE X_NUC_84.L_CORE 0.004427
K_2262 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_2263 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.003368
K_2264 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.003329
K_2265 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.003328
K_2266 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.003365
K_2267 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.004605
K_2268 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.004643
K_2269 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.004566
K_2270 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.004660
K_2271 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.006840
K_2272 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.006634
K_2273 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.006677
K_2274 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.006686
K_2275 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.003198
K_2276 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.003182
K_2277 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.003160
K_2278 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.003205
K_2279 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.008219
K_2280 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.008355
K_2281 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.008035
K_2282 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.008211
K_2283 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.004012
K_2284 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.003953
K_2285 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.003942
K_2286 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.003978
K_2287 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.003818
K_2288 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.003818
K_2289 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.003765
K_2290 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.003825
K_2291 X_NUC_35.L_CORE X_NUC_65.L_CORE 0.006213
K_2292 X_NUC_35.L_CORE X_NUC_66.L_CORE 0.006145
K_2293 X_NUC_35.L_CORE X_NUC_67.L_CORE 0.006039
K_2294 X_NUC_35.L_CORE X_NUC_68.L_CORE 0.006098
K_2295 X_NUC_35.L_CORE X_NUC_69.L_CORE 0.003836
K_2296 X_NUC_35.L_CORE X_NUC_70.L_CORE 0.003807
K_2297 X_NUC_35.L_CORE X_NUC_71.L_CORE 0.003768
K_2298 X_NUC_35.L_CORE X_NUC_72.L_CORE 0.003815
K_2299 X_NUC_35.L_CORE X_NUC_73.L_CORE 0.005230
K_2300 X_NUC_35.L_CORE X_NUC_74.L_CORE 0.003564
K_2301 X_NUC_35.L_CORE X_NUC_75.L_CORE 0.003703
K_2302 X_NUC_35.L_CORE X_NUC_76.L_CORE 0.008346
K_2303 X_NUC_35.L_CORE X_NUC_77.L_CORE 0.002894
K_2304 X_NUC_35.L_CORE X_NUC_78.L_CORE 0.006380
K_2305 X_NUC_35.L_CORE X_NUC_79.L_CORE 0.004176
K_2306 X_NUC_35.L_CORE X_NUC_80.L_CORE 0.003073
K_2307 X_NUC_35.L_CORE X_NUC_81.L_CORE 0.011294
K_2308 X_NUC_35.L_CORE X_NUC_82.L_CORE 0.003157
K_2309 X_NUC_35.L_CORE X_NUC_83.L_CORE 0.004071
K_2310 X_NUC_35.L_CORE X_NUC_84.L_CORE 0.004477
K_2311 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.003331
K_2312 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.003293
K_2313 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.003291
K_2314 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.003328
K_2315 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.004513
K_2316 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.004550
K_2317 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.004477
K_2318 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.004566
K_2319 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.006826
K_2320 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.006622
K_2321 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.006661
K_2322 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.006677
K_2323 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.003154
K_2324 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.003138
K_2325 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.003117
K_2326 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.003160
K_2327 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.008037
K_2328 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.008164
K_2329 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.007858
K_2330 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.008035
K_2331 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.003974
K_2332 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.003917
K_2333 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.003905
K_2334 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.003942
K_2335 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.003757
K_2336 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.003757
K_2337 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.003705
K_2338 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.003765
K_2339 X_NUC_36.L_CORE X_NUC_65.L_CORE 0.006148
K_2340 X_NUC_36.L_CORE X_NUC_66.L_CORE 0.006082
K_2341 X_NUC_36.L_CORE X_NUC_67.L_CORE 0.005977
K_2342 X_NUC_36.L_CORE X_NUC_68.L_CORE 0.006039
K_2343 X_NUC_36.L_CORE X_NUC_69.L_CORE 0.003787
K_2344 X_NUC_36.L_CORE X_NUC_70.L_CORE 0.003760
K_2345 X_NUC_36.L_CORE X_NUC_71.L_CORE 0.003722
K_2346 X_NUC_36.L_CORE X_NUC_72.L_CORE 0.003768
K_2347 X_NUC_36.L_CORE X_NUC_73.L_CORE 0.005168
K_2348 X_NUC_36.L_CORE X_NUC_74.L_CORE 0.003532
K_2349 X_NUC_36.L_CORE X_NUC_75.L_CORE 0.003644
K_2350 X_NUC_36.L_CORE X_NUC_76.L_CORE 0.008422
K_2351 X_NUC_36.L_CORE X_NUC_77.L_CORE 0.002859
K_2352 X_NUC_36.L_CORE X_NUC_78.L_CORE 0.006253
K_2353 X_NUC_36.L_CORE X_NUC_79.L_CORE 0.004159
K_2354 X_NUC_36.L_CORE X_NUC_80.L_CORE 0.003028
K_2355 X_NUC_36.L_CORE X_NUC_81.L_CORE 0.011379
K_2356 X_NUC_36.L_CORE X_NUC_82.L_CORE 0.003127
K_2357 X_NUC_36.L_CORE X_NUC_83.L_CORE 0.004011
K_2358 X_NUC_36.L_CORE X_NUC_84.L_CORE 0.004444
K_2359 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_2360 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_2361 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_2362 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.003349
K_2363 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.003403
K_2364 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.003374
K_2365 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.003373
K_2366 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.004623
K_2367 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.004659
K_2368 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.004676
K_2369 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.004582
K_2370 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.006781
K_2371 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.006949
K_2372 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.006742
K_2373 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.006866
K_2374 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.003249
K_2375 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.003293
K_2376 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.003274
K_2377 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.003251
K_2378 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.008021
K_2379 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.008073
K_2380 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.007991
K_2381 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.007793
K_2382 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.004111
K_2383 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.004184
K_2384 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.004116
K_2385 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.004125
K_2386 X_NUC_37.L_CORE X_NUC_65.L_CORE 0.003992
K_2387 X_NUC_37.L_CORE X_NUC_66.L_CORE 0.004040
K_2388 X_NUC_37.L_CORE X_NUC_67.L_CORE 0.004011
K_2389 X_NUC_37.L_CORE X_NUC_68.L_CORE 0.003965
K_2390 X_NUC_37.L_CORE X_NUC_69.L_CORE 0.005488
K_2391 X_NUC_37.L_CORE X_NUC_70.L_CORE 0.005575
K_2392 X_NUC_37.L_CORE X_NUC_71.L_CORE 0.005459
K_2393 X_NUC_37.L_CORE X_NUC_72.L_CORE 0.005439
K_2394 X_NUC_37.L_CORE X_NUC_73.L_CORE 0.003388
K_2395 X_NUC_37.L_CORE X_NUC_74.L_CORE 0.006159
K_2396 X_NUC_37.L_CORE X_NUC_75.L_CORE 0.003407
K_2397 X_NUC_37.L_CORE X_NUC_76.L_CORE 0.003584
K_2398 X_NUC_37.L_CORE X_NUC_77.L_CORE 0.008839
K_2399 X_NUC_37.L_CORE X_NUC_78.L_CORE 0.002864
K_2400 X_NUC_37.L_CORE X_NUC_79.L_CORE 0.006305
K_2401 X_NUC_37.L_CORE X_NUC_80.L_CORE 0.004233
K_2402 X_NUC_37.L_CORE X_NUC_81.L_CORE 0.003133
K_2403 X_NUC_37.L_CORE X_NUC_82.L_CORE 0.009555
K_2404 X_NUC_37.L_CORE X_NUC_83.L_CORE 0.003344
K_2405 X_NUC_37.L_CORE X_NUC_84.L_CORE 0.004171
K_2406 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_2407 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_2408 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.003296
K_2409 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.003349
K_2410 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.003320
K_2411 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.003319
K_2412 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.004586
K_2413 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.004623
K_2414 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.004639
K_2415 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.004546
K_2416 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.006618
K_2417 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.006781
K_2418 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.006585
K_2419 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.006700
K_2420 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.003206
K_2421 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.003249
K_2422 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.003230
K_2423 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.003208
K_2424 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.007959
K_2425 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.008021
K_2426 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.007935
K_2427 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.007741
K_2428 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.004040
K_2429 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.004111
K_2430 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.004046
K_2431 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.004054
K_2432 X_NUC_38.L_CORE X_NUC_65.L_CORE 0.003944
K_2433 X_NUC_38.L_CORE X_NUC_66.L_CORE 0.003992
K_2434 X_NUC_38.L_CORE X_NUC_67.L_CORE 0.003963
K_2435 X_NUC_38.L_CORE X_NUC_68.L_CORE 0.003919
K_2436 X_NUC_38.L_CORE X_NUC_69.L_CORE 0.005401
K_2437 X_NUC_38.L_CORE X_NUC_70.L_CORE 0.005488
K_2438 X_NUC_38.L_CORE X_NUC_71.L_CORE 0.005375
K_2439 X_NUC_38.L_CORE X_NUC_72.L_CORE 0.005356
K_2440 X_NUC_38.L_CORE X_NUC_73.L_CORE 0.003351
K_2441 X_NUC_38.L_CORE X_NUC_74.L_CORE 0.006135
K_2442 X_NUC_38.L_CORE X_NUC_75.L_CORE 0.003357
K_2443 X_NUC_38.L_CORE X_NUC_76.L_CORE 0.003557
K_2444 X_NUC_38.L_CORE X_NUC_77.L_CORE 0.008703
K_2445 X_NUC_38.L_CORE X_NUC_78.L_CORE 0.002827
K_2446 X_NUC_38.L_CORE X_NUC_79.L_CORE 0.006326
K_2447 X_NUC_38.L_CORE X_NUC_80.L_CORE 0.004160
K_2448 X_NUC_38.L_CORE X_NUC_81.L_CORE 0.003101
K_2449 X_NUC_38.L_CORE X_NUC_82.L_CORE 0.009536
K_2450 X_NUC_38.L_CORE X_NUC_83.L_CORE 0.003296
K_2451 X_NUC_38.L_CORE X_NUC_84.L_CORE 0.004132
K_2452 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_2453 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.003323
K_2454 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.003377
K_2455 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.003349
K_2456 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.003347
K_2457 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.004569
K_2458 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.004605
K_2459 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.004623
K_2460 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.004530
K_2461 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.006813
K_2462 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.006987
K_2463 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.006781
K_2464 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.006903
K_2465 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.003224
K_2466 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.003268
K_2467 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.003249
K_2468 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.003226
K_2469 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.008040
K_2470 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.008098
K_2471 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.008021
K_2472 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.007816
K_2473 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.004104
K_2474 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.004178
K_2475 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.004111
K_2476 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.004119
K_2477 X_NUC_39.L_CORE X_NUC_65.L_CORE 0.003972
K_2478 X_NUC_39.L_CORE X_NUC_66.L_CORE 0.004019
K_2479 X_NUC_39.L_CORE X_NUC_67.L_CORE 0.003992
K_2480 X_NUC_39.L_CORE X_NUC_68.L_CORE 0.003946
K_2481 X_NUC_39.L_CORE X_NUC_69.L_CORE 0.005513
K_2482 X_NUC_39.L_CORE X_NUC_70.L_CORE 0.005603
K_2483 X_NUC_39.L_CORE X_NUC_71.L_CORE 0.005488
K_2484 X_NUC_39.L_CORE X_NUC_72.L_CORE 0.005465
K_2485 X_NUC_39.L_CORE X_NUC_73.L_CORE 0.003335
K_2486 X_NUC_39.L_CORE X_NUC_74.L_CORE 0.006000
K_2487 X_NUC_39.L_CORE X_NUC_75.L_CORE 0.003369
K_2488 X_NUC_39.L_CORE X_NUC_76.L_CORE 0.003532
K_2489 X_NUC_39.L_CORE X_NUC_77.L_CORE 0.008786
K_2490 X_NUC_39.L_CORE X_NUC_78.L_CORE 0.002838
K_2491 X_NUC_39.L_CORE X_NUC_79.L_CORE 0.006228
K_2492 X_NUC_39.L_CORE X_NUC_80.L_CORE 0.004226
K_2493 X_NUC_39.L_CORE X_NUC_81.L_CORE 0.003108
K_2494 X_NUC_39.L_CORE X_NUC_82.L_CORE 0.009861
K_2495 X_NUC_39.L_CORE X_NUC_83.L_CORE 0.003335
K_2496 X_NUC_39.L_CORE X_NUC_84.L_CORE 0.004170
K_2497 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.003325
K_2498 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.003379
K_2499 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.003350
K_2500 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.003349
K_2501 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.004664
K_2502 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.004701
K_2503 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.004719
K_2504 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.004623
K_2505 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.006692
K_2506 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.006857
K_2507 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.006658
K_2508 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.006781
K_2509 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.003246
K_2510 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.003291
K_2511 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.003271
K_2512 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.003249
K_2513 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.008258
K_2514 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.008321
K_2515 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.008231
K_2516 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.008021
K_2517 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.004095
K_2518 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.004168
K_2519 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.004101
K_2520 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.004111
K_2521 X_NUC_40.L_CORE X_NUC_65.L_CORE 0.004018
K_2522 X_NUC_40.L_CORE X_NUC_66.L_CORE 0.004067
K_2523 X_NUC_40.L_CORE X_NUC_67.L_CORE 0.004038
K_2524 X_NUC_40.L_CORE X_NUC_68.L_CORE 0.003992
K_2525 X_NUC_40.L_CORE X_NUC_69.L_CORE 0.005533
K_2526 X_NUC_40.L_CORE X_NUC_70.L_CORE 0.005625
K_2527 X_NUC_40.L_CORE X_NUC_71.L_CORE 0.005506
K_2528 X_NUC_40.L_CORE X_NUC_72.L_CORE 0.005488
K_2529 X_NUC_40.L_CORE X_NUC_73.L_CORE 0.003356
K_2530 X_NUC_40.L_CORE X_NUC_74.L_CORE 0.006059
K_2531 X_NUC_40.L_CORE X_NUC_75.L_CORE 0.003362
K_2532 X_NUC_40.L_CORE X_NUC_76.L_CORE 0.003582
K_2533 X_NUC_40.L_CORE X_NUC_77.L_CORE 0.008506
K_2534 X_NUC_40.L_CORE X_NUC_78.L_CORE 0.002849
K_2535 X_NUC_40.L_CORE X_NUC_79.L_CORE 0.006419
K_2536 X_NUC_40.L_CORE X_NUC_80.L_CORE 0.004185
K_2537 X_NUC_40.L_CORE X_NUC_81.L_CORE 0.003141
K_2538 X_NUC_40.L_CORE X_NUC_82.L_CORE 0.009870
K_2539 X_NUC_40.L_CORE X_NUC_83.L_CORE 0.003338
K_2540 X_NUC_40.L_CORE X_NUC_84.L_CORE 0.004216
K_2541 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_2542 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_2543 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_2544 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.003414
K_2545 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.003372
K_2546 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.003408
K_2547 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.003372
K_2548 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.004743
K_2549 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.004648
K_2550 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.004660
K_2551 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.004704
K_2552 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.006963
K_2553 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.006908
K_2554 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.006976
K_2555 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.006774
K_2556 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.003399
K_2557 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.003347
K_2558 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.003370
K_2559 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.003356
K_2560 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.007955
K_2561 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.007760
K_2562 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.007672
K_2563 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.007747
K_2564 X_NUC_41.L_CORE X_NUC_65.L_CORE 0.004382
K_2565 X_NUC_41.L_CORE X_NUC_66.L_CORE 0.004325
K_2566 X_NUC_41.L_CORE X_NUC_67.L_CORE 0.004351
K_2567 X_NUC_41.L_CORE X_NUC_68.L_CORE 0.004295
K_2568 X_NUC_41.L_CORE X_NUC_69.L_CORE 0.004405
K_2569 X_NUC_41.L_CORE X_NUC_70.L_CORE 0.004329
K_2570 X_NUC_41.L_CORE X_NUC_71.L_CORE 0.004335
K_2571 X_NUC_41.L_CORE X_NUC_72.L_CORE 0.004328
K_2572 X_NUC_41.L_CORE X_NUC_73.L_CORE 0.004028
K_2573 X_NUC_41.L_CORE X_NUC_74.L_CORE 0.003036
K_2574 X_NUC_41.L_CORE X_NUC_75.L_CORE 0.006751
K_2575 X_NUC_41.L_CORE X_NUC_76.L_CORE 0.003278
K_2576 X_NUC_41.L_CORE X_NUC_77.L_CORE 0.003500
K_2577 X_NUC_41.L_CORE X_NUC_78.L_CORE 0.009112
K_2578 X_NUC_41.L_CORE X_NUC_79.L_CORE 0.002849
K_2579 X_NUC_41.L_CORE X_NUC_80.L_CORE 0.006351
K_2580 X_NUC_41.L_CORE X_NUC_81.L_CORE 0.004297
K_2581 X_NUC_41.L_CORE X_NUC_82.L_CORE 0.003245
K_2582 X_NUC_41.L_CORE X_NUC_83.L_CORE 0.008095
K_2583 X_NUC_41.L_CORE X_NUC_84.L_CORE 0.003710
K_2584 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_2585 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_2586 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.003456
K_2587 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.003414
K_2588 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.003451
K_2589 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.003413
K_2590 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.004841
K_2591 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.004743
K_2592 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.004754
K_2593 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.004801
K_2594 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.007011
K_2595 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.006963
K_2596 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.007029
K_2597 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.006822
K_2598 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.003451
K_2599 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.003399
K_2600 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.003422
K_2601 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.003407
K_2602 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.008153
K_2603 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.007955
K_2604 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.007855
K_2605 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.007936
K_2606 X_NUC_42.L_CORE X_NUC_65.L_CORE 0.004439
K_2607 X_NUC_42.L_CORE X_NUC_66.L_CORE 0.004382
K_2608 X_NUC_42.L_CORE X_NUC_67.L_CORE 0.004408
K_2609 X_NUC_42.L_CORE X_NUC_68.L_CORE 0.004350
K_2610 X_NUC_42.L_CORE X_NUC_69.L_CORE 0.004484
K_2611 X_NUC_42.L_CORE X_NUC_70.L_CORE 0.004405
K_2612 X_NUC_42.L_CORE X_NUC_71.L_CORE 0.004410
K_2613 X_NUC_42.L_CORE X_NUC_72.L_CORE 0.004403
K_2614 X_NUC_42.L_CORE X_NUC_73.L_CORE 0.004058
K_2615 X_NUC_42.L_CORE X_NUC_74.L_CORE 0.003074
K_2616 X_NUC_42.L_CORE X_NUC_75.L_CORE 0.006796
K_2617 X_NUC_42.L_CORE X_NUC_76.L_CORE 0.003308
K_2618 X_NUC_42.L_CORE X_NUC_77.L_CORE 0.003554
K_2619 X_NUC_42.L_CORE X_NUC_78.L_CORE 0.008980
K_2620 X_NUC_42.L_CORE X_NUC_79.L_CORE 0.002885
K_2621 X_NUC_42.L_CORE X_NUC_80.L_CORE 0.006469
K_2622 X_NUC_42.L_CORE X_NUC_81.L_CORE 0.004326
K_2623 X_NUC_42.L_CORE X_NUC_82.L_CORE 0.003295
K_2624 X_NUC_42.L_CORE X_NUC_83.L_CORE 0.008173
K_2625 X_NUC_42.L_CORE X_NUC_84.L_CORE 0.003756
K_2626 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_2627 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.003418
K_2628 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.003377
K_2629 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.003414
K_2630 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.003377
K_2631 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.004828
K_2632 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.004730
K_2633 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.004743
K_2634 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.004788
K_2635 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.006941
K_2636 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.006891
K_2637 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.006963
K_2638 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.006758
K_2639 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.003427
K_2640 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.003375
K_2641 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.003399
K_2642 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.003384
K_2643 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.008259
K_2644 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.008047
K_2645 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.007955
K_2646 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.008033
K_2647 X_NUC_43.L_CORE X_NUC_65.L_CORE 0.004412
K_2648 X_NUC_43.L_CORE X_NUC_66.L_CORE 0.004354
K_2649 X_NUC_43.L_CORE X_NUC_67.L_CORE 0.004382
K_2650 X_NUC_43.L_CORE X_NUC_68.L_CORE 0.004324
K_2651 X_NUC_43.L_CORE X_NUC_69.L_CORE 0.004477
K_2652 X_NUC_43.L_CORE X_NUC_70.L_CORE 0.004398
K_2653 X_NUC_43.L_CORE X_NUC_71.L_CORE 0.004405
K_2654 X_NUC_43.L_CORE X_NUC_72.L_CORE 0.004397
K_2655 X_NUC_43.L_CORE X_NUC_73.L_CORE 0.003981
K_2656 X_NUC_43.L_CORE X_NUC_74.L_CORE 0.003035
K_2657 X_NUC_43.L_CORE X_NUC_75.L_CORE 0.006664
K_2658 X_NUC_43.L_CORE X_NUC_76.L_CORE 0.003261
K_2659 X_NUC_43.L_CORE X_NUC_77.L_CORE 0.003526
K_2660 X_NUC_43.L_CORE X_NUC_78.L_CORE 0.008779
K_2661 X_NUC_43.L_CORE X_NUC_79.L_CORE 0.002858
K_2662 X_NUC_43.L_CORE X_NUC_80.L_CORE 0.006508
K_2663 X_NUC_43.L_CORE X_NUC_81.L_CORE 0.004285
K_2664 X_NUC_43.L_CORE X_NUC_82.L_CORE 0.003280
K_2665 X_NUC_43.L_CORE X_NUC_83.L_CORE 0.008342
K_2666 X_NUC_43.L_CORE X_NUC_84.L_CORE 0.003744
K_2667 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.003456
K_2668 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.003413
K_2669 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.003450
K_2670 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.003414
K_2671 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.004780
K_2672 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.004685
K_2673 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.004697
K_2674 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.004743
K_2675 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.007159
K_2676 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.007104
K_2677 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.007178
K_2678 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.006963
K_2679 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.003442
K_2680 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.003389
K_2681 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.003413
K_2682 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.003399
K_2683 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.008168
K_2684 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.007963
K_2685 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.007868
K_2686 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.007955
K_2687 X_NUC_44.L_CORE X_NUC_65.L_CORE 0.004472
K_2688 X_NUC_44.L_CORE X_NUC_66.L_CORE 0.004412
K_2689 X_NUC_44.L_CORE X_NUC_67.L_CORE 0.004440
K_2690 X_NUC_44.L_CORE X_NUC_68.L_CORE 0.004382
K_2691 X_NUC_44.L_CORE X_NUC_69.L_CORE 0.004485
K_2692 X_NUC_44.L_CORE X_NUC_70.L_CORE 0.004406
K_2693 X_NUC_44.L_CORE X_NUC_71.L_CORE 0.004412
K_2694 X_NUC_44.L_CORE X_NUC_72.L_CORE 0.004405
K_2695 X_NUC_44.L_CORE X_NUC_73.L_CORE 0.004015
K_2696 X_NUC_44.L_CORE X_NUC_74.L_CORE 0.003042
K_2697 X_NUC_44.L_CORE X_NUC_75.L_CORE 0.006600
K_2698 X_NUC_44.L_CORE X_NUC_76.L_CORE 0.003300
K_2699 X_NUC_44.L_CORE X_NUC_77.L_CORE 0.003506
K_2700 X_NUC_44.L_CORE X_NUC_78.L_CORE 0.009108
K_2701 X_NUC_44.L_CORE X_NUC_79.L_CORE 0.002875
K_2702 X_NUC_44.L_CORE X_NUC_80.L_CORE 0.006351
K_2703 X_NUC_44.L_CORE X_NUC_81.L_CORE 0.004368
K_2704 X_NUC_44.L_CORE X_NUC_82.L_CORE 0.003279
K_2705 X_NUC_44.L_CORE X_NUC_83.L_CORE 0.008372
K_2706 X_NUC_44.L_CORE X_NUC_84.L_CORE 0.003775
K_2707 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_2708 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_2709 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_2710 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.003530
K_2711 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.003537
K_2712 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.003501
K_2713 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.003561
K_2714 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.004942
K_2715 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.005054
K_2716 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.004962
K_2717 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.004999
K_2718 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.007237
K_2719 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.007136
K_2720 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.007019
K_2721 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.007219
K_2722 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.003639
K_2723 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.003671
K_2724 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.003617
K_2725 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.003670
K_2726 X_NUC_45.L_CORE X_NUC_65.L_CORE 0.007751
K_2727 X_NUC_45.L_CORE X_NUC_66.L_CORE 0.007929
K_2728 X_NUC_45.L_CORE X_NUC_67.L_CORE 0.007640
K_2729 X_NUC_45.L_CORE X_NUC_68.L_CORE 0.007746
K_2730 X_NUC_45.L_CORE X_NUC_69.L_CORE 0.004846
K_2731 X_NUC_45.L_CORE X_NUC_70.L_CORE 0.004863
K_2732 X_NUC_45.L_CORE X_NUC_71.L_CORE 0.004767
K_2733 X_NUC_45.L_CORE X_NUC_72.L_CORE 0.004860
K_2734 X_NUC_45.L_CORE X_NUC_73.L_CORE 0.003779
K_2735 X_NUC_45.L_CORE X_NUC_74.L_CORE 0.004131
K_2736 X_NUC_45.L_CORE X_NUC_75.L_CORE 0.002937
K_2737 X_NUC_45.L_CORE X_NUC_76.L_CORE 0.007343
K_2738 X_NUC_45.L_CORE X_NUC_77.L_CORE 0.003272
K_2739 X_NUC_45.L_CORE X_NUC_78.L_CORE 0.003578
K_2740 X_NUC_45.L_CORE X_NUC_79.L_CORE 0.009225
K_2741 X_NUC_45.L_CORE X_NUC_80.L_CORE 0.002956
K_2742 X_NUC_45.L_CORE X_NUC_81.L_CORE 0.006715
K_2743 X_NUC_45.L_CORE X_NUC_82.L_CORE 0.004513
K_2744 X_NUC_45.L_CORE X_NUC_83.L_CORE 0.003575
K_2745 X_NUC_45.L_CORE X_NUC_84.L_CORE 0.006515
K_2746 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_2747 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_2748 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.003523
K_2749 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.003530
K_2750 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.003495
K_2751 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.003554
K_2752 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.004834
K_2753 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.004942
K_2754 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.004855
K_2755 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.004889
K_2756 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.007333
K_2757 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.007237
K_2758 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.007111
K_2759 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.007319
K_2760 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.003607
K_2761 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.003639
K_2762 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.003586
K_2763 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.003637
K_2764 X_NUC_46.L_CORE X_NUC_65.L_CORE 0.007574
K_2765 X_NUC_46.L_CORE X_NUC_66.L_CORE 0.007751
K_2766 X_NUC_46.L_CORE X_NUC_67.L_CORE 0.007476
K_2767 X_NUC_46.L_CORE X_NUC_68.L_CORE 0.007575
K_2768 X_NUC_46.L_CORE X_NUC_69.L_CORE 0.004827
K_2769 X_NUC_46.L_CORE X_NUC_70.L_CORE 0.004846
K_2770 X_NUC_46.L_CORE X_NUC_71.L_CORE 0.004750
K_2771 X_NUC_46.L_CORE X_NUC_72.L_CORE 0.004842
K_2772 X_NUC_46.L_CORE X_NUC_73.L_CORE 0.003746
K_2773 X_NUC_46.L_CORE X_NUC_74.L_CORE 0.004149
K_2774 X_NUC_46.L_CORE X_NUC_75.L_CORE 0.002914
K_2775 X_NUC_46.L_CORE X_NUC_76.L_CORE 0.007251
K_2776 X_NUC_46.L_CORE X_NUC_77.L_CORE 0.003278
K_2777 X_NUC_46.L_CORE X_NUC_78.L_CORE 0.003523
K_2778 X_NUC_46.L_CORE X_NUC_79.L_CORE 0.009601
K_2779 X_NUC_46.L_CORE X_NUC_80.L_CORE 0.002940
K_2780 X_NUC_46.L_CORE X_NUC_81.L_CORE 0.006513
K_2781 X_NUC_46.L_CORE X_NUC_82.L_CORE 0.004545
K_2782 X_NUC_46.L_CORE X_NUC_83.L_CORE 0.003534
K_2783 X_NUC_46.L_CORE X_NUC_84.L_CORE 0.006468
K_2784 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_2785 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.003559
K_2786 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.003566
K_2787 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.003530
K_2788 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.003591
K_2789 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.004918
K_2790 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.005030
K_2791 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.004942
K_2792 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.004976
K_2793 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.007466
K_2794 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.007361
K_2795 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.007237
K_2796 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.007452
K_2797 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.003660
K_2798 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.003694
K_2799 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.003639
K_2800 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.003692
K_2801 X_NUC_47.L_CORE X_NUC_65.L_CORE 0.007854
K_2802 X_NUC_47.L_CORE X_NUC_66.L_CORE 0.008046
K_2803 X_NUC_47.L_CORE X_NUC_67.L_CORE 0.007751
K_2804 X_NUC_47.L_CORE X_NUC_68.L_CORE 0.007856
K_2805 X_NUC_47.L_CORE X_NUC_69.L_CORE 0.004927
K_2806 X_NUC_47.L_CORE X_NUC_70.L_CORE 0.004946
K_2807 X_NUC_47.L_CORE X_NUC_71.L_CORE 0.004846
K_2808 X_NUC_47.L_CORE X_NUC_72.L_CORE 0.004943
K_2809 X_NUC_47.L_CORE X_NUC_73.L_CORE 0.003734
K_2810 X_NUC_47.L_CORE X_NUC_74.L_CORE 0.004119
K_2811 X_NUC_47.L_CORE X_NUC_75.L_CORE 0.002927
K_2812 X_NUC_47.L_CORE X_NUC_76.L_CORE 0.007106
K_2813 X_NUC_47.L_CORE X_NUC_77.L_CORE 0.003289
K_2814 X_NUC_47.L_CORE X_NUC_78.L_CORE 0.003551
K_2815 X_NUC_47.L_CORE X_NUC_79.L_CORE 0.009409
K_2816 X_NUC_47.L_CORE X_NUC_80.L_CORE 0.002968
K_2817 X_NUC_47.L_CORE X_NUC_81.L_CORE 0.006632
K_2818 X_NUC_47.L_CORE X_NUC_82.L_CORE 0.004596
K_2819 X_NUC_47.L_CORE X_NUC_83.L_CORE 0.003589
K_2820 X_NUC_47.L_CORE X_NUC_84.L_CORE 0.006666
K_2821 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.003500
K_2822 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.003507
K_2823 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.003472
K_2824 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.003530
K_2825 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.004883
K_2826 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.004993
K_2827 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.004905
K_2828 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.004942
K_2829 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.007246
K_2830 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.007149
K_2831 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.007031
K_2832 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.007237
K_2833 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.003608
K_2834 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.003640
K_2835 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.003587
K_2836 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.003639
K_2837 X_NUC_48.L_CORE X_NUC_65.L_CORE 0.007744
K_2838 X_NUC_48.L_CORE X_NUC_66.L_CORE 0.007927
K_2839 X_NUC_48.L_CORE X_NUC_67.L_CORE 0.007639
K_2840 X_NUC_48.L_CORE X_NUC_68.L_CORE 0.007751
K_2841 X_NUC_48.L_CORE X_NUC_69.L_CORE 0.004830
K_2842 X_NUC_48.L_CORE X_NUC_70.L_CORE 0.004848
K_2843 X_NUC_48.L_CORE X_NUC_71.L_CORE 0.004753
K_2844 X_NUC_48.L_CORE X_NUC_72.L_CORE 0.004846
K_2845 X_NUC_48.L_CORE X_NUC_73.L_CORE 0.003713
K_2846 X_NUC_48.L_CORE X_NUC_74.L_CORE 0.004072
K_2847 X_NUC_48.L_CORE X_NUC_75.L_CORE 0.002899
K_2848 X_NUC_48.L_CORE X_NUC_76.L_CORE 0.007169
K_2849 X_NUC_48.L_CORE X_NUC_77.L_CORE 0.003240
K_2850 X_NUC_48.L_CORE X_NUC_78.L_CORE 0.003531
K_2851 X_NUC_48.L_CORE X_NUC_79.L_CORE 0.009246
K_2852 X_NUC_48.L_CORE X_NUC_80.L_CORE 0.002929
K_2853 X_NUC_48.L_CORE X_NUC_81.L_CORE 0.006661
K_2854 X_NUC_48.L_CORE X_NUC_82.L_CORE 0.004506
K_2855 X_NUC_48.L_CORE X_NUC_83.L_CORE 0.003550
K_2856 X_NUC_48.L_CORE X_NUC_84.L_CORE 0.006569
K_2857 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_2858 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_2859 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_2860 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.003716
K_2861 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.003755
K_2862 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.003760
K_2863 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.003705
K_2864 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.005249
K_2865 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.005188
K_2866 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.005257
K_2867 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.005145
K_2868 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.007621
K_2869 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.007852
K_2870 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.007709
K_2871 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.007590
K_2872 X_NUC_49.L_CORE X_NUC_65.L_CORE 0.004044
K_2873 X_NUC_49.L_CORE X_NUC_66.L_CORE 0.004057
K_2874 X_NUC_49.L_CORE X_NUC_67.L_CORE 0.004071
K_2875 X_NUC_49.L_CORE X_NUC_68.L_CORE 0.003998
K_2876 X_NUC_49.L_CORE X_NUC_69.L_CORE 0.007144
K_2877 X_NUC_49.L_CORE X_NUC_70.L_CORE 0.007138
K_2878 X_NUC_49.L_CORE X_NUC_71.L_CORE 0.007122
K_2879 X_NUC_49.L_CORE X_NUC_72.L_CORE 0.006942
K_2880 X_NUC_49.L_CORE X_NUC_73.L_CORE 0.003113
K_2881 X_NUC_49.L_CORE X_NUC_74.L_CORE 0.003801
K_2882 X_NUC_49.L_CORE X_NUC_75.L_CORE 0.004233
K_2883 X_NUC_49.L_CORE X_NUC_76.L_CORE 0.002886
K_2884 X_NUC_49.L_CORE X_NUC_77.L_CORE 0.007687
K_2885 X_NUC_49.L_CORE X_NUC_78.L_CORE 0.003341
K_2886 X_NUC_49.L_CORE X_NUC_79.L_CORE 0.003629
K_2887 X_NUC_49.L_CORE X_NUC_80.L_CORE 0.010143
K_2888 X_NUC_49.L_CORE X_NUC_81.L_CORE 0.003112
K_2889 X_NUC_49.L_CORE X_NUC_82.L_CORE 0.006857
K_2890 X_NUC_49.L_CORE X_NUC_83.L_CORE 0.004942
K_2891 X_NUC_49.L_CORE X_NUC_84.L_CORE 0.004157
K_2892 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_2893 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_2894 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.003678
K_2895 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.003716
K_2896 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.003720
K_2897 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.003667
K_2898 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.005310
K_2899 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.005249
K_2900 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.005320
K_2901 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.005204
K_2902 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.007400
K_2903 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.007621
K_2904 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.007485
K_2905 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.007376
K_2906 X_NUC_50.L_CORE X_NUC_65.L_CORE 0.004028
K_2907 X_NUC_50.L_CORE X_NUC_66.L_CORE 0.004044
K_2908 X_NUC_50.L_CORE X_NUC_67.L_CORE 0.004056
K_2909 X_NUC_50.L_CORE X_NUC_68.L_CORE 0.003984
K_2910 X_NUC_50.L_CORE X_NUC_69.L_CORE 0.007141
K_2911 X_NUC_50.L_CORE X_NUC_70.L_CORE 0.007144
K_2912 X_NUC_50.L_CORE X_NUC_71.L_CORE 0.007124
K_2913 X_NUC_50.L_CORE X_NUC_72.L_CORE 0.006944
K_2914 X_NUC_50.L_CORE X_NUC_73.L_CORE 0.003099
K_2915 X_NUC_50.L_CORE X_NUC_74.L_CORE 0.003824
K_2916 X_NUC_50.L_CORE X_NUC_75.L_CORE 0.004176
K_2917 X_NUC_50.L_CORE X_NUC_76.L_CORE 0.002884
K_2918 X_NUC_50.L_CORE X_NUC_77.L_CORE 0.007840
K_2919 X_NUC_50.L_CORE X_NUC_78.L_CORE 0.003302
K_2920 X_NUC_50.L_CORE X_NUC_79.L_CORE 0.003659
K_2921 X_NUC_50.L_CORE X_NUC_80.L_CORE 0.009701
K_2922 X_NUC_50.L_CORE X_NUC_81.L_CORE 0.003096
K_2923 X_NUC_50.L_CORE X_NUC_82.L_CORE 0.007027
K_2924 X_NUC_50.L_CORE X_NUC_83.L_CORE 0.004853
K_2925 X_NUC_50.L_CORE X_NUC_84.L_CORE 0.004156
K_2926 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_2927 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.003673
K_2928 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.003711
K_2929 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.003716
K_2930 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.003663
K_2931 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.005238
K_2932 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.005179
K_2933 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.005249
K_2934 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.005137
K_2935 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.007527
K_2936 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.007755
K_2937 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.007621
K_2938 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.007502
K_2939 X_NUC_51.L_CORE X_NUC_65.L_CORE 0.004015
K_2940 X_NUC_51.L_CORE X_NUC_66.L_CORE 0.004029
K_2941 X_NUC_51.L_CORE X_NUC_67.L_CORE 0.004044
K_2942 X_NUC_51.L_CORE X_NUC_68.L_CORE 0.003971
K_2943 X_NUC_51.L_CORE X_NUC_69.L_CORE 0.007157
K_2944 X_NUC_51.L_CORE X_NUC_70.L_CORE 0.007156
K_2945 X_NUC_51.L_CORE X_NUC_71.L_CORE 0.007144
K_2946 X_NUC_51.L_CORE X_NUC_72.L_CORE 0.006958
K_2947 X_NUC_51.L_CORE X_NUC_73.L_CORE 0.003068
K_2948 X_NUC_51.L_CORE X_NUC_74.L_CORE 0.003756
K_2949 X_NUC_51.L_CORE X_NUC_75.L_CORE 0.004153
K_2950 X_NUC_51.L_CORE X_NUC_76.L_CORE 0.002856
K_2951 X_NUC_51.L_CORE X_NUC_77.L_CORE 0.007601
K_2952 X_NUC_51.L_CORE X_NUC_78.L_CORE 0.003296
K_2953 X_NUC_51.L_CORE X_NUC_79.L_CORE 0.003609
K_2954 X_NUC_51.L_CORE X_NUC_80.L_CORE 0.009944
K_2955 X_NUC_51.L_CORE X_NUC_81.L_CORE 0.003085
K_2956 X_NUC_51.L_CORE X_NUC_82.L_CORE 0.006929
K_2957 X_NUC_51.L_CORE X_NUC_83.L_CORE 0.004901
K_2958 X_NUC_51.L_CORE X_NUC_84.L_CORE 0.004148
K_2959 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.003727
K_2960 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.003766
K_2961 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.003771
K_2962 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.003716
K_2963 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.005357
K_2964 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.005293
K_2965 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.005367
K_2966 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.005249
K_2967 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.007643
K_2968 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.007882
K_2969 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.007736
K_2970 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.007621
K_2971 X_NUC_52.L_CORE X_NUC_65.L_CORE 0.004089
K_2972 X_NUC_52.L_CORE X_NUC_66.L_CORE 0.004104
K_2973 X_NUC_52.L_CORE X_NUC_67.L_CORE 0.004119
K_2974 X_NUC_52.L_CORE X_NUC_68.L_CORE 0.004044
K_2975 X_NUC_52.L_CORE X_NUC_69.L_CORE 0.007354
K_2976 X_NUC_52.L_CORE X_NUC_70.L_CORE 0.007353
K_2977 X_NUC_52.L_CORE X_NUC_71.L_CORE 0.007336
K_2978 X_NUC_52.L_CORE X_NUC_72.L_CORE 0.007144
K_2979 X_NUC_52.L_CORE X_NUC_73.L_CORE 0.003096
K_2980 X_NUC_52.L_CORE X_NUC_74.L_CORE 0.003792
K_2981 X_NUC_52.L_CORE X_NUC_75.L_CORE 0.004168
K_2982 X_NUC_52.L_CORE X_NUC_76.L_CORE 0.002892
K_2983 X_NUC_52.L_CORE X_NUC_77.L_CORE 0.007583
K_2984 X_NUC_52.L_CORE X_NUC_78.L_CORE 0.003328
K_2985 X_NUC_52.L_CORE X_NUC_79.L_CORE 0.003664
K_2986 X_NUC_52.L_CORE X_NUC_80.L_CORE 0.009789
K_2987 X_NUC_52.L_CORE X_NUC_81.L_CORE 0.003128
K_2988 X_NUC_52.L_CORE X_NUC_82.L_CORE 0.007067
K_2989 X_NUC_52.L_CORE X_NUC_83.L_CORE 0.004958
K_2990 X_NUC_52.L_CORE X_NUC_84.L_CORE 0.004222
K_2991 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_2992 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_2993 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_2994 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.004005
K_2995 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.003932
K_2996 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.003956
K_2997 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.003972
K_2998 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.005729
K_2999 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.005683
K_3000 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.005611
K_3001 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.005756
K_3002 X_NUC_53.L_CORE X_NUC_65.L_CORE 0.008119
K_3003 X_NUC_53.L_CORE X_NUC_66.L_CORE 0.007844
K_3004 X_NUC_53.L_CORE X_NUC_67.L_CORE 0.007900
K_3005 X_NUC_53.L_CORE X_NUC_68.L_CORE 0.007868
K_3006 X_NUC_53.L_CORE X_NUC_69.L_CORE 0.004881
K_3007 X_NUC_53.L_CORE X_NUC_70.L_CORE 0.004794
K_3008 X_NUC_53.L_CORE X_NUC_71.L_CORE 0.004780
K_3009 X_NUC_53.L_CORE X_NUC_72.L_CORE 0.004839
K_3010 X_NUC_53.L_CORE X_NUC_73.L_CORE 0.003790
K_3011 X_NUC_53.L_CORE X_NUC_74.L_CORE 0.002924
K_3012 X_NUC_53.L_CORE X_NUC_75.L_CORE 0.003860
K_3013 X_NUC_53.L_CORE X_NUC_76.L_CORE 0.004259
K_3014 X_NUC_53.L_CORE X_NUC_77.L_CORE 0.002899
K_3015 X_NUC_53.L_CORE X_NUC_78.L_CORE 0.008286
K_3016 X_NUC_53.L_CORE X_NUC_79.L_CORE 0.003412
K_3017 X_NUC_53.L_CORE X_NUC_80.L_CORE 0.003816
K_3018 X_NUC_53.L_CORE X_NUC_81.L_CORE 0.010524
K_3019 X_NUC_53.L_CORE X_NUC_82.L_CORE 0.003354
K_3020 X_NUC_53.L_CORE X_NUC_83.L_CORE 0.007404
K_3021 X_NUC_53.L_CORE X_NUC_84.L_CORE 0.005454
K_3022 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_3023 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_3024 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.004082
K_3025 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.004005
K_3026 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.004030
K_3027 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.004047
K_3028 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.005772
K_3029 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.005729
K_3030 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.005654
K_3031 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.005802
K_3032 X_NUC_54.L_CORE X_NUC_65.L_CORE 0.008411
K_3033 X_NUC_54.L_CORE X_NUC_66.L_CORE 0.008119
K_3034 X_NUC_54.L_CORE X_NUC_67.L_CORE 0.008174
K_3035 X_NUC_54.L_CORE X_NUC_68.L_CORE 0.008139
K_3036 X_NUC_54.L_CORE X_NUC_69.L_CORE 0.004969
K_3037 X_NUC_54.L_CORE X_NUC_70.L_CORE 0.004881
K_3038 X_NUC_54.L_CORE X_NUC_71.L_CORE 0.004864
K_3039 X_NUC_54.L_CORE X_NUC_72.L_CORE 0.004927
K_3040 X_NUC_54.L_CORE X_NUC_73.L_CORE 0.003807
K_3041 X_NUC_54.L_CORE X_NUC_74.L_CORE 0.002954
K_3042 X_NUC_54.L_CORE X_NUC_75.L_CORE 0.003860
K_3043 X_NUC_54.L_CORE X_NUC_76.L_CORE 0.004312
K_3044 X_NUC_54.L_CORE X_NUC_77.L_CORE 0.002925
K_3045 X_NUC_54.L_CORE X_NUC_78.L_CORE 0.008104
K_3046 X_NUC_54.L_CORE X_NUC_79.L_CORE 0.003467
K_3047 X_NUC_54.L_CORE X_NUC_80.L_CORE 0.003833
K_3048 X_NUC_54.L_CORE X_NUC_81.L_CORE 0.010780
K_3049 X_NUC_54.L_CORE X_NUC_82.L_CORE 0.003402
K_3050 X_NUC_54.L_CORE X_NUC_83.L_CORE 0.007401
K_3051 X_NUC_54.L_CORE X_NUC_84.L_CORE 0.005578
K_3052 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_3053 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.004055
K_3054 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.003980
K_3055 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.004005
K_3056 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.004021
K_3057 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.005850
K_3058 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.005803
K_3059 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.005729
K_3060 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.005881
K_3061 X_NUC_55.L_CORE X_NUC_65.L_CORE 0.008343
K_3062 X_NUC_55.L_CORE X_NUC_66.L_CORE 0.008052
K_3063 X_NUC_55.L_CORE X_NUC_67.L_CORE 0.008119
K_3064 X_NUC_55.L_CORE X_NUC_68.L_CORE 0.008078
K_3065 X_NUC_55.L_CORE X_NUC_69.L_CORE 0.004986
K_3066 X_NUC_55.L_CORE X_NUC_70.L_CORE 0.004895
K_3067 X_NUC_55.L_CORE X_NUC_71.L_CORE 0.004881
K_3068 X_NUC_55.L_CORE X_NUC_72.L_CORE 0.004943
K_3069 X_NUC_55.L_CORE X_NUC_73.L_CORE 0.003754
K_3070 X_NUC_55.L_CORE X_NUC_74.L_CORE 0.002924
K_3071 X_NUC_55.L_CORE X_NUC_75.L_CORE 0.003847
K_3072 X_NUC_55.L_CORE X_NUC_76.L_CORE 0.004225
K_3073 X_NUC_55.L_CORE X_NUC_77.L_CORE 0.002914
K_3074 X_NUC_55.L_CORE X_NUC_78.L_CORE 0.008061
K_3075 X_NUC_55.L_CORE X_NUC_79.L_CORE 0.003428
K_3076 X_NUC_55.L_CORE X_NUC_80.L_CORE 0.003852
K_3077 X_NUC_55.L_CORE X_NUC_81.L_CORE 0.010414
K_3078 X_NUC_55.L_CORE X_NUC_82.L_CORE 0.003395
K_3079 X_NUC_55.L_CORE X_NUC_83.L_CORE 0.007614
K_3080 X_NUC_55.L_CORE X_NUC_84.L_CORE 0.005573
K_3081 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.004038
K_3082 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.003963
K_3083 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.003988
K_3084 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.004005
K_3085 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.005699
K_3086 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.005655
K_3087 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.005585
K_3088 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.005729
K_3089 X_NUC_56.L_CORE X_NUC_65.L_CORE 0.008381
K_3090 X_NUC_56.L_CORE X_NUC_66.L_CORE 0.008086
K_3091 X_NUC_56.L_CORE X_NUC_67.L_CORE 0.008148
K_3092 X_NUC_56.L_CORE X_NUC_68.L_CORE 0.008119
K_3093 X_NUC_56.L_CORE X_NUC_69.L_CORE 0.004921
K_3094 X_NUC_56.L_CORE X_NUC_70.L_CORE 0.004834
K_3095 X_NUC_56.L_CORE X_NUC_71.L_CORE 0.004819
K_3096 X_NUC_56.L_CORE X_NUC_72.L_CORE 0.004881
K_3097 X_NUC_56.L_CORE X_NUC_73.L_CORE 0.003749
K_3098 X_NUC_56.L_CORE X_NUC_74.L_CORE 0.002915
K_3099 X_NUC_56.L_CORE X_NUC_75.L_CORE 0.003800
K_3100 X_NUC_56.L_CORE X_NUC_76.L_CORE 0.004261
K_3101 X_NUC_56.L_CORE X_NUC_77.L_CORE 0.002888
K_3102 X_NUC_56.L_CORE X_NUC_78.L_CORE 0.007977
K_3103 X_NUC_56.L_CORE X_NUC_79.L_CORE 0.003432
K_3104 X_NUC_56.L_CORE X_NUC_80.L_CORE 0.003785
K_3105 X_NUC_56.L_CORE X_NUC_81.L_CORE 0.010896
K_3106 X_NUC_56.L_CORE X_NUC_82.L_CORE 0.003369
K_3107 X_NUC_56.L_CORE X_NUC_83.L_CORE 0.007375
K_3108 X_NUC_56.L_CORE X_NUC_84.L_CORE 0.005567
K_3109 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.207973
K_3110 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.207973
K_3111 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.207973
K_3112 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.004473
K_3113 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.004557
K_3114 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.004484
K_3115 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.004533
K_3116 X_NUC_57.L_CORE X_NUC_65.L_CORE 0.006523
K_3117 X_NUC_57.L_CORE X_NUC_66.L_CORE 0.006705
K_3118 X_NUC_57.L_CORE X_NUC_67.L_CORE 0.006621
K_3119 X_NUC_57.L_CORE X_NUC_68.L_CORE 0.006530
K_3120 X_NUC_57.L_CORE X_NUC_69.L_CORE 0.008530
K_3121 X_NUC_57.L_CORE X_NUC_70.L_CORE 0.008794
K_3122 X_NUC_57.L_CORE X_NUC_71.L_CORE 0.008454
K_3123 X_NUC_57.L_CORE X_NUC_72.L_CORE 0.008627
K_3124 X_NUC_57.L_CORE X_NUC_73.L_CORE 0.003060
K_3125 X_NUC_57.L_CORE X_NUC_74.L_CORE 0.004129
K_3126 X_NUC_57.L_CORE X_NUC_75.L_CORE 0.002920
K_3127 X_NUC_57.L_CORE X_NUC_76.L_CORE 0.003950
K_3128 X_NUC_57.L_CORE X_NUC_77.L_CORE 0.004405
K_3129 X_NUC_57.L_CORE X_NUC_78.L_CORE 0.003028
K_3130 X_NUC_57.L_CORE X_NUC_79.L_CORE 0.008537
K_3131 X_NUC_57.L_CORE X_NUC_80.L_CORE 0.003674
K_3132 X_NUC_57.L_CORE X_NUC_81.L_CORE 0.004169
K_3133 X_NUC_57.L_CORE X_NUC_82.L_CORE 0.011685
K_3134 X_NUC_57.L_CORE X_NUC_83.L_CORE 0.003914
K_3135 X_NUC_57.L_CORE X_NUC_84.L_CORE 0.007890
K_3136 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.207973
K_3137 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.207973
K_3138 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.004391
K_3139 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.004473
K_3140 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.004402
K_3141 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.004448
K_3142 X_NUC_58.L_CORE X_NUC_65.L_CORE 0.006349
K_3143 X_NUC_58.L_CORE X_NUC_66.L_CORE 0.006523
K_3144 X_NUC_58.L_CORE X_NUC_67.L_CORE 0.006443
K_3145 X_NUC_58.L_CORE X_NUC_68.L_CORE 0.006359
K_3146 X_NUC_58.L_CORE X_NUC_69.L_CORE 0.008276
K_3147 X_NUC_58.L_CORE X_NUC_70.L_CORE 0.008530
K_3148 X_NUC_58.L_CORE X_NUC_71.L_CORE 0.008213
K_3149 X_NUC_58.L_CORE X_NUC_72.L_CORE 0.008371
K_3150 X_NUC_58.L_CORE X_NUC_73.L_CORE 0.003035
K_3151 X_NUC_58.L_CORE X_NUC_74.L_CORE 0.004129
K_3152 X_NUC_58.L_CORE X_NUC_75.L_CORE 0.002891
K_3153 X_NUC_58.L_CORE X_NUC_76.L_CORE 0.003920
K_3154 X_NUC_58.L_CORE X_NUC_77.L_CORE 0.004397
K_3155 X_NUC_58.L_CORE X_NUC_78.L_CORE 0.002987
K_3156 X_NUC_58.L_CORE X_NUC_79.L_CORE 0.008659
K_3157 X_NUC_58.L_CORE X_NUC_80.L_CORE 0.003631
K_3158 X_NUC_58.L_CORE X_NUC_81.L_CORE 0.004101
K_3159 X_NUC_58.L_CORE X_NUC_82.L_CORE 0.011827
K_3160 X_NUC_58.L_CORE X_NUC_83.L_CORE 0.003846
K_3161 X_NUC_58.L_CORE X_NUC_84.L_CORE 0.007686
K_3162 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.207973
K_3163 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.004459
K_3164 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.004544
K_3165 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.004473
K_3166 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.004520
K_3167 X_NUC_59.L_CORE X_NUC_65.L_CORE 0.006422
K_3168 X_NUC_59.L_CORE X_NUC_66.L_CORE 0.006599
K_3169 X_NUC_59.L_CORE X_NUC_67.L_CORE 0.006523
K_3170 X_NUC_59.L_CORE X_NUC_68.L_CORE 0.006432
K_3171 X_NUC_59.L_CORE X_NUC_69.L_CORE 0.008594
K_3172 X_NUC_59.L_CORE X_NUC_70.L_CORE 0.008872
K_3173 X_NUC_59.L_CORE X_NUC_71.L_CORE 0.008530
K_3174 X_NUC_59.L_CORE X_NUC_72.L_CORE 0.008701
K_3175 X_NUC_59.L_CORE X_NUC_73.L_CORE 0.003019
K_3176 X_NUC_59.L_CORE X_NUC_74.L_CORE 0.004077
K_3177 X_NUC_59.L_CORE X_NUC_75.L_CORE 0.002895
K_3178 X_NUC_59.L_CORE X_NUC_76.L_CORE 0.003877
K_3179 X_NUC_59.L_CORE X_NUC_77.L_CORE 0.004395
K_3180 X_NUC_59.L_CORE X_NUC_78.L_CORE 0.002995
K_3181 X_NUC_59.L_CORE X_NUC_79.L_CORE 0.008321
K_3182 X_NUC_59.L_CORE X_NUC_80.L_CORE 0.003667
K_3183 X_NUC_59.L_CORE X_NUC_81.L_CORE 0.004107
K_3184 X_NUC_59.L_CORE X_NUC_82.L_CORE 0.012169
K_3185 X_NUC_59.L_CORE X_NUC_83.L_CORE 0.003898
K_3186 X_NUC_59.L_CORE X_NUC_84.L_CORE 0.007859
K_3187 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.004413
K_3188 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.004495
K_3189 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.004425
K_3190 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.004473
K_3191 X_NUC_60.L_CORE X_NUC_65.L_CORE 0.006509
K_3192 X_NUC_60.L_CORE X_NUC_66.L_CORE 0.006693
K_3193 X_NUC_60.L_CORE X_NUC_67.L_CORE 0.006610
K_3194 X_NUC_60.L_CORE X_NUC_68.L_CORE 0.006523
K_3195 X_NUC_60.L_CORE X_NUC_69.L_CORE 0.008423
K_3196 X_NUC_60.L_CORE X_NUC_70.L_CORE 0.008684
K_3197 X_NUC_60.L_CORE X_NUC_71.L_CORE 0.008356
K_3198 X_NUC_60.L_CORE X_NUC_72.L_CORE 0.008530
K_3199 X_NUC_60.L_CORE X_NUC_73.L_CORE 0.003023
K_3200 X_NUC_60.L_CORE X_NUC_74.L_CORE 0.004068
K_3201 X_NUC_60.L_CORE X_NUC_75.L_CORE 0.002881
K_3202 X_NUC_60.L_CORE X_NUC_76.L_CORE 0.003920
K_3203 X_NUC_60.L_CORE X_NUC_77.L_CORE 0.004325
K_3204 X_NUC_60.L_CORE X_NUC_78.L_CORE 0.002998
K_3205 X_NUC_60.L_CORE X_NUC_79.L_CORE 0.008532
K_3206 X_NUC_60.L_CORE X_NUC_80.L_CORE 0.003621
K_3207 X_NUC_60.L_CORE X_NUC_81.L_CORE 0.004153
K_3208 X_NUC_60.L_CORE X_NUC_82.L_CORE 0.011518
K_3209 X_NUC_60.L_CORE X_NUC_83.L_CORE 0.003879
K_3210 X_NUC_60.L_CORE X_NUC_84.L_CORE 0.007969
K_3211 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.207973
K_3212 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.207973
K_3213 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.207973
K_3214 X_NUC_61.L_CORE X_NUC_65.L_CORE 0.005320
K_3215 X_NUC_61.L_CORE X_NUC_66.L_CORE 0.005276
K_3216 X_NUC_61.L_CORE X_NUC_67.L_CORE 0.005352
K_3217 X_NUC_61.L_CORE X_NUC_68.L_CORE 0.005226
K_3218 X_NUC_61.L_CORE X_NUC_69.L_CORE 0.008037
K_3219 X_NUC_61.L_CORE X_NUC_70.L_CORE 0.007777
K_3220 X_NUC_61.L_CORE X_NUC_71.L_CORE 0.007903
K_3221 X_NUC_61.L_CORE X_NUC_72.L_CORE 0.007782
K_3222 X_NUC_61.L_CORE X_NUC_73.L_CORE 0.003087
K_3223 X_NUC_61.L_CORE X_NUC_74.L_CORE 0.002981
K_3224 X_NUC_61.L_CORE X_NUC_75.L_CORE 0.004309
K_3225 X_NUC_61.L_CORE X_NUC_76.L_CORE 0.002952
K_3226 X_NUC_61.L_CORE X_NUC_77.L_CORE 0.004022
K_3227 X_NUC_61.L_CORE X_NUC_78.L_CORE 0.004593
K_3228 X_NUC_61.L_CORE X_NUC_79.L_CORE 0.003175
K_3229 X_NUC_61.L_CORE X_NUC_80.L_CORE 0.008931
K_3230 X_NUC_61.L_CORE X_NUC_81.L_CORE 0.004019
K_3231 X_NUC_61.L_CORE X_NUC_82.L_CORE 0.004626
K_3232 X_NUC_61.L_CORE X_NUC_83.L_CORE 0.013785
K_3233 X_NUC_61.L_CORE X_NUC_84.L_CORE 0.005041
K_3234 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.207973
K_3235 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.207973
K_3236 X_NUC_62.L_CORE X_NUC_65.L_CORE 0.005363
K_3237 X_NUC_62.L_CORE X_NUC_66.L_CORE 0.005320
K_3238 X_NUC_62.L_CORE X_NUC_67.L_CORE 0.005397
K_3239 X_NUC_62.L_CORE X_NUC_68.L_CORE 0.005268
K_3240 X_NUC_62.L_CORE X_NUC_69.L_CORE 0.008312
K_3241 X_NUC_62.L_CORE X_NUC_70.L_CORE 0.008037
K_3242 X_NUC_62.L_CORE X_NUC_71.L_CORE 0.008170
K_3243 X_NUC_62.L_CORE X_NUC_72.L_CORE 0.008036
K_3244 X_NUC_62.L_CORE X_NUC_73.L_CORE 0.003089
K_3245 X_NUC_62.L_CORE X_NUC_74.L_CORE 0.003006
K_3246 X_NUC_62.L_CORE X_NUC_75.L_CORE 0.004289
K_3247 X_NUC_62.L_CORE X_NUC_76.L_CORE 0.002963
K_3248 X_NUC_62.L_CORE X_NUC_77.L_CORE 0.004078
K_3249 X_NUC_62.L_CORE X_NUC_78.L_CORE 0.004539
K_3250 X_NUC_62.L_CORE X_NUC_79.L_CORE 0.003212
K_3251 X_NUC_62.L_CORE X_NUC_80.L_CORE 0.008972
K_3252 X_NUC_62.L_CORE X_NUC_81.L_CORE 0.004017
K_3253 X_NUC_62.L_CORE X_NUC_82.L_CORE 0.004730
K_3254 X_NUC_62.L_CORE X_NUC_83.L_CORE 0.013182
K_3255 X_NUC_62.L_CORE X_NUC_84.L_CORE 0.005106
K_3256 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.207973
K_3257 X_NUC_63.L_CORE X_NUC_65.L_CORE 0.005286
K_3258 X_NUC_63.L_CORE X_NUC_66.L_CORE 0.005244
K_3259 X_NUC_63.L_CORE X_NUC_67.L_CORE 0.005320
K_3260 X_NUC_63.L_CORE X_NUC_68.L_CORE 0.005195
K_3261 X_NUC_63.L_CORE X_NUC_69.L_CORE 0.008165
K_3262 X_NUC_63.L_CORE X_NUC_70.L_CORE 0.007899
K_3263 X_NUC_63.L_CORE X_NUC_71.L_CORE 0.008037
K_3264 X_NUC_63.L_CORE X_NUC_72.L_CORE 0.007904
K_3265 X_NUC_63.L_CORE X_NUC_73.L_CORE 0.003049
K_3266 X_NUC_63.L_CORE X_NUC_74.L_CORE 0.002965
K_3267 X_NUC_63.L_CORE X_NUC_75.L_CORE 0.004241
K_3268 X_NUC_63.L_CORE X_NUC_76.L_CORE 0.002925
K_3269 X_NUC_63.L_CORE X_NUC_77.L_CORE 0.004023
K_3270 X_NUC_63.L_CORE X_NUC_78.L_CORE 0.004495
K_3271 X_NUC_63.L_CORE X_NUC_79.L_CORE 0.003168
K_3272 X_NUC_63.L_CORE X_NUC_80.L_CORE 0.008938
K_3273 X_NUC_63.L_CORE X_NUC_81.L_CORE 0.003972
K_3274 X_NUC_63.L_CORE X_NUC_82.L_CORE 0.004669
K_3275 X_NUC_63.L_CORE X_NUC_83.L_CORE 0.013437
K_3276 X_NUC_63.L_CORE X_NUC_84.L_CORE 0.005050
K_3277 X_NUC_64.L_CORE X_NUC_65.L_CORE 0.005416
K_3278 X_NUC_64.L_CORE X_NUC_66.L_CORE 0.005371
K_3279 X_NUC_64.L_CORE X_NUC_67.L_CORE 0.005452
K_3280 X_NUC_64.L_CORE X_NUC_68.L_CORE 0.005320
K_3281 X_NUC_64.L_CORE X_NUC_69.L_CORE 0.008306
K_3282 X_NUC_64.L_CORE X_NUC_70.L_CORE 0.008026
K_3283 X_NUC_64.L_CORE X_NUC_71.L_CORE 0.008165
K_3284 X_NUC_64.L_CORE X_NUC_72.L_CORE 0.008037
K_3285 X_NUC_64.L_CORE X_NUC_73.L_CORE 0.003069
K_3286 X_NUC_64.L_CORE X_NUC_74.L_CORE 0.002975
K_3287 X_NUC_64.L_CORE X_NUC_75.L_CORE 0.004237
K_3288 X_NUC_64.L_CORE X_NUC_76.L_CORE 0.002957
K_3289 X_NUC_64.L_CORE X_NUC_77.L_CORE 0.004004
K_3290 X_NUC_64.L_CORE X_NUC_78.L_CORE 0.004553
K_3291 X_NUC_64.L_CORE X_NUC_79.L_CORE 0.003197
K_3292 X_NUC_64.L_CORE X_NUC_80.L_CORE 0.008648
K_3293 X_NUC_64.L_CORE X_NUC_81.L_CORE 0.004049
K_3294 X_NUC_64.L_CORE X_NUC_82.L_CORE 0.004683
K_3295 X_NUC_64.L_CORE X_NUC_83.L_CORE 0.013996
K_3296 X_NUC_64.L_CORE X_NUC_84.L_CORE 0.005150
K_3297 X_NUC_65.L_CORE X_NUC_66.L_CORE 0.207973
K_3298 X_NUC_65.L_CORE X_NUC_67.L_CORE 0.207973
K_3299 X_NUC_65.L_CORE X_NUC_68.L_CORE 0.207973
K_3300 X_NUC_65.L_CORE X_NUC_69.L_CORE 0.007449
K_3301 X_NUC_65.L_CORE X_NUC_70.L_CORE 0.007354
K_3302 X_NUC_65.L_CORE X_NUC_71.L_CORE 0.007257
K_3303 X_NUC_65.L_CORE X_NUC_72.L_CORE 0.007497
K_3304 X_NUC_65.L_CORE X_NUC_73.L_CORE 0.003190
K_3305 X_NUC_65.L_CORE X_NUC_74.L_CORE 0.003101
K_3306 X_NUC_65.L_CORE X_NUC_75.L_CORE 0.003052
K_3307 X_NUC_65.L_CORE X_NUC_76.L_CORE 0.004332
K_3308 X_NUC_65.L_CORE X_NUC_77.L_CORE 0.003098
K_3309 X_NUC_65.L_CORE X_NUC_78.L_CORE 0.004245
K_3310 X_NUC_65.L_CORE X_NUC_79.L_CORE 0.004743
K_3311 X_NUC_65.L_CORE X_NUC_80.L_CORE 0.003537
K_3312 X_NUC_65.L_CORE X_NUC_81.L_CORE 0.009278
K_3313 X_NUC_65.L_CORE X_NUC_82.L_CORE 0.004655
K_3314 X_NUC_65.L_CORE X_NUC_83.L_CORE 0.005824
K_3315 X_NUC_65.L_CORE X_NUC_84.L_CORE 0.015135
K_3316 X_NUC_66.L_CORE X_NUC_67.L_CORE 0.207973
K_3317 X_NUC_66.L_CORE X_NUC_68.L_CORE 0.207973
K_3318 X_NUC_66.L_CORE X_NUC_69.L_CORE 0.007538
K_3319 X_NUC_66.L_CORE X_NUC_70.L_CORE 0.007449
K_3320 X_NUC_66.L_CORE X_NUC_71.L_CORE 0.007344
K_3321 X_NUC_66.L_CORE X_NUC_72.L_CORE 0.007593
K_3322 X_NUC_66.L_CORE X_NUC_73.L_CORE 0.003183
K_3323 X_NUC_66.L_CORE X_NUC_74.L_CORE 0.003120
K_3324 X_NUC_66.L_CORE X_NUC_75.L_CORE 0.003036
K_3325 X_NUC_66.L_CORE X_NUC_76.L_CORE 0.004343
K_3326 X_NUC_66.L_CORE X_NUC_77.L_CORE 0.003115
K_3327 X_NUC_66.L_CORE X_NUC_78.L_CORE 0.004181
K_3328 X_NUC_66.L_CORE X_NUC_79.L_CORE 0.004834
K_3329 X_NUC_66.L_CORE X_NUC_80.L_CORE 0.003527
K_3330 X_NUC_66.L_CORE X_NUC_81.L_CORE 0.009035
K_3331 X_NUC_66.L_CORE X_NUC_82.L_CORE 0.004730
K_3332 X_NUC_66.L_CORE X_NUC_83.L_CORE 0.005720
K_3333 X_NUC_66.L_CORE X_NUC_84.L_CORE 0.015908
K_3334 X_NUC_67.L_CORE X_NUC_68.L_CORE 0.207973
K_3335 X_NUC_67.L_CORE X_NUC_69.L_CORE 0.007647
K_3336 X_NUC_67.L_CORE X_NUC_70.L_CORE 0.007549
K_3337 X_NUC_67.L_CORE X_NUC_71.L_CORE 0.007449
K_3338 X_NUC_67.L_CORE X_NUC_72.L_CORE 0.007705
K_3339 X_NUC_67.L_CORE X_NUC_73.L_CORE 0.003156
K_3340 X_NUC_67.L_CORE X_NUC_74.L_CORE 0.003089
K_3341 X_NUC_67.L_CORE X_NUC_75.L_CORE 0.003033
K_3342 X_NUC_67.L_CORE X_NUC_76.L_CORE 0.004264
K_3343 X_NUC_67.L_CORE X_NUC_77.L_CORE 0.003105
K_3344 X_NUC_67.L_CORE X_NUC_78.L_CORE 0.004183
K_3345 X_NUC_67.L_CORE X_NUC_79.L_CORE 0.004742
K_3346 X_NUC_67.L_CORE X_NUC_80.L_CORE 0.003547
K_3347 X_NUC_67.L_CORE X_NUC_81.L_CORE 0.008896
K_3348 X_NUC_67.L_CORE X_NUC_82.L_CORE 0.004721
K_3349 X_NUC_67.L_CORE X_NUC_83.L_CORE 0.005840
K_3350 X_NUC_67.L_CORE X_NUC_84.L_CORE 0.016273
K_3351 X_NUC_68.L_CORE X_NUC_69.L_CORE 0.007393
K_3352 X_NUC_68.L_CORE X_NUC_70.L_CORE 0.007304
K_3353 X_NUC_68.L_CORE X_NUC_71.L_CORE 0.007209
K_3354 X_NUC_68.L_CORE X_NUC_72.L_CORE 0.007449
K_3355 X_NUC_68.L_CORE X_NUC_73.L_CORE 0.003151
K_3356 X_NUC_68.L_CORE X_NUC_74.L_CORE 0.003076
K_3357 X_NUC_68.L_CORE X_NUC_75.L_CORE 0.003008
K_3358 X_NUC_68.L_CORE X_NUC_76.L_CORE 0.004295
K_3359 X_NUC_68.L_CORE X_NUC_77.L_CORE 0.003071
K_3360 X_NUC_68.L_CORE X_NUC_78.L_CORE 0.004167
K_3361 X_NUC_68.L_CORE X_NUC_79.L_CORE 0.004746
K_3362 X_NUC_68.L_CORE X_NUC_80.L_CORE 0.003492
K_3363 X_NUC_68.L_CORE X_NUC_81.L_CORE 0.009140
K_3364 X_NUC_68.L_CORE X_NUC_82.L_CORE 0.004648
K_3365 X_NUC_68.L_CORE X_NUC_83.L_CORE 0.005717
K_3366 X_NUC_68.L_CORE X_NUC_84.L_CORE 0.015857
K_3367 X_NUC_69.L_CORE X_NUC_70.L_CORE 0.207973
K_3368 X_NUC_69.L_CORE X_NUC_71.L_CORE 0.207973
K_3369 X_NUC_69.L_CORE X_NUC_72.L_CORE 0.207973
K_3370 X_NUC_69.L_CORE X_NUC_73.L_CORE 0.002854
K_3371 X_NUC_69.L_CORE X_NUC_74.L_CORE 0.003233
K_3372 X_NUC_69.L_CORE X_NUC_75.L_CORE 0.003206
K_3373 X_NUC_69.L_CORE X_NUC_76.L_CORE 0.003214
K_3374 X_NUC_69.L_CORE X_NUC_77.L_CORE 0.004160
K_3375 X_NUC_69.L_CORE X_NUC_78.L_CORE 0.003461
K_3376 X_NUC_69.L_CORE X_NUC_79.L_CORE 0.004386
K_3377 X_NUC_69.L_CORE X_NUC_80.L_CORE 0.005063
K_3378 X_NUC_69.L_CORE X_NUC_81.L_CORE 0.004275
K_3379 X_NUC_69.L_CORE X_NUC_82.L_CORE 0.008585
K_3380 X_NUC_69.L_CORE X_NUC_83.L_CORE 0.006405
K_3381 X_NUC_69.L_CORE X_NUC_84.L_CORE 0.009360
K_3382 X_NUC_70.L_CORE X_NUC_71.L_CORE 0.207973
K_3383 X_NUC_70.L_CORE X_NUC_72.L_CORE 0.207973
K_3384 X_NUC_70.L_CORE X_NUC_73.L_CORE 0.002843
K_3385 X_NUC_70.L_CORE X_NUC_74.L_CORE 0.003247
K_3386 X_NUC_70.L_CORE X_NUC_75.L_CORE 0.003182
K_3387 X_NUC_70.L_CORE X_NUC_76.L_CORE 0.003211
K_3388 X_NUC_70.L_CORE X_NUC_77.L_CORE 0.004184
K_3389 X_NUC_70.L_CORE X_NUC_78.L_CORE 0.003417
K_3390 X_NUC_70.L_CORE X_NUC_79.L_CORE 0.004439
K_3391 X_NUC_70.L_CORE X_NUC_80.L_CORE 0.005005
K_3392 X_NUC_70.L_CORE X_NUC_81.L_CORE 0.004234
K_3393 X_NUC_70.L_CORE X_NUC_82.L_CORE 0.008922
K_3394 X_NUC_70.L_CORE X_NUC_83.L_CORE 0.006214
K_3395 X_NUC_70.L_CORE X_NUC_84.L_CORE 0.009346
K_3396 X_NUC_71.L_CORE X_NUC_72.L_CORE 0.207973
K_3397 X_NUC_71.L_CORE X_NUC_73.L_CORE 0.002818
K_3398 X_NUC_71.L_CORE X_NUC_74.L_CORE 0.003204
K_3399 X_NUC_71.L_CORE X_NUC_75.L_CORE 0.003170
K_3400 X_NUC_71.L_CORE X_NUC_76.L_CORE 0.003170
K_3401 X_NUC_71.L_CORE X_NUC_77.L_CORE 0.004143
K_3402 X_NUC_71.L_CORE X_NUC_78.L_CORE 0.003408
K_3403 X_NUC_71.L_CORE X_NUC_79.L_CORE 0.004347
K_3404 X_NUC_71.L_CORE X_NUC_80.L_CORE 0.005032
K_3405 X_NUC_71.L_CORE X_NUC_81.L_CORE 0.004200
K_3406 X_NUC_71.L_CORE X_NUC_82.L_CORE 0.008696
K_3407 X_NUC_71.L_CORE X_NUC_83.L_CORE 0.006305
K_3408 X_NUC_71.L_CORE X_NUC_84.L_CORE 0.009217
K_3409 X_NUC_72.L_CORE X_NUC_73.L_CORE 0.002828
K_3410 X_NUC_72.L_CORE X_NUC_74.L_CORE 0.003209
K_3411 X_NUC_72.L_CORE X_NUC_75.L_CORE 0.003160
K_3412 X_NUC_72.L_CORE X_NUC_76.L_CORE 0.003203
K_3413 X_NUC_72.L_CORE X_NUC_77.L_CORE 0.004104
K_3414 X_NUC_72.L_CORE X_NUC_78.L_CORE 0.003423
K_3415 X_NUC_72.L_CORE X_NUC_79.L_CORE 0.004400
K_3416 X_NUC_72.L_CORE X_NUC_80.L_CORE 0.004947
K_3417 X_NUC_72.L_CORE X_NUC_81.L_CORE 0.004271
K_3418 X_NUC_72.L_CORE X_NUC_82.L_CORE 0.008621
K_3419 X_NUC_72.L_CORE X_NUC_83.L_CORE 0.006296
K_3420 X_NUC_72.L_CORE X_NUC_84.L_CORE 0.009635
K_3421 X_NUC_73.L_CORE X_NUC_74.L_CORE 0.005177
K_3422 X_NUC_73.L_CORE X_NUC_75.L_CORE 0.005579
K_3423 X_NUC_73.L_CORE X_NUC_76.L_CORE 0.005852
K_3424 X_NUC_73.L_CORE X_NUC_77.L_CORE 0.003436
K_3425 X_NUC_73.L_CORE X_NUC_78.L_CORE 0.004811
K_3426 X_NUC_73.L_CORE X_NUC_79.L_CORE 0.003395
K_3427 X_NUC_73.L_CORE X_NUC_80.L_CORE 0.003108
K_3428 X_NUC_73.L_CORE X_NUC_81.L_CORE 0.003615
K_3429 X_NUC_73.L_CORE X_NUC_82.L_CORE 0.002722
K_3430 X_NUC_73.L_CORE X_NUC_83.L_CORE 0.002938
K_3431 X_NUC_73.L_CORE X_NUC_84.L_CORE 0.002754
K_3432 X_NUC_74.L_CORE X_NUC_75.L_CORE 0.003766
K_3433 X_NUC_74.L_CORE X_NUC_76.L_CORE 0.004628
K_3434 X_NUC_74.L_CORE X_NUC_77.L_CORE 0.005671
K_3435 X_NUC_74.L_CORE X_NUC_78.L_CORE 0.002928
K_3436 X_NUC_74.L_CORE X_NUC_79.L_CORE 0.005182
K_3437 X_NUC_74.L_CORE X_NUC_80.L_CORE 0.003169
K_3438 X_NUC_74.L_CORE X_NUC_81.L_CORE 0.002925
K_3439 X_NUC_74.L_CORE X_NUC_82.L_CORE 0.003818
K_3440 X_NUC_74.L_CORE X_NUC_83.L_CORE 0.002629
K_3441 X_NUC_74.L_CORE X_NUC_84.L_CORE 0.002938
K_3442 X_NUC_75.L_CORE X_NUC_76.L_CORE 0.003232
K_3443 X_NUC_75.L_CORE X_NUC_77.L_CORE 0.004161
K_3444 X_NUC_75.L_CORE X_NUC_78.L_CORE 0.005443
K_3445 X_NUC_75.L_CORE X_NUC_79.L_CORE 0.002714
K_3446 X_NUC_75.L_CORE X_NUC_80.L_CORE 0.005310
K_3447 X_NUC_75.L_CORE X_NUC_81.L_CORE 0.003079
K_3448 X_NUC_75.L_CORE X_NUC_82.L_CORE 0.002876
K_3449 X_NUC_75.L_CORE X_NUC_83.L_CORE 0.003818
K_3450 X_NUC_75.L_CORE X_NUC_84.L_CORE 0.002722
K_3451 X_NUC_76.L_CORE X_NUC_77.L_CORE 0.002967
K_3452 X_NUC_76.L_CORE X_NUC_78.L_CORE 0.003917
K_3453 X_NUC_76.L_CORE X_NUC_79.L_CORE 0.005303
K_3454 X_NUC_76.L_CORE X_NUC_80.L_CORE 0.002627
K_3455 X_NUC_76.L_CORE X_NUC_81.L_CORE 0.005343
K_3456 X_NUC_76.L_CORE X_NUC_82.L_CORE 0.003079
K_3457 X_NUC_76.L_CORE X_NUC_83.L_CORE 0.002925
K_3458 X_NUC_76.L_CORE X_NUC_84.L_CORE 0.003615
K_3459 X_NUC_77.L_CORE X_NUC_78.L_CORE 0.002836
K_3460 X_NUC_77.L_CORE X_NUC_79.L_CORE 0.003810
K_3461 X_NUC_77.L_CORE X_NUC_80.L_CORE 0.005257
K_3462 X_NUC_77.L_CORE X_NUC_81.L_CORE 0.002627
K_3463 X_NUC_77.L_CORE X_NUC_82.L_CORE 0.005310
K_3464 X_NUC_77.L_CORE X_NUC_83.L_CORE 0.003169
K_3465 X_NUC_77.L_CORE X_NUC_84.L_CORE 0.003108
K_3466 X_NUC_78.L_CORE X_NUC_79.L_CORE 0.002796
K_3467 X_NUC_78.L_CORE X_NUC_80.L_CORE 0.003810
K_3468 X_NUC_78.L_CORE X_NUC_81.L_CORE 0.005303
K_3469 X_NUC_78.L_CORE X_NUC_82.L_CORE 0.002714
K_3470 X_NUC_78.L_CORE X_NUC_83.L_CORE 0.005182
K_3471 X_NUC_78.L_CORE X_NUC_84.L_CORE 0.003395
K_3472 X_NUC_79.L_CORE X_NUC_80.L_CORE 0.002836
K_3473 X_NUC_79.L_CORE X_NUC_81.L_CORE 0.003917
K_3474 X_NUC_79.L_CORE X_NUC_82.L_CORE 0.005443
K_3475 X_NUC_79.L_CORE X_NUC_83.L_CORE 0.002928
K_3476 X_NUC_79.L_CORE X_NUC_84.L_CORE 0.004811
K_3477 X_NUC_80.L_CORE X_NUC_81.L_CORE 0.002967
K_3478 X_NUC_80.L_CORE X_NUC_82.L_CORE 0.004161
K_3479 X_NUC_80.L_CORE X_NUC_83.L_CORE 0.005671
K_3480 X_NUC_80.L_CORE X_NUC_84.L_CORE 0.003436
K_3481 X_NUC_81.L_CORE X_NUC_82.L_CORE 0.003232
K_3482 X_NUC_81.L_CORE X_NUC_83.L_CORE 0.004628
K_3483 X_NUC_81.L_CORE X_NUC_84.L_CORE 0.005852
K_3484 X_NUC_82.L_CORE X_NUC_83.L_CORE 0.003766
K_3485 X_NUC_82.L_CORE X_NUC_84.L_CORE 0.005579
K_3486 X_NUC_83.L_CORE X_NUC_84.L_CORE 0.005177

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
