* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Titanium-48 (Z=22, A=48)
* Auto-generated topological mutual impedance array
* Nodes: 48

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.009258
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.008887
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.008957
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.009075
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.009974
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.010137
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.009726
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.010130
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.010427
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.010189
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.010261
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.009940
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.006169
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.006069
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005999
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.006121
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.008523
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.008733
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.008414
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.008437
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.006087
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.005960
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.005950
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.005929
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.005587
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.005584
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.005460
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.005558
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.006351
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.006356
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.006253
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.006198
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.004946
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.004890
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.004835
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.004867
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.005184
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.005189
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.005085
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.005114
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.022694
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.005645
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.005434
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.004795
K_48 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_49 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_50 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.009659
K_51 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.009258
K_52 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.009328
K_53 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.009461
K_54 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.009796
K_55 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.009974
K_56 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.009571
K_57 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.009955
K_58 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.010655
K_59 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.010427
K_60 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.010492
K_61 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.010149
K_62 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.006268
K_63 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.006169
K_64 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.006093
K_65 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.006221
K_66 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.008315
K_67 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.008523
K_68 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.008220
K_69 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.008241
K_70 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.006216
K_71 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.006087
K_72 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.006073
K_73 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.006051
K_74 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.005586
K_75 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.005587
K_76 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.005461
K_77 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.005559
K_78 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.006341
K_79 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.006351
K_80 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.006246
K_81 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.006191
K_82 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.005002
K_83 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.004946
K_84 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.004888
K_85 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.004920
K_86 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.005176
K_87 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.005184
K_88 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.005079
K_89 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.005107
K_90 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.021078
K_91 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.005788
K_92 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.005382
K_93 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.004817
K_94 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_95 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.009571
K_96 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.009172
K_97 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.009258
K_98 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.009379
K_99 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.010216
K_100 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.010405
K_101 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.009974
K_102 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.010397
K_103 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.010574
K_104 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.010338
K_105 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.010427
K_106 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.010079
K_107 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.006347
K_108 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.006241
K_109 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.006169
K_110 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.006298
K_111 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.008622
K_112 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.008847
K_113 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.008523
K_114 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.008540
K_115 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.006228
K_116 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.006095
K_117 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.006087
K_118 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.006062
K_119 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.005719
K_120 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.005717
K_121 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.005587
K_122 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.005690
K_123 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.006448
K_124 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.006456
K_125 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.006351
K_126 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.006290
K_127 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.005063
K_128 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.005004
K_129 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.004946
K_130 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.004979
K_131 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.005286
K_132 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.005293
K_133 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.005184
K_134 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.005213
K_135 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.020872
K_136 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.005771
K_137 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.005523
K_138 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.004865
K_139 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.009433
K_140 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.009050
K_141 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.009124
K_142 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.009258
K_143 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.009803
K_144 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.009969
K_145 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.009578
K_146 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.009974
K_147 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.010963
K_148 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.010701
K_149 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.010785
K_150 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.010427
K_151 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.006212
K_152 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.006113
K_153 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.006042
K_154 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.006169
K_155 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.008598
K_156 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.008821
K_157 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.008493
K_158 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.008523
K_159 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.006252
K_160 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.006117
K_161 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.006106
K_162 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.006087
K_163 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.005612
K_164 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.005611
K_165 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.005485
K_166 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.005587
K_167 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.006510
K_168 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006519
K_169 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.006408
K_170 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.006351
K_171 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.005028
K_172 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.004970
K_173 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.004912
K_174 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.004946
K_175 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.005254
K_176 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.005261
K_177 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.005153
K_178 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.005184
K_179 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.022437
K_180 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.005738
K_181 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.005433
K_182 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.004897
K_183 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_184 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_185 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_186 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.006771
K_187 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.006981
K_188 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.006811
K_189 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.006892
K_190 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.008326
K_191 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.008485
K_192 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.008466
K_193 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.008193
K_194 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.010152
K_195 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.010203
K_196 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.009791
K_197 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.010173
K_198 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.005302
K_199 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.005427
K_200 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.005333
K_201 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.005315
K_202 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.009149
K_203 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.009078
K_204 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008969
K_205 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008789
K_206 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.005739
K_207 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.005829
K_208 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.005671
K_209 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.005750
K_210 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.005324
K_211 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.005402
K_212 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.005324
K_213 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.005266
K_214 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006585
K_215 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.006589
K_216 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.006429
K_217 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.006460
K_218 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.004946
K_219 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.005011
K_220 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.004905
K_221 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.004912
K_222 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.006750
K_223 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.013366
K_224 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.004636
K_225 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.004839
K_226 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_227 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_228 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.006573
K_229 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.006771
K_230 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.006613
K_231 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.006687
K_232 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.008163
K_233 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.008326
K_234 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.008301
K_235 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.008044
K_236 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.010077
K_237 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.010152
K_238 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.009734
K_239 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.010110
K_240 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.005182
K_241 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.005302
K_242 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.005212
K_243 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.005195
K_244 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.009204
K_245 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.009149
K_246 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.009030
K_247 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008845
K_248 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.005648
K_249 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.005739
K_250 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.005585
K_251 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.005661
K_252 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.005247
K_253 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.005324
K_254 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.005248
K_255 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.005192
K_256 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006574
K_257 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006585
K_258 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.006422
K_259 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.006453
K_260 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.004882
K_261 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.004946
K_262 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.004843
K_263 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.004850
K_264 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.006561
K_265 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.014094
K_266 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.004557
K_267 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.004807
K_268 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_269 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.006725
K_270 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.006934
K_271 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.006771
K_272 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.006847
K_273 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.008180
K_274 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.008337
K_275 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.008326
K_276 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.008060
K_277 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.010529
K_278 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.010600
K_279 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.010152
K_280 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.010566
K_281 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.005268
K_282 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.005393
K_283 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.005302
K_284 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.005282
K_285 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.009322
K_286 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.009256
K_287 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.009149
K_288 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.008950
K_289 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.005805
K_290 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.005901
K_291 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.005739
K_292 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.005819
K_293 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.005322
K_294 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.005401
K_295 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.005324
K_296 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.005265
K_297 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006746
K_298 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006754
K_299 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006585
K_300 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006615
K_301 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.004986
K_302 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.005053
K_303 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.004946
K_304 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.004952
K_305 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.006583
K_306 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.014112
K_307 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.004651
K_308 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.004866
K_309 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.006650
K_310 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.006852
K_311 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.006691
K_312 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.006771
K_313 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.008451
K_314 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.008625
K_315 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.008605
K_316 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.008326
K_317 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.010107
K_318 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.010170
K_319 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.009761
K_320 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.010152
K_321 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.005286
K_322 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.005412
K_323 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.005319
K_324 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.005302
K_325 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.009538
K_326 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.009468
K_327 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.009344
K_328 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.009149
K_329 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.005724
K_330 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.005816
K_331 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.005658
K_332 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.005739
K_333 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.005382
K_334 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.005464
K_335 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.005383
K_336 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.005324
K_337 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006711
K_338 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006718
K_339 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.006549
K_340 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006585
K_341 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.004979
K_342 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.005046
K_343 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.004938
K_344 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.004946
K_345 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.006675
K_346 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.014078
K_347 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.004613
K_348 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.004917
K_349 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_350 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_351 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_352 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.005848
K_353 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.005772
K_354 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.005868
K_355 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.005727
K_356 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.007540
K_357 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.007291
K_358 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.007333
K_359 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.007385
K_360 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.009805
K_361 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.009953
K_362 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.009869
K_363 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.009528
K_364 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.004965
K_365 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.004876
K_366 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.004919
K_367 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.004860
K_368 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.009344
K_369 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.009192
K_370 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008957
K_371 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.009084
K_372 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.005642
K_373 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.005615
K_374 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.005617
K_375 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.005506
K_376 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.005324
K_377 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.005230
K_378 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.005221
K_379 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.005202
K_380 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006351
K_381 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006317
K_382 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006231
K_383 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006184
K_384 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.007969
K_385 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.004867
K_386 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.009983
K_387 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.004390
K_388 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_389 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_390 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.005923
K_391 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.005848
K_392 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.005946
K_393 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.005799
K_394 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.007804
K_395 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.007540
K_396 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.007580
K_397 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.007638
K_398 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.009642
K_399 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.009805
K_400 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.009714
K_401 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.009388
K_402 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.005057
K_403 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.004965
K_404 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.005010
K_405 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.004947
K_406 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.009484
K_407 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.009344
K_408 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.009088
K_409 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.009221
K_410 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.005666
K_411 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.005642
K_412 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.005642
K_413 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.005530
K_414 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.005421
K_415 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.005324
K_416 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.005313
K_417 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.005293
K_418 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006380
K_419 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006351
K_420 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006261
K_421 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.006213
K_422 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.007978
K_423 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.004979
K_424 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.009829
K_425 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.004422
K_426 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_427 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.005824
K_428 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.005751
K_429 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.005848
K_430 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.005707
K_431 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.007754
K_432 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.007490
K_433 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.007540
K_434 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.007592
K_435 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.009721
K_436 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.009876
K_437 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.009805
K_438 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.009460
K_439 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.005010
K_440 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.004919
K_441 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.004965
K_442 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.004903
K_443 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009765
K_444 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.009602
K_445 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.009344
K_446 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.009479
K_447 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.005664
K_448 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.005638
K_449 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.005642
K_450 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.005528
K_451 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.005430
K_452 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.005332
K_453 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.005324
K_454 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.005302
K_455 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006473
K_456 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006440
K_457 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006351
K_458 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006299
K_459 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.007762
K_460 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.004917
K_461 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.010287
K_462 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.004422
K_463 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.005973
K_464 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.005894
K_465 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.005996
K_466 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.005848
K_467 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.007693
K_468 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.007435
K_469 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.007479
K_470 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.007540
K_471 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.010084
K_472 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.010258
K_473 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.010166
K_474 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.009805
K_475 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.005075
K_476 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.004981
K_477 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.005028
K_478 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.004965
K_479 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.009608
K_480 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.009453
K_481 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.009197
K_482 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.009344
K_483 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.005785
K_484 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.005757
K_485 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.005759
K_486 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.005642
K_487 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.005452
K_488 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.005353
K_489 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.005343
K_490 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.005324
K_491 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006527
K_492 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006493
K_493 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006399
K_494 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006351
K_495 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.008042
K_496 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.004946
K_497 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.010145
K_498 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.004482
K_499 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_500 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_501 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_502 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.005411
K_503 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.005374
K_504 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.005316
K_505 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.005450
K_506 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.007162
K_507 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.007366
K_508 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.007146
K_509 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.007277
K_510 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.009623
K_511 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.009307
K_512 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.009213
K_513 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.009386
K_514 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.004870
K_515 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.004891
K_516 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.004800
K_517 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.004903
K_518 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.009344
K_519 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.009532
K_520 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.009144
K_521 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.009207
K_522 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.005739
K_523 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.005689
K_524 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.005591
K_525 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.005697
K_526 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.005587
K_527 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.005630
K_528 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.005486
K_529 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.005575
K_530 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.009964
K_531 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006405
K_532 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.004518
K_533 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.007164
K_534 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_535 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_536 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.005444
K_537 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.005411
K_538 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.005349
K_539 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.005485
K_540 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.006966
K_541 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.007162
K_542 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.006956
K_543 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.007076
K_544 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.009951
K_545 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.009623
K_546 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.009510
K_547 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.009700
K_548 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.004845
K_549 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.004870
K_550 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.004778
K_551 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.004879
K_552 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.009149
K_553 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.009344
K_554 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008970
K_555 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.009029
K_556 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.005785
K_557 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.005739
K_558 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.005636
K_559 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.005744
K_560 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.005541
K_561 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.005587
K_562 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.005444
K_563 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.005532
K_564 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.009625
K_565 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006558
K_566 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.004469
K_567 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.007162
K_568 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_569 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.005506
K_570 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.005470
K_571 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.005411
K_572 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.005550
K_573 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.007169
K_574 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.007378
K_575 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.007162
K_576 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.007289
K_577 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.010068
K_578 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.009718
K_579 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.009623
K_580 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.009809
K_581 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.004939
K_582 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.004964
K_583 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.004870
K_584 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.004975
K_585 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.009537
K_586 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.009748
K_587 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.009344
K_588 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.009401
K_589 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.005895
K_590 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.005843
K_591 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.005739
K_592 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.005851
K_593 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.005689
K_594 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.005736
K_595 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.005587
K_596 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.005679
K_597 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.009666
K_598 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006551
K_599 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.004555
K_600 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.007349
K_601 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.005369
K_602 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.005335
K_603 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.005278
K_604 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.005411
K_605 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.007043
K_606 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.007241
K_607 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.007032
K_608 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.007162
K_609 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.009857
K_610 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.009528
K_611 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.009428
K_612 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.009623
K_613 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.004835
K_614 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.004857
K_615 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.004768
K_616 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.004870
K_617 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.009468
K_618 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.009674
K_619 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.009269
K_620 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.009344
K_621 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.005778
K_622 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.005729
K_623 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.005629
K_624 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.005739
K_625 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.005594
K_626 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.005639
K_627 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.005495
K_628 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.005587
K_629 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.009527
K_630 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006419
K_631 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.004476
K_632 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.007334
K_633 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_634 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_635 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_636 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.005226
K_637 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.005336
K_638 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.005308
K_639 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.005233
K_640 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.007048
K_641 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.006994
K_642 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.007087
K_643 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.006869
K_644 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.009623
K_645 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.010007
K_646 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.009610
K_647 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.009647
K_648 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.004965
K_649 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.005021
K_650 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.005009
K_651 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.004914
K_652 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.009149
K_653 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.009114
K_654 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.008991
K_655 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.008801
K_656 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.006087
K_657 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.006194
K_658 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.006088
K_659 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.006015
K_660 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.004909
K_661 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.009297
K_662 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.006102
K_663 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.004682
K_664 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_665 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_666 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.005119
K_667 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.005226
K_668 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.005197
K_669 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.005127
K_670 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.007094
K_671 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.007048
K_672 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.007138
K_673 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.006915
K_674 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.009261
K_675 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.009623
K_676 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.009259
K_677 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.009292
K_678 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.004909
K_679 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.004965
K_680 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.004953
K_681 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.004861
K_682 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.009167
K_683 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.009149
K_684 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.009016
K_685 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.008825
K_686 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.005980
K_687 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.006087
K_688 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.005984
K_689 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.005915
K_690 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.004842
K_691 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.009585
K_692 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.005937
K_693 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.004659
K_694 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_695 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.005145
K_696 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.005252
K_697 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.005226
K_698 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.005153
K_699 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.007001
K_700 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.006953
K_701 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.007048
K_702 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.006829
K_703 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.009615
K_704 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.010009
K_705 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.009623
K_706 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.009649
K_707 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.004921
K_708 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.004976
K_709 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.004965
K_710 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.004872
K_711 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.009299
K_712 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.009271
K_713 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.009149
K_714 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.008942
K_715 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.006080
K_716 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.006189
K_717 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.006087
K_718 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.006011
K_719 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.004804
K_720 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.009246
K_721 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.006057
K_722 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.004670
K_723 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.005215
K_724 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.005327
K_725 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.005298
K_726 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.005226
K_727 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.007233
K_728 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.007179
K_729 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.007279
K_730 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.007048
K_731 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.009578
K_732 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.009969
K_733 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.009576
K_734 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.009623
K_735 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.005016
K_736 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.005074
K_737 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.005062
K_738 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.004965
K_739 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.009522
K_740 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.009492
K_741 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.009353
K_742 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.009149
K_743 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.006155
K_744 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.006269
K_745 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.006160
K_746 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.006087
K_747 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.004883
K_748 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.009555
K_749 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.006057
K_750 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.004756
K_751 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_752 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_753 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_754 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.005226
K_755 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.005100
K_756 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.005161
K_757 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.005143
K_758 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.007162
K_759 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.007034
K_760 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.006956
K_761 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.007148
K_762 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.009805
K_763 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.009517
K_764 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.009602
K_765 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.009372
K_766 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.005302
K_767 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.005185
K_768 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.005189
K_769 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.005223
K_770 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.008523
K_771 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.008343
K_772 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.008194
K_773 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.008294
K_774 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.008786
K_775 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.004236
K_776 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.008988
K_777 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.006001
K_778 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_779 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_780 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.005358
K_781 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.005226
K_782 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.005291
K_783 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.005271
K_784 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.007287
K_785 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.007162
K_786 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.007075
K_787 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.007277
K_788 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.010097
K_789 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.009805
K_790 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.009887
K_791 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.009637
K_792 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.005423
K_793 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.005302
K_794 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.005304
K_795 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.005340
K_796 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.008701
K_797 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.008523
K_798 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.008359
K_799 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.008464
K_800 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.008913
K_801 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.004323
K_802 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.008993
K_803 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.006122
K_804 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_805 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.005289
K_806 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.005160
K_807 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.005226
K_808 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.005205
K_809 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.007377
K_810 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.007243
K_811 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.007162
K_812 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.007367
K_813 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.009998
K_814 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.009704
K_815 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.009805
K_816 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.009551
K_817 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.005419
K_818 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.005297
K_819 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.005302
K_820 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.005336
K_821 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.008879
K_822 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.008683
K_823 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.008523
K_824 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.008628
K_825 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.008561
K_826 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.004276
K_827 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.009270
K_828 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.006102
K_829 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.005310
K_830 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.005179
K_831 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.005244
K_832 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.005226
K_833 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.007167
K_834 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.007043
K_835 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.006965
K_836 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.007162
K_837 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.010279
K_838 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.009959
K_839 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.010057
K_840 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.009805
K_841 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.005382
K_842 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.005262
K_843 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.005265
K_844 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.005302
K_845 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.008757
K_846 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.008569
K_847 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.008408
K_848 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.008523
K_849 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.008684
K_850 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.004265
K_851 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.008891
K_852 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.006175
K_853 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_854 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_855 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_856 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.005411
K_857 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.005500
K_858 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.005389
K_859 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.005499
K_860 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.007540
K_861 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.007804
K_862 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.007638
K_863 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.007580
K_864 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.010152
K_865 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.010254
K_866 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.009818
K_867 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.010192
K_868 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.006169
K_869 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.006316
K_870 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.006142
K_871 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.006216
K_872 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.005289
K_873 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.011446
K_874 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.004377
K_875 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.008532
K_876 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_877 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_878 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.005322
K_879 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.005411
K_880 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.005303
K_881 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.005408
K_882 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.007291
K_883 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.007540
K_884 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.007385
K_885 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.007332
K_886 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.010029
K_887 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.010152
K_888 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.009717
K_889 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.010080
K_890 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.006026
K_891 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.006169
K_892 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.006004
K_893 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.006073
K_894 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.005185
K_895 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.011758
K_896 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.004304
K_897 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.008313
K_898 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_899 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.005429
K_900 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.005521
K_901 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.005411
K_902 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.005520
K_903 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.007435
K_904 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.007693
K_905 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.007540
K_906 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.007478
K_907 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.010495
K_908 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.010622
K_909 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.010152
K_910 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.010553
K_911 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.006190
K_912 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.006342
K_913 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.006169
K_914 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.006241
K_915 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.005175
K_916 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.011534
K_917 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.004371
K_918 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.008535
K_919 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.005322
K_920 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.005409
K_921 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.005304
K_922 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.005411
K_923 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.007490
K_924 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.007755
K_925 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.007592
K_926 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.007540
K_927 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.010088
K_928 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.010201
K_929 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.009771
K_930 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.010152
K_931 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.006117
K_932 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.006263
K_933 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.006094
K_934 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.006169
K_935 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.005183
K_936 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.011140
K_937 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.004318
K_938 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.008648
K_939 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_940 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_941 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_942 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.005848
K_943 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.005853
K_944 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.005920
K_945 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.005757
K_946 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.008326
K_947 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.008070
K_948 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.008207
K_949 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.008041
K_950 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.010427
K_951 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.010477
K_952 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.010438
K_953 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.010042
K_954 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.004813
K_955 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.005134
K_956 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.014633
K_957 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.005125
K_958 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_959 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_960 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.005839
K_961 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.005848
K_962 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.005912
K_963 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.005751
K_964 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.008593
K_965 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.008326
K_966 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.008469
K_967 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.008287
K_968 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.010353
K_969 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.010427
K_970 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.010376
K_971 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.009987
K_972 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.004795
K_973 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.005240
K_974 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.013678
K_975 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.005151
K_976 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_977 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.005775
K_978 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.005782
K_979 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.005848
K_980 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.005690
K_981 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.008436
K_982 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.008177
K_983 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.008326
K_984 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.008146
K_985 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.010390
K_986 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.010452
K_987 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.010427
K_988 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.010020
K_989 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.004713
K_990 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.005125
K_991 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.014037
K_992 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.005108
K_993 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.005939
K_994 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.005947
K_995 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.006016
K_996 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.005848
K_997 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.008628
K_998 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.008351
K_999 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.008503
K_1000 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.008326
K_1001 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.010832
K_1002 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.010902
K_1003 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.010859
K_1004 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.010427
K_1005 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.004793
K_1006 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.005181
K_1007 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.014150
K_1008 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.005227
K_1009 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_1010 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_1011 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_1012 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.006771
K_1013 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.006621
K_1014 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.006600
K_1015 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.006751
K_1016 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.009974
K_1017 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.009981
K_1018 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.009641
K_1019 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.010068
K_1020 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.006357
K_1021 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.004821
K_1022 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.005760
K_1023 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.014562
K_1024 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_1025 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_1026 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.006925
K_1027 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.006771
K_1028 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.006745
K_1029 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.006907
K_1030 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.009944
K_1031 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.009974
K_1032 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.009624
K_1033 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.010049
K_1034 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.006325
K_1035 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.004913
K_1036 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.005703
K_1037 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.015331
K_1038 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_1039 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.006949
K_1040 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.006790
K_1041 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.006771
K_1042 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.006931
K_1043 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.010318
K_1044 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.010339
K_1045 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.009974
K_1046 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.010436
K_1047 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.006219
K_1048 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.004855
K_1049 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.005791
K_1050 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.015374
K_1051 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.006785
K_1052 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.006637
K_1053 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.006616
K_1054 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.006771
K_1055 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.009860
K_1056 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.009878
K_1057 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.009548
K_1058 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.009974
K_1059 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.006201
K_1060 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.004809
K_1061 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.005646
K_1062 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.015540
K_1063 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_1064 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_1065 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_1066 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.009258
K_1067 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.009679
K_1068 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.009428
K_1069 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.009378
K_1070 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.004310
K_1071 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.007848
K_1072 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.005682
K_1073 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.007778
K_1074 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_1075 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_1076 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.008871
K_1077 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.009258
K_1078 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.009029
K_1079 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.008985
K_1080 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.004262
K_1081 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.008001
K_1082 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.005543
K_1083 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.007659
K_1084 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_1085 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.009079
K_1086 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.009485
K_1087 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.009258
K_1088 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.009201
K_1089 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.004223
K_1090 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.007723
K_1091 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.005610
K_1092 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.007632
K_1093 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.009124
K_1094 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.009537
K_1095 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.009297
K_1096 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.009258
K_1097 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.004256
K_1098 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.007771
K_1099 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.005563
K_1100 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.007889
K_1101 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_1102 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_1103 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_1104 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.004808
K_1105 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.004694
K_1106 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.009407
K_1107 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.008615
K_1108 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_1109 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_1110 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.004796
K_1111 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.004781
K_1112 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.009180
K_1113 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.008779
K_1114 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_1115 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.004711
K_1116 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.004689
K_1117 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.009260
K_1118 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.008553
K_1119 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.004750
K_1120 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.004694
K_1121 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.009009
K_1122 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.008878
K_1123 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.004669
K_1124 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.004975
K_1125 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.004648
K_1126 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.003996
K_1127 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.004975
K_1128 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.004669

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
