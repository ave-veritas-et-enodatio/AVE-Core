* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Holmium-165 (Z=67, A=165)
* Auto-generated topological mutual impedance array
* Nodes: 165

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON
X_NUC_65 NODE_65 0 NUCLEON
X_NUC_66 NODE_66 0 NUCLEON
X_NUC_67 NODE_67 0 NUCLEON
X_NUC_68 NODE_68 0 NUCLEON
X_NUC_69 NODE_69 0 NUCLEON
X_NUC_70 NODE_70 0 NUCLEON
X_NUC_71 NODE_71 0 NUCLEON
X_NUC_72 NODE_72 0 NUCLEON
X_NUC_73 NODE_73 0 NUCLEON
X_NUC_74 NODE_74 0 NUCLEON
X_NUC_75 NODE_75 0 NUCLEON
X_NUC_76 NODE_76 0 NUCLEON
X_NUC_77 NODE_77 0 NUCLEON
X_NUC_78 NODE_78 0 NUCLEON
X_NUC_79 NODE_79 0 NUCLEON
X_NUC_80 NODE_80 0 NUCLEON
X_NUC_81 NODE_81 0 NUCLEON
X_NUC_82 NODE_82 0 NUCLEON
X_NUC_83 NODE_83 0 NUCLEON
X_NUC_84 NODE_84 0 NUCLEON
X_NUC_85 NODE_85 0 NUCLEON
X_NUC_86 NODE_86 0 NUCLEON
X_NUC_87 NODE_87 0 NUCLEON
X_NUC_88 NODE_88 0 NUCLEON
X_NUC_89 NODE_89 0 NUCLEON
X_NUC_90 NODE_90 0 NUCLEON
X_NUC_91 NODE_91 0 NUCLEON
X_NUC_92 NODE_92 0 NUCLEON
X_NUC_93 NODE_93 0 NUCLEON
X_NUC_94 NODE_94 0 NUCLEON
X_NUC_95 NODE_95 0 NUCLEON
X_NUC_96 NODE_96 0 NUCLEON
X_NUC_97 NODE_97 0 NUCLEON
X_NUC_98 NODE_98 0 NUCLEON
X_NUC_99 NODE_99 0 NUCLEON
X_NUC_100 NODE_100 0 NUCLEON
X_NUC_101 NODE_101 0 NUCLEON
X_NUC_102 NODE_102 0 NUCLEON
X_NUC_103 NODE_103 0 NUCLEON
X_NUC_104 NODE_104 0 NUCLEON
X_NUC_105 NODE_105 0 NUCLEON
X_NUC_106 NODE_106 0 NUCLEON
X_NUC_107 NODE_107 0 NUCLEON
X_NUC_108 NODE_108 0 NUCLEON
X_NUC_109 NODE_109 0 NUCLEON
X_NUC_110 NODE_110 0 NUCLEON
X_NUC_111 NODE_111 0 NUCLEON
X_NUC_112 NODE_112 0 NUCLEON
X_NUC_113 NODE_113 0 NUCLEON
X_NUC_114 NODE_114 0 NUCLEON
X_NUC_115 NODE_115 0 NUCLEON
X_NUC_116 NODE_116 0 NUCLEON
X_NUC_117 NODE_117 0 NUCLEON
X_NUC_118 NODE_118 0 NUCLEON
X_NUC_119 NODE_119 0 NUCLEON
X_NUC_120 NODE_120 0 NUCLEON
X_NUC_121 NODE_121 0 NUCLEON
X_NUC_122 NODE_122 0 NUCLEON
X_NUC_123 NODE_123 0 NUCLEON
X_NUC_124 NODE_124 0 NUCLEON
X_NUC_125 NODE_125 0 NUCLEON
X_NUC_126 NODE_126 0 NUCLEON
X_NUC_127 NODE_127 0 NUCLEON
X_NUC_128 NODE_128 0 NUCLEON
X_NUC_129 NODE_129 0 NUCLEON
X_NUC_130 NODE_130 0 NUCLEON
X_NUC_131 NODE_131 0 NUCLEON
X_NUC_132 NODE_132 0 NUCLEON
X_NUC_133 NODE_133 0 NUCLEON
X_NUC_134 NODE_134 0 NUCLEON
X_NUC_135 NODE_135 0 NUCLEON
X_NUC_136 NODE_136 0 NUCLEON
X_NUC_137 NODE_137 0 NUCLEON
X_NUC_138 NODE_138 0 NUCLEON
X_NUC_139 NODE_139 0 NUCLEON
X_NUC_140 NODE_140 0 NUCLEON
X_NUC_141 NODE_141 0 NUCLEON
X_NUC_142 NODE_142 0 NUCLEON
X_NUC_143 NODE_143 0 NUCLEON
X_NUC_144 NODE_144 0 NUCLEON
X_NUC_145 NODE_145 0 NUCLEON
X_NUC_146 NODE_146 0 NUCLEON
X_NUC_147 NODE_147 0 NUCLEON
X_NUC_148 NODE_148 0 NUCLEON
X_NUC_149 NODE_149 0 NUCLEON
X_NUC_150 NODE_150 0 NUCLEON
X_NUC_151 NODE_151 0 NUCLEON
X_NUC_152 NODE_152 0 NUCLEON
X_NUC_153 NODE_153 0 NUCLEON
X_NUC_154 NODE_154 0 NUCLEON
X_NUC_155 NODE_155 0 NUCLEON
X_NUC_156 NODE_156 0 NUCLEON
X_NUC_157 NODE_157 0 NUCLEON
X_NUC_158 NODE_158 0 NUCLEON
X_NUC_159 NODE_159 0 NUCLEON
X_NUC_160 NODE_160 0 NUCLEON
X_NUC_161 NODE_161 0 NUCLEON
X_NUC_162 NODE_162 0 NUCLEON
X_NUC_163 NODE_163 0 NUCLEON
X_NUC_164 NODE_164 0 NUCLEON
X_NUC_165 NODE_165 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.005505
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.005371
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.005405
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.005448
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.005945
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.006013
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.005878
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.006029
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.006372
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.006279
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.006356
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.006204
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.003571
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.003535
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.003519
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.003565
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.005417
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.005543
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.005428
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.005430
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.003560
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.003506
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.003524
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.003510
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.003221
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.003224
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.003186
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.003231
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.004221
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.004241
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.004227
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.004163
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.002719
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.002691
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.002687
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.002702
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.003263
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.003297
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.003247
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.003271
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.003036
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.003011
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.003018
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.002992
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.002459
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.002450
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.002433
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.002455
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.003155
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.003184
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.003153
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.003137
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.002396
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.002374
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.002373
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.002373
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.002456
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.002465
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.002437
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.002457
K_64 X_NUC_1.L_CORE X_NUC_65.L_CORE 0.002686
K_65 X_NUC_1.L_CORE X_NUC_66.L_CORE 0.002683
K_66 X_NUC_1.L_CORE X_NUC_67.L_CORE 0.002677
K_67 X_NUC_1.L_CORE X_NUC_68.L_CORE 0.002655
K_68 X_NUC_1.L_CORE X_NUC_69.L_CORE 0.002122
K_69 X_NUC_1.L_CORE X_NUC_70.L_CORE 0.002110
K_70 X_NUC_1.L_CORE X_NUC_71.L_CORE 0.002101
K_71 X_NUC_1.L_CORE X_NUC_72.L_CORE 0.002112
K_72 X_NUC_1.L_CORE X_NUC_73.L_CORE 0.002490
K_73 X_NUC_1.L_CORE X_NUC_74.L_CORE 0.002508
K_74 X_NUC_1.L_CORE X_NUC_75.L_CORE 0.002481
K_75 X_NUC_1.L_CORE X_NUC_76.L_CORE 0.002484
K_76 X_NUC_1.L_CORE X_NUC_77.L_CORE 0.002222
K_77 X_NUC_1.L_CORE X_NUC_78.L_CORE 0.002209
K_78 X_NUC_1.L_CORE X_NUC_79.L_CORE 0.002207
K_79 X_NUC_1.L_CORE X_NUC_80.L_CORE 0.002199
K_80 X_NUC_1.L_CORE X_NUC_81.L_CORE 0.002056
K_81 X_NUC_1.L_CORE X_NUC_82.L_CORE 0.002055
K_82 X_NUC_1.L_CORE X_NUC_83.L_CORE 0.002039
K_83 X_NUC_1.L_CORE X_NUC_84.L_CORE 0.002052
K_84 X_NUC_1.L_CORE X_NUC_85.L_CORE 0.002349
K_85 X_NUC_1.L_CORE X_NUC_86.L_CORE 0.002356
K_86 X_NUC_1.L_CORE X_NUC_87.L_CORE 0.002341
K_87 X_NUC_1.L_CORE X_NUC_88.L_CORE 0.002331
K_88 X_NUC_1.L_CORE X_NUC_89.L_CORE 0.001952
K_89 X_NUC_1.L_CORE X_NUC_90.L_CORE 0.001941
K_90 X_NUC_1.L_CORE X_NUC_91.L_CORE 0.001935
K_91 X_NUC_1.L_CORE X_NUC_92.L_CORE 0.001938
K_92 X_NUC_1.L_CORE X_NUC_93.L_CORE 0.002075
K_93 X_NUC_1.L_CORE X_NUC_94.L_CORE 0.002082
K_94 X_NUC_1.L_CORE X_NUC_95.L_CORE 0.002062
K_95 X_NUC_1.L_CORE X_NUC_96.L_CORE 0.002070
K_96 X_NUC_1.L_CORE X_NUC_97.L_CORE 0.002074
K_97 X_NUC_1.L_CORE X_NUC_98.L_CORE 0.002069
K_98 X_NUC_1.L_CORE X_NUC_99.L_CORE 0.002062
K_99 X_NUC_1.L_CORE X_NUC_100.L_CORE 0.002054
K_100 X_NUC_1.L_CORE X_NUC_101.L_CORE 0.001844
K_101 X_NUC_1.L_CORE X_NUC_102.L_CORE 0.001840
K_102 X_NUC_1.L_CORE X_NUC_103.L_CORE 0.001829
K_103 X_NUC_1.L_CORE X_NUC_104.L_CORE 0.001837
K_104 X_NUC_1.L_CORE X_NUC_105.L_CORE 0.002039
K_105 X_NUC_1.L_CORE X_NUC_106.L_CORE 0.002045
K_106 X_NUC_1.L_CORE X_NUC_107.L_CORE 0.002029
K_107 X_NUC_1.L_CORE X_NUC_108.L_CORE 0.002028
K_108 X_NUC_1.L_CORE X_NUC_109.L_CORE 0.001848
K_109 X_NUC_1.L_CORE X_NUC_110.L_CORE 0.001841
K_110 X_NUC_1.L_CORE X_NUC_111.L_CORE 0.001835
K_111 X_NUC_1.L_CORE X_NUC_112.L_CORE 0.001834
K_112 X_NUC_1.L_CORE X_NUC_113.L_CORE 0.001824
K_113 X_NUC_1.L_CORE X_NUC_114.L_CORE 0.001825
K_114 X_NUC_1.L_CORE X_NUC_115.L_CORE 0.001811
K_115 X_NUC_1.L_CORE X_NUC_116.L_CORE 0.001818
K_116 X_NUC_1.L_CORE X_NUC_117.L_CORE 0.001896
K_117 X_NUC_1.L_CORE X_NUC_118.L_CORE 0.001896
K_118 X_NUC_1.L_CORE X_NUC_119.L_CORE 0.001887
K_119 X_NUC_1.L_CORE X_NUC_120.L_CORE 0.001883
K_120 X_NUC_1.L_CORE X_NUC_121.L_CORE 0.001735
K_121 X_NUC_1.L_CORE X_NUC_122.L_CORE 0.001731
K_122 X_NUC_1.L_CORE X_NUC_123.L_CORE 0.001722
K_123 X_NUC_1.L_CORE X_NUC_124.L_CORE 0.001725
K_124 X_NUC_1.L_CORE X_NUC_125.L_CORE 0.001792
K_125 X_NUC_1.L_CORE X_NUC_126.L_CORE 0.001794
K_126 X_NUC_1.L_CORE X_NUC_127.L_CORE 0.001781
K_127 X_NUC_1.L_CORE X_NUC_128.L_CORE 0.001783
K_128 X_NUC_1.L_CORE X_NUC_129.L_CORE 0.001743
K_129 X_NUC_1.L_CORE X_NUC_130.L_CORE 0.001741
K_130 X_NUC_1.L_CORE X_NUC_131.L_CORE 0.001732
K_131 X_NUC_1.L_CORE X_NUC_132.L_CORE 0.001732
K_132 X_NUC_1.L_CORE X_NUC_133.L_CORE 0.034949
K_133 X_NUC_1.L_CORE X_NUC_134.L_CORE 0.005113
K_134 X_NUC_1.L_CORE X_NUC_135.L_CORE 0.005604
K_135 X_NUC_1.L_CORE X_NUC_136.L_CORE 0.005911
K_136 X_NUC_1.L_CORE X_NUC_137.L_CORE 0.003360
K_137 X_NUC_1.L_CORE X_NUC_138.L_CORE 0.005134
K_138 X_NUC_1.L_CORE X_NUC_139.L_CORE 0.003338
K_139 X_NUC_1.L_CORE X_NUC_140.L_CORE 0.003048
K_140 X_NUC_1.L_CORE X_NUC_141.L_CORE 0.003983
K_141 X_NUC_1.L_CORE X_NUC_142.L_CORE 0.002562
K_142 X_NUC_1.L_CORE X_NUC_143.L_CORE 0.003098
K_143 X_NUC_1.L_CORE X_NUC_144.L_CORE 0.002858
K_144 X_NUC_1.L_CORE X_NUC_145.L_CORE 0.002325
K_145 X_NUC_1.L_CORE X_NUC_146.L_CORE 0.002993
K_146 X_NUC_1.L_CORE X_NUC_147.L_CORE 0.002259
K_147 X_NUC_1.L_CORE X_NUC_148.L_CORE 0.002329
K_148 X_NUC_1.L_CORE X_NUC_149.L_CORE 0.002538
K_149 X_NUC_1.L_CORE X_NUC_150.L_CORE 0.002005
K_150 X_NUC_1.L_CORE X_NUC_151.L_CORE 0.002364
K_151 X_NUC_1.L_CORE X_NUC_152.L_CORE 0.002098
K_152 X_NUC_1.L_CORE X_NUC_153.L_CORE 0.001948
K_153 X_NUC_1.L_CORE X_NUC_154.L_CORE 0.002226
K_154 X_NUC_1.L_CORE X_NUC_155.L_CORE 0.001844
K_155 X_NUC_1.L_CORE X_NUC_156.L_CORE 0.001968
K_156 X_NUC_1.L_CORE X_NUC_157.L_CORE 0.001961
K_157 X_NUC_1.L_CORE X_NUC_158.L_CORE 0.001746
K_158 X_NUC_1.L_CORE X_NUC_159.L_CORE 0.001933
K_159 X_NUC_1.L_CORE X_NUC_160.L_CORE 0.001748
K_160 X_NUC_1.L_CORE X_NUC_161.L_CORE 0.001729
K_161 X_NUC_1.L_CORE X_NUC_162.L_CORE 0.001796
K_162 X_NUC_1.L_CORE X_NUC_163.L_CORE 0.001642
K_163 X_NUC_1.L_CORE X_NUC_164.L_CORE 0.001699
K_164 X_NUC_1.L_CORE X_NUC_165.L_CORE 0.001651
K_165 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_166 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_167 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.005647
K_168 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.005505
K_169 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.005540
K_170 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.005587
K_171 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.005876
K_172 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.005945
K_173 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.005812
K_174 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.005959
K_175 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.006463
K_176 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.006372
K_177 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.006449
K_178 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.006290
K_179 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.003607
K_180 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.003571
K_181 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.003554
K_182 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.003602
K_183 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.005295
K_184 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.005417
K_185 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.005307
K_186 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.005310
K_187 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.003615
K_188 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.003560
K_189 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.003578
K_190 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.003564
K_191 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.003217
K_192 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.003221
K_193 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.003182
K_194 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.003227
K_195 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.004200
K_196 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.004221
K_197 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.004207
K_198 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.004143
K_199 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.002748
K_200 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.002719
K_201 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.002715
K_202 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.002730
K_203 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.003229
K_204 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.003263
K_205 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.003214
K_206 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.003237
K_207 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.003060
K_208 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.003036
K_209 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.003042
K_210 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.003016
K_211 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.002468
K_212 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.002459
K_213 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.002441
K_214 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.002464
K_215 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.003127
K_216 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.003155
K_217 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.003124
K_218 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.003109
K_219 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.002418
K_220 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.002396
K_221 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.002395
K_222 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.002395
K_223 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.002447
K_224 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.002456
K_225 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.002428
K_226 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.002448
K_227 X_NUC_2.L_CORE X_NUC_65.L_CORE 0.002688
K_228 X_NUC_2.L_CORE X_NUC_66.L_CORE 0.002686
K_229 X_NUC_2.L_CORE X_NUC_67.L_CORE 0.002679
K_230 X_NUC_2.L_CORE X_NUC_68.L_CORE 0.002657
K_231 X_NUC_2.L_CORE X_NUC_69.L_CORE 0.002134
K_232 X_NUC_2.L_CORE X_NUC_70.L_CORE 0.002122
K_233 X_NUC_2.L_CORE X_NUC_71.L_CORE 0.002113
K_234 X_NUC_2.L_CORE X_NUC_72.L_CORE 0.002124
K_235 X_NUC_2.L_CORE X_NUC_73.L_CORE 0.002473
K_236 X_NUC_2.L_CORE X_NUC_74.L_CORE 0.002490
K_237 X_NUC_2.L_CORE X_NUC_75.L_CORE 0.002463
K_238 X_NUC_2.L_CORE X_NUC_76.L_CORE 0.002467
K_239 X_NUC_2.L_CORE X_NUC_77.L_CORE 0.002236
K_240 X_NUC_2.L_CORE X_NUC_78.L_CORE 0.002222
K_241 X_NUC_2.L_CORE X_NUC_79.L_CORE 0.002221
K_242 X_NUC_2.L_CORE X_NUC_80.L_CORE 0.002213
K_243 X_NUC_2.L_CORE X_NUC_81.L_CORE 0.002057
K_244 X_NUC_2.L_CORE X_NUC_82.L_CORE 0.002056
K_245 X_NUC_2.L_CORE X_NUC_83.L_CORE 0.002040
K_246 X_NUC_2.L_CORE X_NUC_84.L_CORE 0.002053
K_247 X_NUC_2.L_CORE X_NUC_85.L_CORE 0.002341
K_248 X_NUC_2.L_CORE X_NUC_86.L_CORE 0.002349
K_249 X_NUC_2.L_CORE X_NUC_87.L_CORE 0.002334
K_250 X_NUC_2.L_CORE X_NUC_88.L_CORE 0.002324
K_251 X_NUC_2.L_CORE X_NUC_89.L_CORE 0.001963
K_252 X_NUC_2.L_CORE X_NUC_90.L_CORE 0.001952
K_253 X_NUC_2.L_CORE X_NUC_91.L_CORE 0.001946
K_254 X_NUC_2.L_CORE X_NUC_92.L_CORE 0.001949
K_255 X_NUC_2.L_CORE X_NUC_93.L_CORE 0.002067
K_256 X_NUC_2.L_CORE X_NUC_94.L_CORE 0.002075
K_257 X_NUC_2.L_CORE X_NUC_95.L_CORE 0.002055
K_258 X_NUC_2.L_CORE X_NUC_96.L_CORE 0.002063
K_259 X_NUC_2.L_CORE X_NUC_97.L_CORE 0.002079
K_260 X_NUC_2.L_CORE X_NUC_98.L_CORE 0.002074
K_261 X_NUC_2.L_CORE X_NUC_99.L_CORE 0.002067
K_262 X_NUC_2.L_CORE X_NUC_100.L_CORE 0.002059
K_263 X_NUC_2.L_CORE X_NUC_101.L_CORE 0.001849
K_264 X_NUC_2.L_CORE X_NUC_102.L_CORE 0.001844
K_265 X_NUC_2.L_CORE X_NUC_103.L_CORE 0.001833
K_266 X_NUC_2.L_CORE X_NUC_104.L_CORE 0.001841
K_267 X_NUC_2.L_CORE X_NUC_105.L_CORE 0.002032
K_268 X_NUC_2.L_CORE X_NUC_106.L_CORE 0.002039
K_269 X_NUC_2.L_CORE X_NUC_107.L_CORE 0.002023
K_270 X_NUC_2.L_CORE X_NUC_108.L_CORE 0.002021
K_271 X_NUC_2.L_CORE X_NUC_109.L_CORE 0.001856
K_272 X_NUC_2.L_CORE X_NUC_110.L_CORE 0.001848
K_273 X_NUC_2.L_CORE X_NUC_111.L_CORE 0.001842
K_274 X_NUC_2.L_CORE X_NUC_112.L_CORE 0.001841
K_275 X_NUC_2.L_CORE X_NUC_113.L_CORE 0.001823
K_276 X_NUC_2.L_CORE X_NUC_114.L_CORE 0.001824
K_277 X_NUC_2.L_CORE X_NUC_115.L_CORE 0.001810
K_278 X_NUC_2.L_CORE X_NUC_116.L_CORE 0.001817
K_279 X_NUC_2.L_CORE X_NUC_117.L_CORE 0.001896
K_280 X_NUC_2.L_CORE X_NUC_118.L_CORE 0.001896
K_281 X_NUC_2.L_CORE X_NUC_119.L_CORE 0.001886
K_282 X_NUC_2.L_CORE X_NUC_120.L_CORE 0.001883
K_283 X_NUC_2.L_CORE X_NUC_121.L_CORE 0.001740
K_284 X_NUC_2.L_CORE X_NUC_122.L_CORE 0.001735
K_285 X_NUC_2.L_CORE X_NUC_123.L_CORE 0.001727
K_286 X_NUC_2.L_CORE X_NUC_124.L_CORE 0.001730
K_287 X_NUC_2.L_CORE X_NUC_125.L_CORE 0.001790
K_288 X_NUC_2.L_CORE X_NUC_126.L_CORE 0.001792
K_289 X_NUC_2.L_CORE X_NUC_127.L_CORE 0.001779
K_290 X_NUC_2.L_CORE X_NUC_128.L_CORE 0.001781
K_291 X_NUC_2.L_CORE X_NUC_129.L_CORE 0.001745
K_292 X_NUC_2.L_CORE X_NUC_130.L_CORE 0.001743
K_293 X_NUC_2.L_CORE X_NUC_131.L_CORE 0.001734
K_294 X_NUC_2.L_CORE X_NUC_132.L_CORE 0.001734
K_295 X_NUC_2.L_CORE X_NUC_133.L_CORE 0.033912
K_296 X_NUC_2.L_CORE X_NUC_134.L_CORE 0.005236
K_297 X_NUC_2.L_CORE X_NUC_135.L_CORE 0.005537
K_298 X_NUC_2.L_CORE X_NUC_136.L_CORE 0.005988
K_299 X_NUC_2.L_CORE X_NUC_137.L_CORE 0.003393
K_300 X_NUC_2.L_CORE X_NUC_138.L_CORE 0.005018
K_301 X_NUC_2.L_CORE X_NUC_139.L_CORE 0.003388
K_302 X_NUC_2.L_CORE X_NUC_140.L_CORE 0.003043
K_303 X_NUC_2.L_CORE X_NUC_141.L_CORE 0.003962
K_304 X_NUC_2.L_CORE X_NUC_142.L_CORE 0.002588
K_305 X_NUC_2.L_CORE X_NUC_143.L_CORE 0.003066
K_306 X_NUC_2.L_CORE X_NUC_144.L_CORE 0.002880
K_307 X_NUC_2.L_CORE X_NUC_145.L_CORE 0.002333
K_308 X_NUC_2.L_CORE X_NUC_146.L_CORE 0.002966
K_309 X_NUC_2.L_CORE X_NUC_147.L_CORE 0.002279
K_310 X_NUC_2.L_CORE X_NUC_148.L_CORE 0.002320
K_311 X_NUC_2.L_CORE X_NUC_149.L_CORE 0.002540
K_312 X_NUC_2.L_CORE X_NUC_150.L_CORE 0.002016
K_313 X_NUC_2.L_CORE X_NUC_151.L_CORE 0.002347
K_314 X_NUC_2.L_CORE X_NUC_152.L_CORE 0.002111
K_315 X_NUC_2.L_CORE X_NUC_153.L_CORE 0.001949
K_316 X_NUC_2.L_CORE X_NUC_154.L_CORE 0.002219
K_317 X_NUC_2.L_CORE X_NUC_155.L_CORE 0.001855
K_318 X_NUC_2.L_CORE X_NUC_156.L_CORE 0.001961
K_319 X_NUC_2.L_CORE X_NUC_157.L_CORE 0.001966
K_320 X_NUC_2.L_CORE X_NUC_158.L_CORE 0.001750
K_321 X_NUC_2.L_CORE X_NUC_159.L_CORE 0.001927
K_322 X_NUC_2.L_CORE X_NUC_160.L_CORE 0.001755
K_323 X_NUC_2.L_CORE X_NUC_161.L_CORE 0.001728
K_324 X_NUC_2.L_CORE X_NUC_162.L_CORE 0.001796
K_325 X_NUC_2.L_CORE X_NUC_163.L_CORE 0.001647
K_326 X_NUC_2.L_CORE X_NUC_164.L_CORE 0.001697
K_327 X_NUC_2.L_CORE X_NUC_165.L_CORE 0.001653
K_328 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_329 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.005608
K_330 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.005467
K_331 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.005505
K_332 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.005549
K_333 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.006011
K_334 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.006083
K_335 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.005945
K_336 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.006100
K_337 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.006382
K_338 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.006292
K_339 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.006372
K_340 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.006216
K_341 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.003624
K_342 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.003587
K_343 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.003571
K_344 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.003619
K_345 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.005402
K_346 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.005529
K_347 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.005417
K_348 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.005417
K_349 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.003597
K_350 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.003542
K_351 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.003560
K_352 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.003545
K_353 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.003256
K_354 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.003260
K_355 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.003221
K_356 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.003267
K_357 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.004214
K_358 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.004234
K_359 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.004221
K_360 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.004157
K_361 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.002752
K_362 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.002723
K_363 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.002719
K_364 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.002734
K_365 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.003278
K_366 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.003314
K_367 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.003263
K_368 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.003287
K_369 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.003053
K_370 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.003029
K_371 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.003036
K_372 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.003009
K_373 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.002486
K_374 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.002477
K_375 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.002459
K_376 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.002482
K_377 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.003157
K_378 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.003187
K_379 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.003155
K_380 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.003139
K_381 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.002419
K_382 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.002396
K_383 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.002396
K_384 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.002396
K_385 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.002475
K_386 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.002484
K_387 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.002456
K_388 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.002476
K_389 X_NUC_3.L_CORE X_NUC_65.L_CORE 0.002694
K_390 X_NUC_3.L_CORE X_NUC_66.L_CORE 0.002692
K_391 X_NUC_3.L_CORE X_NUC_67.L_CORE 0.002686
K_392 X_NUC_3.L_CORE X_NUC_68.L_CORE 0.002663
K_393 X_NUC_3.L_CORE X_NUC_69.L_CORE 0.002144
K_394 X_NUC_3.L_CORE X_NUC_70.L_CORE 0.002131
K_395 X_NUC_3.L_CORE X_NUC_71.L_CORE 0.002122
K_396 X_NUC_3.L_CORE X_NUC_72.L_CORE 0.002133
K_397 X_NUC_3.L_CORE X_NUC_73.L_CORE 0.002500
K_398 X_NUC_3.L_CORE X_NUC_74.L_CORE 0.002518
K_399 X_NUC_3.L_CORE X_NUC_75.L_CORE 0.002490
K_400 X_NUC_3.L_CORE X_NUC_76.L_CORE 0.002494
K_401 X_NUC_3.L_CORE X_NUC_77.L_CORE 0.002238
K_402 X_NUC_3.L_CORE X_NUC_78.L_CORE 0.002224
K_403 X_NUC_3.L_CORE X_NUC_79.L_CORE 0.002222
K_404 X_NUC_3.L_CORE X_NUC_80.L_CORE 0.002215
K_405 X_NUC_3.L_CORE X_NUC_81.L_CORE 0.002074
K_406 X_NUC_3.L_CORE X_NUC_82.L_CORE 0.002073
K_407 X_NUC_3.L_CORE X_NUC_83.L_CORE 0.002056
K_408 X_NUC_3.L_CORE X_NUC_84.L_CORE 0.002070
K_409 X_NUC_3.L_CORE X_NUC_85.L_CORE 0.002356
K_410 X_NUC_3.L_CORE X_NUC_86.L_CORE 0.002364
K_411 X_NUC_3.L_CORE X_NUC_87.L_CORE 0.002349
K_412 X_NUC_3.L_CORE X_NUC_88.L_CORE 0.002338
K_413 X_NUC_3.L_CORE X_NUC_89.L_CORE 0.001969
K_414 X_NUC_3.L_CORE X_NUC_90.L_CORE 0.001958
K_415 X_NUC_3.L_CORE X_NUC_91.L_CORE 0.001952
K_416 X_NUC_3.L_CORE X_NUC_92.L_CORE 0.001955
K_417 X_NUC_3.L_CORE X_NUC_93.L_CORE 0.002087
K_418 X_NUC_3.L_CORE X_NUC_94.L_CORE 0.002095
K_419 X_NUC_3.L_CORE X_NUC_95.L_CORE 0.002075
K_420 X_NUC_3.L_CORE X_NUC_96.L_CORE 0.002083
K_421 X_NUC_3.L_CORE X_NUC_97.L_CORE 0.002085
K_422 X_NUC_3.L_CORE X_NUC_98.L_CORE 0.002080
K_423 X_NUC_3.L_CORE X_NUC_99.L_CORE 0.002074
K_424 X_NUC_3.L_CORE X_NUC_100.L_CORE 0.002065
K_425 X_NUC_3.L_CORE X_NUC_101.L_CORE 0.001861
K_426 X_NUC_3.L_CORE X_NUC_102.L_CORE 0.001856
K_427 X_NUC_3.L_CORE X_NUC_103.L_CORE 0.001844
K_428 X_NUC_3.L_CORE X_NUC_104.L_CORE 0.001853
K_429 X_NUC_3.L_CORE X_NUC_105.L_CORE 0.002048
K_430 X_NUC_3.L_CORE X_NUC_106.L_CORE 0.002055
K_431 X_NUC_3.L_CORE X_NUC_107.L_CORE 0.002039
K_432 X_NUC_3.L_CORE X_NUC_108.L_CORE 0.002037
K_433 X_NUC_3.L_CORE X_NUC_109.L_CORE 0.001862
K_434 X_NUC_3.L_CORE X_NUC_110.L_CORE 0.001854
K_435 X_NUC_3.L_CORE X_NUC_111.L_CORE 0.001848
K_436 X_NUC_3.L_CORE X_NUC_112.L_CORE 0.001847
K_437 X_NUC_3.L_CORE X_NUC_113.L_CORE 0.001838
K_438 X_NUC_3.L_CORE X_NUC_114.L_CORE 0.001839
K_439 X_NUC_3.L_CORE X_NUC_115.L_CORE 0.001824
K_440 X_NUC_3.L_CORE X_NUC_116.L_CORE 0.001831
K_441 X_NUC_3.L_CORE X_NUC_117.L_CORE 0.001906
K_442 X_NUC_3.L_CORE X_NUC_118.L_CORE 0.001906
K_443 X_NUC_3.L_CORE X_NUC_119.L_CORE 0.001896
K_444 X_NUC_3.L_CORE X_NUC_120.L_CORE 0.001892
K_445 X_NUC_3.L_CORE X_NUC_121.L_CORE 0.001749
K_446 X_NUC_3.L_CORE X_NUC_122.L_CORE 0.001744
K_447 X_NUC_3.L_CORE X_NUC_123.L_CORE 0.001735
K_448 X_NUC_3.L_CORE X_NUC_124.L_CORE 0.001738
K_449 X_NUC_3.L_CORE X_NUC_125.L_CORE 0.001803
K_450 X_NUC_3.L_CORE X_NUC_126.L_CORE 0.001805
K_451 X_NUC_3.L_CORE X_NUC_127.L_CORE 0.001792
K_452 X_NUC_3.L_CORE X_NUC_128.L_CORE 0.001794
K_453 X_NUC_3.L_CORE X_NUC_129.L_CORE 0.001754
K_454 X_NUC_3.L_CORE X_NUC_130.L_CORE 0.001752
K_455 X_NUC_3.L_CORE X_NUC_131.L_CORE 0.001743
K_456 X_NUC_3.L_CORE X_NUC_132.L_CORE 0.001743
K_457 X_NUC_3.L_CORE X_NUC_133.L_CORE 0.030552
K_458 X_NUC_3.L_CORE X_NUC_134.L_CORE 0.005188
K_459 X_NUC_3.L_CORE X_NUC_135.L_CORE 0.005644
K_460 X_NUC_3.L_CORE X_NUC_136.L_CORE 0.005897
K_461 X_NUC_3.L_CORE X_NUC_137.L_CORE 0.003404
K_462 X_NUC_3.L_CORE X_NUC_138.L_CORE 0.005105
K_463 X_NUC_3.L_CORE X_NUC_139.L_CORE 0.003367
K_464 X_NUC_3.L_CORE X_NUC_140.L_CORE 0.003077
K_465 X_NUC_3.L_CORE X_NUC_141.L_CORE 0.003968
K_466 X_NUC_3.L_CORE X_NUC_142.L_CORE 0.002590
K_467 X_NUC_3.L_CORE X_NUC_143.L_CORE 0.003110
K_468 X_NUC_3.L_CORE X_NUC_144.L_CORE 0.002872
K_469 X_NUC_3.L_CORE X_NUC_145.L_CORE 0.002349
K_470 X_NUC_3.L_CORE X_NUC_146.L_CORE 0.002992
K_471 X_NUC_3.L_CORE X_NUC_147.L_CORE 0.002278
K_472 X_NUC_3.L_CORE X_NUC_148.L_CORE 0.002345
K_473 X_NUC_3.L_CORE X_NUC_149.L_CORE 0.002544
K_474 X_NUC_3.L_CORE X_NUC_150.L_CORE 0.002025
K_475 X_NUC_3.L_CORE X_NUC_151.L_CORE 0.002372
K_476 X_NUC_3.L_CORE X_NUC_152.L_CORE 0.002112
K_477 X_NUC_3.L_CORE X_NUC_153.L_CORE 0.001964
K_478 X_NUC_3.L_CORE X_NUC_154.L_CORE 0.002231
K_479 X_NUC_3.L_CORE X_NUC_155.L_CORE 0.001860
K_480 X_NUC_3.L_CORE X_NUC_156.L_CORE 0.001979
K_481 X_NUC_3.L_CORE X_NUC_157.L_CORE 0.001971
K_482 X_NUC_3.L_CORE X_NUC_158.L_CORE 0.001760
K_483 X_NUC_3.L_CORE X_NUC_159.L_CORE 0.001941
K_484 X_NUC_3.L_CORE X_NUC_160.L_CORE 0.001760
K_485 X_NUC_3.L_CORE X_NUC_161.L_CORE 0.001741
K_486 X_NUC_3.L_CORE X_NUC_162.L_CORE 0.001805
K_487 X_NUC_3.L_CORE X_NUC_163.L_CORE 0.001655
K_488 X_NUC_3.L_CORE X_NUC_164.L_CORE 0.001708
K_489 X_NUC_3.L_CORE X_NUC_165.L_CORE 0.001661
K_490 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.005561
K_491 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.005424
K_492 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.005459
K_493 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.005505
K_494 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.005860
K_495 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.005927
K_496 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.005797
K_497 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.005945
K_498 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.006548
K_499 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.006451
K_500 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.006534
K_501 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.006372
K_502 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.003576
K_503 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.003540
K_504 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.003525
K_505 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.003571
K_506 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.005400
K_507 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.005527
K_508 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.005413
K_509 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.005417
K_510 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.003611
K_511 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.003556
K_512 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.003574
K_513 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.003560
K_514 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.003210
K_515 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.003213
K_516 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.003176
K_517 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.003221
K_518 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.004280
K_519 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.004302
K_520 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.004288
K_521 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.004221
K_522 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.002737
K_523 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.002709
K_524 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.002705
K_525 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.002719
K_526 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.003254
K_527 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.003289
K_528 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.003239
K_529 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.003263
K_530 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.003080
K_531 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.003055
K_532 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.003062
K_533 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.003036
K_534 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.002462
K_535 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.002454
K_536 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.002436
K_537 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.002459
K_538 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.003173
K_539 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.003203
K_540 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.003171
K_541 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.003155
K_542 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.002419
K_543 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.002396
K_544 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.002395
K_545 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.002396
K_546 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.002454
K_547 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.002463
K_548 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.002436
K_549 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.002456
K_550 X_NUC_4.L_CORE X_NUC_65.L_CORE 0.002717
K_551 X_NUC_4.L_CORE X_NUC_66.L_CORE 0.002715
K_552 X_NUC_4.L_CORE X_NUC_67.L_CORE 0.002708
K_553 X_NUC_4.L_CORE X_NUC_68.L_CORE 0.002686
K_554 X_NUC_4.L_CORE X_NUC_69.L_CORE 0.002132
K_555 X_NUC_4.L_CORE X_NUC_70.L_CORE 0.002120
K_556 X_NUC_4.L_CORE X_NUC_71.L_CORE 0.002111
K_557 X_NUC_4.L_CORE X_NUC_72.L_CORE 0.002122
K_558 X_NUC_4.L_CORE X_NUC_73.L_CORE 0.002496
K_559 X_NUC_4.L_CORE X_NUC_74.L_CORE 0.002514
K_560 X_NUC_4.L_CORE X_NUC_75.L_CORE 0.002487
K_561 X_NUC_4.L_CORE X_NUC_76.L_CORE 0.002490
K_562 X_NUC_4.L_CORE X_NUC_77.L_CORE 0.002246
K_563 X_NUC_4.L_CORE X_NUC_78.L_CORE 0.002232
K_564 X_NUC_4.L_CORE X_NUC_79.L_CORE 0.002230
K_565 X_NUC_4.L_CORE X_NUC_80.L_CORE 0.002222
K_566 X_NUC_4.L_CORE X_NUC_81.L_CORE 0.002060
K_567 X_NUC_4.L_CORE X_NUC_82.L_CORE 0.002059
K_568 X_NUC_4.L_CORE X_NUC_83.L_CORE 0.002043
K_569 X_NUC_4.L_CORE X_NUC_84.L_CORE 0.002056
K_570 X_NUC_4.L_CORE X_NUC_85.L_CORE 0.002367
K_571 X_NUC_4.L_CORE X_NUC_86.L_CORE 0.002374
K_572 X_NUC_4.L_CORE X_NUC_87.L_CORE 0.002359
K_573 X_NUC_4.L_CORE X_NUC_88.L_CORE 0.002349
K_574 X_NUC_4.L_CORE X_NUC_89.L_CORE 0.001966
K_575 X_NUC_4.L_CORE X_NUC_90.L_CORE 0.001954
K_576 X_NUC_4.L_CORE X_NUC_91.L_CORE 0.001948
K_577 X_NUC_4.L_CORE X_NUC_92.L_CORE 0.001952
K_578 X_NUC_4.L_CORE X_NUC_93.L_CORE 0.002079
K_579 X_NUC_4.L_CORE X_NUC_94.L_CORE 0.002086
K_580 X_NUC_4.L_CORE X_NUC_95.L_CORE 0.002066
K_581 X_NUC_4.L_CORE X_NUC_96.L_CORE 0.002075
K_582 X_NUC_4.L_CORE X_NUC_97.L_CORE 0.002093
K_583 X_NUC_4.L_CORE X_NUC_98.L_CORE 0.002088
K_584 X_NUC_4.L_CORE X_NUC_99.L_CORE 0.002082
K_585 X_NUC_4.L_CORE X_NUC_100.L_CORE 0.002074
K_586 X_NUC_4.L_CORE X_NUC_101.L_CORE 0.001852
K_587 X_NUC_4.L_CORE X_NUC_102.L_CORE 0.001847
K_588 X_NUC_4.L_CORE X_NUC_103.L_CORE 0.001836
K_589 X_NUC_4.L_CORE X_NUC_104.L_CORE 0.001844
K_590 X_NUC_4.L_CORE X_NUC_105.L_CORE 0.002049
K_591 X_NUC_4.L_CORE X_NUC_106.L_CORE 0.002056
K_592 X_NUC_4.L_CORE X_NUC_107.L_CORE 0.002040
K_593 X_NUC_4.L_CORE X_NUC_108.L_CORE 0.002039
K_594 X_NUC_4.L_CORE X_NUC_109.L_CORE 0.001863
K_595 X_NUC_4.L_CORE X_NUC_110.L_CORE 0.001855
K_596 X_NUC_4.L_CORE X_NUC_111.L_CORE 0.001849
K_597 X_NUC_4.L_CORE X_NUC_112.L_CORE 0.001848
K_598 X_NUC_4.L_CORE X_NUC_113.L_CORE 0.001831
K_599 X_NUC_4.L_CORE X_NUC_114.L_CORE 0.001832
K_600 X_NUC_4.L_CORE X_NUC_115.L_CORE 0.001818
K_601 X_NUC_4.L_CORE X_NUC_116.L_CORE 0.001824
K_602 X_NUC_4.L_CORE X_NUC_117.L_CORE 0.001910
K_603 X_NUC_4.L_CORE X_NUC_118.L_CORE 0.001910
K_604 X_NUC_4.L_CORE X_NUC_119.L_CORE 0.001900
K_605 X_NUC_4.L_CORE X_NUC_120.L_CORE 0.001896
K_606 X_NUC_4.L_CORE X_NUC_121.L_CORE 0.001745
K_607 X_NUC_4.L_CORE X_NUC_122.L_CORE 0.001741
K_608 X_NUC_4.L_CORE X_NUC_123.L_CORE 0.001732
K_609 X_NUC_4.L_CORE X_NUC_124.L_CORE 0.001735
K_610 X_NUC_4.L_CORE X_NUC_125.L_CORE 0.001801
K_611 X_NUC_4.L_CORE X_NUC_126.L_CORE 0.001803
K_612 X_NUC_4.L_CORE X_NUC_127.L_CORE 0.001790
K_613 X_NUC_4.L_CORE X_NUC_128.L_CORE 0.001792
K_614 X_NUC_4.L_CORE X_NUC_129.L_CORE 0.001755
K_615 X_NUC_4.L_CORE X_NUC_130.L_CORE 0.001752
K_616 X_NUC_4.L_CORE X_NUC_131.L_CORE 0.001743
K_617 X_NUC_4.L_CORE X_NUC_132.L_CORE 0.001743
K_618 X_NUC_4.L_CORE X_NUC_133.L_CORE 0.031304
K_619 X_NUC_4.L_CORE X_NUC_134.L_CORE 0.005150
K_620 X_NUC_4.L_CORE X_NUC_135.L_CORE 0.005510
K_621 X_NUC_4.L_CORE X_NUC_136.L_CORE 0.006046
K_622 X_NUC_4.L_CORE X_NUC_137.L_CORE 0.003361
K_623 X_NUC_4.L_CORE X_NUC_138.L_CORE 0.005106
K_624 X_NUC_4.L_CORE X_NUC_139.L_CORE 0.003382
K_625 X_NUC_4.L_CORE X_NUC_140.L_CORE 0.003035
K_626 X_NUC_4.L_CORE X_NUC_141.L_CORE 0.004032
K_627 X_NUC_4.L_CORE X_NUC_142.L_CORE 0.002577
K_628 X_NUC_4.L_CORE X_NUC_143.L_CORE 0.003088
K_629 X_NUC_4.L_CORE X_NUC_144.L_CORE 0.002897
K_630 X_NUC_4.L_CORE X_NUC_145.L_CORE 0.002327
K_631 X_NUC_4.L_CORE X_NUC_146.L_CORE 0.003007
K_632 X_NUC_4.L_CORE X_NUC_147.L_CORE 0.002279
K_633 X_NUC_4.L_CORE X_NUC_148.L_CORE 0.002327
K_634 X_NUC_4.L_CORE X_NUC_149.L_CORE 0.002566
K_635 X_NUC_4.L_CORE X_NUC_150.L_CORE 0.002014
K_636 X_NUC_4.L_CORE X_NUC_151.L_CORE 0.002369
K_637 X_NUC_4.L_CORE X_NUC_152.L_CORE 0.002119
K_638 X_NUC_4.L_CORE X_NUC_153.L_CORE 0.001951
K_639 X_NUC_4.L_CORE X_NUC_154.L_CORE 0.002242
K_640 X_NUC_4.L_CORE X_NUC_155.L_CORE 0.001857
K_641 X_NUC_4.L_CORE X_NUC_156.L_CORE 0.001972
K_642 X_NUC_4.L_CORE X_NUC_157.L_CORE 0.001979
K_643 X_NUC_4.L_CORE X_NUC_158.L_CORE 0.001753
K_644 X_NUC_4.L_CORE X_NUC_159.L_CORE 0.001943
K_645 X_NUC_4.L_CORE X_NUC_160.L_CORE 0.001761
K_646 X_NUC_4.L_CORE X_NUC_161.L_CORE 0.001735
K_647 X_NUC_4.L_CORE X_NUC_162.L_CORE 0.001809
K_648 X_NUC_4.L_CORE X_NUC_163.L_CORE 0.001652
K_649 X_NUC_4.L_CORE X_NUC_164.L_CORE 0.001706
K_650 X_NUC_4.L_CORE X_NUC_165.L_CORE 0.001661
K_651 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_652 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_653 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_654 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.003872
K_655 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.003940
K_656 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.003888
K_657 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.003915
K_658 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.004738
K_659 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.004787
K_660 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.004797
K_661 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.004702
K_662 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.005964
K_663 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.005969
K_664 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.005849
K_665 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.006009
K_666 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.002895
K_667 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.002935
K_668 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.002912
K_669 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.002906
K_670 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.005883
K_671 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.005805
K_672 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.005841
K_673 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.005728
K_674 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.003140
K_675 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.003169
K_676 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.003126
K_677 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.003160
K_678 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.002840
K_679 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.002865
K_680 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.002856
K_681 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.002830
K_682 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.004750
K_683 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.004687
K_684 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.004644
K_685 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.004691
K_686 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.002388
K_687 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.002413
K_688 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.002390
K_689 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.002396
K_690 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.003247
K_691 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.003246
K_692 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.003246
K_693 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.003206
K_694 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.002984
K_695 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.002990
K_696 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.002953
K_697 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.002986
K_698 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.002221
K_699 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.002240
K_700 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.002227
K_701 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.002218
K_702 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.003474
K_703 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.003441
K_704 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.003431
K_705 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.003420
K_706 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.002226
K_707 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.002242
K_708 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.002218
K_709 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.002230
K_710 X_NUC_5.L_CORE X_NUC_65.L_CORE 0.002359
K_711 X_NUC_5.L_CORE X_NUC_66.L_CORE 0.002369
K_712 X_NUC_5.L_CORE X_NUC_67.L_CORE 0.002361
K_713 X_NUC_5.L_CORE X_NUC_68.L_CORE 0.002343
K_714 X_NUC_5.L_CORE X_NUC_69.L_CORE 0.002821
K_715 X_NUC_5.L_CORE X_NUC_70.L_CORE 0.002811
K_716 X_NUC_5.L_CORE X_NUC_71.L_CORE 0.002784
K_717 X_NUC_5.L_CORE X_NUC_72.L_CORE 0.002804
K_718 X_NUC_5.L_CORE X_NUC_73.L_CORE 0.001962
K_719 X_NUC_5.L_CORE X_NUC_74.L_CORE 0.001977
K_720 X_NUC_5.L_CORE X_NUC_75.L_CORE 0.001962
K_721 X_NUC_5.L_CORE X_NUC_76.L_CORE 0.001962
K_722 X_NUC_5.L_CORE X_NUC_77.L_CORE 0.002589
K_723 X_NUC_5.L_CORE X_NUC_78.L_CORE 0.002581
K_724 X_NUC_5.L_CORE X_NUC_79.L_CORE 0.002575
K_725 X_NUC_5.L_CORE X_NUC_80.L_CORE 0.002559
K_726 X_NUC_5.L_CORE X_NUC_81.L_CORE 0.002176
K_727 X_NUC_5.L_CORE X_NUC_82.L_CORE 0.002183
K_728 X_NUC_5.L_CORE X_NUC_83.L_CORE 0.002161
K_729 X_NUC_5.L_CORE X_NUC_84.L_CORE 0.002174
K_730 X_NUC_5.L_CORE X_NUC_85.L_CORE 0.001958
K_731 X_NUC_5.L_CORE X_NUC_86.L_CORE 0.001968
K_732 X_NUC_5.L_CORE X_NUC_87.L_CORE 0.001958
K_733 X_NUC_5.L_CORE X_NUC_88.L_CORE 0.001950
K_734 X_NUC_5.L_CORE X_NUC_89.L_CORE 0.002490
K_735 X_NUC_5.L_CORE X_NUC_90.L_CORE 0.002479
K_736 X_NUC_5.L_CORE X_NUC_91.L_CORE 0.002464
K_737 X_NUC_5.L_CORE X_NUC_92.L_CORE 0.002467
K_738 X_NUC_5.L_CORE X_NUC_93.L_CORE 0.001860
K_739 X_NUC_5.L_CORE X_NUC_94.L_CORE 0.001871
K_740 X_NUC_5.L_CORE X_NUC_95.L_CORE 0.001855
K_741 X_NUC_5.L_CORE X_NUC_96.L_CORE 0.001859
K_742 X_NUC_5.L_CORE X_NUC_97.L_CORE 0.002076
K_743 X_NUC_5.L_CORE X_NUC_98.L_CORE 0.002078
K_744 X_NUC_5.L_CORE X_NUC_99.L_CORE 0.002070
K_745 X_NUC_5.L_CORE X_NUC_100.L_CORE 0.002060
K_746 X_NUC_5.L_CORE X_NUC_101.L_CORE 0.002106
K_747 X_NUC_5.L_CORE X_NUC_102.L_CORE 0.002106
K_748 X_NUC_5.L_CORE X_NUC_103.L_CORE 0.002088
K_749 X_NUC_5.L_CORE X_NUC_104.L_CORE 0.002098
K_750 X_NUC_5.L_CORE X_NUC_105.L_CORE 0.001773
K_751 X_NUC_5.L_CORE X_NUC_106.L_CORE 0.001782
K_752 X_NUC_5.L_CORE X_NUC_107.L_CORE 0.001770
K_753 X_NUC_5.L_CORE X_NUC_108.L_CORE 0.001768
K_754 X_NUC_5.L_CORE X_NUC_109.L_CORE 0.002105
K_755 X_NUC_5.L_CORE X_NUC_110.L_CORE 0.002101
K_756 X_NUC_5.L_CORE X_NUC_111.L_CORE 0.002090
K_757 X_NUC_5.L_CORE X_NUC_112.L_CORE 0.002086
K_758 X_NUC_5.L_CORE X_NUC_113.L_CORE 0.001820
K_759 X_NUC_5.L_CORE X_NUC_114.L_CORE 0.001825
K_760 X_NUC_5.L_CORE X_NUC_115.L_CORE 0.001810
K_761 X_NUC_5.L_CORE X_NUC_116.L_CORE 0.001815
K_762 X_NUC_5.L_CORE X_NUC_117.L_CORE 0.001804
K_763 X_NUC_5.L_CORE X_NUC_118.L_CORE 0.001808
K_764 X_NUC_5.L_CORE X_NUC_119.L_CORE 0.001799
K_765 X_NUC_5.L_CORE X_NUC_120.L_CORE 0.001794
K_766 X_NUC_5.L_CORE X_NUC_121.L_CORE 0.001929
K_767 X_NUC_5.L_CORE X_NUC_122.L_CORE 0.001929
K_768 X_NUC_5.L_CORE X_NUC_123.L_CORE 0.001915
K_769 X_NUC_5.L_CORE X_NUC_124.L_CORE 0.001918
K_770 X_NUC_5.L_CORE X_NUC_125.L_CORE 0.001715
K_771 X_NUC_5.L_CORE X_NUC_126.L_CORE 0.001721
K_772 X_NUC_5.L_CORE X_NUC_127.L_CORE 0.001708
K_773 X_NUC_5.L_CORE X_NUC_128.L_CORE 0.001709
K_774 X_NUC_5.L_CORE X_NUC_129.L_CORE 0.001792
K_775 X_NUC_5.L_CORE X_NUC_130.L_CORE 0.001794
K_776 X_NUC_5.L_CORE X_NUC_131.L_CORE 0.001783
K_777 X_NUC_5.L_CORE X_NUC_132.L_CORE 0.001781
K_778 X_NUC_5.L_CORE X_NUC_133.L_CORE 0.005243
K_779 X_NUC_5.L_CORE X_NUC_134.L_CORE 0.033119
K_780 X_NUC_5.L_CORE X_NUC_135.L_CORE 0.003691
K_781 X_NUC_5.L_CORE X_NUC_136.L_CORE 0.004483
K_782 X_NUC_5.L_CORE X_NUC_137.L_CORE 0.005579
K_783 X_NUC_5.L_CORE X_NUC_138.L_CORE 0.002761
K_784 X_NUC_5.L_CORE X_NUC_139.L_CORE 0.005457
K_785 X_NUC_5.L_CORE X_NUC_140.L_CORE 0.002984
K_786 X_NUC_5.L_CORE X_NUC_141.L_CORE 0.002700
K_787 X_NUC_5.L_CORE X_NUC_142.L_CORE 0.004425
K_788 X_NUC_5.L_CORE X_NUC_143.L_CORE 0.002275
K_789 X_NUC_5.L_CORE X_NUC_144.L_CORE 0.003066
K_790 X_NUC_5.L_CORE X_NUC_145.L_CORE 0.002823
K_791 X_NUC_5.L_CORE X_NUC_146.L_CORE 0.002114
K_792 X_NUC_5.L_CORE X_NUC_147.L_CORE 0.003259
K_793 X_NUC_5.L_CORE X_NUC_148.L_CORE 0.002116
K_794 X_NUC_5.L_CORE X_NUC_149.L_CORE 0.002238
K_795 X_NUC_5.L_CORE X_NUC_150.L_CORE 0.002660
K_796 X_NUC_5.L_CORE X_NUC_151.L_CORE 0.001867
K_797 X_NUC_5.L_CORE X_NUC_152.L_CORE 0.002444
K_798 X_NUC_5.L_CORE X_NUC_153.L_CORE 0.002064
K_799 X_NUC_5.L_CORE X_NUC_154.L_CORE 0.001861
K_800 X_NUC_5.L_CORE X_NUC_155.L_CORE 0.002349
K_801 X_NUC_5.L_CORE X_NUC_156.L_CORE 0.001768
K_802 X_NUC_5.L_CORE X_NUC_157.L_CORE 0.001967
K_803 X_NUC_5.L_CORE X_NUC_158.L_CORE 0.001994
K_804 X_NUC_5.L_CORE X_NUC_159.L_CORE 0.001685
K_805 X_NUC_5.L_CORE X_NUC_160.L_CORE 0.001990
K_806 X_NUC_5.L_CORE X_NUC_161.L_CORE 0.001727
K_807 X_NUC_5.L_CORE X_NUC_162.L_CORE 0.001711
K_808 X_NUC_5.L_CORE X_NUC_163.L_CORE 0.001826
K_809 X_NUC_5.L_CORE X_NUC_164.L_CORE 0.001628
K_810 X_NUC_5.L_CORE X_NUC_165.L_CORE 0.001699
K_811 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_812 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_813 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.003806
K_814 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.003872
K_815 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.003822
K_816 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.003848
K_817 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.004687
K_818 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.004738
K_819 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.004745
K_820 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.004654
K_821 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.005955
K_822 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.005964
K_823 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.005843
K_824 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.006002
K_825 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.002857
K_826 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.002895
K_827 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.002873
K_828 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.002867
K_829 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.005961
K_830 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.005883
K_831 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.005919
K_832 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.005801
K_833 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.003111
K_834 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.003140
K_835 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.003098
K_836 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.003131
K_837 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.002815
K_838 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.002840
K_839 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.002831
K_840 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.002805
K_841 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.004813
K_842 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.004750
K_843 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.004705
K_844 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.004753
K_845 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.002364
K_846 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.002388
K_847 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.002366
K_848 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.002372
K_849 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.003248
K_850 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.003247
K_851 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.003248
K_852 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.003207
K_853 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.002978
K_854 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.002984
K_855 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.002947
K_856 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.002980
K_857 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.002202
K_858 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.002221
K_859 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.002208
K_860 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.002199
K_861 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.003507
K_862 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.003474
K_863 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.003463
K_864 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.003452
K_865 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.002210
K_866 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.002226
K_867 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.002203
K_868 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.002214
K_869 X_NUC_6.L_CORE X_NUC_65.L_CORE 0.002350
K_870 X_NUC_6.L_CORE X_NUC_66.L_CORE 0.002359
K_871 X_NUC_6.L_CORE X_NUC_67.L_CORE 0.002352
K_872 X_NUC_6.L_CORE X_NUC_68.L_CORE 0.002334
K_873 X_NUC_6.L_CORE X_NUC_69.L_CORE 0.002831
K_874 X_NUC_6.L_CORE X_NUC_70.L_CORE 0.002821
K_875 X_NUC_6.L_CORE X_NUC_71.L_CORE 0.002794
K_876 X_NUC_6.L_CORE X_NUC_72.L_CORE 0.002814
K_877 X_NUC_6.L_CORE X_NUC_73.L_CORE 0.001947
K_878 X_NUC_6.L_CORE X_NUC_74.L_CORE 0.001962
K_879 X_NUC_6.L_CORE X_NUC_75.L_CORE 0.001947
K_880 X_NUC_6.L_CORE X_NUC_76.L_CORE 0.001947
K_881 X_NUC_6.L_CORE X_NUC_77.L_CORE 0.002597
K_882 X_NUC_6.L_CORE X_NUC_78.L_CORE 0.002589
K_883 X_NUC_6.L_CORE X_NUC_79.L_CORE 0.002582
K_884 X_NUC_6.L_CORE X_NUC_80.L_CORE 0.002566
K_885 X_NUC_6.L_CORE X_NUC_81.L_CORE 0.002168
K_886 X_NUC_6.L_CORE X_NUC_82.L_CORE 0.002176
K_887 X_NUC_6.L_CORE X_NUC_83.L_CORE 0.002154
K_888 X_NUC_6.L_CORE X_NUC_84.L_CORE 0.002167
K_889 X_NUC_6.L_CORE X_NUC_85.L_CORE 0.001948
K_890 X_NUC_6.L_CORE X_NUC_86.L_CORE 0.001958
K_891 X_NUC_6.L_CORE X_NUC_87.L_CORE 0.001948
K_892 X_NUC_6.L_CORE X_NUC_88.L_CORE 0.001940
K_893 X_NUC_6.L_CORE X_NUC_89.L_CORE 0.002501
K_894 X_NUC_6.L_CORE X_NUC_90.L_CORE 0.002490
K_895 X_NUC_6.L_CORE X_NUC_91.L_CORE 0.002474
K_896 X_NUC_6.L_CORE X_NUC_92.L_CORE 0.002477
K_897 X_NUC_6.L_CORE X_NUC_93.L_CORE 0.001849
K_898 X_NUC_6.L_CORE X_NUC_94.L_CORE 0.001860
K_899 X_NUC_6.L_CORE X_NUC_95.L_CORE 0.001844
K_900 X_NUC_6.L_CORE X_NUC_96.L_CORE 0.001848
K_901 X_NUC_6.L_CORE X_NUC_97.L_CORE 0.002074
K_902 X_NUC_6.L_CORE X_NUC_98.L_CORE 0.002076
K_903 X_NUC_6.L_CORE X_NUC_99.L_CORE 0.002068
K_904 X_NUC_6.L_CORE X_NUC_100.L_CORE 0.002057
K_905 X_NUC_6.L_CORE X_NUC_101.L_CORE 0.002106
K_906 X_NUC_6.L_CORE X_NUC_102.L_CORE 0.002106
K_907 X_NUC_6.L_CORE X_NUC_103.L_CORE 0.002088
K_908 X_NUC_6.L_CORE X_NUC_104.L_CORE 0.002097
K_909 X_NUC_6.L_CORE X_NUC_105.L_CORE 0.001763
K_910 X_NUC_6.L_CORE X_NUC_106.L_CORE 0.001773
K_911 X_NUC_6.L_CORE X_NUC_107.L_CORE 0.001761
K_912 X_NUC_6.L_CORE X_NUC_108.L_CORE 0.001759
K_913 X_NUC_6.L_CORE X_NUC_109.L_CORE 0.002108
K_914 X_NUC_6.L_CORE X_NUC_110.L_CORE 0.002105
K_915 X_NUC_6.L_CORE X_NUC_111.L_CORE 0.002094
K_916 X_NUC_6.L_CORE X_NUC_112.L_CORE 0.002090
K_917 X_NUC_6.L_CORE X_NUC_113.L_CORE 0.001814
K_918 X_NUC_6.L_CORE X_NUC_114.L_CORE 0.001820
K_919 X_NUC_6.L_CORE X_NUC_115.L_CORE 0.001804
K_920 X_NUC_6.L_CORE X_NUC_116.L_CORE 0.001809
K_921 X_NUC_6.L_CORE X_NUC_117.L_CORE 0.001799
K_922 X_NUC_6.L_CORE X_NUC_118.L_CORE 0.001804
K_923 X_NUC_6.L_CORE X_NUC_119.L_CORE 0.001794
K_924 X_NUC_6.L_CORE X_NUC_120.L_CORE 0.001789
K_925 X_NUC_6.L_CORE X_NUC_121.L_CORE 0.001929
K_926 X_NUC_6.L_CORE X_NUC_122.L_CORE 0.001929
K_927 X_NUC_6.L_CORE X_NUC_123.L_CORE 0.001916
K_928 X_NUC_6.L_CORE X_NUC_124.L_CORE 0.001918
K_929 X_NUC_6.L_CORE X_NUC_125.L_CORE 0.001709
K_930 X_NUC_6.L_CORE X_NUC_126.L_CORE 0.001715
K_931 X_NUC_6.L_CORE X_NUC_127.L_CORE 0.001703
K_932 X_NUC_6.L_CORE X_NUC_128.L_CORE 0.001703
K_933 X_NUC_6.L_CORE X_NUC_129.L_CORE 0.001790
K_934 X_NUC_6.L_CORE X_NUC_130.L_CORE 0.001792
K_935 X_NUC_6.L_CORE X_NUC_131.L_CORE 0.001781
K_936 X_NUC_6.L_CORE X_NUC_132.L_CORE 0.001779
K_937 X_NUC_6.L_CORE X_NUC_133.L_CORE 0.005124
K_938 X_NUC_6.L_CORE X_NUC_134.L_CORE 0.035596
K_939 X_NUC_6.L_CORE X_NUC_135.L_CORE 0.003632
K_940 X_NUC_6.L_CORE X_NUC_136.L_CORE 0.004443
K_941 X_NUC_6.L_CORE X_NUC_137.L_CORE 0.005583
K_942 X_NUC_6.L_CORE X_NUC_138.L_CORE 0.002725
K_943 X_NUC_6.L_CORE X_NUC_139.L_CORE 0.005537
K_944 X_NUC_6.L_CORE X_NUC_140.L_CORE 0.002958
K_945 X_NUC_6.L_CORE X_NUC_141.L_CORE 0.002678
K_946 X_NUC_6.L_CORE X_NUC_142.L_CORE 0.004488
K_947 X_NUC_6.L_CORE X_NUC_143.L_CORE 0.002253
K_948 X_NUC_6.L_CORE X_NUC_144.L_CORE 0.003069
K_949 X_NUC_6.L_CORE X_NUC_145.L_CORE 0.002819
K_950 X_NUC_6.L_CORE X_NUC_146.L_CORE 0.002097
K_951 X_NUC_6.L_CORE X_NUC_147.L_CORE 0.003291
K_952 X_NUC_6.L_CORE X_NUC_148.L_CORE 0.002102
K_953 X_NUC_6.L_CORE X_NUC_149.L_CORE 0.002230
K_954 X_NUC_6.L_CORE X_NUC_150.L_CORE 0.002671
K_955 X_NUC_6.L_CORE X_NUC_151.L_CORE 0.001854
K_956 X_NUC_6.L_CORE X_NUC_152.L_CORE 0.002452
K_957 X_NUC_6.L_CORE X_NUC_153.L_CORE 0.002057
K_958 X_NUC_6.L_CORE X_NUC_154.L_CORE 0.001851
K_959 X_NUC_6.L_CORE X_NUC_155.L_CORE 0.002360
K_960 X_NUC_6.L_CORE X_NUC_156.L_CORE 0.001758
K_961 X_NUC_6.L_CORE X_NUC_157.L_CORE 0.001965
K_962 X_NUC_6.L_CORE X_NUC_158.L_CORE 0.001994
K_963 X_NUC_6.L_CORE X_NUC_159.L_CORE 0.001676
K_964 X_NUC_6.L_CORE X_NUC_160.L_CORE 0.001994
K_965 X_NUC_6.L_CORE X_NUC_161.L_CORE 0.001722
K_966 X_NUC_6.L_CORE X_NUC_162.L_CORE 0.001707
K_967 X_NUC_6.L_CORE X_NUC_163.L_CORE 0.001827
K_968 X_NUC_6.L_CORE X_NUC_164.L_CORE 0.001623
K_969 X_NUC_6.L_CORE X_NUC_165.L_CORE 0.001697
K_970 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_971 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.003855
K_972 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.003922
K_973 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.003872
K_974 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.003898
K_975 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.004678
K_976 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.004727
K_977 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.004738
K_978 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.004645
K_979 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.006081
K_980 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.006088
K_981 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.005964
K_982 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.006131
K_983 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.002878
K_984 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.002917
K_985 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.002895
K_986 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.002889
K_987 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.005922
K_988 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.005844
K_989 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.005883
K_990 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.005766
K_991 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.003154
K_992 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.003183
K_993 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.003140
K_994 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.003174
K_995 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.002824
K_996 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.002849
K_997 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.002840
K_998 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.002814
K_999 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.004860
K_1000 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.004794
K_1001 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.004750
K_1002 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.004799
K_1003 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.002386
K_1004 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.002411
K_1005 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.002388
K_1006 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.002394
K_1007 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.003247
K_1008 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.003246
K_1009 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.003247
K_1010 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.003206
K_1011 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.003016
K_1012 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.003022
K_1013 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.002984
K_1014 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.003019
K_1015 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.002215
K_1016 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.002234
K_1017 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.002221
K_1018 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.002212
K_1019 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.003518
K_1020 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.003484
K_1021 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.003474
K_1022 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.003463
K_1023 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.002233
K_1024 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.002249
K_1025 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.002226
K_1026 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.002238
K_1027 X_NUC_7.L_CORE X_NUC_65.L_CORE 0.002357
K_1028 X_NUC_7.L_CORE X_NUC_66.L_CORE 0.002366
K_1029 X_NUC_7.L_CORE X_NUC_67.L_CORE 0.002359
K_1030 X_NUC_7.L_CORE X_NUC_68.L_CORE 0.002341
K_1031 X_NUC_7.L_CORE X_NUC_69.L_CORE 0.002858
K_1032 X_NUC_7.L_CORE X_NUC_70.L_CORE 0.002848
K_1033 X_NUC_7.L_CORE X_NUC_71.L_CORE 0.002821
K_1034 X_NUC_7.L_CORE X_NUC_72.L_CORE 0.002841
K_1035 X_NUC_7.L_CORE X_NUC_73.L_CORE 0.001962
K_1036 X_NUC_7.L_CORE X_NUC_74.L_CORE 0.001977
K_1037 X_NUC_7.L_CORE X_NUC_75.L_CORE 0.001962
K_1038 X_NUC_7.L_CORE X_NUC_76.L_CORE 0.001962
K_1039 X_NUC_7.L_CORE X_NUC_77.L_CORE 0.002603
K_1040 X_NUC_7.L_CORE X_NUC_78.L_CORE 0.002596
K_1041 X_NUC_7.L_CORE X_NUC_79.L_CORE 0.002589
K_1042 X_NUC_7.L_CORE X_NUC_80.L_CORE 0.002573
K_1043 X_NUC_7.L_CORE X_NUC_81.L_CORE 0.002191
K_1044 X_NUC_7.L_CORE X_NUC_82.L_CORE 0.002198
K_1045 X_NUC_7.L_CORE X_NUC_83.L_CORE 0.002176
K_1046 X_NUC_7.L_CORE X_NUC_84.L_CORE 0.002189
K_1047 X_NUC_7.L_CORE X_NUC_85.L_CORE 0.001958
K_1048 X_NUC_7.L_CORE X_NUC_86.L_CORE 0.001968
K_1049 X_NUC_7.L_CORE X_NUC_87.L_CORE 0.001958
K_1050 X_NUC_7.L_CORE X_NUC_88.L_CORE 0.001950
K_1051 X_NUC_7.L_CORE X_NUC_89.L_CORE 0.002517
K_1052 X_NUC_7.L_CORE X_NUC_90.L_CORE 0.002506
K_1053 X_NUC_7.L_CORE X_NUC_91.L_CORE 0.002490
K_1054 X_NUC_7.L_CORE X_NUC_92.L_CORE 0.002493
K_1055 X_NUC_7.L_CORE X_NUC_93.L_CORE 0.001865
K_1056 X_NUC_7.L_CORE X_NUC_94.L_CORE 0.001876
K_1057 X_NUC_7.L_CORE X_NUC_95.L_CORE 0.001860
K_1058 X_NUC_7.L_CORE X_NUC_96.L_CORE 0.001864
K_1059 X_NUC_7.L_CORE X_NUC_97.L_CORE 0.002082
K_1060 X_NUC_7.L_CORE X_NUC_98.L_CORE 0.002084
K_1061 X_NUC_7.L_CORE X_NUC_99.L_CORE 0.002076
K_1062 X_NUC_7.L_CORE X_NUC_100.L_CORE 0.002065
K_1063 X_NUC_7.L_CORE X_NUC_101.L_CORE 0.002124
K_1064 X_NUC_7.L_CORE X_NUC_102.L_CORE 0.002125
K_1065 X_NUC_7.L_CORE X_NUC_103.L_CORE 0.002106
K_1066 X_NUC_7.L_CORE X_NUC_104.L_CORE 0.002116
K_1067 X_NUC_7.L_CORE X_NUC_105.L_CORE 0.001775
K_1068 X_NUC_7.L_CORE X_NUC_106.L_CORE 0.001784
K_1069 X_NUC_7.L_CORE X_NUC_107.L_CORE 0.001773
K_1070 X_NUC_7.L_CORE X_NUC_108.L_CORE 0.001770
K_1071 X_NUC_7.L_CORE X_NUC_109.L_CORE 0.002119
K_1072 X_NUC_7.L_CORE X_NUC_110.L_CORE 0.002115
K_1073 X_NUC_7.L_CORE X_NUC_111.L_CORE 0.002105
K_1074 X_NUC_7.L_CORE X_NUC_112.L_CORE 0.002101
K_1075 X_NUC_7.L_CORE X_NUC_113.L_CORE 0.001829
K_1076 X_NUC_7.L_CORE X_NUC_114.L_CORE 0.001835
K_1077 X_NUC_7.L_CORE X_NUC_115.L_CORE 0.001820
K_1078 X_NUC_7.L_CORE X_NUC_116.L_CORE 0.001825
K_1079 X_NUC_7.L_CORE X_NUC_117.L_CORE 0.001808
K_1080 X_NUC_7.L_CORE X_NUC_118.L_CORE 0.001813
K_1081 X_NUC_7.L_CORE X_NUC_119.L_CORE 0.001804
K_1082 X_NUC_7.L_CORE X_NUC_120.L_CORE 0.001799
K_1083 X_NUC_7.L_CORE X_NUC_121.L_CORE 0.001943
K_1084 X_NUC_7.L_CORE X_NUC_122.L_CORE 0.001943
K_1085 X_NUC_7.L_CORE X_NUC_123.L_CORE 0.001929
K_1086 X_NUC_7.L_CORE X_NUC_124.L_CORE 0.001931
K_1087 X_NUC_7.L_CORE X_NUC_125.L_CORE 0.001721
K_1088 X_NUC_7.L_CORE X_NUC_126.L_CORE 0.001727
K_1089 X_NUC_7.L_CORE X_NUC_127.L_CORE 0.001715
K_1090 X_NUC_7.L_CORE X_NUC_128.L_CORE 0.001715
K_1091 X_NUC_7.L_CORE X_NUC_129.L_CORE 0.001801
K_1092 X_NUC_7.L_CORE X_NUC_130.L_CORE 0.001803
K_1093 X_NUC_7.L_CORE X_NUC_131.L_CORE 0.001792
K_1094 X_NUC_7.L_CORE X_NUC_132.L_CORE 0.001790
K_1095 X_NUC_7.L_CORE X_NUC_133.L_CORE 0.005140
K_1096 X_NUC_7.L_CORE X_NUC_134.L_CORE 0.031055
K_1097 X_NUC_7.L_CORE X_NUC_135.L_CORE 0.003672
K_1098 X_NUC_7.L_CORE X_NUC_136.L_CORE 0.004424
K_1099 X_NUC_7.L_CORE X_NUC_137.L_CORE 0.005675
K_1100 X_NUC_7.L_CORE X_NUC_138.L_CORE 0.002744
K_1101 X_NUC_7.L_CORE X_NUC_139.L_CORE 0.005483
K_1102 X_NUC_7.L_CORE X_NUC_140.L_CORE 0.002995
K_1103 X_NUC_7.L_CORE X_NUC_141.L_CORE 0.002684
K_1104 X_NUC_7.L_CORE X_NUC_142.L_CORE 0.004519
K_1105 X_NUC_7.L_CORE X_NUC_143.L_CORE 0.002272
K_1106 X_NUC_7.L_CORE X_NUC_144.L_CORE 0.003064
K_1107 X_NUC_7.L_CORE X_NUC_145.L_CORE 0.002852
K_1108 X_NUC_7.L_CORE X_NUC_146.L_CORE 0.002108
K_1109 X_NUC_7.L_CORE X_NUC_147.L_CORE 0.003297
K_1110 X_NUC_7.L_CORE X_NUC_148.L_CORE 0.002123
K_1111 X_NUC_7.L_CORE X_NUC_149.L_CORE 0.002236
K_1112 X_NUC_7.L_CORE X_NUC_150.L_CORE 0.002694
K_1113 X_NUC_7.L_CORE X_NUC_151.L_CORE 0.001867
K_1114 X_NUC_7.L_CORE X_NUC_152.L_CORE 0.002457
K_1115 X_NUC_7.L_CORE X_NUC_153.L_CORE 0.002077
K_1116 X_NUC_7.L_CORE X_NUC_154.L_CORE 0.001860
K_1117 X_NUC_7.L_CORE X_NUC_155.L_CORE 0.002373
K_1118 X_NUC_7.L_CORE X_NUC_156.L_CORE 0.001773
K_1119 X_NUC_7.L_CORE X_NUC_157.L_CORE 0.001972
K_1120 X_NUC_7.L_CORE X_NUC_158.L_CORE 0.002011
K_1121 X_NUC_7.L_CORE X_NUC_159.L_CORE 0.001687
K_1122 X_NUC_7.L_CORE X_NUC_160.L_CORE 0.002003
K_1123 X_NUC_7.L_CORE X_NUC_161.L_CORE 0.001736
K_1124 X_NUC_7.L_CORE X_NUC_162.L_CORE 0.001716
K_1125 X_NUC_7.L_CORE X_NUC_163.L_CORE 0.001839
K_1126 X_NUC_7.L_CORE X_NUC_164.L_CORE 0.001634
K_1127 X_NUC_7.L_CORE X_NUC_165.L_CORE 0.001707
K_1128 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.003829
K_1129 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.003895
K_1130 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.003845
K_1131 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.003872
K_1132 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.004771
K_1133 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.004823
K_1134 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.004833
K_1135 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.004738
K_1136 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.005916
K_1137 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.005923
K_1138 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.005806
K_1139 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.005964
K_1140 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.002884
K_1141 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.002924
K_1142 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.002901
K_1143 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.002895
K_1144 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.006047
K_1145 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.005964
K_1146 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.006003
K_1147 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.005883
K_1148 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.003120
K_1149 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.003149
K_1150 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.003106
K_1151 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.003140
K_1152 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.002850
K_1153 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.002876
K_1154 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.002866
K_1155 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.002840
K_1156 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.004808
K_1157 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.004744
K_1158 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.004700
K_1159 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.004750
K_1160 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.002380
K_1161 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.002405
K_1162 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.002383
K_1163 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.002388
K_1164 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.003290
K_1165 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.003288
K_1166 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.003289
K_1167 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.003247
K_1168 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.002981
K_1169 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.002987
K_1170 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.002950
K_1171 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.002984
K_1172 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.002223
K_1173 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.002243
K_1174 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.002229
K_1175 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.002221
K_1176 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.003530
K_1177 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.003496
K_1178 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.003485
K_1179 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.003474
K_1180 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.002221
K_1181 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.002237
K_1182 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.002214
K_1183 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.002226
K_1184 X_NUC_8.L_CORE X_NUC_65.L_CORE 0.002376
K_1185 X_NUC_8.L_CORE X_NUC_66.L_CORE 0.002386
K_1186 X_NUC_8.L_CORE X_NUC_67.L_CORE 0.002378
K_1187 X_NUC_8.L_CORE X_NUC_68.L_CORE 0.002359
K_1188 X_NUC_8.L_CORE X_NUC_69.L_CORE 0.002837
K_1189 X_NUC_8.L_CORE X_NUC_70.L_CORE 0.002827
K_1190 X_NUC_8.L_CORE X_NUC_71.L_CORE 0.002800
K_1191 X_NUC_8.L_CORE X_NUC_72.L_CORE 0.002821
K_1192 X_NUC_8.L_CORE X_NUC_73.L_CORE 0.001962
K_1193 X_NUC_8.L_CORE X_NUC_74.L_CORE 0.001978
K_1194 X_NUC_8.L_CORE X_NUC_75.L_CORE 0.001962
K_1195 X_NUC_8.L_CORE X_NUC_76.L_CORE 0.001962
K_1196 X_NUC_8.L_CORE X_NUC_77.L_CORE 0.002620
K_1197 X_NUC_8.L_CORE X_NUC_78.L_CORE 0.002613
K_1198 X_NUC_8.L_CORE X_NUC_79.L_CORE 0.002606
K_1199 X_NUC_8.L_CORE X_NUC_80.L_CORE 0.002589
K_1200 X_NUC_8.L_CORE X_NUC_81.L_CORE 0.002177
K_1201 X_NUC_8.L_CORE X_NUC_82.L_CORE 0.002184
K_1202 X_NUC_8.L_CORE X_NUC_83.L_CORE 0.002162
K_1203 X_NUC_8.L_CORE X_NUC_84.L_CORE 0.002176
K_1204 X_NUC_8.L_CORE X_NUC_85.L_CORE 0.001966
K_1205 X_NUC_8.L_CORE X_NUC_86.L_CORE 0.001977
K_1206 X_NUC_8.L_CORE X_NUC_87.L_CORE 0.001966
K_1207 X_NUC_8.L_CORE X_NUC_88.L_CORE 0.001958
K_1208 X_NUC_8.L_CORE X_NUC_89.L_CORE 0.002514
K_1209 X_NUC_8.L_CORE X_NUC_90.L_CORE 0.002502
K_1210 X_NUC_8.L_CORE X_NUC_91.L_CORE 0.002487
K_1211 X_NUC_8.L_CORE X_NUC_92.L_CORE 0.002490
K_1212 X_NUC_8.L_CORE X_NUC_93.L_CORE 0.001861
K_1213 X_NUC_8.L_CORE X_NUC_94.L_CORE 0.001872
K_1214 X_NUC_8.L_CORE X_NUC_95.L_CORE 0.001856
K_1215 X_NUC_8.L_CORE X_NUC_96.L_CORE 0.001860
K_1216 X_NUC_8.L_CORE X_NUC_97.L_CORE 0.002093
K_1217 X_NUC_8.L_CORE X_NUC_98.L_CORE 0.002095
K_1218 X_NUC_8.L_CORE X_NUC_99.L_CORE 0.002087
K_1219 X_NUC_8.L_CORE X_NUC_100.L_CORE 0.002076
K_1220 X_NUC_8.L_CORE X_NUC_101.L_CORE 0.002115
K_1221 X_NUC_8.L_CORE X_NUC_102.L_CORE 0.002115
K_1222 X_NUC_8.L_CORE X_NUC_103.L_CORE 0.002097
K_1223 X_NUC_8.L_CORE X_NUC_104.L_CORE 0.002106
K_1224 X_NUC_8.L_CORE X_NUC_105.L_CORE 0.001778
K_1225 X_NUC_8.L_CORE X_NUC_106.L_CORE 0.001787
K_1226 X_NUC_8.L_CORE X_NUC_107.L_CORE 0.001775
K_1227 X_NUC_8.L_CORE X_NUC_108.L_CORE 0.001773
K_1228 X_NUC_8.L_CORE X_NUC_109.L_CORE 0.002123
K_1229 X_NUC_8.L_CORE X_NUC_110.L_CORE 0.002119
K_1230 X_NUC_8.L_CORE X_NUC_111.L_CORE 0.002108
K_1231 X_NUC_8.L_CORE X_NUC_112.L_CORE 0.002105
K_1232 X_NUC_8.L_CORE X_NUC_113.L_CORE 0.001824
K_1233 X_NUC_8.L_CORE X_NUC_114.L_CORE 0.001830
K_1234 X_NUC_8.L_CORE X_NUC_115.L_CORE 0.001814
K_1235 X_NUC_8.L_CORE X_NUC_116.L_CORE 0.001820
K_1236 X_NUC_8.L_CORE X_NUC_117.L_CORE 0.001813
K_1237 X_NUC_8.L_CORE X_NUC_118.L_CORE 0.001819
K_1238 X_NUC_8.L_CORE X_NUC_119.L_CORE 0.001809
K_1239 X_NUC_8.L_CORE X_NUC_120.L_CORE 0.001804
K_1240 X_NUC_8.L_CORE X_NUC_121.L_CORE 0.001941
K_1241 X_NUC_8.L_CORE X_NUC_122.L_CORE 0.001940
K_1242 X_NUC_8.L_CORE X_NUC_123.L_CORE 0.001926
K_1243 X_NUC_8.L_CORE X_NUC_124.L_CORE 0.001929
K_1244 X_NUC_8.L_CORE X_NUC_125.L_CORE 0.001721
K_1245 X_NUC_8.L_CORE X_NUC_126.L_CORE 0.001727
K_1246 X_NUC_8.L_CORE X_NUC_127.L_CORE 0.001714
K_1247 X_NUC_8.L_CORE X_NUC_128.L_CORE 0.001715
K_1248 X_NUC_8.L_CORE X_NUC_129.L_CORE 0.001802
K_1249 X_NUC_8.L_CORE X_NUC_130.L_CORE 0.001805
K_1250 X_NUC_8.L_CORE X_NUC_131.L_CORE 0.001794
K_1251 X_NUC_8.L_CORE X_NUC_132.L_CORE 0.001792
K_1252 X_NUC_8.L_CORE X_NUC_133.L_CORE 0.005180
K_1253 X_NUC_8.L_CORE X_NUC_134.L_CORE 0.030975
K_1254 X_NUC_8.L_CORE X_NUC_135.L_CORE 0.003647
K_1255 X_NUC_8.L_CORE X_NUC_136.L_CORE 0.004510
K_1256 X_NUC_8.L_CORE X_NUC_137.L_CORE 0.005526
K_1257 X_NUC_8.L_CORE X_NUC_138.L_CORE 0.002749
K_1258 X_NUC_8.L_CORE X_NUC_139.L_CORE 0.005592
K_1259 X_NUC_8.L_CORE X_NUC_140.L_CORE 0.002963
K_1260 X_NUC_8.L_CORE X_NUC_141.L_CORE 0.002709
K_1261 X_NUC_8.L_CORE X_NUC_142.L_CORE 0.004473
K_1262 X_NUC_8.L_CORE X_NUC_143.L_CORE 0.002267
K_1263 X_NUC_8.L_CORE X_NUC_144.L_CORE 0.003104
K_1264 X_NUC_8.L_CORE X_NUC_145.L_CORE 0.002819
K_1265 X_NUC_8.L_CORE X_NUC_146.L_CORE 0.002116
K_1266 X_NUC_8.L_CORE X_NUC_147.L_CORE 0.003307
K_1267 X_NUC_8.L_CORE X_NUC_148.L_CORE 0.002111
K_1268 X_NUC_8.L_CORE X_NUC_149.L_CORE 0.002253
K_1269 X_NUC_8.L_CORE X_NUC_150.L_CORE 0.002674
K_1270 X_NUC_8.L_CORE X_NUC_151.L_CORE 0.001867
K_1271 X_NUC_8.L_CORE X_NUC_152.L_CORE 0.002472
K_1272 X_NUC_8.L_CORE X_NUC_153.L_CORE 0.002064
K_1273 X_NUC_8.L_CORE X_NUC_154.L_CORE 0.001868
K_1274 X_NUC_8.L_CORE X_NUC_155.L_CORE 0.002370
K_1275 X_NUC_8.L_CORE X_NUC_156.L_CORE 0.001769
K_1276 X_NUC_8.L_CORE X_NUC_157.L_CORE 0.001982
K_1277 X_NUC_8.L_CORE X_NUC_158.L_CORE 0.002001
K_1278 X_NUC_8.L_CORE X_NUC_159.L_CORE 0.001689
K_1279 X_NUC_8.L_CORE X_NUC_160.L_CORE 0.002007
K_1280 X_NUC_8.L_CORE X_NUC_161.L_CORE 0.001731
K_1281 X_NUC_8.L_CORE X_NUC_162.L_CORE 0.001720
K_1282 X_NUC_8.L_CORE X_NUC_163.L_CORE 0.001837
K_1283 X_NUC_8.L_CORE X_NUC_164.L_CORE 0.001633
K_1284 X_NUC_8.L_CORE X_NUC_165.L_CORE 0.001708
K_1285 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_1286 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_1287 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_1288 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.003203
K_1289 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.003180
K_1290 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.003211
K_1291 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.003168
K_1292 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.004087
K_1293 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.004012
K_1294 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.004030
K_1295 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.004051
K_1296 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.005494
K_1297 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.005568
K_1298 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.005559
K_1299 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.005442
K_1300 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.002552
K_1301 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.002527
K_1302 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.002544
K_1303 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.002527
K_1304 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.006000
K_1305 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.005952
K_1306 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.005846
K_1307 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.005979
K_1308 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.002877
K_1309 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.002875
K_1310 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.002886
K_1311 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.002849
K_1312 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.002610
K_1313 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.002579
K_1314 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.002587
K_1315 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.002587
K_1316 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.005068
K_1317 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.005154
K_1318 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.005049
K_1319 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.005045
K_1320 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.002202
K_1321 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.002190
K_1322 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.002199
K_1323 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.002182
K_1324 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.003189
K_1325 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.003159
K_1326 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.003142
K_1327 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.003168
K_1328 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.002916
K_1329 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.002930
K_1330 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.002921
K_1331 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.002891
K_1332 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.002083
K_1333 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.002066
K_1334 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.002071
K_1335 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.002065
K_1336 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.003682
K_1337 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.003696
K_1338 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.003635
K_1339 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.003665
K_1340 X_NUC_9.L_CORE X_NUC_65.L_CORE 0.002121
K_1341 X_NUC_9.L_CORE X_NUC_66.L_CORE 0.002116
K_1342 X_NUC_9.L_CORE X_NUC_67.L_CORE 0.002119
K_1343 X_NUC_9.L_CORE X_NUC_68.L_CORE 0.002102
K_1344 X_NUC_9.L_CORE X_NUC_69.L_CORE 0.002289
K_1345 X_NUC_9.L_CORE X_NUC_70.L_CORE 0.002270
K_1346 X_NUC_9.L_CORE X_NUC_71.L_CORE 0.002266
K_1347 X_NUC_9.L_CORE X_NUC_72.L_CORE 0.002272
K_1348 X_NUC_9.L_CORE X_NUC_73.L_CORE 0.002892
K_1349 X_NUC_9.L_CORE X_NUC_74.L_CORE 0.002912
K_1350 X_NUC_9.L_CORE X_NUC_75.L_CORE 0.002884
K_1351 X_NUC_9.L_CORE X_NUC_76.L_CORE 0.002873
K_1352 X_NUC_9.L_CORE X_NUC_77.L_CORE 0.001872
K_1353 X_NUC_9.L_CORE X_NUC_78.L_CORE 0.001861
K_1354 X_NUC_9.L_CORE X_NUC_79.L_CORE 0.001864
K_1355 X_NUC_9.L_CORE X_NUC_80.L_CORE 0.001855
K_1356 X_NUC_9.L_CORE X_NUC_81.L_CORE 0.002640
K_1357 X_NUC_9.L_CORE X_NUC_82.L_CORE 0.002631
K_1358 X_NUC_9.L_CORE X_NUC_83.L_CORE 0.002608
K_1359 X_NUC_9.L_CORE X_NUC_84.L_CORE 0.002624
K_1360 X_NUC_9.L_CORE X_NUC_85.L_CORE 0.002140
K_1361 X_NUC_9.L_CORE X_NUC_86.L_CORE 0.002143
K_1362 X_NUC_9.L_CORE X_NUC_87.L_CORE 0.002138
K_1363 X_NUC_9.L_CORE X_NUC_88.L_CORE 0.002123
K_1364 X_NUC_9.L_CORE X_NUC_89.L_CORE 0.001900
K_1365 X_NUC_9.L_CORE X_NUC_90.L_CORE 0.001887
K_1366 X_NUC_9.L_CORE X_NUC_91.L_CORE 0.001886
K_1367 X_NUC_9.L_CORE X_NUC_92.L_CORE 0.001885
K_1368 X_NUC_9.L_CORE X_NUC_93.L_CORE 0.002574
K_1369 X_NUC_9.L_CORE X_NUC_94.L_CORE 0.002583
K_1370 X_NUC_9.L_CORE X_NUC_95.L_CORE 0.002555
K_1371 X_NUC_9.L_CORE X_NUC_96.L_CORE 0.002559
K_1372 X_NUC_9.L_CORE X_NUC_97.L_CORE 0.001809
K_1373 X_NUC_9.L_CORE X_NUC_98.L_CORE 0.001804
K_1374 X_NUC_9.L_CORE X_NUC_99.L_CORE 0.001804
K_1375 X_NUC_9.L_CORE X_NUC_100.L_CORE 0.001794
K_1376 X_NUC_9.L_CORE X_NUC_101.L_CORE 0.002073
K_1377 X_NUC_9.L_CORE X_NUC_102.L_CORE 0.002063
K_1378 X_NUC_9.L_CORE X_NUC_103.L_CORE 0.002053
K_1379 X_NUC_9.L_CORE X_NUC_104.L_CORE 0.002058
K_1380 X_NUC_9.L_CORE X_NUC_105.L_CORE 0.002120
K_1381 X_NUC_9.L_CORE X_NUC_106.L_CORE 0.002125
K_1382 X_NUC_9.L_CORE X_NUC_107.L_CORE 0.002113
K_1383 X_NUC_9.L_CORE X_NUC_108.L_CORE 0.002105
K_1384 X_NUC_9.L_CORE X_NUC_109.L_CORE 0.001738
K_1385 X_NUC_9.L_CORE X_NUC_110.L_CORE 0.001730
K_1386 X_NUC_9.L_CORE X_NUC_111.L_CORE 0.001728
K_1387 X_NUC_9.L_CORE X_NUC_112.L_CORE 0.001724
K_1388 X_NUC_9.L_CORE X_NUC_113.L_CORE 0.002134
K_1389 X_NUC_9.L_CORE X_NUC_114.L_CORE 0.002133
K_1390 X_NUC_9.L_CORE X_NUC_115.L_CORE 0.002117
K_1391 X_NUC_9.L_CORE X_NUC_116.L_CORE 0.002120
K_1392 X_NUC_9.L_CORE X_NUC_117.L_CORE 0.001808
K_1393 X_NUC_9.L_CORE X_NUC_118.L_CORE 0.001806
K_1394 X_NUC_9.L_CORE X_NUC_119.L_CORE 0.001801
K_1395 X_NUC_9.L_CORE X_NUC_120.L_CORE 0.001794
K_1396 X_NUC_9.L_CORE X_NUC_121.L_CORE 0.001798
K_1397 X_NUC_9.L_CORE X_NUC_122.L_CORE 0.001791
K_1398 X_NUC_9.L_CORE X_NUC_123.L_CORE 0.001785
K_1399 X_NUC_9.L_CORE X_NUC_124.L_CORE 0.001784
K_1400 X_NUC_9.L_CORE X_NUC_125.L_CORE 0.001929
K_1401 X_NUC_9.L_CORE X_NUC_126.L_CORE 0.001929
K_1402 X_NUC_9.L_CORE X_NUC_127.L_CORE 0.001918
K_1403 X_NUC_9.L_CORE X_NUC_128.L_CORE 0.001915
K_1404 X_NUC_9.L_CORE X_NUC_129.L_CORE 0.001735
K_1405 X_NUC_9.L_CORE X_NUC_130.L_CORE 0.001731
K_1406 X_NUC_9.L_CORE X_NUC_131.L_CORE 0.001726
K_1407 X_NUC_9.L_CORE X_NUC_132.L_CORE 0.001722
K_1408 X_NUC_9.L_CORE X_NUC_133.L_CORE 0.005566
K_1409 X_NUC_9.L_CORE X_NUC_134.L_CORE 0.003635
K_1410 X_NUC_9.L_CORE X_NUC_135.L_CORE 0.035420
K_1411 X_NUC_9.L_CORE X_NUC_136.L_CORE 0.003024
K_1412 X_NUC_9.L_CORE X_NUC_137.L_CORE 0.003826
K_1413 X_NUC_9.L_CORE X_NUC_138.L_CORE 0.005191
K_1414 X_NUC_9.L_CORE X_NUC_139.L_CORE 0.002409
K_1415 X_NUC_9.L_CORE X_NUC_140.L_CORE 0.005585
K_1416 X_NUC_9.L_CORE X_NUC_141.L_CORE 0.002724
K_1417 X_NUC_9.L_CORE X_NUC_142.L_CORE 0.002459
K_1418 X_NUC_9.L_CORE X_NUC_143.L_CORE 0.004788
K_1419 X_NUC_9.L_CORE X_NUC_144.L_CORE 0.002083
K_1420 X_NUC_9.L_CORE X_NUC_145.L_CORE 0.003000
K_1421 X_NUC_9.L_CORE X_NUC_146.L_CORE 0.002765
K_1422 X_NUC_9.L_CORE X_NUC_147.L_CORE 0.001967
K_1423 X_NUC_9.L_CORE X_NUC_148.L_CORE 0.003474
K_1424 X_NUC_9.L_CORE X_NUC_149.L_CORE 0.002008
K_1425 X_NUC_9.L_CORE X_NUC_150.L_CORE 0.002160
K_1426 X_NUC_9.L_CORE X_NUC_151.L_CORE 0.002742
K_1427 X_NUC_9.L_CORE X_NUC_152.L_CORE 0.001770
K_1428 X_NUC_9.L_CORE X_NUC_153.L_CORE 0.002492
K_1429 X_NUC_9.L_CORE X_NUC_154.L_CORE 0.002029
K_1430 X_NUC_9.L_CORE X_NUC_155.L_CORE 0.001796
K_1431 X_NUC_9.L_CORE X_NUC_156.L_CORE 0.002437
K_1432 X_NUC_9.L_CORE X_NUC_157.L_CORE 0.001713
K_1433 X_NUC_9.L_CORE X_NUC_158.L_CORE 0.001958
K_1434 X_NUC_9.L_CORE X_NUC_159.L_CORE 0.002009
K_1435 X_NUC_9.L_CORE X_NUC_160.L_CORE 0.001644
K_1436 X_NUC_9.L_CORE X_NUC_161.L_CORE 0.002020
K_1437 X_NUC_9.L_CORE X_NUC_162.L_CORE 0.001713
K_1438 X_NUC_9.L_CORE X_NUC_163.L_CORE 0.001700
K_1439 X_NUC_9.L_CORE X_NUC_164.L_CORE 0.001827
K_1440 X_NUC_9.L_CORE X_NUC_165.L_CORE 0.001643
K_1441 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_1442 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_1443 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.003225
K_1444 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.003203
K_1445 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.003234
K_1446 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.003190
K_1447 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.004165
K_1448 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.004087
K_1449 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.004106
K_1450 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.004127
K_1451 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.005418
K_1452 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.005494
K_1453 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.005483
K_1454 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.005370
K_1455 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.002578
K_1456 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.002552
K_1457 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.002570
K_1458 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.002552
K_1459 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.006044
K_1460 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.006000
K_1461 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.005889
K_1462 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.006025
K_1463 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.002878
K_1464 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.002877
K_1465 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.002887
K_1466 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.002850
K_1467 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.002641
K_1468 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.002610
K_1469 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.002618
K_1470 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.002618
K_1471 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.004982
K_1472 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.005068
K_1473 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.004966
K_1474 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.004962
K_1475 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.002215
K_1476 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.002202
K_1477 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.002212
K_1478 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.002194
K_1479 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.003219
K_1480 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.003189
K_1481 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.003171
K_1482 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.003198
K_1483 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.002901
K_1484 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.002916
K_1485 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.002907
K_1486 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.002877
K_1487 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.002101
K_1488 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.002083
K_1489 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.002088
K_1490 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.002082
K_1491 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.003667
K_1492 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.003682
K_1493 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.003621
K_1494 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.003651
K_1495 X_NUC_10.L_CORE X_NUC_65.L_CORE 0.002125
K_1496 X_NUC_10.L_CORE X_NUC_66.L_CORE 0.002121
K_1497 X_NUC_10.L_CORE X_NUC_67.L_CORE 0.002123
K_1498 X_NUC_10.L_CORE X_NUC_68.L_CORE 0.002106
K_1499 X_NUC_10.L_CORE X_NUC_69.L_CORE 0.002308
K_1500 X_NUC_10.L_CORE X_NUC_70.L_CORE 0.002289
K_1501 X_NUC_10.L_CORE X_NUC_71.L_CORE 0.002285
K_1502 X_NUC_10.L_CORE X_NUC_72.L_CORE 0.002291
K_1503 X_NUC_10.L_CORE X_NUC_73.L_CORE 0.002872
K_1504 X_NUC_10.L_CORE X_NUC_74.L_CORE 0.002892
K_1505 X_NUC_10.L_CORE X_NUC_75.L_CORE 0.002865
K_1506 X_NUC_10.L_CORE X_NUC_76.L_CORE 0.002854
K_1507 X_NUC_10.L_CORE X_NUC_77.L_CORE 0.001882
K_1508 X_NUC_10.L_CORE X_NUC_78.L_CORE 0.001872
K_1509 X_NUC_10.L_CORE X_NUC_79.L_CORE 0.001875
K_1510 X_NUC_10.L_CORE X_NUC_80.L_CORE 0.001866
K_1511 X_NUC_10.L_CORE X_NUC_81.L_CORE 0.002648
K_1512 X_NUC_10.L_CORE X_NUC_82.L_CORE 0.002640
K_1513 X_NUC_10.L_CORE X_NUC_83.L_CORE 0.002616
K_1514 X_NUC_10.L_CORE X_NUC_84.L_CORE 0.002632
K_1515 X_NUC_10.L_CORE X_NUC_85.L_CORE 0.002138
K_1516 X_NUC_10.L_CORE X_NUC_86.L_CORE 0.002140
K_1517 X_NUC_10.L_CORE X_NUC_87.L_CORE 0.002135
K_1518 X_NUC_10.L_CORE X_NUC_88.L_CORE 0.002120
K_1519 X_NUC_10.L_CORE X_NUC_89.L_CORE 0.001913
K_1520 X_NUC_10.L_CORE X_NUC_90.L_CORE 0.001900
K_1521 X_NUC_10.L_CORE X_NUC_91.L_CORE 0.001899
K_1522 X_NUC_10.L_CORE X_NUC_92.L_CORE 0.001897
K_1523 X_NUC_10.L_CORE X_NUC_93.L_CORE 0.002566
K_1524 X_NUC_10.L_CORE X_NUC_94.L_CORE 0.002574
K_1525 X_NUC_10.L_CORE X_NUC_95.L_CORE 0.002547
K_1526 X_NUC_10.L_CORE X_NUC_96.L_CORE 0.002550
K_1527 X_NUC_10.L_CORE X_NUC_97.L_CORE 0.001815
K_1528 X_NUC_10.L_CORE X_NUC_98.L_CORE 0.001809
K_1529 X_NUC_10.L_CORE X_NUC_99.L_CORE 0.001809
K_1530 X_NUC_10.L_CORE X_NUC_100.L_CORE 0.001799
K_1531 X_NUC_10.L_CORE X_NUC_101.L_CORE 0.002082
K_1532 X_NUC_10.L_CORE X_NUC_102.L_CORE 0.002073
K_1533 X_NUC_10.L_CORE X_NUC_103.L_CORE 0.002063
K_1534 X_NUC_10.L_CORE X_NUC_104.L_CORE 0.002068
K_1535 X_NUC_10.L_CORE X_NUC_105.L_CORE 0.002115
K_1536 X_NUC_10.L_CORE X_NUC_106.L_CORE 0.002120
K_1537 X_NUC_10.L_CORE X_NUC_107.L_CORE 0.002108
K_1538 X_NUC_10.L_CORE X_NUC_108.L_CORE 0.002100
K_1539 X_NUC_10.L_CORE X_NUC_109.L_CORE 0.001746
K_1540 X_NUC_10.L_CORE X_NUC_110.L_CORE 0.001738
K_1541 X_NUC_10.L_CORE X_NUC_111.L_CORE 0.001736
K_1542 X_NUC_10.L_CORE X_NUC_112.L_CORE 0.001732
K_1543 X_NUC_10.L_CORE X_NUC_113.L_CORE 0.002136
K_1544 X_NUC_10.L_CORE X_NUC_114.L_CORE 0.002134
K_1545 X_NUC_10.L_CORE X_NUC_115.L_CORE 0.002118
K_1546 X_NUC_10.L_CORE X_NUC_116.L_CORE 0.002122
K_1547 X_NUC_10.L_CORE X_NUC_117.L_CORE 0.001810
K_1548 X_NUC_10.L_CORE X_NUC_118.L_CORE 0.001808
K_1549 X_NUC_10.L_CORE X_NUC_119.L_CORE 0.001803
K_1550 X_NUC_10.L_CORE X_NUC_120.L_CORE 0.001795
K_1551 X_NUC_10.L_CORE X_NUC_121.L_CORE 0.001805
K_1552 X_NUC_10.L_CORE X_NUC_122.L_CORE 0.001798
K_1553 X_NUC_10.L_CORE X_NUC_123.L_CORE 0.001792
K_1554 X_NUC_10.L_CORE X_NUC_124.L_CORE 0.001791
K_1555 X_NUC_10.L_CORE X_NUC_125.L_CORE 0.001929
K_1556 X_NUC_10.L_CORE X_NUC_126.L_CORE 0.001929
K_1557 X_NUC_10.L_CORE X_NUC_127.L_CORE 0.001918
K_1558 X_NUC_10.L_CORE X_NUC_128.L_CORE 0.001915
K_1559 X_NUC_10.L_CORE X_NUC_129.L_CORE 0.001739
K_1560 X_NUC_10.L_CORE X_NUC_130.L_CORE 0.001735
K_1561 X_NUC_10.L_CORE X_NUC_131.L_CORE 0.001730
K_1562 X_NUC_10.L_CORE X_NUC_132.L_CORE 0.001726
K_1563 X_NUC_10.L_CORE X_NUC_133.L_CORE 0.005619
K_1564 X_NUC_10.L_CORE X_NUC_134.L_CORE 0.003694
K_1565 X_NUC_10.L_CORE X_NUC_135.L_CORE 0.033033
K_1566 X_NUC_10.L_CORE X_NUC_136.L_CORE 0.003044
K_1567 X_NUC_10.L_CORE X_NUC_137.L_CORE 0.003894
K_1568 X_NUC_10.L_CORE X_NUC_138.L_CORE 0.005115
K_1569 X_NUC_10.L_CORE X_NUC_139.L_CORE 0.002432
K_1570 X_NUC_10.L_CORE X_NUC_140.L_CORE 0.005616
K_1571 X_NUC_10.L_CORE X_NUC_141.L_CORE 0.002724
K_1572 X_NUC_10.L_CORE X_NUC_142.L_CORE 0.002487
K_1573 X_NUC_10.L_CORE X_NUC_143.L_CORE 0.004704
K_1574 X_NUC_10.L_CORE X_NUC_144.L_CORE 0.002094
K_1575 X_NUC_10.L_CORE X_NUC_145.L_CORE 0.003026
K_1576 X_NUC_10.L_CORE X_NUC_146.L_CORE 0.002750
K_1577 X_NUC_10.L_CORE X_NUC_147.L_CORE 0.001983
K_1578 X_NUC_10.L_CORE X_NUC_148.L_CORE 0.003459
K_1579 X_NUC_10.L_CORE X_NUC_149.L_CORE 0.002012
K_1580 X_NUC_10.L_CORE X_NUC_150.L_CORE 0.002177
K_1581 X_NUC_10.L_CORE X_NUC_151.L_CORE 0.002722
K_1582 X_NUC_10.L_CORE X_NUC_152.L_CORE 0.001780
K_1583 X_NUC_10.L_CORE X_NUC_153.L_CORE 0.002499
K_1584 X_NUC_10.L_CORE X_NUC_154.L_CORE 0.002026
K_1585 X_NUC_10.L_CORE X_NUC_155.L_CORE 0.001807
K_1586 X_NUC_10.L_CORE X_NUC_156.L_CORE 0.002428
K_1587 X_NUC_10.L_CORE X_NUC_157.L_CORE 0.001718
K_1588 X_NUC_10.L_CORE X_NUC_158.L_CORE 0.001967
K_1589 X_NUC_10.L_CORE X_NUC_159.L_CORE 0.002005
K_1590 X_NUC_10.L_CORE X_NUC_160.L_CORE 0.001652
K_1591 X_NUC_10.L_CORE X_NUC_161.L_CORE 0.002020
K_1592 X_NUC_10.L_CORE X_NUC_162.L_CORE 0.001714
K_1593 X_NUC_10.L_CORE X_NUC_163.L_CORE 0.001707
K_1594 X_NUC_10.L_CORE X_NUC_164.L_CORE 0.001827
K_1595 X_NUC_10.L_CORE X_NUC_165.L_CORE 0.001646
K_1596 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_1597 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.003194
K_1598 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.003172
K_1599 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.003203
K_1600 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.003159
K_1601 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.004144
K_1602 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.004067
K_1603 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.004087
K_1604 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.004107
K_1605 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.005427
K_1606 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.005501
K_1607 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.005494
K_1608 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.005379
K_1609 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.002560
K_1610 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.002535
K_1611 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.002552
K_1612 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.002535
K_1613 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.006161
K_1614 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.006112
K_1615 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.006000
K_1616 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.006141
K_1617 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.002867
K_1618 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.002865
K_1619 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.002877
K_1620 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.002839
K_1621 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.002633
K_1622 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.002602
K_1623 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.002610
K_1624 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.002610
K_1625 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.005084
K_1626 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.005173
K_1627 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.005068
K_1628 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.005062
K_1629 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.002206
K_1630 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.002193
K_1631 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.002202
K_1632 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.002185
K_1633 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.003238
K_1634 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.003207
K_1635 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.003189
K_1636 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.003216
K_1637 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.002909
K_1638 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.002924
K_1639 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.002916
K_1640 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.002885
K_1641 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.002095
K_1642 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.002078
K_1643 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.002083
K_1644 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.002077
K_1645 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.003730
K_1646 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.003745
K_1647 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.003682
K_1648 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.003713
K_1649 X_NUC_11.L_CORE X_NUC_65.L_CORE 0.002122
K_1650 X_NUC_11.L_CORE X_NUC_66.L_CORE 0.002117
K_1651 X_NUC_11.L_CORE X_NUC_67.L_CORE 0.002121
K_1652 X_NUC_11.L_CORE X_NUC_68.L_CORE 0.002103
K_1653 X_NUC_11.L_CORE X_NUC_69.L_CORE 0.002313
K_1654 X_NUC_11.L_CORE X_NUC_70.L_CORE 0.002293
K_1655 X_NUC_11.L_CORE X_NUC_71.L_CORE 0.002289
K_1656 X_NUC_11.L_CORE X_NUC_72.L_CORE 0.002295
K_1657 X_NUC_11.L_CORE X_NUC_73.L_CORE 0.002899
K_1658 X_NUC_11.L_CORE X_NUC_74.L_CORE 0.002920
K_1659 X_NUC_11.L_CORE X_NUC_75.L_CORE 0.002892
K_1660 X_NUC_11.L_CORE X_NUC_76.L_CORE 0.002880
K_1661 X_NUC_11.L_CORE X_NUC_77.L_CORE 0.001879
K_1662 X_NUC_11.L_CORE X_NUC_78.L_CORE 0.001868
K_1663 X_NUC_11.L_CORE X_NUC_79.L_CORE 0.001872
K_1664 X_NUC_11.L_CORE X_NUC_80.L_CORE 0.001862
K_1665 X_NUC_11.L_CORE X_NUC_81.L_CORE 0.002672
K_1666 X_NUC_11.L_CORE X_NUC_82.L_CORE 0.002664
K_1667 X_NUC_11.L_CORE X_NUC_83.L_CORE 0.002640
K_1668 X_NUC_11.L_CORE X_NUC_84.L_CORE 0.002656
K_1669 X_NUC_11.L_CORE X_NUC_85.L_CORE 0.002143
K_1670 X_NUC_11.L_CORE X_NUC_86.L_CORE 0.002145
K_1671 X_NUC_11.L_CORE X_NUC_87.L_CORE 0.002140
K_1672 X_NUC_11.L_CORE X_NUC_88.L_CORE 0.002125
K_1673 X_NUC_11.L_CORE X_NUC_89.L_CORE 0.001914
K_1674 X_NUC_11.L_CORE X_NUC_90.L_CORE 0.001901
K_1675 X_NUC_11.L_CORE X_NUC_91.L_CORE 0.001900
K_1676 X_NUC_11.L_CORE X_NUC_92.L_CORE 0.001898
K_1677 X_NUC_11.L_CORE X_NUC_93.L_CORE 0.002593
K_1678 X_NUC_11.L_CORE X_NUC_94.L_CORE 0.002602
K_1679 X_NUC_11.L_CORE X_NUC_95.L_CORE 0.002574
K_1680 X_NUC_11.L_CORE X_NUC_96.L_CORE 0.002578
K_1681 X_NUC_11.L_CORE X_NUC_97.L_CORE 0.001815
K_1682 X_NUC_11.L_CORE X_NUC_98.L_CORE 0.001810
K_1683 X_NUC_11.L_CORE X_NUC_99.L_CORE 0.001809
K_1684 X_NUC_11.L_CORE X_NUC_100.L_CORE 0.001800
K_1685 X_NUC_11.L_CORE X_NUC_101.L_CORE 0.002092
K_1686 X_NUC_11.L_CORE X_NUC_102.L_CORE 0.002082
K_1687 X_NUC_11.L_CORE X_NUC_103.L_CORE 0.002073
K_1688 X_NUC_11.L_CORE X_NUC_104.L_CORE 0.002078
K_1689 X_NUC_11.L_CORE X_NUC_105.L_CORE 0.002127
K_1690 X_NUC_11.L_CORE X_NUC_106.L_CORE 0.002132
K_1691 X_NUC_11.L_CORE X_NUC_107.L_CORE 0.002120
K_1692 X_NUC_11.L_CORE X_NUC_108.L_CORE 0.002112
K_1693 X_NUC_11.L_CORE X_NUC_109.L_CORE 0.001748
K_1694 X_NUC_11.L_CORE X_NUC_110.L_CORE 0.001740
K_1695 X_NUC_11.L_CORE X_NUC_111.L_CORE 0.001738
K_1696 X_NUC_11.L_CORE X_NUC_112.L_CORE 0.001733
K_1697 X_NUC_11.L_CORE X_NUC_113.L_CORE 0.002152
K_1698 X_NUC_11.L_CORE X_NUC_114.L_CORE 0.002151
K_1699 X_NUC_11.L_CORE X_NUC_115.L_CORE 0.002134
K_1700 X_NUC_11.L_CORE X_NUC_116.L_CORE 0.002138
K_1701 X_NUC_11.L_CORE X_NUC_117.L_CORE 0.001815
K_1702 X_NUC_11.L_CORE X_NUC_118.L_CORE 0.001813
K_1703 X_NUC_11.L_CORE X_NUC_119.L_CORE 0.001808
K_1704 X_NUC_11.L_CORE X_NUC_120.L_CORE 0.001800
K_1705 X_NUC_11.L_CORE X_NUC_121.L_CORE 0.001811
K_1706 X_NUC_11.L_CORE X_NUC_122.L_CORE 0.001804
K_1707 X_NUC_11.L_CORE X_NUC_123.L_CORE 0.001798
K_1708 X_NUC_11.L_CORE X_NUC_124.L_CORE 0.001797
K_1709 X_NUC_11.L_CORE X_NUC_125.L_CORE 0.001940
K_1710 X_NUC_11.L_CORE X_NUC_126.L_CORE 0.001940
K_1711 X_NUC_11.L_CORE X_NUC_127.L_CORE 0.001929
K_1712 X_NUC_11.L_CORE X_NUC_128.L_CORE 0.001926
K_1713 X_NUC_11.L_CORE X_NUC_129.L_CORE 0.001745
K_1714 X_NUC_11.L_CORE X_NUC_130.L_CORE 0.001741
K_1715 X_NUC_11.L_CORE X_NUC_131.L_CORE 0.001735
K_1716 X_NUC_11.L_CORE X_NUC_132.L_CORE 0.001731
K_1717 X_NUC_11.L_CORE X_NUC_133.L_CORE 0.005491
K_1718 X_NUC_11.L_CORE X_NUC_134.L_CORE 0.003646
K_1719 X_NUC_11.L_CORE X_NUC_135.L_CORE 0.031891
K_1720 X_NUC_11.L_CORE X_NUC_136.L_CORE 0.003014
K_1721 X_NUC_11.L_CORE X_NUC_137.L_CORE 0.003873
K_1722 X_NUC_11.L_CORE X_NUC_138.L_CORE 0.005118
K_1723 X_NUC_11.L_CORE X_NUC_139.L_CORE 0.002415
K_1724 X_NUC_11.L_CORE X_NUC_140.L_CORE 0.005714
K_1725 X_NUC_11.L_CORE X_NUC_141.L_CORE 0.002713
K_1726 X_NUC_11.L_CORE X_NUC_142.L_CORE 0.002479
K_1727 X_NUC_11.L_CORE X_NUC_143.L_CORE 0.004794
K_1728 X_NUC_11.L_CORE X_NUC_144.L_CORE 0.002085
K_1729 X_NUC_11.L_CORE X_NUC_145.L_CORE 0.003043
K_1730 X_NUC_11.L_CORE X_NUC_146.L_CORE 0.002757
K_1731 X_NUC_11.L_CORE X_NUC_147.L_CORE 0.001978
K_1732 X_NUC_11.L_CORE X_NUC_148.L_CORE 0.003515
K_1733 X_NUC_11.L_CORE X_NUC_149.L_CORE 0.002009
K_1734 X_NUC_11.L_CORE X_NUC_150.L_CORE 0.002181
K_1735 X_NUC_11.L_CORE X_NUC_151.L_CORE 0.002747
K_1736 X_NUC_11.L_CORE X_NUC_152.L_CORE 0.001777
K_1737 X_NUC_11.L_CORE X_NUC_153.L_CORE 0.002521
K_1738 X_NUC_11.L_CORE X_NUC_154.L_CORE 0.002030
K_1739 X_NUC_11.L_CORE X_NUC_155.L_CORE 0.001808
K_1740 X_NUC_11.L_CORE X_NUC_156.L_CORE 0.002454
K_1741 X_NUC_11.L_CORE X_NUC_157.L_CORE 0.001718
K_1742 X_NUC_11.L_CORE X_NUC_158.L_CORE 0.001976
K_1743 X_NUC_11.L_CORE X_NUC_159.L_CORE 0.002016
K_1744 X_NUC_11.L_CORE X_NUC_160.L_CORE 0.001653
K_1745 X_NUC_11.L_CORE X_NUC_161.L_CORE 0.002036
K_1746 X_NUC_11.L_CORE X_NUC_162.L_CORE 0.001718
K_1747 X_NUC_11.L_CORE X_NUC_163.L_CORE 0.001712
K_1748 X_NUC_11.L_CORE X_NUC_164.L_CORE 0.001837
K_1749 X_NUC_11.L_CORE X_NUC_165.L_CORE 0.001651
K_1750 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.003238
K_1751 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.003215
K_1752 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.003247
K_1753 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.003203
K_1754 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.004122
K_1755 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.004046
K_1756 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.004065
K_1757 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.004087
K_1758 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.005543
K_1759 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.005622
K_1760 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.005612
K_1761 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.005494
K_1762 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.002578
K_1763 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.002552
K_1764 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.002570
K_1765 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.002552
K_1766 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.006016
K_1767 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.005970
K_1768 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.005863
K_1769 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.006000
K_1770 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.002905
K_1771 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.002904
K_1772 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.002915
K_1773 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.002877
K_1774 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.002633
K_1775 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.002602
K_1776 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.002610
K_1777 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.002610
K_1778 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.005088
K_1779 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.005177
K_1780 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.005070
K_1781 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.005068
K_1782 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.002224
K_1783 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.002211
K_1784 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.002220
K_1785 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.002202
K_1786 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.003210
K_1787 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.003180
K_1788 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.003162
K_1789 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.003189
K_1790 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.002940
K_1791 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.002955
K_1792 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.002946
K_1793 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.002916
K_1794 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.002102
K_1795 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.002084
K_1796 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.002089
K_1797 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.002083
K_1798 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.003698
K_1799 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.003712
K_1800 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.003650
K_1801 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.003682
K_1802 X_NUC_12.L_CORE X_NUC_65.L_CORE 0.002140
K_1803 X_NUC_12.L_CORE X_NUC_66.L_CORE 0.002135
K_1804 X_NUC_12.L_CORE X_NUC_67.L_CORE 0.002139
K_1805 X_NUC_12.L_CORE X_NUC_68.L_CORE 0.002121
K_1806 X_NUC_12.L_CORE X_NUC_69.L_CORE 0.002307
K_1807 X_NUC_12.L_CORE X_NUC_70.L_CORE 0.002287
K_1808 X_NUC_12.L_CORE X_NUC_71.L_CORE 0.002283
K_1809 X_NUC_12.L_CORE X_NUC_72.L_CORE 0.002289
K_1810 X_NUC_12.L_CORE X_NUC_73.L_CORE 0.002911
K_1811 X_NUC_12.L_CORE X_NUC_74.L_CORE 0.002932
K_1812 X_NUC_12.L_CORE X_NUC_75.L_CORE 0.002904
K_1813 X_NUC_12.L_CORE X_NUC_76.L_CORE 0.002892
K_1814 X_NUC_12.L_CORE X_NUC_77.L_CORE 0.001888
K_1815 X_NUC_12.L_CORE X_NUC_78.L_CORE 0.001878
K_1816 X_NUC_12.L_CORE X_NUC_79.L_CORE 0.001881
K_1817 X_NUC_12.L_CORE X_NUC_80.L_CORE 0.001872
K_1818 X_NUC_12.L_CORE X_NUC_81.L_CORE 0.002656
K_1819 X_NUC_12.L_CORE X_NUC_82.L_CORE 0.002647
K_1820 X_NUC_12.L_CORE X_NUC_83.L_CORE 0.002623
K_1821 X_NUC_12.L_CORE X_NUC_84.L_CORE 0.002640
K_1822 X_NUC_12.L_CORE X_NUC_85.L_CORE 0.002158
K_1823 X_NUC_12.L_CORE X_NUC_86.L_CORE 0.002160
K_1824 X_NUC_12.L_CORE X_NUC_87.L_CORE 0.002155
K_1825 X_NUC_12.L_CORE X_NUC_88.L_CORE 0.002140
K_1826 X_NUC_12.L_CORE X_NUC_89.L_CORE 0.001916
K_1827 X_NUC_12.L_CORE X_NUC_90.L_CORE 0.001903
K_1828 X_NUC_12.L_CORE X_NUC_91.L_CORE 0.001902
K_1829 X_NUC_12.L_CORE X_NUC_92.L_CORE 0.001900
K_1830 X_NUC_12.L_CORE X_NUC_93.L_CORE 0.002590
K_1831 X_NUC_12.L_CORE X_NUC_94.L_CORE 0.002599
K_1832 X_NUC_12.L_CORE X_NUC_95.L_CORE 0.002571
K_1833 X_NUC_12.L_CORE X_NUC_96.L_CORE 0.002574
K_1834 X_NUC_12.L_CORE X_NUC_97.L_CORE 0.001825
K_1835 X_NUC_12.L_CORE X_NUC_98.L_CORE 0.001820
K_1836 X_NUC_12.L_CORE X_NUC_99.L_CORE 0.001819
K_1837 X_NUC_12.L_CORE X_NUC_100.L_CORE 0.001809
K_1838 X_NUC_12.L_CORE X_NUC_101.L_CORE 0.002087
K_1839 X_NUC_12.L_CORE X_NUC_102.L_CORE 0.002077
K_1840 X_NUC_12.L_CORE X_NUC_103.L_CORE 0.002067
K_1841 X_NUC_12.L_CORE X_NUC_104.L_CORE 0.002073
K_1842 X_NUC_12.L_CORE X_NUC_105.L_CORE 0.002136
K_1843 X_NUC_12.L_CORE X_NUC_106.L_CORE 0.002140
K_1844 X_NUC_12.L_CORE X_NUC_107.L_CORE 0.002128
K_1845 X_NUC_12.L_CORE X_NUC_108.L_CORE 0.002120
K_1846 X_NUC_12.L_CORE X_NUC_109.L_CORE 0.001752
K_1847 X_NUC_12.L_CORE X_NUC_110.L_CORE 0.001744
K_1848 X_NUC_12.L_CORE X_NUC_111.L_CORE 0.001743
K_1849 X_NUC_12.L_CORE X_NUC_112.L_CORE 0.001738
K_1850 X_NUC_12.L_CORE X_NUC_113.L_CORE 0.002149
K_1851 X_NUC_12.L_CORE X_NUC_114.L_CORE 0.002147
K_1852 X_NUC_12.L_CORE X_NUC_115.L_CORE 0.002131
K_1853 X_NUC_12.L_CORE X_NUC_116.L_CORE 0.002134
K_1854 X_NUC_12.L_CORE X_NUC_117.L_CORE 0.001822
K_1855 X_NUC_12.L_CORE X_NUC_118.L_CORE 0.001821
K_1856 X_NUC_12.L_CORE X_NUC_119.L_CORE 0.001816
K_1857 X_NUC_12.L_CORE X_NUC_120.L_CORE 0.001808
K_1858 X_NUC_12.L_CORE X_NUC_121.L_CORE 0.001811
K_1859 X_NUC_12.L_CORE X_NUC_122.L_CORE 0.001804
K_1860 X_NUC_12.L_CORE X_NUC_123.L_CORE 0.001798
K_1861 X_NUC_12.L_CORE X_NUC_124.L_CORE 0.001798
K_1862 X_NUC_12.L_CORE X_NUC_125.L_CORE 0.001943
K_1863 X_NUC_12.L_CORE X_NUC_126.L_CORE 0.001943
K_1864 X_NUC_12.L_CORE X_NUC_127.L_CORE 0.001931
K_1865 X_NUC_12.L_CORE X_NUC_128.L_CORE 0.001929
K_1866 X_NUC_12.L_CORE X_NUC_129.L_CORE 0.001749
K_1867 X_NUC_12.L_CORE X_NUC_130.L_CORE 0.001745
K_1868 X_NUC_12.L_CORE X_NUC_131.L_CORE 0.001739
K_1869 X_NUC_12.L_CORE X_NUC_132.L_CORE 0.001735
K_1870 X_NUC_12.L_CORE X_NUC_133.L_CORE 0.005619
K_1871 X_NUC_12.L_CORE X_NUC_134.L_CORE 0.003668
K_1872 X_NUC_12.L_CORE X_NUC_135.L_CORE 0.030382
K_1873 X_NUC_12.L_CORE X_NUC_136.L_CORE 0.003053
K_1874 X_NUC_12.L_CORE X_NUC_137.L_CORE 0.003851
K_1875 X_NUC_12.L_CORE X_NUC_138.L_CORE 0.005219
K_1876 X_NUC_12.L_CORE X_NUC_139.L_CORE 0.002431
K_1877 X_NUC_12.L_CORE X_NUC_140.L_CORE 0.005577
K_1878 X_NUC_12.L_CORE X_NUC_141.L_CORE 0.002748
K_1879 X_NUC_12.L_CORE X_NUC_142.L_CORE 0.002478
K_1880 X_NUC_12.L_CORE X_NUC_143.L_CORE 0.004793
K_1881 X_NUC_12.L_CORE X_NUC_144.L_CORE 0.002102
K_1882 X_NUC_12.L_CORE X_NUC_145.L_CORE 0.003015
K_1883 X_NUC_12.L_CORE X_NUC_146.L_CORE 0.002785
K_1884 X_NUC_12.L_CORE X_NUC_147.L_CORE 0.001984
K_1885 X_NUC_12.L_CORE X_NUC_148.L_CORE 0.003483
K_1886 X_NUC_12.L_CORE X_NUC_149.L_CORE 0.002025
K_1887 X_NUC_12.L_CORE X_NUC_150.L_CORE 0.002175
K_1888 X_NUC_12.L_CORE X_NUC_151.L_CORE 0.002757
K_1889 X_NUC_12.L_CORE X_NUC_152.L_CORE 0.001785
K_1890 X_NUC_12.L_CORE X_NUC_153.L_CORE 0.002505
K_1891 X_NUC_12.L_CORE X_NUC_154.L_CORE 0.002044
K_1892 X_NUC_12.L_CORE X_NUC_155.L_CORE 0.001809
K_1893 X_NUC_12.L_CORE X_NUC_156.L_CORE 0.002450
K_1894 X_NUC_12.L_CORE X_NUC_157.L_CORE 0.001727
K_1895 X_NUC_12.L_CORE X_NUC_158.L_CORE 0.001971
K_1896 X_NUC_12.L_CORE X_NUC_159.L_CORE 0.002023
K_1897 X_NUC_12.L_CORE X_NUC_160.L_CORE 0.001657
K_1898 X_NUC_12.L_CORE X_NUC_161.L_CORE 0.002032
K_1899 X_NUC_12.L_CORE X_NUC_162.L_CORE 0.001726
K_1900 X_NUC_12.L_CORE X_NUC_163.L_CORE 0.001713
K_1901 X_NUC_12.L_CORE X_NUC_164.L_CORE 0.001839
K_1902 X_NUC_12.L_CORE X_NUC_165.L_CORE 0.001655
K_1903 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_1904 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_1905 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_1906 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.002818
K_1907 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.002808
K_1908 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.002793
K_1909 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.002830
K_1910 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.003674
K_1911 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.003731
K_1912 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.003680
K_1913 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.003711
K_1914 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.005112
K_1915 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.005000
K_1916 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.005012
K_1917 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.005050
K_1918 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.002332
K_1919 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.002338
K_1920 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.002319
K_1921 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.002344
K_1922 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.005988
K_1923 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.006126
K_1924 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.006017
K_1925 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.005962
K_1926 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.002690
K_1927 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.002669
K_1928 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.002660
K_1929 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.002686
K_1930 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.002449
K_1931 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.002469
K_1932 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.002443
K_1933 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.002462
K_1934 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.005285
K_1935 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.005210
K_1936 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.005201
K_1937 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.005156
K_1938 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.002076
K_1939 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.002073
K_1940 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.002060
K_1941 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.002079
K_1942 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.003126
K_1943 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.003166
K_1944 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.003125
K_1945 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.003129
K_1946 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.002851
K_1947 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.002822
K_1948 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.002814
K_1949 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.002828
K_1950 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.001988
K_1951 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.001996
K_1952 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.001978
K_1953 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.001994
K_1954 X_NUC_13.L_CORE X_NUC_65.L_CORE 0.003836
K_1955 X_NUC_13.L_CORE X_NUC_66.L_CORE 0.003849
K_1956 X_NUC_13.L_CORE X_NUC_67.L_CORE 0.003813
K_1957 X_NUC_13.L_CORE X_NUC_68.L_CORE 0.003784
K_1958 X_NUC_13.L_CORE X_NUC_69.L_CORE 0.002046
K_1959 X_NUC_13.L_CORE X_NUC_70.L_CORE 0.002038
K_1960 X_NUC_13.L_CORE X_NUC_71.L_CORE 0.002027
K_1961 X_NUC_13.L_CORE X_NUC_72.L_CORE 0.002042
K_1962 X_NUC_13.L_CORE X_NUC_73.L_CORE 0.002235
K_1963 X_NUC_13.L_CORE X_NUC_74.L_CORE 0.002252
K_1964 X_NUC_13.L_CORE X_NUC_75.L_CORE 0.002229
K_1965 X_NUC_13.L_CORE X_NUC_76.L_CORE 0.002238
K_1966 X_NUC_13.L_CORE X_NUC_77.L_CORE 0.002936
K_1967 X_NUC_13.L_CORE X_NUC_78.L_CORE 0.002913
K_1968 X_NUC_13.L_CORE X_NUC_79.L_CORE 0.002902
K_1969 X_NUC_13.L_CORE X_NUC_80.L_CORE 0.002900
K_1970 X_NUC_13.L_CORE X_NUC_81.L_CORE 0.001811
K_1971 X_NUC_13.L_CORE X_NUC_82.L_CORE 0.001813
K_1972 X_NUC_13.L_CORE X_NUC_83.L_CORE 0.001799
K_1973 X_NUC_13.L_CORE X_NUC_84.L_CORE 0.001812
K_1974 X_NUC_13.L_CORE X_NUC_85.L_CORE 0.002670
K_1975 X_NUC_13.L_CORE X_NUC_86.L_CORE 0.002688
K_1976 X_NUC_13.L_CORE X_NUC_87.L_CORE 0.002660
K_1977 X_NUC_13.L_CORE X_NUC_88.L_CORE 0.002656
K_1978 X_NUC_13.L_CORE X_NUC_89.L_CORE 0.002114
K_1979 X_NUC_13.L_CORE X_NUC_90.L_CORE 0.002102
K_1980 X_NUC_13.L_CORE X_NUC_91.L_CORE 0.002092
K_1981 X_NUC_13.L_CORE X_NUC_92.L_CORE 0.002102
K_1982 X_NUC_13.L_CORE X_NUC_93.L_CORE 0.001862
K_1983 X_NUC_13.L_CORE X_NUC_94.L_CORE 0.001870
K_1984 X_NUC_13.L_CORE X_NUC_95.L_CORE 0.001853
K_1985 X_NUC_13.L_CORE X_NUC_96.L_CORE 0.001863
K_1986 X_NUC_13.L_CORE X_NUC_97.L_CORE 0.002630
K_1987 X_NUC_13.L_CORE X_NUC_98.L_CORE 0.002626
K_1988 X_NUC_13.L_CORE X_NUC_99.L_CORE 0.002608
K_1989 X_NUC_13.L_CORE X_NUC_100.L_CORE 0.002602
K_1990 X_NUC_13.L_CORE X_NUC_101.L_CORE 0.001779
K_1991 X_NUC_13.L_CORE X_NUC_102.L_CORE 0.001776
K_1992 X_NUC_13.L_CORE X_NUC_103.L_CORE 0.001765
K_1993 X_NUC_13.L_CORE X_NUC_104.L_CORE 0.001776
K_1994 X_NUC_13.L_CORE X_NUC_105.L_CORE 0.002069
K_1995 X_NUC_13.L_CORE X_NUC_106.L_CORE 0.002079
K_1996 X_NUC_13.L_CORE X_NUC_107.L_CORE 0.002060
K_1997 X_NUC_13.L_CORE X_NUC_108.L_CORE 0.002064
K_1998 X_NUC_13.L_CORE X_NUC_109.L_CORE 0.002126
K_1999 X_NUC_13.L_CORE X_NUC_110.L_CORE 0.002118
K_2000 X_NUC_13.L_CORE X_NUC_111.L_CORE 0.002106
K_2001 X_NUC_13.L_CORE X_NUC_112.L_CORE 0.002111
K_2002 X_NUC_13.L_CORE X_NUC_113.L_CORE 0.001723
K_2003 X_NUC_13.L_CORE X_NUC_114.L_CORE 0.001726
K_2004 X_NUC_13.L_CORE X_NUC_115.L_CORE 0.001712
K_2005 X_NUC_13.L_CORE X_NUC_116.L_CORE 0.001721
K_2006 X_NUC_13.L_CORE X_NUC_117.L_CORE 0.002144
K_2007 X_NUC_13.L_CORE X_NUC_118.L_CORE 0.002147
K_2008 X_NUC_13.L_CORE X_NUC_119.L_CORE 0.002130
K_2009 X_NUC_13.L_CORE X_NUC_120.L_CORE 0.002130
K_2010 X_NUC_13.L_CORE X_NUC_121.L_CORE 0.001808
K_2011 X_NUC_13.L_CORE X_NUC_122.L_CORE 0.001805
K_2012 X_NUC_13.L_CORE X_NUC_123.L_CORE 0.001793
K_2013 X_NUC_13.L_CORE X_NUC_124.L_CORE 0.001800
K_2014 X_NUC_13.L_CORE X_NUC_125.L_CORE 0.001804
K_2015 X_NUC_13.L_CORE X_NUC_126.L_CORE 0.001808
K_2016 X_NUC_13.L_CORE X_NUC_127.L_CORE 0.001793
K_2017 X_NUC_13.L_CORE X_NUC_128.L_CORE 0.001799
K_2018 X_NUC_13.L_CORE X_NUC_129.L_CORE 0.001896
K_2019 X_NUC_13.L_CORE X_NUC_130.L_CORE 0.001896
K_2020 X_NUC_13.L_CORE X_NUC_131.L_CORE 0.001882
K_2021 X_NUC_13.L_CORE X_NUC_132.L_CORE 0.001886
K_2022 X_NUC_13.L_CORE X_NUC_133.L_CORE 0.006031
K_2023 X_NUC_13.L_CORE X_NUC_134.L_CORE 0.004451
K_2024 X_NUC_13.L_CORE X_NUC_135.L_CORE 0.003046
K_2025 X_NUC_13.L_CORE X_NUC_136.L_CORE 0.033808
K_2026 X_NUC_13.L_CORE X_NUC_137.L_CORE 0.002667
K_2027 X_NUC_13.L_CORE X_NUC_138.L_CORE 0.003500
K_2028 X_NUC_13.L_CORE X_NUC_139.L_CORE 0.004751
K_2029 X_NUC_13.L_CORE X_NUC_140.L_CORE 0.002215
K_2030 X_NUC_13.L_CORE X_NUC_141.L_CORE 0.005651
K_2031 X_NUC_13.L_CORE X_NUC_142.L_CORE 0.002539
K_2032 X_NUC_13.L_CORE X_NUC_143.L_CORE 0.002331
K_2033 X_NUC_13.L_CORE X_NUC_144.L_CORE 0.004908
K_2034 X_NUC_13.L_CORE X_NUC_145.L_CORE 0.001968
K_2035 X_NUC_13.L_CORE X_NUC_146.L_CORE 0.002973
K_2036 X_NUC_13.L_CORE X_NUC_147.L_CORE 0.002683
K_2037 X_NUC_13.L_CORE X_NUC_148.L_CORE 0.001889
K_2038 X_NUC_13.L_CORE X_NUC_149.L_CORE 0.003614
K_2039 X_NUC_13.L_CORE X_NUC_150.L_CORE 0.001936
K_2040 X_NUC_13.L_CORE X_NUC_151.L_CORE 0.002125
K_2041 X_NUC_13.L_CORE X_NUC_152.L_CORE 0.002762
K_2042 X_NUC_13.L_CORE X_NUC_153.L_CORE 0.001719
K_2043 X_NUC_13.L_CORE X_NUC_154.L_CORE 0.002532
K_2044 X_NUC_13.L_CORE X_NUC_155.L_CORE 0.001997
K_2045 X_NUC_13.L_CORE X_NUC_156.L_CORE 0.001769
K_2046 X_NUC_13.L_CORE X_NUC_157.L_CORE 0.002482
K_2047 X_NUC_13.L_CORE X_NUC_158.L_CORE 0.001686
K_2048 X_NUC_13.L_CORE X_NUC_159.L_CORE 0.001964
K_2049 X_NUC_13.L_CORE X_NUC_160.L_CORE 0.002009
K_2050 X_NUC_13.L_CORE X_NUC_161.L_CORE 0.001635
K_2051 X_NUC_13.L_CORE X_NUC_162.L_CORE 0.002030
K_2052 X_NUC_13.L_CORE X_NUC_163.L_CORE 0.001712
K_2053 X_NUC_13.L_CORE X_NUC_164.L_CORE 0.001711
K_2054 X_NUC_13.L_CORE X_NUC_165.L_CORE 0.001796
K_2055 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_2056 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_2057 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.002827
K_2058 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.002818
K_2059 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.002803
K_2060 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.002840
K_2061 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.003618
K_2062 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.003674
K_2063 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.003624
K_2064 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.003655
K_2065 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.005228
K_2066 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.005112
K_2067 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.005123
K_2068 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.005164
K_2069 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.002326
K_2070 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.002332
K_2071 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.002313
K_2072 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.002338
K_2073 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.005855
K_2074 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.005988
K_2075 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.005884
K_2076 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.005832
K_2077 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.002711
K_2078 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.002690
K_2079 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.002680
K_2080 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.002706
K_2081 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.002429
K_2082 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.002449
K_2083 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.002424
K_2084 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.002442
K_2085 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.005360
K_2086 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.005285
K_2087 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.005274
K_2088 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.005226
K_2089 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.002078
K_2090 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.002076
K_2091 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.002062
K_2092 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.002082
K_2093 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.003088
K_2094 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.003126
K_2095 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.003087
K_2096 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.003090
K_2097 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.002880
K_2098 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.002851
K_2099 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.002843
K_2100 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.002857
K_2101 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.001980
K_2102 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.001988
K_2103 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.001971
K_2104 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.001986
K_2105 X_NUC_14.L_CORE X_NUC_65.L_CORE 0.003823
K_2106 X_NUC_14.L_CORE X_NUC_66.L_CORE 0.003836
K_2107 X_NUC_14.L_CORE X_NUC_67.L_CORE 0.003801
K_2108 X_NUC_14.L_CORE X_NUC_68.L_CORE 0.003771
K_2109 X_NUC_14.L_CORE X_NUC_69.L_CORE 0.002054
K_2110 X_NUC_14.L_CORE X_NUC_70.L_CORE 0.002046
K_2111 X_NUC_14.L_CORE X_NUC_71.L_CORE 0.002035
K_2112 X_NUC_14.L_CORE X_NUC_72.L_CORE 0.002050
K_2113 X_NUC_14.L_CORE X_NUC_73.L_CORE 0.002218
K_2114 X_NUC_14.L_CORE X_NUC_74.L_CORE 0.002235
K_2115 X_NUC_14.L_CORE X_NUC_75.L_CORE 0.002212
K_2116 X_NUC_14.L_CORE X_NUC_76.L_CORE 0.002221
K_2117 X_NUC_14.L_CORE X_NUC_77.L_CORE 0.002959
K_2118 X_NUC_14.L_CORE X_NUC_78.L_CORE 0.002936
K_2119 X_NUC_14.L_CORE X_NUC_79.L_CORE 0.002924
K_2120 X_NUC_14.L_CORE X_NUC_80.L_CORE 0.002922
K_2121 X_NUC_14.L_CORE X_NUC_81.L_CORE 0.001810
K_2122 X_NUC_14.L_CORE X_NUC_82.L_CORE 0.001811
K_2123 X_NUC_14.L_CORE X_NUC_83.L_CORE 0.001798
K_2124 X_NUC_14.L_CORE X_NUC_84.L_CORE 0.001811
K_2125 X_NUC_14.L_CORE X_NUC_85.L_CORE 0.002652
K_2126 X_NUC_14.L_CORE X_NUC_86.L_CORE 0.002670
K_2127 X_NUC_14.L_CORE X_NUC_87.L_CORE 0.002643
K_2128 X_NUC_14.L_CORE X_NUC_88.L_CORE 0.002639
K_2129 X_NUC_14.L_CORE X_NUC_89.L_CORE 0.002125
K_2130 X_NUC_14.L_CORE X_NUC_90.L_CORE 0.002114
K_2131 X_NUC_14.L_CORE X_NUC_91.L_CORE 0.002103
K_2132 X_NUC_14.L_CORE X_NUC_92.L_CORE 0.002113
K_2133 X_NUC_14.L_CORE X_NUC_93.L_CORE 0.001854
K_2134 X_NUC_14.L_CORE X_NUC_94.L_CORE 0.001862
K_2135 X_NUC_14.L_CORE X_NUC_95.L_CORE 0.001846
K_2136 X_NUC_14.L_CORE X_NUC_96.L_CORE 0.001855
K_2137 X_NUC_14.L_CORE X_NUC_97.L_CORE 0.002633
K_2138 X_NUC_14.L_CORE X_NUC_98.L_CORE 0.002630
K_2139 X_NUC_14.L_CORE X_NUC_99.L_CORE 0.002611
K_2140 X_NUC_14.L_CORE X_NUC_100.L_CORE 0.002606
K_2141 X_NUC_14.L_CORE X_NUC_101.L_CORE 0.001781
K_2142 X_NUC_14.L_CORE X_NUC_102.L_CORE 0.001779
K_2143 X_NUC_14.L_CORE X_NUC_103.L_CORE 0.001767
K_2144 X_NUC_14.L_CORE X_NUC_104.L_CORE 0.001778
K_2145 X_NUC_14.L_CORE X_NUC_105.L_CORE 0.002059
K_2146 X_NUC_14.L_CORE X_NUC_106.L_CORE 0.002069
K_2147 X_NUC_14.L_CORE X_NUC_107.L_CORE 0.002050
K_2148 X_NUC_14.L_CORE X_NUC_108.L_CORE 0.002054
K_2149 X_NUC_14.L_CORE X_NUC_109.L_CORE 0.002135
K_2150 X_NUC_14.L_CORE X_NUC_110.L_CORE 0.002126
K_2151 X_NUC_14.L_CORE X_NUC_111.L_CORE 0.002114
K_2152 X_NUC_14.L_CORE X_NUC_112.L_CORE 0.002119
K_2153 X_NUC_14.L_CORE X_NUC_113.L_CORE 0.001720
K_2154 X_NUC_14.L_CORE X_NUC_114.L_CORE 0.001723
K_2155 X_NUC_14.L_CORE X_NUC_115.L_CORE 0.001710
K_2156 X_NUC_14.L_CORE X_NUC_116.L_CORE 0.001718
K_2157 X_NUC_14.L_CORE X_NUC_117.L_CORE 0.002140
K_2158 X_NUC_14.L_CORE X_NUC_118.L_CORE 0.002144
K_2159 X_NUC_14.L_CORE X_NUC_119.L_CORE 0.002126
K_2160 X_NUC_14.L_CORE X_NUC_120.L_CORE 0.002127
K_2161 X_NUC_14.L_CORE X_NUC_121.L_CORE 0.001811
K_2162 X_NUC_14.L_CORE X_NUC_122.L_CORE 0.001808
K_2163 X_NUC_14.L_CORE X_NUC_123.L_CORE 0.001796
K_2164 X_NUC_14.L_CORE X_NUC_124.L_CORE 0.001804
K_2165 X_NUC_14.L_CORE X_NUC_125.L_CORE 0.001799
K_2166 X_NUC_14.L_CORE X_NUC_126.L_CORE 0.001804
K_2167 X_NUC_14.L_CORE X_NUC_127.L_CORE 0.001789
K_2168 X_NUC_14.L_CORE X_NUC_128.L_CORE 0.001795
K_2169 X_NUC_14.L_CORE X_NUC_129.L_CORE 0.001897
K_2170 X_NUC_14.L_CORE X_NUC_130.L_CORE 0.001896
K_2171 X_NUC_14.L_CORE X_NUC_131.L_CORE 0.001883
K_2172 X_NUC_14.L_CORE X_NUC_132.L_CORE 0.001887
K_2173 X_NUC_14.L_CORE X_NUC_133.L_CORE 0.005949
K_2174 X_NUC_14.L_CORE X_NUC_134.L_CORE 0.004498
K_2175 X_NUC_14.L_CORE X_NUC_135.L_CORE 0.003025
K_2176 X_NUC_14.L_CORE X_NUC_136.L_CORE 0.034276
K_2177 X_NUC_14.L_CORE X_NUC_137.L_CORE 0.002677
K_2178 X_NUC_14.L_CORE X_NUC_138.L_CORE 0.003448
K_2179 X_NUC_14.L_CORE X_NUC_139.L_CORE 0.004857
K_2180 X_NUC_14.L_CORE X_NUC_140.L_CORE 0.002210
K_2181 X_NUC_14.L_CORE X_NUC_141.L_CORE 0.005531
K_2182 X_NUC_14.L_CORE X_NUC_142.L_CORE 0.002559
K_2183 X_NUC_14.L_CORE X_NUC_143.L_CORE 0.002312
K_2184 X_NUC_14.L_CORE X_NUC_144.L_CORE 0.004977
K_2185 X_NUC_14.L_CORE X_NUC_145.L_CORE 0.001970
K_2186 X_NUC_14.L_CORE X_NUC_146.L_CORE 0.002937
K_2187 X_NUC_14.L_CORE X_NUC_147.L_CORE 0.002711
K_2188 X_NUC_14.L_CORE X_NUC_148.L_CORE 0.001882
K_2189 X_NUC_14.L_CORE X_NUC_149.L_CORE 0.003603
K_2190 X_NUC_14.L_CORE X_NUC_150.L_CORE 0.001944
K_2191 X_NUC_14.L_CORE X_NUC_151.L_CORE 0.002110
K_2192 X_NUC_14.L_CORE X_NUC_152.L_CORE 0.002784
K_2193 X_NUC_14.L_CORE X_NUC_153.L_CORE 0.001717
K_2194 X_NUC_14.L_CORE X_NUC_154.L_CORE 0.002515
K_2195 X_NUC_14.L_CORE X_NUC_155.L_CORE 0.002007
K_2196 X_NUC_14.L_CORE X_NUC_156.L_CORE 0.001762
K_2197 X_NUC_14.L_CORE X_NUC_157.L_CORE 0.002486
K_2198 X_NUC_14.L_CORE X_NUC_158.L_CORE 0.001688
K_2199 X_NUC_14.L_CORE X_NUC_159.L_CORE 0.001955
K_2200 X_NUC_14.L_CORE X_NUC_160.L_CORE 0.002017
K_2201 X_NUC_14.L_CORE X_NUC_161.L_CORE 0.001632
K_2202 X_NUC_14.L_CORE X_NUC_162.L_CORE 0.002027
K_2203 X_NUC_14.L_CORE X_NUC_163.L_CORE 0.001715
K_2204 X_NUC_14.L_CORE X_NUC_164.L_CORE 0.001707
K_2205 X_NUC_14.L_CORE X_NUC_165.L_CORE 0.001796
K_2206 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_2207 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.002843
K_2208 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.002833
K_2209 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.002818
K_2210 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.002855
K_2211 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.003666
K_2212 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.003724
K_2213 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.003674
K_2214 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.003705
K_2215 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.005214
K_2216 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.005097
K_2217 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.005112
K_2218 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.005151
K_2219 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.002345
K_2220 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.002351
K_2221 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.002332
K_2222 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.002357
K_2223 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.005956
K_2224 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.006094
K_2225 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.005988
K_2226 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.005932
K_2227 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.002721
K_2228 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.002700
K_2229 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.002690
K_2230 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.002716
K_2231 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.002455
K_2232 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.002475
K_2233 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.002449
K_2234 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.002468
K_2235 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.005369
K_2236 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.005293
K_2237 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.005285
K_2238 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.005235
K_2239 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.002091
K_2240 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.002089
K_2241 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.002076
K_2242 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.002095
K_2243 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.003127
K_2244 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.003166
K_2245 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.003126
K_2246 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.003129
K_2247 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.002889
K_2248 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.002859
K_2249 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.002851
K_2250 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.002865
K_2251 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.001998
K_2252 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.002005
K_2253 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.001988
K_2254 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.002004
K_2255 X_NUC_15.L_CORE X_NUC_65.L_CORE 0.003858
K_2256 X_NUC_15.L_CORE X_NUC_66.L_CORE 0.003872
K_2257 X_NUC_15.L_CORE X_NUC_67.L_CORE 0.003836
K_2258 X_NUC_15.L_CORE X_NUC_68.L_CORE 0.003805
K_2259 X_NUC_15.L_CORE X_NUC_69.L_CORE 0.002065
K_2260 X_NUC_15.L_CORE X_NUC_70.L_CORE 0.002057
K_2261 X_NUC_15.L_CORE X_NUC_71.L_CORE 0.002046
K_2262 X_NUC_15.L_CORE X_NUC_72.L_CORE 0.002061
K_2263 X_NUC_15.L_CORE X_NUC_73.L_CORE 0.002241
K_2264 X_NUC_15.L_CORE X_NUC_74.L_CORE 0.002259
K_2265 X_NUC_15.L_CORE X_NUC_75.L_CORE 0.002235
K_2266 X_NUC_15.L_CORE X_NUC_76.L_CORE 0.002245
K_2267 X_NUC_15.L_CORE X_NUC_77.L_CORE 0.002972
K_2268 X_NUC_15.L_CORE X_NUC_78.L_CORE 0.002948
K_2269 X_NUC_15.L_CORE X_NUC_79.L_CORE 0.002936
K_2270 X_NUC_15.L_CORE X_NUC_80.L_CORE 0.002934
K_2271 X_NUC_15.L_CORE X_NUC_81.L_CORE 0.001823
K_2272 X_NUC_15.L_CORE X_NUC_82.L_CORE 0.001825
K_2273 X_NUC_15.L_CORE X_NUC_83.L_CORE 0.001811
K_2274 X_NUC_15.L_CORE X_NUC_84.L_CORE 0.001824
K_2275 X_NUC_15.L_CORE X_NUC_85.L_CORE 0.002680
K_2276 X_NUC_15.L_CORE X_NUC_86.L_CORE 0.002698
K_2277 X_NUC_15.L_CORE X_NUC_87.L_CORE 0.002670
K_2278 X_NUC_15.L_CORE X_NUC_88.L_CORE 0.002666
K_2279 X_NUC_15.L_CORE X_NUC_89.L_CORE 0.002135
K_2280 X_NUC_15.L_CORE X_NUC_90.L_CORE 0.002124
K_2281 X_NUC_15.L_CORE X_NUC_91.L_CORE 0.002114
K_2282 X_NUC_15.L_CORE X_NUC_92.L_CORE 0.002124
K_2283 X_NUC_15.L_CORE X_NUC_93.L_CORE 0.001871
K_2284 X_NUC_15.L_CORE X_NUC_94.L_CORE 0.001879
K_2285 X_NUC_15.L_CORE X_NUC_95.L_CORE 0.001862
K_2286 X_NUC_15.L_CORE X_NUC_96.L_CORE 0.001872
K_2287 X_NUC_15.L_CORE X_NUC_97.L_CORE 0.002652
K_2288 X_NUC_15.L_CORE X_NUC_98.L_CORE 0.002648
K_2289 X_NUC_15.L_CORE X_NUC_99.L_CORE 0.002630
K_2290 X_NUC_15.L_CORE X_NUC_100.L_CORE 0.002623
K_2291 X_NUC_15.L_CORE X_NUC_101.L_CORE 0.001793
K_2292 X_NUC_15.L_CORE X_NUC_102.L_CORE 0.001791
K_2293 X_NUC_15.L_CORE X_NUC_103.L_CORE 0.001779
K_2294 X_NUC_15.L_CORE X_NUC_104.L_CORE 0.001790
K_2295 X_NUC_15.L_CORE X_NUC_105.L_CORE 0.002078
K_2296 X_NUC_15.L_CORE X_NUC_106.L_CORE 0.002089
K_2297 X_NUC_15.L_CORE X_NUC_107.L_CORE 0.002069
K_2298 X_NUC_15.L_CORE X_NUC_108.L_CORE 0.002073
K_2299 X_NUC_15.L_CORE X_NUC_109.L_CORE 0.002147
K_2300 X_NUC_15.L_CORE X_NUC_110.L_CORE 0.002138
K_2301 X_NUC_15.L_CORE X_NUC_111.L_CORE 0.002126
K_2302 X_NUC_15.L_CORE X_NUC_112.L_CORE 0.002131
K_2303 X_NUC_15.L_CORE X_NUC_113.L_CORE 0.001734
K_2304 X_NUC_15.L_CORE X_NUC_114.L_CORE 0.001737
K_2305 X_NUC_15.L_CORE X_NUC_115.L_CORE 0.001723
K_2306 X_NUC_15.L_CORE X_NUC_116.L_CORE 0.001732
K_2307 X_NUC_15.L_CORE X_NUC_117.L_CORE 0.002157
K_2308 X_NUC_15.L_CORE X_NUC_118.L_CORE 0.002161
K_2309 X_NUC_15.L_CORE X_NUC_119.L_CORE 0.002144
K_2310 X_NUC_15.L_CORE X_NUC_120.L_CORE 0.002144
K_2311 X_NUC_15.L_CORE X_NUC_121.L_CORE 0.001823
K_2312 X_NUC_15.L_CORE X_NUC_122.L_CORE 0.001820
K_2313 X_NUC_15.L_CORE X_NUC_123.L_CORE 0.001808
K_2314 X_NUC_15.L_CORE X_NUC_124.L_CORE 0.001815
K_2315 X_NUC_15.L_CORE X_NUC_125.L_CORE 0.001814
K_2316 X_NUC_15.L_CORE X_NUC_126.L_CORE 0.001818
K_2317 X_NUC_15.L_CORE X_NUC_127.L_CORE 0.001804
K_2318 X_NUC_15.L_CORE X_NUC_128.L_CORE 0.001809
K_2319 X_NUC_15.L_CORE X_NUC_129.L_CORE 0.001911
K_2320 X_NUC_15.L_CORE X_NUC_130.L_CORE 0.001910
K_2321 X_NUC_15.L_CORE X_NUC_131.L_CORE 0.001896
K_2322 X_NUC_15.L_CORE X_NUC_132.L_CORE 0.001900
K_2323 X_NUC_15.L_CORE X_NUC_133.L_CORE 0.005992
K_2324 X_NUC_15.L_CORE X_NUC_134.L_CORE 0.004495
K_2325 X_NUC_15.L_CORE X_NUC_135.L_CORE 0.003051
K_2326 X_NUC_15.L_CORE X_NUC_136.L_CORE 0.029923
K_2327 X_NUC_15.L_CORE X_NUC_137.L_CORE 0.002688
K_2328 X_NUC_15.L_CORE X_NUC_138.L_CORE 0.003489
K_2329 X_NUC_15.L_CORE X_NUC_139.L_CORE 0.004830
K_2330 X_NUC_15.L_CORE X_NUC_140.L_CORE 0.002226
K_2331 X_NUC_15.L_CORE X_NUC_141.L_CORE 0.005601
K_2332 X_NUC_15.L_CORE X_NUC_142.L_CORE 0.002566
K_2333 X_NUC_15.L_CORE X_NUC_143.L_CORE 0.002335
K_2334 X_NUC_15.L_CORE X_NUC_144.L_CORE 0.004969
K_2335 X_NUC_15.L_CORE X_NUC_145.L_CORE 0.001982
K_2336 X_NUC_15.L_CORE X_NUC_146.L_CORE 0.002970
K_2337 X_NUC_15.L_CORE X_NUC_147.L_CORE 0.002715
K_2338 X_NUC_15.L_CORE X_NUC_148.L_CORE 0.001898
K_2339 X_NUC_15.L_CORE X_NUC_149.L_CORE 0.003629
K_2340 X_NUC_15.L_CORE X_NUC_150.L_CORE 0.001953
K_2341 X_NUC_15.L_CORE X_NUC_151.L_CORE 0.002130
K_2342 X_NUC_15.L_CORE X_NUC_152.L_CORE 0.002792
K_2343 X_NUC_15.L_CORE X_NUC_153.L_CORE 0.001729
K_2344 X_NUC_15.L_CORE X_NUC_154.L_CORE 0.002539
K_2345 X_NUC_15.L_CORE X_NUC_155.L_CORE 0.002016
K_2346 X_NUC_15.L_CORE X_NUC_156.L_CORE 0.001777
K_2347 X_NUC_15.L_CORE X_NUC_157.L_CORE 0.002501
K_2348 X_NUC_15.L_CORE X_NUC_158.L_CORE 0.001698
K_2349 X_NUC_15.L_CORE X_NUC_159.L_CORE 0.001972
K_2350 X_NUC_15.L_CORE X_NUC_160.L_CORE 0.002027
K_2351 X_NUC_15.L_CORE X_NUC_161.L_CORE 0.001645
K_2352 X_NUC_15.L_CORE X_NUC_162.L_CORE 0.002042
K_2353 X_NUC_15.L_CORE X_NUC_163.L_CORE 0.001725
K_2354 X_NUC_15.L_CORE X_NUC_164.L_CORE 0.001721
K_2355 X_NUC_15.L_CORE X_NUC_165.L_CORE 0.001809
K_2356 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.002805
K_2357 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.002796
K_2358 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.002781
K_2359 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.002818
K_2360 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.003636
K_2361 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.003692
K_2362 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.003642
K_2363 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.003674
K_2364 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.005172
K_2365 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.005058
K_2366 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.005071
K_2367 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.005112
K_2368 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.002319
K_2369 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.002325
K_2370 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.002307
K_2371 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.002332
K_2372 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.006010
K_2373 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.006152
K_2374 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.006042
K_2375 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.005988
K_2376 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.002694
K_2377 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.002674
K_2378 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.002664
K_2379 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.002690
K_2380 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.002436
K_2381 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.002455
K_2382 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.002430
K_2383 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.002449
K_2384 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.005421
K_2385 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.005342
K_2386 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.005332
K_2387 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.005285
K_2388 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.002072
K_2389 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.002070
K_2390 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.002056
K_2391 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.002076
K_2392 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.003123
K_2393 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.003163
K_2394 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.003123
K_2395 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.003126
K_2396 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.002874
K_2397 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.002844
K_2398 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.002837
K_2399 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.002851
K_2400 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.001982
K_2401 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.001990
K_2402 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.001973
K_2403 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.001988
K_2404 X_NUC_16.L_CORE X_NUC_65.L_CORE 0.003890
K_2405 X_NUC_16.L_CORE X_NUC_66.L_CORE 0.003903
K_2406 X_NUC_16.L_CORE X_NUC_67.L_CORE 0.003867
K_2407 X_NUC_16.L_CORE X_NUC_68.L_CORE 0.003836
K_2408 X_NUC_16.L_CORE X_NUC_69.L_CORE 0.002049
K_2409 X_NUC_16.L_CORE X_NUC_70.L_CORE 0.002041
K_2410 X_NUC_16.L_CORE X_NUC_71.L_CORE 0.002030
K_2411 X_NUC_16.L_CORE X_NUC_72.L_CORE 0.002046
K_2412 X_NUC_16.L_CORE X_NUC_73.L_CORE 0.002232
K_2413 X_NUC_16.L_CORE X_NUC_74.L_CORE 0.002249
K_2414 X_NUC_16.L_CORE X_NUC_75.L_CORE 0.002225
K_2415 X_NUC_16.L_CORE X_NUC_76.L_CORE 0.002235
K_2416 X_NUC_16.L_CORE X_NUC_77.L_CORE 0.002974
K_2417 X_NUC_16.L_CORE X_NUC_78.L_CORE 0.002950
K_2418 X_NUC_16.L_CORE X_NUC_79.L_CORE 0.002938
K_2419 X_NUC_16.L_CORE X_NUC_80.L_CORE 0.002936
K_2420 X_NUC_16.L_CORE X_NUC_81.L_CORE 0.001810
K_2421 X_NUC_16.L_CORE X_NUC_82.L_CORE 0.001811
K_2422 X_NUC_16.L_CORE X_NUC_83.L_CORE 0.001798
K_2423 X_NUC_16.L_CORE X_NUC_84.L_CORE 0.001811
K_2424 X_NUC_16.L_CORE X_NUC_85.L_CORE 0.002684
K_2425 X_NUC_16.L_CORE X_NUC_86.L_CORE 0.002702
K_2426 X_NUC_16.L_CORE X_NUC_87.L_CORE 0.002674
K_2427 X_NUC_16.L_CORE X_NUC_88.L_CORE 0.002670
K_2428 X_NUC_16.L_CORE X_NUC_89.L_CORE 0.002125
K_2429 X_NUC_16.L_CORE X_NUC_90.L_CORE 0.002114
K_2430 X_NUC_16.L_CORE X_NUC_91.L_CORE 0.002103
K_2431 X_NUC_16.L_CORE X_NUC_92.L_CORE 0.002114
K_2432 X_NUC_16.L_CORE X_NUC_93.L_CORE 0.001861
K_2433 X_NUC_16.L_CORE X_NUC_94.L_CORE 0.001869
K_2434 X_NUC_16.L_CORE X_NUC_95.L_CORE 0.001852
K_2435 X_NUC_16.L_CORE X_NUC_96.L_CORE 0.001862
K_2436 X_NUC_16.L_CORE X_NUC_97.L_CORE 0.002658
K_2437 X_NUC_16.L_CORE X_NUC_98.L_CORE 0.002654
K_2438 X_NUC_16.L_CORE X_NUC_99.L_CORE 0.002635
K_2439 X_NUC_16.L_CORE X_NUC_100.L_CORE 0.002630
K_2440 X_NUC_16.L_CORE X_NUC_101.L_CORE 0.001782
K_2441 X_NUC_16.L_CORE X_NUC_102.L_CORE 0.001780
K_2442 X_NUC_16.L_CORE X_NUC_103.L_CORE 0.001768
K_2443 X_NUC_16.L_CORE X_NUC_104.L_CORE 0.001779
K_2444 X_NUC_16.L_CORE X_NUC_105.L_CORE 0.002074
K_2445 X_NUC_16.L_CORE X_NUC_106.L_CORE 0.002084
K_2446 X_NUC_16.L_CORE X_NUC_107.L_CORE 0.002065
K_2447 X_NUC_16.L_CORE X_NUC_108.L_CORE 0.002069
K_2448 X_NUC_16.L_CORE X_NUC_109.L_CORE 0.002142
K_2449 X_NUC_16.L_CORE X_NUC_110.L_CORE 0.002134
K_2450 X_NUC_16.L_CORE X_NUC_111.L_CORE 0.002122
K_2451 X_NUC_16.L_CORE X_NUC_112.L_CORE 0.002126
K_2452 X_NUC_16.L_CORE X_NUC_113.L_CORE 0.001725
K_2453 X_NUC_16.L_CORE X_NUC_114.L_CORE 0.001728
K_2454 X_NUC_16.L_CORE X_NUC_115.L_CORE 0.001714
K_2455 X_NUC_16.L_CORE X_NUC_116.L_CORE 0.001723
K_2456 X_NUC_16.L_CORE X_NUC_117.L_CORE 0.002157
K_2457 X_NUC_16.L_CORE X_NUC_118.L_CORE 0.002161
K_2458 X_NUC_16.L_CORE X_NUC_119.L_CORE 0.002143
K_2459 X_NUC_16.L_CORE X_NUC_120.L_CORE 0.002144
K_2460 X_NUC_16.L_CORE X_NUC_121.L_CORE 0.001815
K_2461 X_NUC_16.L_CORE X_NUC_122.L_CORE 0.001812
K_2462 X_NUC_16.L_CORE X_NUC_123.L_CORE 0.001801
K_2463 X_NUC_16.L_CORE X_NUC_124.L_CORE 0.001808
K_2464 X_NUC_16.L_CORE X_NUC_125.L_CORE 0.001809
K_2465 X_NUC_16.L_CORE X_NUC_126.L_CORE 0.001813
K_2466 X_NUC_16.L_CORE X_NUC_127.L_CORE 0.001798
K_2467 X_NUC_16.L_CORE X_NUC_128.L_CORE 0.001804
K_2468 X_NUC_16.L_CORE X_NUC_129.L_CORE 0.001907
K_2469 X_NUC_16.L_CORE X_NUC_130.L_CORE 0.001906
K_2470 X_NUC_16.L_CORE X_NUC_131.L_CORE 0.001892
K_2471 X_NUC_16.L_CORE X_NUC_132.L_CORE 0.001896
K_2472 X_NUC_16.L_CORE X_NUC_133.L_CORE 0.005870
K_2473 X_NUC_16.L_CORE X_NUC_134.L_CORE 0.004416
K_2474 X_NUC_16.L_CORE X_NUC_135.L_CORE 0.003013
K_2475 X_NUC_16.L_CORE X_NUC_136.L_CORE 0.032666
K_2476 X_NUC_16.L_CORE X_NUC_137.L_CORE 0.002655
K_2477 X_NUC_16.L_CORE X_NUC_138.L_CORE 0.003463
K_2478 X_NUC_16.L_CORE X_NUC_139.L_CORE 0.004803
K_2479 X_NUC_16.L_CORE X_NUC_140.L_CORE 0.002203
K_2480 X_NUC_16.L_CORE X_NUC_141.L_CORE 0.005668
K_2481 X_NUC_16.L_CORE X_NUC_142.L_CORE 0.002542
K_2482 X_NUC_16.L_CORE X_NUC_143.L_CORE 0.002318
K_2483 X_NUC_16.L_CORE X_NUC_144.L_CORE 0.005025
K_2484 X_NUC_16.L_CORE X_NUC_145.L_CORE 0.001964
K_2485 X_NUC_16.L_CORE X_NUC_146.L_CORE 0.002969
K_2486 X_NUC_16.L_CORE X_NUC_147.L_CORE 0.002704
K_2487 X_NUC_16.L_CORE X_NUC_148.L_CORE 0.001884
K_2488 X_NUC_16.L_CORE X_NUC_149.L_CORE 0.003663
K_2489 X_NUC_16.L_CORE X_NUC_150.L_CORE 0.001939
K_2490 X_NUC_16.L_CORE X_NUC_151.L_CORE 0.002122
K_2491 X_NUC_16.L_CORE X_NUC_152.L_CORE 0.002796
K_2492 X_NUC_16.L_CORE X_NUC_153.L_CORE 0.001717
K_2493 X_NUC_16.L_CORE X_NUC_154.L_CORE 0.002544
K_2494 X_NUC_16.L_CORE X_NUC_155.L_CORE 0.002007
K_2495 X_NUC_16.L_CORE X_NUC_156.L_CORE 0.001768
K_2496 X_NUC_16.L_CORE X_NUC_157.L_CORE 0.002508
K_2497 X_NUC_16.L_CORE X_NUC_158.L_CORE 0.001689
K_2498 X_NUC_16.L_CORE X_NUC_159.L_CORE 0.001969
K_2499 X_NUC_16.L_CORE X_NUC_160.L_CORE 0.002024
K_2500 X_NUC_16.L_CORE X_NUC_161.L_CORE 0.001637
K_2501 X_NUC_16.L_CORE X_NUC_162.L_CORE 0.002043
K_2502 X_NUC_16.L_CORE X_NUC_163.L_CORE 0.001719
K_2503 X_NUC_16.L_CORE X_NUC_164.L_CORE 0.001715
K_2504 X_NUC_16.L_CORE X_NUC_165.L_CORE 0.001805
K_2505 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_2506 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_2507 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_2508 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.002564
K_2509 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.002590
K_2510 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.002585
K_2511 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.002567
K_2512 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.003386
K_2513 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.003370
K_2514 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.003399
K_2515 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.003348
K_2516 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.004812
K_2517 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.004915
K_2518 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.004823
K_2519 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.004860
K_2520 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.002176
K_2521 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.002187
K_2522 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.002189
K_2523 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.002169
K_2524 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.005925
K_2525 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.005798
K_2526 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.005830
K_2527 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.005771
K_2528 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.002551
K_2529 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.002581
K_2530 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.002562
K_2531 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.002556
K_2532 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.002329
K_2533 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.002328
K_2534 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.002336
K_2535 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.002311
K_2536 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.005440
K_2537 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.005470
K_2538 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.005337
K_2539 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.005419
K_2540 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.001983
K_2541 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.001996
K_2542 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.001991
K_2543 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.001979
K_2544 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.003068
K_2545 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.003044
K_2546 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.003053
K_2547 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.003025
K_2548 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.002795
K_2549 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.002826
K_2550 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.002792
K_2551 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.002799
K_2552 X_NUC_17.L_CORE X_NUC_65.L_CORE 0.001918
K_2553 X_NUC_17.L_CORE X_NUC_66.L_CORE 0.001923
K_2554 X_NUC_17.L_CORE X_NUC_67.L_CORE 0.001923
K_2555 X_NUC_17.L_CORE X_NUC_68.L_CORE 0.001908
K_2556 X_NUC_17.L_CORE X_NUC_69.L_CORE 0.003955
K_2557 X_NUC_17.L_CORE X_NUC_70.L_CORE 0.003925
K_2558 X_NUC_17.L_CORE X_NUC_71.L_CORE 0.003888
K_2559 X_NUC_17.L_CORE X_NUC_72.L_CORE 0.003897
K_2560 X_NUC_17.L_CORE X_NUC_73.L_CORE 0.001991
K_2561 X_NUC_17.L_CORE X_NUC_74.L_CORE 0.002006
K_2562 X_NUC_17.L_CORE X_NUC_75.L_CORE 0.001995
K_2563 X_NUC_17.L_CORE X_NUC_76.L_CORE 0.001989
K_2564 X_NUC_17.L_CORE X_NUC_77.L_CORE 0.002194
K_2565 X_NUC_17.L_CORE X_NUC_78.L_CORE 0.002188
K_2566 X_NUC_17.L_CORE X_NUC_79.L_CORE 0.002190
K_2567 X_NUC_17.L_CORE X_NUC_80.L_CORE 0.002173
K_2568 X_NUC_17.L_CORE X_NUC_81.L_CORE 0.002965
K_2569 X_NUC_17.L_CORE X_NUC_82.L_CORE 0.002982
K_2570 X_NUC_17.L_CORE X_NUC_83.L_CORE 0.002941
K_2571 X_NUC_17.L_CORE X_NUC_84.L_CORE 0.002956
K_2572 X_NUC_17.L_CORE X_NUC_85.L_CORE 0.001769
K_2573 X_NUC_17.L_CORE X_NUC_86.L_CORE 0.001777
K_2574 X_NUC_17.L_CORE X_NUC_87.L_CORE 0.001772
K_2575 X_NUC_17.L_CORE X_NUC_88.L_CORE 0.001762
K_2576 X_NUC_17.L_CORE X_NUC_89.L_CORE 0.002689
K_2577 X_NUC_17.L_CORE X_NUC_90.L_CORE 0.002674
K_2578 X_NUC_17.L_CORE X_NUC_91.L_CORE 0.002666
K_2579 X_NUC_17.L_CORE X_NUC_92.L_CORE 0.002656
K_2580 X_NUC_17.L_CORE X_NUC_93.L_CORE 0.002094
K_2581 X_NUC_17.L_CORE X_NUC_94.L_CORE 0.002109
K_2582 X_NUC_17.L_CORE X_NUC_95.L_CORE 0.002092
K_2583 X_NUC_17.L_CORE X_NUC_96.L_CORE 0.002091
K_2584 X_NUC_17.L_CORE X_NUC_97.L_CORE 0.001837
K_2585 X_NUC_17.L_CORE X_NUC_98.L_CORE 0.001839
K_2586 X_NUC_17.L_CORE X_NUC_99.L_CORE 0.001837
K_2587 X_NUC_17.L_CORE X_NUC_100.L_CORE 0.001825
K_2588 X_NUC_17.L_CORE X_NUC_101.L_CORE 0.002664
K_2589 X_NUC_17.L_CORE X_NUC_102.L_CORE 0.002664
K_2590 X_NUC_17.L_CORE X_NUC_103.L_CORE 0.002638
K_2591 X_NUC_17.L_CORE X_NUC_104.L_CORE 0.002642
K_2592 X_NUC_17.L_CORE X_NUC_105.L_CORE 0.001762
K_2593 X_NUC_17.L_CORE X_NUC_106.L_CORE 0.001771
K_2594 X_NUC_17.L_CORE X_NUC_107.L_CORE 0.001762
K_2595 X_NUC_17.L_CORE X_NUC_108.L_CORE 0.001756
K_2596 X_NUC_17.L_CORE X_NUC_109.L_CORE 0.002067
K_2597 X_NUC_17.L_CORE X_NUC_110.L_CORE 0.002063
K_2598 X_NUC_17.L_CORE X_NUC_111.L_CORE 0.002058
K_2599 X_NUC_17.L_CORE X_NUC_112.L_CORE 0.002048
K_2600 X_NUC_17.L_CORE X_NUC_113.L_CORE 0.002128
K_2601 X_NUC_17.L_CORE X_NUC_114.L_CORE 0.002138
K_2602 X_NUC_17.L_CORE X_NUC_115.L_CORE 0.002119
K_2603 X_NUC_17.L_CORE X_NUC_116.L_CORE 0.002119
K_2604 X_NUC_17.L_CORE X_NUC_117.L_CORE 0.001723
K_2605 X_NUC_17.L_CORE X_NUC_118.L_CORE 0.001727
K_2606 X_NUC_17.L_CORE X_NUC_119.L_CORE 0.001721
K_2607 X_NUC_17.L_CORE X_NUC_120.L_CORE 0.001713
K_2608 X_NUC_17.L_CORE X_NUC_121.L_CORE 0.002134
K_2609 X_NUC_17.L_CORE X_NUC_122.L_CORE 0.002133
K_2610 X_NUC_17.L_CORE X_NUC_123.L_CORE 0.002121
K_2611 X_NUC_17.L_CORE X_NUC_124.L_CORE 0.002117
K_2612 X_NUC_17.L_CORE X_NUC_125.L_CORE 0.001820
K_2613 X_NUC_17.L_CORE X_NUC_126.L_CORE 0.001826
K_2614 X_NUC_17.L_CORE X_NUC_127.L_CORE 0.001815
K_2615 X_NUC_17.L_CORE X_NUC_128.L_CORE 0.001811
K_2616 X_NUC_17.L_CORE X_NUC_129.L_CORE 0.001824
K_2617 X_NUC_17.L_CORE X_NUC_130.L_CORE 0.001827
K_2618 X_NUC_17.L_CORE X_NUC_131.L_CORE 0.001819
K_2619 X_NUC_17.L_CORE X_NUC_132.L_CORE 0.001812
K_2620 X_NUC_17.L_CORE X_NUC_133.L_CORE 0.003402
K_2621 X_NUC_17.L_CORE X_NUC_134.L_CORE 0.005606
K_2622 X_NUC_17.L_CORE X_NUC_135.L_CORE 0.003901
K_2623 X_NUC_17.L_CORE X_NUC_136.L_CORE 0.002677
K_2624 X_NUC_17.L_CORE X_NUC_137.L_CORE 0.032840
K_2625 X_NUC_17.L_CORE X_NUC_138.L_CORE 0.002444
K_2626 X_NUC_17.L_CORE X_NUC_139.L_CORE 0.003197
K_2627 X_NUC_17.L_CORE X_NUC_140.L_CORE 0.004572
K_2628 X_NUC_17.L_CORE X_NUC_141.L_CORE 0.002070
K_2629 X_NUC_17.L_CORE X_NUC_142.L_CORE 0.005471
K_2630 X_NUC_17.L_CORE X_NUC_143.L_CORE 0.002431
K_2631 X_NUC_17.L_CORE X_NUC_144.L_CORE 0.002208
K_2632 X_NUC_17.L_CORE X_NUC_145.L_CORE 0.005092
K_2633 X_NUC_17.L_CORE X_NUC_146.L_CORE 0.001888
K_2634 X_NUC_17.L_CORE X_NUC_147.L_CORE 0.002888
K_2635 X_NUC_17.L_CORE X_NUC_148.L_CORE 0.002658
K_2636 X_NUC_17.L_CORE X_NUC_149.L_CORE 0.001822
K_2637 X_NUC_17.L_CORE X_NUC_150.L_CORE 0.003702
K_2638 X_NUC_17.L_CORE X_NUC_151.L_CORE 0.001895
K_2639 X_NUC_17.L_CORE X_NUC_152.L_CORE 0.002076
K_2640 X_NUC_17.L_CORE X_NUC_153.L_CORE 0.002807
K_2641 X_NUC_17.L_CORE X_NUC_154.L_CORE 0.001682
K_2642 X_NUC_17.L_CORE X_NUC_155.L_CORE 0.002534
K_2643 X_NUC_17.L_CORE X_NUC_156.L_CORE 0.001991
K_2644 X_NUC_17.L_CORE X_NUC_157.L_CORE 0.001743
K_2645 X_NUC_17.L_CORE X_NUC_158.L_CORE 0.002516
K_2646 X_NUC_17.L_CORE X_NUC_159.L_CORE 0.001675
K_2647 X_NUC_17.L_CORE X_NUC_160.L_CORE 0.001956
K_2648 X_NUC_17.L_CORE X_NUC_161.L_CORE 0.002019
K_2649 X_NUC_17.L_CORE X_NUC_162.L_CORE 0.001636
K_2650 X_NUC_17.L_CORE X_NUC_163.L_CORE 0.002019
K_2651 X_NUC_17.L_CORE X_NUC_164.L_CORE 0.001727
K_2652 X_NUC_17.L_CORE X_NUC_165.L_CORE 0.001730
K_2653 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_2654 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_2655 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.002537
K_2656 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.002564
K_2657 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.002558
K_2658 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.002541
K_2659 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.003402
K_2660 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.003386
K_2661 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.003416
K_2662 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.003363
K_2663 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.004713
K_2664 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.004812
K_2665 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.004724
K_2666 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.004759
K_2667 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.002165
K_2668 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.002176
K_2669 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.002178
K_2670 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.002158
K_2671 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.006057
K_2672 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.005925
K_2673 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.005957
K_2674 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.005894
K_2675 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.002521
K_2676 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.002551
K_2677 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.002533
K_2678 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.002527
K_2679 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.002330
K_2680 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.002329
K_2681 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.002337
K_2682 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.002312
K_2683 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.005406
K_2684 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.005440
K_2685 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.005307
K_2686 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.005387
K_2687 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.001970
K_2688 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.001983
K_2689 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.001978
K_2690 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.001966
K_2691 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.003092
K_2692 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.003068
K_2693 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.003077
K_2694 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.003048
K_2695 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.002764
K_2696 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.002795
K_2697 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.002762
K_2698 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.002769
K_2699 X_NUC_18.L_CORE X_NUC_65.L_CORE 0.001913
K_2700 X_NUC_18.L_CORE X_NUC_66.L_CORE 0.001918
K_2701 X_NUC_18.L_CORE X_NUC_67.L_CORE 0.001918
K_2702 X_NUC_18.L_CORE X_NUC_68.L_CORE 0.001903
K_2703 X_NUC_18.L_CORE X_NUC_69.L_CORE 0.003984
K_2704 X_NUC_18.L_CORE X_NUC_70.L_CORE 0.003955
K_2705 X_NUC_18.L_CORE X_NUC_71.L_CORE 0.003916
K_2706 X_NUC_18.L_CORE X_NUC_72.L_CORE 0.003926
K_2707 X_NUC_18.L_CORE X_NUC_73.L_CORE 0.001975
K_2708 X_NUC_18.L_CORE X_NUC_74.L_CORE 0.001991
K_2709 X_NUC_18.L_CORE X_NUC_75.L_CORE 0.001980
K_2710 X_NUC_18.L_CORE X_NUC_76.L_CORE 0.001973
K_2711 X_NUC_18.L_CORE X_NUC_77.L_CORE 0.002198
K_2712 X_NUC_18.L_CORE X_NUC_78.L_CORE 0.002194
K_2713 X_NUC_18.L_CORE X_NUC_79.L_CORE 0.002195
K_2714 X_NUC_18.L_CORE X_NUC_80.L_CORE 0.002177
K_2715 X_NUC_18.L_CORE X_NUC_81.L_CORE 0.002947
K_2716 X_NUC_18.L_CORE X_NUC_82.L_CORE 0.002965
K_2717 X_NUC_18.L_CORE X_NUC_83.L_CORE 0.002924
K_2718 X_NUC_18.L_CORE X_NUC_84.L_CORE 0.002939
K_2719 X_NUC_18.L_CORE X_NUC_85.L_CORE 0.001762
K_2720 X_NUC_18.L_CORE X_NUC_86.L_CORE 0.001769
K_2721 X_NUC_18.L_CORE X_NUC_87.L_CORE 0.001765
K_2722 X_NUC_18.L_CORE X_NUC_88.L_CORE 0.001755
K_2723 X_NUC_18.L_CORE X_NUC_89.L_CORE 0.002703
K_2724 X_NUC_18.L_CORE X_NUC_90.L_CORE 0.002689
K_2725 X_NUC_18.L_CORE X_NUC_91.L_CORE 0.002680
K_2726 X_NUC_18.L_CORE X_NUC_92.L_CORE 0.002669
K_2727 X_NUC_18.L_CORE X_NUC_93.L_CORE 0.002079
K_2728 X_NUC_18.L_CORE X_NUC_94.L_CORE 0.002094
K_2729 X_NUC_18.L_CORE X_NUC_95.L_CORE 0.002077
K_2730 X_NUC_18.L_CORE X_NUC_96.L_CORE 0.002076
K_2731 X_NUC_18.L_CORE X_NUC_97.L_CORE 0.001836
K_2732 X_NUC_18.L_CORE X_NUC_98.L_CORE 0.001837
K_2733 X_NUC_18.L_CORE X_NUC_99.L_CORE 0.001835
K_2734 X_NUC_18.L_CORE X_NUC_100.L_CORE 0.001823
K_2735 X_NUC_18.L_CORE X_NUC_101.L_CORE 0.002663
K_2736 X_NUC_18.L_CORE X_NUC_102.L_CORE 0.002664
K_2737 X_NUC_18.L_CORE X_NUC_103.L_CORE 0.002638
K_2738 X_NUC_18.L_CORE X_NUC_104.L_CORE 0.002642
K_2739 X_NUC_18.L_CORE X_NUC_105.L_CORE 0.001753
K_2740 X_NUC_18.L_CORE X_NUC_106.L_CORE 0.001762
K_2741 X_NUC_18.L_CORE X_NUC_107.L_CORE 0.001754
K_2742 X_NUC_18.L_CORE X_NUC_108.L_CORE 0.001747
K_2743 X_NUC_18.L_CORE X_NUC_109.L_CORE 0.002071
K_2744 X_NUC_18.L_CORE X_NUC_110.L_CORE 0.002067
K_2745 X_NUC_18.L_CORE X_NUC_111.L_CORE 0.002062
K_2746 X_NUC_18.L_CORE X_NUC_112.L_CORE 0.002052
K_2747 X_NUC_18.L_CORE X_NUC_113.L_CORE 0.002119
K_2748 X_NUC_18.L_CORE X_NUC_114.L_CORE 0.002128
K_2749 X_NUC_18.L_CORE X_NUC_115.L_CORE 0.002110
K_2750 X_NUC_18.L_CORE X_NUC_116.L_CORE 0.002110
K_2751 X_NUC_18.L_CORE X_NUC_117.L_CORE 0.001719
K_2752 X_NUC_18.L_CORE X_NUC_118.L_CORE 0.001723
K_2753 X_NUC_18.L_CORE X_NUC_119.L_CORE 0.001717
K_2754 X_NUC_18.L_CORE X_NUC_120.L_CORE 0.001709
K_2755 X_NUC_18.L_CORE X_NUC_121.L_CORE 0.002135
K_2756 X_NUC_18.L_CORE X_NUC_122.L_CORE 0.002134
K_2757 X_NUC_18.L_CORE X_NUC_123.L_CORE 0.002122
K_2758 X_NUC_18.L_CORE X_NUC_124.L_CORE 0.002118
K_2759 X_NUC_18.L_CORE X_NUC_125.L_CORE 0.001813
K_2760 X_NUC_18.L_CORE X_NUC_126.L_CORE 0.001820
K_2761 X_NUC_18.L_CORE X_NUC_127.L_CORE 0.001808
K_2762 X_NUC_18.L_CORE X_NUC_128.L_CORE 0.001804
K_2763 X_NUC_18.L_CORE X_NUC_129.L_CORE 0.001822
K_2764 X_NUC_18.L_CORE X_NUC_130.L_CORE 0.001824
K_2765 X_NUC_18.L_CORE X_NUC_131.L_CORE 0.001816
K_2766 X_NUC_18.L_CORE X_NUC_132.L_CORE 0.001810
K_2767 X_NUC_18.L_CORE X_NUC_133.L_CORE 0.003370
K_2768 X_NUC_18.L_CORE X_NUC_134.L_CORE 0.005622
K_2769 X_NUC_18.L_CORE X_NUC_135.L_CORE 0.003833
K_2770 X_NUC_18.L_CORE X_NUC_136.L_CORE 0.002669
K_2771 X_NUC_18.L_CORE X_NUC_137.L_CORE 0.035104
K_2772 X_NUC_18.L_CORE X_NUC_138.L_CORE 0.002420
K_2773 X_NUC_18.L_CORE X_NUC_139.L_CORE 0.003214
K_2774 X_NUC_18.L_CORE X_NUC_140.L_CORE 0.004484
K_2775 X_NUC_18.L_CORE X_NUC_141.L_CORE 0.002060
K_2776 X_NUC_18.L_CORE X_NUC_142.L_CORE 0.005597
K_2777 X_NUC_18.L_CORE X_NUC_143.L_CORE 0.002404
K_2778 X_NUC_18.L_CORE X_NUC_144.L_CORE 0.002209
K_2779 X_NUC_18.L_CORE X_NUC_145.L_CORE 0.005070
K_2780 X_NUC_18.L_CORE X_NUC_146.L_CORE 0.001876
K_2781 X_NUC_18.L_CORE X_NUC_147.L_CORE 0.002912
K_2782 X_NUC_18.L_CORE X_NUC_148.L_CORE 0.002630
K_2783 X_NUC_18.L_CORE X_NUC_149.L_CORE 0.001818
K_2784 X_NUC_18.L_CORE X_NUC_150.L_CORE 0.003733
K_2785 X_NUC_18.L_CORE X_NUC_151.L_CORE 0.001881
K_2786 X_NUC_18.L_CORE X_NUC_152.L_CORE 0.002081
K_2787 X_NUC_18.L_CORE X_NUC_153.L_CORE 0.002792
K_2788 X_NUC_18.L_CORE X_NUC_154.L_CORE 0.001675
K_2789 X_NUC_18.L_CORE X_NUC_155.L_CORE 0.002548
K_2790 X_NUC_18.L_CORE X_NUC_156.L_CORE 0.001977
K_2791 X_NUC_18.L_CORE X_NUC_157.L_CORE 0.001742
K_2792 X_NUC_18.L_CORE X_NUC_158.L_CORE 0.002516
K_2793 X_NUC_18.L_CORE X_NUC_159.L_CORE 0.001667
K_2794 X_NUC_18.L_CORE X_NUC_160.L_CORE 0.001960
K_2795 X_NUC_18.L_CORE X_NUC_161.L_CORE 0.002011
K_2796 X_NUC_18.L_CORE X_NUC_162.L_CORE 0.001632
K_2797 X_NUC_18.L_CORE X_NUC_163.L_CORE 0.002021
K_2798 X_NUC_18.L_CORE X_NUC_164.L_CORE 0.001721
K_2799 X_NUC_18.L_CORE X_NUC_165.L_CORE 0.001728
K_2800 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_2801 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.002543
K_2802 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.002569
K_2803 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.002564
K_2804 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.002547
K_2805 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.003372
K_2806 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.003357
K_2807 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.003386
K_2808 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.003335
K_2809 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.004799
K_2810 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.004902
K_2811 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.004812
K_2812 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.004848
K_2813 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.002163
K_2814 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.002174
K_2815 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.002176
K_2816 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.002157
K_2817 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.006021
K_2818 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.005890
K_2819 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.005925
K_2820 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.005861
K_2821 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.002539
K_2822 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.002569
K_2823 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.002551
K_2824 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.002545
K_2825 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.002322
K_2826 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.002322
K_2827 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.002329
K_2828 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.002305
K_2829 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.005544
K_2830 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.005579
K_2831 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.005440
K_2832 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.005524
K_2833 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.001974
K_2834 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.001988
K_2835 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.001983
K_2836 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.001971
K_2837 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.003082
K_2838 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.003058
K_2839 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.003068
K_2840 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.003038
K_2841 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.002797
K_2842 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.002828
K_2843 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.002795
K_2844 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.002802
K_2845 X_NUC_19.L_CORE X_NUC_65.L_CORE 0.001913
K_2846 X_NUC_19.L_CORE X_NUC_66.L_CORE 0.001918
K_2847 X_NUC_19.L_CORE X_NUC_67.L_CORE 0.001918
K_2848 X_NUC_19.L_CORE X_NUC_68.L_CORE 0.001903
K_2849 X_NUC_19.L_CORE X_NUC_69.L_CORE 0.004024
K_2850 X_NUC_19.L_CORE X_NUC_70.L_CORE 0.003993
K_2851 X_NUC_19.L_CORE X_NUC_71.L_CORE 0.003955
K_2852 X_NUC_19.L_CORE X_NUC_72.L_CORE 0.003964
K_2853 X_NUC_19.L_CORE X_NUC_73.L_CORE 0.001986
K_2854 X_NUC_19.L_CORE X_NUC_74.L_CORE 0.002002
K_2855 X_NUC_19.L_CORE X_NUC_75.L_CORE 0.001991
K_2856 X_NUC_19.L_CORE X_NUC_76.L_CORE 0.001984
K_2857 X_NUC_19.L_CORE X_NUC_77.L_CORE 0.002196
K_2858 X_NUC_19.L_CORE X_NUC_78.L_CORE 0.002191
K_2859 X_NUC_19.L_CORE X_NUC_79.L_CORE 0.002194
K_2860 X_NUC_19.L_CORE X_NUC_80.L_CORE 0.002175
K_2861 X_NUC_19.L_CORE X_NUC_81.L_CORE 0.002989
K_2862 X_NUC_19.L_CORE X_NUC_82.L_CORE 0.003007
K_2863 X_NUC_19.L_CORE X_NUC_83.L_CORE 0.002965
K_2864 X_NUC_19.L_CORE X_NUC_84.L_CORE 0.002980
K_2865 X_NUC_19.L_CORE X_NUC_85.L_CORE 0.001766
K_2866 X_NUC_19.L_CORE X_NUC_86.L_CORE 0.001773
K_2867 X_NUC_19.L_CORE X_NUC_87.L_CORE 0.001769
K_2868 X_NUC_19.L_CORE X_NUC_88.L_CORE 0.001759
K_2869 X_NUC_19.L_CORE X_NUC_89.L_CORE 0.002712
K_2870 X_NUC_19.L_CORE X_NUC_90.L_CORE 0.002697
K_2871 X_NUC_19.L_CORE X_NUC_91.L_CORE 0.002689
K_2872 X_NUC_19.L_CORE X_NUC_92.L_CORE 0.002678
K_2873 X_NUC_19.L_CORE X_NUC_93.L_CORE 0.002097
K_2874 X_NUC_19.L_CORE X_NUC_94.L_CORE 0.002112
K_2875 X_NUC_19.L_CORE X_NUC_95.L_CORE 0.002094
K_2876 X_NUC_19.L_CORE X_NUC_96.L_CORE 0.002093
K_2877 X_NUC_19.L_CORE X_NUC_97.L_CORE 0.001838
K_2878 X_NUC_19.L_CORE X_NUC_98.L_CORE 0.001839
K_2879 X_NUC_19.L_CORE X_NUC_99.L_CORE 0.001837
K_2880 X_NUC_19.L_CORE X_NUC_100.L_CORE 0.001825
K_2881 X_NUC_19.L_CORE X_NUC_101.L_CORE 0.002690
K_2882 X_NUC_19.L_CORE X_NUC_102.L_CORE 0.002690
K_2883 X_NUC_19.L_CORE X_NUC_103.L_CORE 0.002664
K_2884 X_NUC_19.L_CORE X_NUC_104.L_CORE 0.002668
K_2885 X_NUC_19.L_CORE X_NUC_105.L_CORE 0.001762
K_2886 X_NUC_19.L_CORE X_NUC_106.L_CORE 0.001771
K_2887 X_NUC_19.L_CORE X_NUC_107.L_CORE 0.001762
K_2888 X_NUC_19.L_CORE X_NUC_108.L_CORE 0.001756
K_2889 X_NUC_19.L_CORE X_NUC_109.L_CORE 0.002076
K_2890 X_NUC_19.L_CORE X_NUC_110.L_CORE 0.002072
K_2891 X_NUC_19.L_CORE X_NUC_111.L_CORE 0.002067
K_2892 X_NUC_19.L_CORE X_NUC_112.L_CORE 0.002057
K_2893 X_NUC_19.L_CORE X_NUC_113.L_CORE 0.002138
K_2894 X_NUC_19.L_CORE X_NUC_114.L_CORE 0.002147
K_2895 X_NUC_19.L_CORE X_NUC_115.L_CORE 0.002128
K_2896 X_NUC_19.L_CORE X_NUC_116.L_CORE 0.002129
K_2897 X_NUC_19.L_CORE X_NUC_117.L_CORE 0.001724
K_2898 X_NUC_19.L_CORE X_NUC_118.L_CORE 0.001729
K_2899 X_NUC_19.L_CORE X_NUC_119.L_CORE 0.001723
K_2900 X_NUC_19.L_CORE X_NUC_120.L_CORE 0.001715
K_2901 X_NUC_19.L_CORE X_NUC_121.L_CORE 0.002148
K_2902 X_NUC_19.L_CORE X_NUC_122.L_CORE 0.002147
K_2903 X_NUC_19.L_CORE X_NUC_123.L_CORE 0.002134
K_2904 X_NUC_19.L_CORE X_NUC_124.L_CORE 0.002130
K_2905 X_NUC_19.L_CORE X_NUC_125.L_CORE 0.001824
K_2906 X_NUC_19.L_CORE X_NUC_126.L_CORE 0.001831
K_2907 X_NUC_19.L_CORE X_NUC_127.L_CORE 0.001820
K_2908 X_NUC_19.L_CORE X_NUC_128.L_CORE 0.001815
K_2909 X_NUC_19.L_CORE X_NUC_129.L_CORE 0.001830
K_2910 X_NUC_19.L_CORE X_NUC_130.L_CORE 0.001833
K_2911 X_NUC_19.L_CORE X_NUC_131.L_CORE 0.001824
K_2912 X_NUC_19.L_CORE X_NUC_132.L_CORE 0.001818
K_2913 X_NUC_19.L_CORE X_NUC_133.L_CORE 0.003353
K_2914 X_NUC_19.L_CORE X_NUC_134.L_CORE 0.005502
K_2915 X_NUC_19.L_CORE X_NUC_135.L_CORE 0.003847
K_2916 X_NUC_19.L_CORE X_NUC_136.L_CORE 0.002654
K_2917 X_NUC_19.L_CORE X_NUC_137.L_CORE 0.032652
K_2918 X_NUC_19.L_CORE X_NUC_138.L_CORE 0.002425
K_2919 X_NUC_19.L_CORE X_NUC_139.L_CORE 0.003184
K_2920 X_NUC_19.L_CORE X_NUC_140.L_CORE 0.004560
K_2921 X_NUC_19.L_CORE X_NUC_141.L_CORE 0.002058
K_2922 X_NUC_19.L_CORE X_NUC_142.L_CORE 0.005555
K_2923 X_NUC_19.L_CORE X_NUC_143.L_CORE 0.002420
K_2924 X_NUC_19.L_CORE X_NUC_144.L_CORE 0.002202
K_2925 X_NUC_19.L_CORE X_NUC_145.L_CORE 0.005187
K_2926 X_NUC_19.L_CORE X_NUC_146.L_CORE 0.001880
K_2927 X_NUC_19.L_CORE X_NUC_147.L_CORE 0.002902
K_2928 X_NUC_19.L_CORE X_NUC_148.L_CORE 0.002660
K_2929 X_NUC_19.L_CORE X_NUC_149.L_CORE 0.001817
K_2930 X_NUC_19.L_CORE X_NUC_150.L_CORE 0.003765
K_2931 X_NUC_19.L_CORE X_NUC_151.L_CORE 0.001891
K_2932 X_NUC_19.L_CORE X_NUC_152.L_CORE 0.002079
K_2933 X_NUC_19.L_CORE X_NUC_153.L_CORE 0.002829
K_2934 X_NUC_19.L_CORE X_NUC_154.L_CORE 0.001679
K_2935 X_NUC_19.L_CORE X_NUC_155.L_CORE 0.002555
K_2936 X_NUC_19.L_CORE X_NUC_156.L_CORE 0.001993
K_2937 X_NUC_19.L_CORE X_NUC_157.L_CORE 0.001743
K_2938 X_NUC_19.L_CORE X_NUC_158.L_CORE 0.002540
K_2939 X_NUC_19.L_CORE X_NUC_159.L_CORE 0.001675
K_2940 X_NUC_19.L_CORE X_NUC_160.L_CORE 0.001964
K_2941 X_NUC_19.L_CORE X_NUC_161.L_CORE 0.002028
K_2942 X_NUC_19.L_CORE X_NUC_162.L_CORE 0.001637
K_2943 X_NUC_19.L_CORE X_NUC_163.L_CORE 0.002032
K_2944 X_NUC_19.L_CORE X_NUC_164.L_CORE 0.001731
K_2945 X_NUC_19.L_CORE X_NUC_165.L_CORE 0.001735
K_2946 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.002560
K_2947 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.002587
K_2948 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.002581
K_2949 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.002564
K_2950 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.003425
K_2951 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.003409
K_2952 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.003439
K_2953 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.003386
K_2954 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.004763
K_2955 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.004864
K_2956 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.004774
K_2957 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.004812
K_2958 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.002183
K_2959 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.002194
K_2960 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.002196
K_2961 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.002176
K_2962 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.006088
K_2963 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.005952
K_2964 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.005987
K_2965 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.005925
K_2966 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.002545
K_2967 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.002574
K_2968 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.002556
K_2969 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.002551
K_2970 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.002348
K_2971 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.002347
K_2972 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.002354
K_2973 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.002329
K_2974 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.005457
K_2975 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.005490
K_2976 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.005355
K_2977 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.005440
K_2978 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.001986
K_2979 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.002000
K_2980 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.001995
K_2981 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.001983
K_2982 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.003113
K_2983 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.003088
K_2984 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.003098
K_2985 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.003068
K_2986 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.002790
K_2987 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.002821
K_2988 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.002788
K_2989 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.002795
K_2990 X_NUC_20.L_CORE X_NUC_65.L_CORE 0.001929
K_2991 X_NUC_20.L_CORE X_NUC_66.L_CORE 0.001934
K_2992 X_NUC_20.L_CORE X_NUC_67.L_CORE 0.001934
K_2993 X_NUC_20.L_CORE X_NUC_68.L_CORE 0.001918
K_2994 X_NUC_20.L_CORE X_NUC_69.L_CORE 0.004014
K_2995 X_NUC_20.L_CORE X_NUC_70.L_CORE 0.003983
K_2996 X_NUC_20.L_CORE X_NUC_71.L_CORE 0.003944
K_2997 X_NUC_20.L_CORE X_NUC_72.L_CORE 0.003955
K_2998 X_NUC_20.L_CORE X_NUC_73.L_CORE 0.001993
K_2999 X_NUC_20.L_CORE X_NUC_74.L_CORE 0.002008
K_3000 X_NUC_20.L_CORE X_NUC_75.L_CORE 0.001997
K_3001 X_NUC_20.L_CORE X_NUC_76.L_CORE 0.001991
K_3002 X_NUC_20.L_CORE X_NUC_77.L_CORE 0.002215
K_3003 X_NUC_20.L_CORE X_NUC_78.L_CORE 0.002210
K_3004 X_NUC_20.L_CORE X_NUC_79.L_CORE 0.002212
K_3005 X_NUC_20.L_CORE X_NUC_80.L_CORE 0.002194
K_3006 X_NUC_20.L_CORE X_NUC_81.L_CORE 0.002974
K_3007 X_NUC_20.L_CORE X_NUC_82.L_CORE 0.002992
K_3008 X_NUC_20.L_CORE X_NUC_83.L_CORE 0.002950
K_3009 X_NUC_20.L_CORE X_NUC_84.L_CORE 0.002965
K_3010 X_NUC_20.L_CORE X_NUC_85.L_CORE 0.001776
K_3011 X_NUC_20.L_CORE X_NUC_86.L_CORE 0.001784
K_3012 X_NUC_20.L_CORE X_NUC_87.L_CORE 0.001779
K_3013 X_NUC_20.L_CORE X_NUC_88.L_CORE 0.001769
K_3014 X_NUC_20.L_CORE X_NUC_89.L_CORE 0.002723
K_3015 X_NUC_20.L_CORE X_NUC_90.L_CORE 0.002708
K_3016 X_NUC_20.L_CORE X_NUC_91.L_CORE 0.002699
K_3017 X_NUC_20.L_CORE X_NUC_92.L_CORE 0.002689
K_3018 X_NUC_20.L_CORE X_NUC_93.L_CORE 0.002098
K_3019 X_NUC_20.L_CORE X_NUC_94.L_CORE 0.002113
K_3020 X_NUC_20.L_CORE X_NUC_95.L_CORE 0.002095
K_3021 X_NUC_20.L_CORE X_NUC_96.L_CORE 0.002094
K_3022 X_NUC_20.L_CORE X_NUC_97.L_CORE 0.001850
K_3023 X_NUC_20.L_CORE X_NUC_98.L_CORE 0.001852
K_3024 X_NUC_20.L_CORE X_NUC_99.L_CORE 0.001850
K_3025 X_NUC_20.L_CORE X_NUC_100.L_CORE 0.001837
K_3026 X_NUC_20.L_CORE X_NUC_101.L_CORE 0.002685
K_3027 X_NUC_20.L_CORE X_NUC_102.L_CORE 0.002685
K_3028 X_NUC_20.L_CORE X_NUC_103.L_CORE 0.002659
K_3029 X_NUC_20.L_CORE X_NUC_104.L_CORE 0.002664
K_3030 X_NUC_20.L_CORE X_NUC_105.L_CORE 0.001768
K_3031 X_NUC_20.L_CORE X_NUC_106.L_CORE 0.001777
K_3032 X_NUC_20.L_CORE X_NUC_107.L_CORE 0.001769
K_3033 X_NUC_20.L_CORE X_NUC_108.L_CORE 0.001762
K_3034 X_NUC_20.L_CORE X_NUC_109.L_CORE 0.002087
K_3035 X_NUC_20.L_CORE X_NUC_110.L_CORE 0.002083
K_3036 X_NUC_20.L_CORE X_NUC_111.L_CORE 0.002078
K_3037 X_NUC_20.L_CORE X_NUC_112.L_CORE 0.002067
K_3038 X_NUC_20.L_CORE X_NUC_113.L_CORE 0.002137
K_3039 X_NUC_20.L_CORE X_NUC_114.L_CORE 0.002147
K_3040 X_NUC_20.L_CORE X_NUC_115.L_CORE 0.002127
K_3041 X_NUC_20.L_CORE X_NUC_116.L_CORE 0.002128
K_3042 X_NUC_20.L_CORE X_NUC_117.L_CORE 0.001733
K_3043 X_NUC_20.L_CORE X_NUC_118.L_CORE 0.001737
K_3044 X_NUC_20.L_CORE X_NUC_119.L_CORE 0.001731
K_3045 X_NUC_20.L_CORE X_NUC_120.L_CORE 0.001723
K_3046 X_NUC_20.L_CORE X_NUC_121.L_CORE 0.002152
K_3047 X_NUC_20.L_CORE X_NUC_122.L_CORE 0.002151
K_3048 X_NUC_20.L_CORE X_NUC_123.L_CORE 0.002138
K_3049 X_NUC_20.L_CORE X_NUC_124.L_CORE 0.002134
K_3050 X_NUC_20.L_CORE X_NUC_125.L_CORE 0.001828
K_3051 X_NUC_20.L_CORE X_NUC_126.L_CORE 0.001835
K_3052 X_NUC_20.L_CORE X_NUC_127.L_CORE 0.001823
K_3053 X_NUC_20.L_CORE X_NUC_128.L_CORE 0.001820
K_3054 X_NUC_20.L_CORE X_NUC_129.L_CORE 0.001837
K_3055 X_NUC_20.L_CORE X_NUC_130.L_CORE 0.001839
K_3056 X_NUC_20.L_CORE X_NUC_131.L_CORE 0.001831
K_3057 X_NUC_20.L_CORE X_NUC_132.L_CORE 0.001824
K_3058 X_NUC_20.L_CORE X_NUC_133.L_CORE 0.003393
K_3059 X_NUC_20.L_CORE X_NUC_134.L_CORE 0.005633
K_3060 X_NUC_20.L_CORE X_NUC_135.L_CORE 0.003862
K_3061 X_NUC_20.L_CORE X_NUC_136.L_CORE 0.002687
K_3062 X_NUC_20.L_CORE X_NUC_137.L_CORE 0.030104
K_3063 X_NUC_20.L_CORE X_NUC_138.L_CORE 0.002440
K_3064 X_NUC_20.L_CORE X_NUC_139.L_CORE 0.003230
K_3065 X_NUC_20.L_CORE X_NUC_140.L_CORE 0.004518
K_3066 X_NUC_20.L_CORE X_NUC_141.L_CORE 0.002076
K_3067 X_NUC_20.L_CORE X_NUC_142.L_CORE 0.005599
K_3068 X_NUC_20.L_CORE X_NUC_143.L_CORE 0.002424
K_3069 X_NUC_20.L_CORE X_NUC_144.L_CORE 0.002224
K_3070 X_NUC_20.L_CORE X_NUC_145.L_CORE 0.005097
K_3071 X_NUC_20.L_CORE X_NUC_146.L_CORE 0.001891
K_3072 X_NUC_20.L_CORE X_NUC_147.L_CORE 0.002928
K_3073 X_NUC_20.L_CORE X_NUC_148.L_CORE 0.002652
K_3074 X_NUC_20.L_CORE X_NUC_149.L_CORE 0.001832
K_3075 X_NUC_20.L_CORE X_NUC_150.L_CORE 0.003752
K_3076 X_NUC_20.L_CORE X_NUC_151.L_CORE 0.001896
K_3077 X_NUC_20.L_CORE X_NUC_152.L_CORE 0.002095
K_3078 X_NUC_20.L_CORE X_NUC_153.L_CORE 0.002813
K_3079 X_NUC_20.L_CORE X_NUC_154.L_CORE 0.001688
K_3080 X_NUC_20.L_CORE X_NUC_155.L_CORE 0.002564
K_3081 X_NUC_20.L_CORE X_NUC_156.L_CORE 0.001994
K_3082 X_NUC_20.L_CORE X_NUC_157.L_CORE 0.001755
K_3083 X_NUC_20.L_CORE X_NUC_158.L_CORE 0.002534
K_3084 X_NUC_20.L_CORE X_NUC_159.L_CORE 0.001680
K_3085 X_NUC_20.L_CORE X_NUC_160.L_CORE 0.001973
K_3086 X_NUC_20.L_CORE X_NUC_161.L_CORE 0.002027
K_3087 X_NUC_20.L_CORE X_NUC_162.L_CORE 0.001644
K_3088 X_NUC_20.L_CORE X_NUC_163.L_CORE 0.002035
K_3089 X_NUC_20.L_CORE X_NUC_164.L_CORE 0.001735
K_3090 X_NUC_20.L_CORE X_NUC_165.L_CORE 0.001741
K_3091 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_3092 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_3093 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_3094 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.002383
K_3095 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.002356
K_3096 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.002371
K_3097 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.002366
K_3098 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.003175
K_3099 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.003154
K_3100 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.003139
K_3101 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.003182
K_3102 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.004576
K_3103 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.004527
K_3104 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.004576
K_3105 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.004493
K_3106 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.002060
K_3107 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.002041
K_3108 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.002045
K_3109 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.002052
K_3110 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.005844
K_3111 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.005884
K_3112 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.005738
K_3113 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.005870
K_3114 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.002443
K_3115 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.002420
K_3116 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.002433
K_3117 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.002419
K_3118 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.002237
K_3119 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.002222
K_3120 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.002216
K_3121 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.002233
K_3122 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.005551
K_3123 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.005574
K_3124 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.005523
K_3125 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.005438
K_3126 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.001913
K_3127 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.001896
K_3128 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.001901
K_3129 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.001901
K_3130 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.003017
K_3131 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.003012
K_3132 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.002980
K_3133 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.003016
K_3134 X_NUC_21.L_CORE X_NUC_65.L_CORE 0.002748
K_3135 X_NUC_21.L_CORE X_NUC_66.L_CORE 0.002729
K_3136 X_NUC_21.L_CORE X_NUC_67.L_CORE 0.002736
K_3137 X_NUC_21.L_CORE X_NUC_68.L_CORE 0.002713
K_3138 X_NUC_21.L_CORE X_NUC_69.L_CORE 0.001866
K_3139 X_NUC_21.L_CORE X_NUC_70.L_CORE 0.001853
K_3140 X_NUC_21.L_CORE X_NUC_71.L_CORE 0.001851
K_3141 X_NUC_21.L_CORE X_NUC_72.L_CORE 0.001859
K_3142 X_NUC_21.L_CORE X_NUC_73.L_CORE 0.004046
K_3143 X_NUC_21.L_CORE X_NUC_74.L_CORE 0.004071
K_3144 X_NUC_21.L_CORE X_NUC_75.L_CORE 0.004000
K_3145 X_NUC_21.L_CORE X_NUC_76.L_CORE 0.004014
K_3146 X_NUC_21.L_CORE X_NUC_77.L_CORE 0.001950
K_3147 X_NUC_21.L_CORE X_NUC_78.L_CORE 0.001935
K_3148 X_NUC_21.L_CORE X_NUC_79.L_CORE 0.001939
K_3149 X_NUC_21.L_CORE X_NUC_80.L_CORE 0.001934
K_3150 X_NUC_21.L_CORE X_NUC_81.L_CORE 0.002162
K_3151 X_NUC_21.L_CORE X_NUC_82.L_CORE 0.002153
K_3152 X_NUC_21.L_CORE X_NUC_83.L_CORE 0.002141
K_3153 X_NUC_21.L_CORE X_NUC_84.L_CORE 0.002156
K_3154 X_NUC_21.L_CORE X_NUC_85.L_CORE 0.002984
K_3155 X_NUC_21.L_CORE X_NUC_86.L_CORE 0.002978
K_3156 X_NUC_21.L_CORE X_NUC_87.L_CORE 0.002966
K_3157 X_NUC_21.L_CORE X_NUC_88.L_CORE 0.002945
K_3158 X_NUC_21.L_CORE X_NUC_89.L_CORE 0.001740
K_3159 X_NUC_21.L_CORE X_NUC_90.L_CORE 0.001728
K_3160 X_NUC_21.L_CORE X_NUC_91.L_CORE 0.001728
K_3161 X_NUC_21.L_CORE X_NUC_92.L_CORE 0.001730
K_3162 X_NUC_21.L_CORE X_NUC_93.L_CORE 0.002700
K_3163 X_NUC_21.L_CORE X_NUC_94.L_CORE 0.002701
K_3164 X_NUC_21.L_CORE X_NUC_95.L_CORE 0.002671
K_3165 X_NUC_21.L_CORE X_NUC_96.L_CORE 0.002688
K_3166 X_NUC_21.L_CORE X_NUC_97.L_CORE 0.002082
K_3167 X_NUC_21.L_CORE X_NUC_98.L_CORE 0.002070
K_3168 X_NUC_21.L_CORE X_NUC_99.L_CORE 0.002070
K_3169 X_NUC_21.L_CORE X_NUC_100.L_CORE 0.002061
K_3170 X_NUC_21.L_CORE X_NUC_101.L_CORE 0.001823
K_3171 X_NUC_21.L_CORE X_NUC_102.L_CORE 0.001814
K_3172 X_NUC_21.L_CORE X_NUC_103.L_CORE 0.001808
K_3173 X_NUC_21.L_CORE X_NUC_104.L_CORE 0.001815
K_3174 X_NUC_21.L_CORE X_NUC_105.L_CORE 0.002680
K_3175 X_NUC_21.L_CORE X_NUC_106.L_CORE 0.002681
K_3176 X_NUC_21.L_CORE X_NUC_107.L_CORE 0.002658
K_3177 X_NUC_21.L_CORE X_NUC_108.L_CORE 0.002655
K_3178 X_NUC_21.L_CORE X_NUC_109.L_CORE 0.001757
K_3179 X_NUC_21.L_CORE X_NUC_110.L_CORE 0.001746
K_3180 X_NUC_21.L_CORE X_NUC_111.L_CORE 0.001745
K_3181 X_NUC_21.L_CORE X_NUC_112.L_CORE 0.001744
K_3182 X_NUC_21.L_CORE X_NUC_113.L_CORE 0.002067
K_3183 X_NUC_21.L_CORE X_NUC_114.L_CORE 0.002062
K_3184 X_NUC_21.L_CORE X_NUC_115.L_CORE 0.002048
K_3185 X_NUC_21.L_CORE X_NUC_116.L_CORE 0.002057
K_3186 X_NUC_21.L_CORE X_NUC_117.L_CORE 0.002126
K_3187 X_NUC_21.L_CORE X_NUC_118.L_CORE 0.002119
K_3188 X_NUC_21.L_CORE X_NUC_119.L_CORE 0.002112
K_3189 X_NUC_21.L_CORE X_NUC_120.L_CORE 0.002106
K_3190 X_NUC_21.L_CORE X_NUC_121.L_CORE 0.001738
K_3191 X_NUC_21.L_CORE X_NUC_122.L_CORE 0.001729
K_3192 X_NUC_21.L_CORE X_NUC_123.L_CORE 0.001724
K_3193 X_NUC_21.L_CORE X_NUC_124.L_CORE 0.001727
K_3194 X_NUC_21.L_CORE X_NUC_125.L_CORE 0.002105
K_3195 X_NUC_21.L_CORE X_NUC_126.L_CORE 0.002100
K_3196 X_NUC_21.L_CORE X_NUC_127.L_CORE 0.002086
K_3197 X_NUC_21.L_CORE X_NUC_128.L_CORE 0.002090
K_3198 X_NUC_21.L_CORE X_NUC_129.L_CORE 0.001848
K_3199 X_NUC_21.L_CORE X_NUC_130.L_CORE 0.001841
K_3200 X_NUC_21.L_CORE X_NUC_131.L_CORE 0.001834
K_3201 X_NUC_21.L_CORE X_NUC_132.L_CORE 0.001834
K_3202 X_NUC_21.L_CORE X_NUC_133.L_CORE 0.005067
K_3203 X_NUC_21.L_CORE X_NUC_134.L_CORE 0.002731
K_3204 X_NUC_21.L_CORE X_NUC_135.L_CORE 0.005152
K_3205 X_NUC_21.L_CORE X_NUC_136.L_CORE 0.003455
K_3206 X_NUC_21.L_CORE X_NUC_137.L_CORE 0.002422
K_3207 X_NUC_21.L_CORE X_NUC_138.L_CORE 0.036070
K_3208 X_NUC_21.L_CORE X_NUC_139.L_CORE 0.002249
K_3209 X_NUC_21.L_CORE X_NUC_140.L_CORE 0.002999
K_3210 X_NUC_21.L_CORE X_NUC_141.L_CORE 0.004292
K_3211 X_NUC_21.L_CORE X_NUC_142.L_CORE 0.001947
K_3212 X_NUC_21.L_CORE X_NUC_143.L_CORE 0.005487
K_3213 X_NUC_21.L_CORE X_NUC_144.L_CORE 0.002306
K_3214 X_NUC_21.L_CORE X_NUC_145.L_CORE 0.002115
K_3215 X_NUC_21.L_CORE X_NUC_146.L_CORE 0.005199
K_3216 X_NUC_21.L_CORE X_NUC_147.L_CORE 0.001808
K_3217 X_NUC_21.L_CORE X_NUC_148.L_CORE 0.002852
K_3218 X_NUC_21.L_CORE X_NUC_149.L_CORE 0.002592
K_3219 X_NUC_21.L_CORE X_NUC_150.L_CORE 0.001765
K_3220 X_NUC_21.L_CORE X_NUC_151.L_CORE 0.003815
K_3221 X_NUC_21.L_CORE X_NUC_152.L_CORE 0.001843
K_3222 X_NUC_21.L_CORE X_NUC_153.L_CORE 0.002045
K_3223 X_NUC_21.L_CORE X_NUC_154.L_CORE 0.002815
K_3224 X_NUC_21.L_CORE X_NUC_155.L_CORE 0.001646
K_3225 X_NUC_21.L_CORE X_NUC_156.L_CORE 0.002553
K_3226 X_NUC_21.L_CORE X_NUC_157.L_CORE 0.001967
K_3227 X_NUC_21.L_CORE X_NUC_158.L_CORE 0.001725
K_3228 X_NUC_21.L_CORE X_NUC_159.L_CORE 0.002532
K_3229 X_NUC_21.L_CORE X_NUC_160.L_CORE 0.001661
K_3230 X_NUC_21.L_CORE X_NUC_161.L_CORE 0.001955
K_3231 X_NUC_21.L_CORE X_NUC_162.L_CORE 0.002010
K_3232 X_NUC_21.L_CORE X_NUC_163.L_CORE 0.001644
K_3233 X_NUC_21.L_CORE X_NUC_164.L_CORE 0.001990
K_3234 X_NUC_21.L_CORE X_NUC_165.L_CORE 0.001748
K_3235 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_3236 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_3237 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.002410
K_3238 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.002383
K_3239 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.002398
K_3240 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.002393
K_3241 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.003196
K_3242 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.003175
K_3243 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.003160
K_3244 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.003204
K_3245 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.004624
K_3246 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.004576
K_3247 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.004625
K_3248 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.004539
K_3249 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.002080
K_3250 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.002060
K_3251 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.002065
K_3252 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.002071
K_3253 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.005801
K_3254 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.005844
K_3255 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.005699
K_3256 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.005828
K_3257 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.002468
K_3258 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.002443
K_3259 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.002457
K_3260 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.002443
K_3261 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.002253
K_3262 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.002237
K_3263 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.002232
K_3264 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.002249
K_3265 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.005525
K_3266 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.005551
K_3267 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.005500
K_3268 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.005416
K_3269 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.001930
K_3270 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.001913
K_3271 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.001917
K_3272 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.001917
K_3273 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.003021
K_3274 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.003017
K_3275 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.002985
K_3276 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.003021
K_3277 X_NUC_22.L_CORE X_NUC_65.L_CORE 0.002766
K_3278 X_NUC_22.L_CORE X_NUC_66.L_CORE 0.002748
K_3279 X_NUC_22.L_CORE X_NUC_67.L_CORE 0.002755
K_3280 X_NUC_22.L_CORE X_NUC_68.L_CORE 0.002731
K_3281 X_NUC_22.L_CORE X_NUC_69.L_CORE 0.001880
K_3282 X_NUC_22.L_CORE X_NUC_70.L_CORE 0.001866
K_3283 X_NUC_22.L_CORE X_NUC_71.L_CORE 0.001864
K_3284 X_NUC_22.L_CORE X_NUC_72.L_CORE 0.001872
K_3285 X_NUC_22.L_CORE X_NUC_73.L_CORE 0.004021
K_3286 X_NUC_22.L_CORE X_NUC_74.L_CORE 0.004046
K_3287 X_NUC_22.L_CORE X_NUC_75.L_CORE 0.003976
K_3288 X_NUC_22.L_CORE X_NUC_76.L_CORE 0.003990
K_3289 X_NUC_22.L_CORE X_NUC_77.L_CORE 0.001965
K_3290 X_NUC_22.L_CORE X_NUC_78.L_CORE 0.001950
K_3291 X_NUC_22.L_CORE X_NUC_79.L_CORE 0.001954
K_3292 X_NUC_22.L_CORE X_NUC_80.L_CORE 0.001948
K_3293 X_NUC_22.L_CORE X_NUC_81.L_CORE 0.002171
K_3294 X_NUC_22.L_CORE X_NUC_82.L_CORE 0.002162
K_3295 X_NUC_22.L_CORE X_NUC_83.L_CORE 0.002150
K_3296 X_NUC_22.L_CORE X_NUC_84.L_CORE 0.002166
K_3297 X_NUC_22.L_CORE X_NUC_85.L_CORE 0.002989
K_3298 X_NUC_22.L_CORE X_NUC_86.L_CORE 0.002984
K_3299 X_NUC_22.L_CORE X_NUC_87.L_CORE 0.002972
K_3300 X_NUC_22.L_CORE X_NUC_88.L_CORE 0.002950
K_3301 X_NUC_22.L_CORE X_NUC_89.L_CORE 0.001753
K_3302 X_NUC_22.L_CORE X_NUC_90.L_CORE 0.001740
K_3303 X_NUC_22.L_CORE X_NUC_91.L_CORE 0.001740
K_3304 X_NUC_22.L_CORE X_NUC_92.L_CORE 0.001742
K_3305 X_NUC_22.L_CORE X_NUC_93.L_CORE 0.002699
K_3306 X_NUC_22.L_CORE X_NUC_94.L_CORE 0.002700
K_3307 X_NUC_22.L_CORE X_NUC_95.L_CORE 0.002670
K_3308 X_NUC_22.L_CORE X_NUC_96.L_CORE 0.002687
K_3309 X_NUC_22.L_CORE X_NUC_97.L_CORE 0.002094
K_3310 X_NUC_22.L_CORE X_NUC_98.L_CORE 0.002082
K_3311 X_NUC_22.L_CORE X_NUC_99.L_CORE 0.002082
K_3312 X_NUC_22.L_CORE X_NUC_100.L_CORE 0.002073
K_3313 X_NUC_22.L_CORE X_NUC_101.L_CORE 0.001833
K_3314 X_NUC_22.L_CORE X_NUC_102.L_CORE 0.001823
K_3315 X_NUC_22.L_CORE X_NUC_103.L_CORE 0.001817
K_3316 X_NUC_22.L_CORE X_NUC_104.L_CORE 0.001825
K_3317 X_NUC_22.L_CORE X_NUC_105.L_CORE 0.002679
K_3318 X_NUC_22.L_CORE X_NUC_106.L_CORE 0.002680
K_3319 X_NUC_22.L_CORE X_NUC_107.L_CORE 0.002657
K_3320 X_NUC_22.L_CORE X_NUC_108.L_CORE 0.002654
K_3321 X_NUC_22.L_CORE X_NUC_109.L_CORE 0.001768
K_3322 X_NUC_22.L_CORE X_NUC_110.L_CORE 0.001757
K_3323 X_NUC_22.L_CORE X_NUC_111.L_CORE 0.001755
K_3324 X_NUC_22.L_CORE X_NUC_112.L_CORE 0.001754
K_3325 X_NUC_22.L_CORE X_NUC_113.L_CORE 0.002072
K_3326 X_NUC_22.L_CORE X_NUC_114.L_CORE 0.002067
K_3327 X_NUC_22.L_CORE X_NUC_115.L_CORE 0.002053
K_3328 X_NUC_22.L_CORE X_NUC_116.L_CORE 0.002062
K_3329 X_NUC_22.L_CORE X_NUC_117.L_CORE 0.002134
K_3330 X_NUC_22.L_CORE X_NUC_118.L_CORE 0.002126
K_3331 X_NUC_22.L_CORE X_NUC_119.L_CORE 0.002119
K_3332 X_NUC_22.L_CORE X_NUC_120.L_CORE 0.002113
K_3333 X_NUC_22.L_CORE X_NUC_121.L_CORE 0.001747
K_3334 X_NUC_22.L_CORE X_NUC_122.L_CORE 0.001738
K_3335 X_NUC_22.L_CORE X_NUC_123.L_CORE 0.001733
K_3336 X_NUC_22.L_CORE X_NUC_124.L_CORE 0.001736
K_3337 X_NUC_22.L_CORE X_NUC_125.L_CORE 0.002109
K_3338 X_NUC_22.L_CORE X_NUC_126.L_CORE 0.002105
K_3339 X_NUC_22.L_CORE X_NUC_127.L_CORE 0.002090
K_3340 X_NUC_22.L_CORE X_NUC_128.L_CORE 0.002094
K_3341 X_NUC_22.L_CORE X_NUC_129.L_CORE 0.001856
K_3342 X_NUC_22.L_CORE X_NUC_130.L_CORE 0.001848
K_3343 X_NUC_22.L_CORE X_NUC_131.L_CORE 0.001842
K_3344 X_NUC_22.L_CORE X_NUC_132.L_CORE 0.001842
K_3345 X_NUC_22.L_CORE X_NUC_133.L_CORE 0.005168
K_3346 X_NUC_22.L_CORE X_NUC_134.L_CORE 0.002766
K_3347 X_NUC_22.L_CORE X_NUC_135.L_CORE 0.005206
K_3348 X_NUC_22.L_CORE X_NUC_136.L_CORE 0.003504
K_3349 X_NUC_22.L_CORE X_NUC_137.L_CORE 0.002445
K_3350 X_NUC_22.L_CORE X_NUC_138.L_CORE 0.031900
K_3351 X_NUC_22.L_CORE X_NUC_139.L_CORE 0.002274
K_3352 X_NUC_22.L_CORE X_NUC_140.L_CORE 0.003016
K_3353 X_NUC_22.L_CORE X_NUC_141.L_CORE 0.004328
K_3354 X_NUC_22.L_CORE X_NUC_142.L_CORE 0.001965
K_3355 X_NUC_22.L_CORE X_NUC_143.L_CORE 0.005432
K_3356 X_NUC_22.L_CORE X_NUC_144.L_CORE 0.002327
K_3357 X_NUC_22.L_CORE X_NUC_145.L_CORE 0.002129
K_3358 X_NUC_22.L_CORE X_NUC_146.L_CORE 0.005162
K_3359 X_NUC_22.L_CORE X_NUC_147.L_CORE 0.001823
K_3360 X_NUC_22.L_CORE X_NUC_148.L_CORE 0.002853
K_3361 X_NUC_22.L_CORE X_NUC_149.L_CORE 0.002608
K_3362 X_NUC_22.L_CORE X_NUC_150.L_CORE 0.001777
K_3363 X_NUC_22.L_CORE X_NUC_151.L_CORE 0.003787
K_3364 X_NUC_22.L_CORE X_NUC_152.L_CORE 0.001856
K_3365 X_NUC_22.L_CORE X_NUC_153.L_CORE 0.002053
K_3366 X_NUC_22.L_CORE X_NUC_154.L_CORE 0.002818
K_3367 X_NUC_22.L_CORE X_NUC_155.L_CORE 0.001657
K_3368 X_NUC_22.L_CORE X_NUC_156.L_CORE 0.002550
K_3369 X_NUC_22.L_CORE X_NUC_157.L_CORE 0.001978
K_3370 X_NUC_22.L_CORE X_NUC_158.L_CORE 0.001733
K_3371 X_NUC_22.L_CORE X_NUC_159.L_CORE 0.002530
K_3372 X_NUC_22.L_CORE X_NUC_160.L_CORE 0.001671
K_3373 X_NUC_22.L_CORE X_NUC_161.L_CORE 0.001960
K_3374 X_NUC_22.L_CORE X_NUC_162.L_CORE 0.002016
K_3375 X_NUC_22.L_CORE X_NUC_163.L_CORE 0.001652
K_3376 X_NUC_22.L_CORE X_NUC_164.L_CORE 0.001993
K_3377 X_NUC_22.L_CORE X_NUC_165.L_CORE 0.001755
K_3378 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_3379 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.002395
K_3380 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.002368
K_3381 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.002383
K_3382 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.002378
K_3383 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.003212
K_3384 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.003190
K_3385 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.003175
K_3386 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.003219
K_3387 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.004574
K_3388 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.004526
K_3389 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.004576
K_3390 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.004492
K_3391 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.002075
K_3392 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.002056
K_3393 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.002060
K_3394 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.002066
K_3395 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.005951
K_3396 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.005995
K_3397 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.005844
K_3398 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.005981
K_3399 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.002454
K_3400 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.002430
K_3401 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.002443
K_3402 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.002429
K_3403 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.002259
K_3404 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.002243
K_3405 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.002237
K_3406 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.002255
K_3407 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.005575
K_3408 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.005600
K_3409 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.005551
K_3410 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.005463
K_3411 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.001925
K_3412 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.001908
K_3413 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.001913
K_3414 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.001913
K_3415 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.003055
K_3416 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.003050
K_3417 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.003017
K_3418 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.003054
K_3419 X_NUC_23.L_CORE X_NUC_65.L_CORE 0.002758
K_3420 X_NUC_23.L_CORE X_NUC_66.L_CORE 0.002740
K_3421 X_NUC_23.L_CORE X_NUC_67.L_CORE 0.002748
K_3422 X_NUC_23.L_CORE X_NUC_68.L_CORE 0.002723
K_3423 X_NUC_23.L_CORE X_NUC_69.L_CORE 0.001881
K_3424 X_NUC_23.L_CORE X_NUC_70.L_CORE 0.001868
K_3425 X_NUC_23.L_CORE X_NUC_71.L_CORE 0.001866
K_3426 X_NUC_23.L_CORE X_NUC_72.L_CORE 0.001874
K_3427 X_NUC_23.L_CORE X_NUC_73.L_CORE 0.004093
K_3428 X_NUC_23.L_CORE X_NUC_74.L_CORE 0.004119
K_3429 X_NUC_23.L_CORE X_NUC_75.L_CORE 0.004046
K_3430 X_NUC_23.L_CORE X_NUC_76.L_CORE 0.004061
K_3431 X_NUC_23.L_CORE X_NUC_77.L_CORE 0.001961
K_3432 X_NUC_23.L_CORE X_NUC_78.L_CORE 0.001946
K_3433 X_NUC_23.L_CORE X_NUC_79.L_CORE 0.001950
K_3434 X_NUC_23.L_CORE X_NUC_80.L_CORE 0.001945
K_3435 X_NUC_23.L_CORE X_NUC_81.L_CORE 0.002184
K_3436 X_NUC_23.L_CORE X_NUC_82.L_CORE 0.002175
K_3437 X_NUC_23.L_CORE X_NUC_83.L_CORE 0.002162
K_3438 X_NUC_23.L_CORE X_NUC_84.L_CORE 0.002178
K_3439 X_NUC_23.L_CORE X_NUC_85.L_CORE 0.003001
K_3440 X_NUC_23.L_CORE X_NUC_86.L_CORE 0.002995
K_3441 X_NUC_23.L_CORE X_NUC_87.L_CORE 0.002984
K_3442 X_NUC_23.L_CORE X_NUC_88.L_CORE 0.002961
K_3443 X_NUC_23.L_CORE X_NUC_89.L_CORE 0.001753
K_3444 X_NUC_23.L_CORE X_NUC_90.L_CORE 0.001741
K_3445 X_NUC_23.L_CORE X_NUC_91.L_CORE 0.001740
K_3446 X_NUC_23.L_CORE X_NUC_92.L_CORE 0.001743
K_3447 X_NUC_23.L_CORE X_NUC_93.L_CORE 0.002730
K_3448 X_NUC_23.L_CORE X_NUC_94.L_CORE 0.002731
K_3449 X_NUC_23.L_CORE X_NUC_95.L_CORE 0.002700
K_3450 X_NUC_23.L_CORE X_NUC_96.L_CORE 0.002718
K_3451 X_NUC_23.L_CORE X_NUC_97.L_CORE 0.002094
K_3452 X_NUC_23.L_CORE X_NUC_98.L_CORE 0.002082
K_3453 X_NUC_23.L_CORE X_NUC_99.L_CORE 0.002082
K_3454 X_NUC_23.L_CORE X_NUC_100.L_CORE 0.002073
K_3455 X_NUC_23.L_CORE X_NUC_101.L_CORE 0.001840
K_3456 X_NUC_23.L_CORE X_NUC_102.L_CORE 0.001830
K_3457 X_NUC_23.L_CORE X_NUC_103.L_CORE 0.001823
K_3458 X_NUC_23.L_CORE X_NUC_104.L_CORE 0.001831
K_3459 X_NUC_23.L_CORE X_NUC_105.L_CORE 0.002703
K_3460 X_NUC_23.L_CORE X_NUC_106.L_CORE 0.002703
K_3461 X_NUC_23.L_CORE X_NUC_107.L_CORE 0.002680
K_3462 X_NUC_23.L_CORE X_NUC_108.L_CORE 0.002677
K_3463 X_NUC_23.L_CORE X_NUC_109.L_CORE 0.001769
K_3464 X_NUC_23.L_CORE X_NUC_110.L_CORE 0.001758
K_3465 X_NUC_23.L_CORE X_NUC_111.L_CORE 0.001757
K_3466 X_NUC_23.L_CORE X_NUC_112.L_CORE 0.001756
K_3467 X_NUC_23.L_CORE X_NUC_113.L_CORE 0.002087
K_3468 X_NUC_23.L_CORE X_NUC_114.L_CORE 0.002082
K_3469 X_NUC_23.L_CORE X_NUC_115.L_CORE 0.002067
K_3470 X_NUC_23.L_CORE X_NUC_116.L_CORE 0.002077
K_3471 X_NUC_23.L_CORE X_NUC_117.L_CORE 0.002141
K_3472 X_NUC_23.L_CORE X_NUC_118.L_CORE 0.002134
K_3473 X_NUC_23.L_CORE X_NUC_119.L_CORE 0.002126
K_3474 X_NUC_23.L_CORE X_NUC_120.L_CORE 0.002121
K_3475 X_NUC_23.L_CORE X_NUC_121.L_CORE 0.001752
K_3476 X_NUC_23.L_CORE X_NUC_122.L_CORE 0.001743
K_3477 X_NUC_23.L_CORE X_NUC_123.L_CORE 0.001738
K_3478 X_NUC_23.L_CORE X_NUC_124.L_CORE 0.001741
K_3479 X_NUC_23.L_CORE X_NUC_125.L_CORE 0.002123
K_3480 X_NUC_23.L_CORE X_NUC_126.L_CORE 0.002119
K_3481 X_NUC_23.L_CORE X_NUC_127.L_CORE 0.002105
K_3482 X_NUC_23.L_CORE X_NUC_128.L_CORE 0.002108
K_3483 X_NUC_23.L_CORE X_NUC_129.L_CORE 0.001862
K_3484 X_NUC_23.L_CORE X_NUC_130.L_CORE 0.001855
K_3485 X_NUC_23.L_CORE X_NUC_131.L_CORE 0.001848
K_3486 X_NUC_23.L_CORE X_NUC_132.L_CORE 0.001848
K_3487 X_NUC_23.L_CORE X_NUC_133.L_CORE 0.005061
K_3488 X_NUC_23.L_CORE X_NUC_134.L_CORE 0.002744
K_3489 X_NUC_23.L_CORE X_NUC_135.L_CORE 0.005194
K_3490 X_NUC_23.L_CORE X_NUC_136.L_CORE 0.003456
K_3491 X_NUC_23.L_CORE X_NUC_137.L_CORE 0.002439
K_3492 X_NUC_23.L_CORE X_NUC_138.L_CORE 0.031036
K_3493 X_NUC_23.L_CORE X_NUC_139.L_CORE 0.002259
K_3494 X_NUC_23.L_CORE X_NUC_140.L_CORE 0.003029
K_3495 X_NUC_23.L_CORE X_NUC_141.L_CORE 0.004280
K_3496 X_NUC_23.L_CORE X_NUC_142.L_CORE 0.001960
K_3497 X_NUC_23.L_CORE X_NUC_143.L_CORE 0.005563
K_3498 X_NUC_23.L_CORE X_NUC_144.L_CORE 0.002314
K_3499 X_NUC_23.L_CORE X_NUC_145.L_CORE 0.002134
K_3500 X_NUC_23.L_CORE X_NUC_146.L_CORE 0.005204
K_3501 X_NUC_23.L_CORE X_NUC_147.L_CORE 0.001818
K_3502 X_NUC_23.L_CORE X_NUC_148.L_CORE 0.002884
K_3503 X_NUC_23.L_CORE X_NUC_149.L_CORE 0.002600
K_3504 X_NUC_23.L_CORE X_NUC_150.L_CORE 0.001778
K_3505 X_NUC_23.L_CORE X_NUC_151.L_CORE 0.003852
K_3506 X_NUC_23.L_CORE X_NUC_152.L_CORE 0.001852
K_3507 X_NUC_23.L_CORE X_NUC_153.L_CORE 0.002065
K_3508 X_NUC_23.L_CORE X_NUC_154.L_CORE 0.002828
K_3509 X_NUC_23.L_CORE X_NUC_155.L_CORE 0.001657
K_3510 X_NUC_23.L_CORE X_NUC_156.L_CORE 0.002579
K_3511 X_NUC_23.L_CORE X_NUC_157.L_CORE 0.001977
K_3512 X_NUC_23.L_CORE X_NUC_158.L_CORE 0.001739
K_3513 X_NUC_23.L_CORE X_NUC_159.L_CORE 0.002551
K_3514 X_NUC_23.L_CORE X_NUC_160.L_CORE 0.001672
K_3515 X_NUC_23.L_CORE X_NUC_161.L_CORE 0.001973
K_3516 X_NUC_23.L_CORE X_NUC_162.L_CORE 0.002023
K_3517 X_NUC_23.L_CORE X_NUC_163.L_CORE 0.001657
K_3518 X_NUC_23.L_CORE X_NUC_164.L_CORE 0.002007
K_3519 X_NUC_23.L_CORE X_NUC_165.L_CORE 0.001760
K_3520 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.002399
K_3521 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.002372
K_3522 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.002387
K_3523 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.002383
K_3524 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.003168
K_3525 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.003147
K_3526 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.003133
K_3527 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.003175
K_3528 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.004661
K_3529 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.004611
K_3530 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.004662
K_3531 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.004576
K_3532 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.002069
K_3533 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.002050
K_3534 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.002054
K_3535 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.002060
K_3536 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.005814
K_3537 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.005855
K_3538 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.005712
K_3539 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.005844
K_3540 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.002468
K_3541 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.002444
K_3542 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.002457
K_3543 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.002443
K_3544 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.002241
K_3545 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.002226
K_3546 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.002220
K_3547 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.002237
K_3548 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.005667
K_3549 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.005693
K_3550 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.005640
K_3551 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.005551
K_3552 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.001925
K_3553 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.001908
K_3554 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.001913
K_3555 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.001913
K_3556 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.003017
K_3557 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.003013
K_3558 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.002981
K_3559 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.003017
K_3560 X_NUC_24.L_CORE X_NUC_65.L_CORE 0.002783
K_3561 X_NUC_24.L_CORE X_NUC_66.L_CORE 0.002764
K_3562 X_NUC_24.L_CORE X_NUC_67.L_CORE 0.002772
K_3563 X_NUC_24.L_CORE X_NUC_68.L_CORE 0.002748
K_3564 X_NUC_24.L_CORE X_NUC_69.L_CORE 0.001874
K_3565 X_NUC_24.L_CORE X_NUC_70.L_CORE 0.001860
K_3566 X_NUC_24.L_CORE X_NUC_71.L_CORE 0.001859
K_3567 X_NUC_24.L_CORE X_NUC_72.L_CORE 0.001866
K_3568 X_NUC_24.L_CORE X_NUC_73.L_CORE 0.004078
K_3569 X_NUC_24.L_CORE X_NUC_74.L_CORE 0.004104
K_3570 X_NUC_24.L_CORE X_NUC_75.L_CORE 0.004031
K_3571 X_NUC_24.L_CORE X_NUC_76.L_CORE 0.004046
K_3572 X_NUC_24.L_CORE X_NUC_77.L_CORE 0.001966
K_3573 X_NUC_24.L_CORE X_NUC_78.L_CORE 0.001951
K_3574 X_NUC_24.L_CORE X_NUC_79.L_CORE 0.001955
K_3575 X_NUC_24.L_CORE X_NUC_80.L_CORE 0.001950
K_3576 X_NUC_24.L_CORE X_NUC_81.L_CORE 0.002168
K_3577 X_NUC_24.L_CORE X_NUC_82.L_CORE 0.002159
K_3578 X_NUC_24.L_CORE X_NUC_83.L_CORE 0.002146
K_3579 X_NUC_24.L_CORE X_NUC_84.L_CORE 0.002162
K_3580 X_NUC_24.L_CORE X_NUC_85.L_CORE 0.003024
K_3581 X_NUC_24.L_CORE X_NUC_86.L_CORE 0.003018
K_3582 X_NUC_24.L_CORE X_NUC_87.L_CORE 0.003006
K_3583 X_NUC_24.L_CORE X_NUC_88.L_CORE 0.002984
K_3584 X_NUC_24.L_CORE X_NUC_89.L_CORE 0.001751
K_3585 X_NUC_24.L_CORE X_NUC_90.L_CORE 0.001739
K_3586 X_NUC_24.L_CORE X_NUC_91.L_CORE 0.001738
K_3587 X_NUC_24.L_CORE X_NUC_92.L_CORE 0.001740
K_3588 X_NUC_24.L_CORE X_NUC_93.L_CORE 0.002712
K_3589 X_NUC_24.L_CORE X_NUC_94.L_CORE 0.002713
K_3590 X_NUC_24.L_CORE X_NUC_95.L_CORE 0.002682
K_3591 X_NUC_24.L_CORE X_NUC_96.L_CORE 0.002700
K_3592 X_NUC_24.L_CORE X_NUC_97.L_CORE 0.002103
K_3593 X_NUC_24.L_CORE X_NUC_98.L_CORE 0.002090
K_3594 X_NUC_24.L_CORE X_NUC_99.L_CORE 0.002090
K_3595 X_NUC_24.L_CORE X_NUC_100.L_CORE 0.002082
K_3596 X_NUC_24.L_CORE X_NUC_101.L_CORE 0.001832
K_3597 X_NUC_24.L_CORE X_NUC_102.L_CORE 0.001822
K_3598 X_NUC_24.L_CORE X_NUC_103.L_CORE 0.001816
K_3599 X_NUC_24.L_CORE X_NUC_104.L_CORE 0.001823
K_3600 X_NUC_24.L_CORE X_NUC_105.L_CORE 0.002706
K_3601 X_NUC_24.L_CORE X_NUC_106.L_CORE 0.002706
K_3602 X_NUC_24.L_CORE X_NUC_107.L_CORE 0.002683
K_3603 X_NUC_24.L_CORE X_NUC_108.L_CORE 0.002680
K_3604 X_NUC_24.L_CORE X_NUC_109.L_CORE 0.001770
K_3605 X_NUC_24.L_CORE X_NUC_110.L_CORE 0.001759
K_3606 X_NUC_24.L_CORE X_NUC_111.L_CORE 0.001758
K_3607 X_NUC_24.L_CORE X_NUC_112.L_CORE 0.001757
K_3608 X_NUC_24.L_CORE X_NUC_113.L_CORE 0.002077
K_3609 X_NUC_24.L_CORE X_NUC_114.L_CORE 0.002072
K_3610 X_NUC_24.L_CORE X_NUC_115.L_CORE 0.002057
K_3611 X_NUC_24.L_CORE X_NUC_116.L_CORE 0.002067
K_3612 X_NUC_24.L_CORE X_NUC_117.L_CORE 0.002147
K_3613 X_NUC_24.L_CORE X_NUC_118.L_CORE 0.002140
K_3614 X_NUC_24.L_CORE X_NUC_119.L_CORE 0.002132
K_3615 X_NUC_24.L_CORE X_NUC_120.L_CORE 0.002126
K_3616 X_NUC_24.L_CORE X_NUC_121.L_CORE 0.001749
K_3617 X_NUC_24.L_CORE X_NUC_122.L_CORE 0.001740
K_3618 X_NUC_24.L_CORE X_NUC_123.L_CORE 0.001735
K_3619 X_NUC_24.L_CORE X_NUC_124.L_CORE 0.001738
K_3620 X_NUC_24.L_CORE X_NUC_125.L_CORE 0.002120
K_3621 X_NUC_24.L_CORE X_NUC_126.L_CORE 0.002115
K_3622 X_NUC_24.L_CORE X_NUC_127.L_CORE 0.002101
K_3623 X_NUC_24.L_CORE X_NUC_128.L_CORE 0.002105
K_3624 X_NUC_24.L_CORE X_NUC_129.L_CORE 0.001863
K_3625 X_NUC_24.L_CORE X_NUC_130.L_CORE 0.001855
K_3626 X_NUC_24.L_CORE X_NUC_131.L_CORE 0.001849
K_3627 X_NUC_24.L_CORE X_NUC_132.L_CORE 0.001848
K_3628 X_NUC_24.L_CORE X_NUC_133.L_CORE 0.005066
K_3629 X_NUC_24.L_CORE X_NUC_134.L_CORE 0.002739
K_3630 X_NUC_24.L_CORE X_NUC_135.L_CORE 0.005091
K_3631 X_NUC_24.L_CORE X_NUC_136.L_CORE 0.003486
K_3632 X_NUC_24.L_CORE X_NUC_137.L_CORE 0.002423
K_3633 X_NUC_24.L_CORE X_NUC_138.L_CORE 0.031773
K_3634 X_NUC_24.L_CORE X_NUC_139.L_CORE 0.002264
K_3635 X_NUC_24.L_CORE X_NUC_140.L_CORE 0.002989
K_3636 X_NUC_24.L_CORE X_NUC_141.L_CORE 0.004361
K_3637 X_NUC_24.L_CORE X_NUC_142.L_CORE 0.001954
K_3638 X_NUC_24.L_CORE X_NUC_143.L_CORE 0.005443
K_3639 X_NUC_24.L_CORE X_NUC_144.L_CORE 0.002328
K_3640 X_NUC_24.L_CORE X_NUC_145.L_CORE 0.002118
K_3641 X_NUC_24.L_CORE X_NUC_146.L_CORE 0.005290
K_3642 X_NUC_24.L_CORE X_NUC_147.L_CORE 0.001819
K_3643 X_NUC_24.L_CORE X_NUC_148.L_CORE 0.002849
K_3644 X_NUC_24.L_CORE X_NUC_149.L_CORE 0.002623
K_3645 X_NUC_24.L_CORE X_NUC_150.L_CORE 0.001771
K_3646 X_NUC_24.L_CORE X_NUC_151.L_CORE 0.003839
K_3647 X_NUC_24.L_CORE X_NUC_152.L_CORE 0.001857
K_3648 X_NUC_24.L_CORE X_NUC_153.L_CORE 0.002050
K_3649 X_NUC_24.L_CORE X_NUC_154.L_CORE 0.002850
K_3650 X_NUC_24.L_CORE X_NUC_155.L_CORE 0.001655
K_3651 X_NUC_24.L_CORE X_NUC_156.L_CORE 0.002562
K_3652 X_NUC_24.L_CORE X_NUC_157.L_CORE 0.001986
K_3653 X_NUC_24.L_CORE X_NUC_158.L_CORE 0.001732
K_3654 X_NUC_24.L_CORE X_NUC_159.L_CORE 0.002555
K_3655 X_NUC_24.L_CORE X_NUC_160.L_CORE 0.001673
K_3656 X_NUC_24.L_CORE X_NUC_161.L_CORE 0.001964
K_3657 X_NUC_24.L_CORE X_NUC_162.L_CORE 0.002028
K_3658 X_NUC_24.L_CORE X_NUC_163.L_CORE 0.001654
K_3659 X_NUC_24.L_CORE X_NUC_164.L_CORE 0.002004
K_3660 X_NUC_24.L_CORE X_NUC_165.L_CORE 0.001761
K_3661 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_3662 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_3663 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_3664 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.002248
K_3665 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.002263
K_3666 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.002245
K_3667 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.002264
K_3668 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.003015
K_3669 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.003056
K_3670 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.003039
K_3671 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.003024
K_3672 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.004388
K_3673 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.004370
K_3674 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.004320
K_3675 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.004407
K_3676 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.001971
K_3677 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.001988
K_3678 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.001974
K_3679 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.001982
K_3680 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.005760
K_3681 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.005826
K_3682 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.005794
K_3683 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.005676
K_3684 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.002360
K_3685 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.002368
K_3686 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.002347
K_3687 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.002371
K_3688 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.002166
K_3689 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.002188
K_3690 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.002173
K_3691 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.002171
K_3692 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.005632
K_3693 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.005559
K_3694 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.005485
K_3695 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.005539
K_3696 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.001859
K_3697 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.001871
K_3698 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.001856
K_3699 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.001867
K_3700 X_NUC_25.L_CORE X_NUC_65.L_CORE 0.002975
K_3701 X_NUC_25.L_CORE X_NUC_66.L_CORE 0.003003
K_3702 X_NUC_25.L_CORE X_NUC_67.L_CORE 0.002984
K_3703 X_NUC_25.L_CORE X_NUC_68.L_CORE 0.002962
K_3704 X_NUC_25.L_CORE X_NUC_69.L_CORE 0.002709
K_3705 X_NUC_25.L_CORE X_NUC_70.L_CORE 0.002708
K_3706 X_NUC_25.L_CORE X_NUC_71.L_CORE 0.002681
K_3707 X_NUC_25.L_CORE X_NUC_72.L_CORE 0.002710
K_3708 X_NUC_25.L_CORE X_NUC_73.L_CORE 0.001827
K_3709 X_NUC_25.L_CORE X_NUC_74.L_CORE 0.001842
K_3710 X_NUC_25.L_CORE X_NUC_75.L_CORE 0.001828
K_3711 X_NUC_25.L_CORE X_NUC_76.L_CORE 0.001832
K_3712 X_NUC_25.L_CORE X_NUC_77.L_CORE 0.004116
K_3713 X_NUC_25.L_CORE X_NUC_78.L_CORE 0.004111
K_3714 X_NUC_25.L_CORE X_NUC_79.L_CORE 0.004072
K_3715 X_NUC_25.L_CORE X_NUC_80.L_CORE 0.004047
K_3716 X_NUC_25.L_CORE X_NUC_81.L_CORE 0.001920
K_3717 X_NUC_25.L_CORE X_NUC_82.L_CORE 0.001928
K_3718 X_NUC_25.L_CORE X_NUC_83.L_CORE 0.001911
K_3719 X_NUC_25.L_CORE X_NUC_84.L_CORE 0.001925
K_3720 X_NUC_25.L_CORE X_NUC_85.L_CORE 0.002140
K_3721 X_NUC_25.L_CORE X_NUC_86.L_CORE 0.002157
K_3722 X_NUC_25.L_CORE X_NUC_87.L_CORE 0.002142
K_3723 X_NUC_25.L_CORE X_NUC_88.L_CORE 0.002137
K_3724 X_NUC_25.L_CORE X_NUC_89.L_CORE 0.002995
K_3725 X_NUC_25.L_CORE X_NUC_90.L_CORE 0.002986
K_3726 X_NUC_25.L_CORE X_NUC_91.L_CORE 0.002955
K_3727 X_NUC_25.L_CORE X_NUC_92.L_CORE 0.002975
K_3728 X_NUC_25.L_CORE X_NUC_93.L_CORE 0.001722
K_3729 X_NUC_25.L_CORE X_NUC_94.L_CORE 0.001733
K_3730 X_NUC_25.L_CORE X_NUC_95.L_CORE 0.001719
K_3731 X_NUC_25.L_CORE X_NUC_96.L_CORE 0.001726
K_3732 X_NUC_25.L_CORE X_NUC_97.L_CORE 0.002706
K_3733 X_NUC_25.L_CORE X_NUC_98.L_CORE 0.002719
K_3734 X_NUC_25.L_CORE X_NUC_99.L_CORE 0.002697
K_3735 X_NUC_25.L_CORE X_NUC_100.L_CORE 0.002685
K_3736 X_NUC_25.L_CORE X_NUC_101.L_CORE 0.002076
K_3737 X_NUC_25.L_CORE X_NUC_102.L_CORE 0.002079
K_3738 X_NUC_25.L_CORE X_NUC_103.L_CORE 0.002060
K_3739 X_NUC_25.L_CORE X_NUC_104.L_CORE 0.002074
K_3740 X_NUC_25.L_CORE X_NUC_105.L_CORE 0.001819
K_3741 X_NUC_25.L_CORE X_NUC_106.L_CORE 0.001831
K_3742 X_NUC_25.L_CORE X_NUC_107.L_CORE 0.001817
K_3743 X_NUC_25.L_CORE X_NUC_108.L_CORE 0.001818
K_3744 X_NUC_25.L_CORE X_NUC_109.L_CORE 0.002680
K_3745 X_NUC_25.L_CORE X_NUC_110.L_CORE 0.002680
K_3746 X_NUC_25.L_CORE X_NUC_111.L_CORE 0.002654
K_3747 X_NUC_25.L_CORE X_NUC_112.L_CORE 0.002658
K_3748 X_NUC_25.L_CORE X_NUC_113.L_CORE 0.001762
K_3749 X_NUC_25.L_CORE X_NUC_114.L_CORE 0.001770
K_3750 X_NUC_25.L_CORE X_NUC_115.L_CORE 0.001755
K_3751 X_NUC_25.L_CORE X_NUC_116.L_CORE 0.001762
K_3752 X_NUC_25.L_CORE X_NUC_117.L_CORE 0.002069
K_3753 X_NUC_25.L_CORE X_NUC_118.L_CORE 0.002080
K_3754 X_NUC_25.L_CORE X_NUC_119.L_CORE 0.002063
K_3755 X_NUC_25.L_CORE X_NUC_120.L_CORE 0.002061
K_3756 X_NUC_25.L_CORE X_NUC_121.L_CORE 0.002120
K_3757 X_NUC_25.L_CORE X_NUC_122.L_CORE 0.002123
K_3758 X_NUC_25.L_CORE X_NUC_123.L_CORE 0.002103
K_3759 X_NUC_25.L_CORE X_NUC_124.L_CORE 0.002112
K_3760 X_NUC_25.L_CORE X_NUC_125.L_CORE 0.001773
K_3761 X_NUC_25.L_CORE X_NUC_126.L_CORE 0.001781
K_3762 X_NUC_25.L_CORE X_NUC_127.L_CORE 0.001767
K_3763 X_NUC_25.L_CORE X_NUC_128.L_CORE 0.001770
K_3764 X_NUC_25.L_CORE X_NUC_129.L_CORE 0.002039
K_3765 X_NUC_25.L_CORE X_NUC_130.L_CORE 0.002045
K_3766 X_NUC_25.L_CORE X_NUC_131.L_CORE 0.002027
K_3767 X_NUC_25.L_CORE X_NUC_132.L_CORE 0.002030
K_3768 X_NUC_25.L_CORE X_NUC_133.L_CORE 0.003402
K_3769 X_NUC_25.L_CORE X_NUC_134.L_CORE 0.005578
K_3770 X_NUC_25.L_CORE X_NUC_135.L_CORE 0.002435
K_3771 X_NUC_25.L_CORE X_NUC_136.L_CORE 0.004872
K_3772 X_NUC_25.L_CORE X_NUC_137.L_CORE 0.003215
K_3773 X_NUC_25.L_CORE X_NUC_138.L_CORE 0.002274
K_3774 X_NUC_25.L_CORE X_NUC_139.L_CORE 0.031889
K_3775 X_NUC_25.L_CORE X_NUC_140.L_CORE 0.002140
K_3776 X_NUC_25.L_CORE X_NUC_141.L_CORE 0.002874
K_3777 X_NUC_25.L_CORE X_NUC_142.L_CORE 0.004124
K_3778 X_NUC_25.L_CORE X_NUC_143.L_CORE 0.001879
K_3779 X_NUC_25.L_CORE X_NUC_144.L_CORE 0.005405
K_3780 X_NUC_25.L_CORE X_NUC_145.L_CORE 0.002241
K_3781 X_NUC_25.L_CORE X_NUC_146.L_CORE 0.002065
K_3782 X_NUC_25.L_CORE X_NUC_147.L_CORE 0.005214
K_3783 X_NUC_25.L_CORE X_NUC_148.L_CORE 0.001770
K_3784 X_NUC_25.L_CORE X_NUC_149.L_CORE 0.002825
K_3785 X_NUC_25.L_CORE X_NUC_150.L_CORE 0.002562
K_3786 X_NUC_25.L_CORE X_NUC_151.L_CORE 0.001741
K_3787 X_NUC_25.L_CORE X_NUC_152.L_CORE 0.003860
K_3788 X_NUC_25.L_CORE X_NUC_153.L_CORE 0.001825
K_3789 X_NUC_25.L_CORE X_NUC_154.L_CORE 0.002036
K_3790 X_NUC_25.L_CORE X_NUC_155.L_CORE 0.002822
K_3791 X_NUC_25.L_CORE X_NUC_156.L_CORE 0.001639
K_3792 X_NUC_25.L_CORE X_NUC_157.L_CORE 0.002562
K_3793 X_NUC_25.L_CORE X_NUC_158.L_CORE 0.001968
K_3794 X_NUC_25.L_CORE X_NUC_159.L_CORE 0.001730
K_3795 X_NUC_25.L_CORE X_NUC_160.L_CORE 0.002530
K_3796 X_NUC_25.L_CORE X_NUC_161.L_CORE 0.001674
K_3797 X_NUC_25.L_CORE X_NUC_162.L_CORE 0.001964
K_3798 X_NUC_25.L_CORE X_NUC_163.L_CORE 0.002008
K_3799 X_NUC_25.L_CORE X_NUC_164.L_CORE 0.001684
K_3800 X_NUC_25.L_CORE X_NUC_165.L_CORE 0.001933
K_3801 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_3802 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_3803 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.002233
K_3804 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.002248
K_3805 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.002230
K_3806 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.002249
K_3807 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.002975
K_3808 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.003015
K_3809 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.002999
K_3810 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.002984
K_3811 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.004404
K_3812 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.004388
K_3813 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.004337
K_3814 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.004425
K_3815 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.001955
K_3816 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.001971
K_3817 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.001957
K_3818 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.001965
K_3819 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.005693
K_3820 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.005760
K_3821 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.005728
K_3822 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.005613
K_3823 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.002351
K_3824 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.002360
K_3825 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.002339
K_3826 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.002363
K_3827 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.002144
K_3828 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.002166
K_3829 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.002152
K_3830 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.002150
K_3831 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.005704
K_3832 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.005632
K_3833 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.005554
K_3834 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.005609
K_3835 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.001847
K_3836 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.001859
K_3837 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.001844
K_3838 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.001855
K_3839 X_NUC_26.L_CORE X_NUC_65.L_CORE 0.002946
K_3840 X_NUC_26.L_CORE X_NUC_66.L_CORE 0.002975
K_3841 X_NUC_26.L_CORE X_NUC_67.L_CORE 0.002955
K_3842 X_NUC_26.L_CORE X_NUC_68.L_CORE 0.002934
K_3843 X_NUC_26.L_CORE X_NUC_69.L_CORE 0.002710
K_3844 X_NUC_26.L_CORE X_NUC_70.L_CORE 0.002709
K_3845 X_NUC_26.L_CORE X_NUC_71.L_CORE 0.002682
K_3846 X_NUC_26.L_CORE X_NUC_72.L_CORE 0.002711
K_3847 X_NUC_26.L_CORE X_NUC_73.L_CORE 0.001813
K_3848 X_NUC_26.L_CORE X_NUC_74.L_CORE 0.001827
K_3849 X_NUC_26.L_CORE X_NUC_75.L_CORE 0.001814
K_3850 X_NUC_26.L_CORE X_NUC_76.L_CORE 0.001817
K_3851 X_NUC_26.L_CORE X_NUC_77.L_CORE 0.004118
K_3852 X_NUC_26.L_CORE X_NUC_78.L_CORE 0.004116
K_3853 X_NUC_26.L_CORE X_NUC_79.L_CORE 0.004076
K_3854 X_NUC_26.L_CORE X_NUC_80.L_CORE 0.004051
K_3855 X_NUC_26.L_CORE X_NUC_81.L_CORE 0.001912
K_3856 X_NUC_26.L_CORE X_NUC_82.L_CORE 0.001920
K_3857 X_NUC_26.L_CORE X_NUC_83.L_CORE 0.001904
K_3858 X_NUC_26.L_CORE X_NUC_84.L_CORE 0.001917
K_3859 X_NUC_26.L_CORE X_NUC_85.L_CORE 0.002122
K_3860 X_NUC_26.L_CORE X_NUC_86.L_CORE 0.002140
K_3861 X_NUC_26.L_CORE X_NUC_87.L_CORE 0.002125
K_3862 X_NUC_26.L_CORE X_NUC_88.L_CORE 0.002120
K_3863 X_NUC_26.L_CORE X_NUC_89.L_CORE 0.003003
K_3864 X_NUC_26.L_CORE X_NUC_90.L_CORE 0.002995
K_3865 X_NUC_26.L_CORE X_NUC_91.L_CORE 0.002963
K_3866 X_NUC_26.L_CORE X_NUC_92.L_CORE 0.002984
K_3867 X_NUC_26.L_CORE X_NUC_93.L_CORE 0.001712
K_3868 X_NUC_26.L_CORE X_NUC_94.L_CORE 0.001722
K_3869 X_NUC_26.L_CORE X_NUC_95.L_CORE 0.001709
K_3870 X_NUC_26.L_CORE X_NUC_96.L_CORE 0.001715
K_3871 X_NUC_26.L_CORE X_NUC_97.L_CORE 0.002693
K_3872 X_NUC_26.L_CORE X_NUC_98.L_CORE 0.002706
K_3873 X_NUC_26.L_CORE X_NUC_99.L_CORE 0.002685
K_3874 X_NUC_26.L_CORE X_NUC_100.L_CORE 0.002673
K_3875 X_NUC_26.L_CORE X_NUC_101.L_CORE 0.002072
K_3876 X_NUC_26.L_CORE X_NUC_102.L_CORE 0.002076
K_3877 X_NUC_26.L_CORE X_NUC_103.L_CORE 0.002056
K_3878 X_NUC_26.L_CORE X_NUC_104.L_CORE 0.002071
K_3879 X_NUC_26.L_CORE X_NUC_105.L_CORE 0.001807
K_3880 X_NUC_26.L_CORE X_NUC_106.L_CORE 0.001819
K_3881 X_NUC_26.L_CORE X_NUC_107.L_CORE 0.001805
K_3882 X_NUC_26.L_CORE X_NUC_108.L_CORE 0.001806
K_3883 X_NUC_26.L_CORE X_NUC_109.L_CORE 0.002680
K_3884 X_NUC_26.L_CORE X_NUC_110.L_CORE 0.002680
K_3885 X_NUC_26.L_CORE X_NUC_111.L_CORE 0.002655
K_3886 X_NUC_26.L_CORE X_NUC_112.L_CORE 0.002658
K_3887 X_NUC_26.L_CORE X_NUC_113.L_CORE 0.001755
K_3888 X_NUC_26.L_CORE X_NUC_114.L_CORE 0.001762
K_3889 X_NUC_26.L_CORE X_NUC_115.L_CORE 0.001747
K_3890 X_NUC_26.L_CORE X_NUC_116.L_CORE 0.001755
K_3891 X_NUC_26.L_CORE X_NUC_117.L_CORE 0.002058
K_3892 X_NUC_26.L_CORE X_NUC_118.L_CORE 0.002069
K_3893 X_NUC_26.L_CORE X_NUC_119.L_CORE 0.002053
K_3894 X_NUC_26.L_CORE X_NUC_120.L_CORE 0.002050
K_3895 X_NUC_26.L_CORE X_NUC_121.L_CORE 0.002117
K_3896 X_NUC_26.L_CORE X_NUC_122.L_CORE 0.002120
K_3897 X_NUC_26.L_CORE X_NUC_123.L_CORE 0.002100
K_3898 X_NUC_26.L_CORE X_NUC_124.L_CORE 0.002109
K_3899 X_NUC_26.L_CORE X_NUC_125.L_CORE 0.001764
K_3900 X_NUC_26.L_CORE X_NUC_126.L_CORE 0.001773
K_3901 X_NUC_26.L_CORE X_NUC_127.L_CORE 0.001758
K_3902 X_NUC_26.L_CORE X_NUC_128.L_CORE 0.001762
K_3903 X_NUC_26.L_CORE X_NUC_129.L_CORE 0.002032
K_3904 X_NUC_26.L_CORE X_NUC_130.L_CORE 0.002039
K_3905 X_NUC_26.L_CORE X_NUC_131.L_CORE 0.002021
K_3906 X_NUC_26.L_CORE X_NUC_132.L_CORE 0.002023
K_3907 X_NUC_26.L_CORE X_NUC_133.L_CORE 0.003354
K_3908 X_NUC_26.L_CORE X_NUC_134.L_CORE 0.005523
K_3909 X_NUC_26.L_CORE X_NUC_135.L_CORE 0.002413
K_3910 X_NUC_26.L_CORE X_NUC_136.L_CORE 0.004778
K_3911 X_NUC_26.L_CORE X_NUC_137.L_CORE 0.003203
K_3912 X_NUC_26.L_CORE X_NUC_138.L_CORE 0.002250
K_3913 X_NUC_26.L_CORE X_NUC_139.L_CORE 0.035793
K_3914 X_NUC_26.L_CORE X_NUC_140.L_CORE 0.002127
K_3915 X_NUC_26.L_CORE X_NUC_141.L_CORE 0.002839
K_3916 X_NUC_26.L_CORE X_NUC_142.L_CORE 0.004147
K_3917 X_NUC_26.L_CORE X_NUC_143.L_CORE 0.001864
K_3918 X_NUC_26.L_CORE X_NUC_144.L_CORE 0.005361
K_3919 X_NUC_26.L_CORE X_NUC_145.L_CORE 0.002234
K_3920 X_NUC_26.L_CORE X_NUC_146.L_CORE 0.002045
K_3921 X_NUC_26.L_CORE X_NUC_147.L_CORE 0.005293
K_3922 X_NUC_26.L_CORE X_NUC_148.L_CORE 0.001759
K_3923 X_NUC_26.L_CORE X_NUC_149.L_CORE 0.002800
K_3924 X_NUC_26.L_CORE X_NUC_150.L_CORE 0.002565
K_3925 X_NUC_26.L_CORE X_NUC_151.L_CORE 0.001728
K_3926 X_NUC_26.L_CORE X_NUC_152.L_CORE 0.003869
K_3927 X_NUC_26.L_CORE X_NUC_153.L_CORE 0.001818
K_3928 X_NUC_26.L_CORE X_NUC_154.L_CORE 0.002020
K_3929 X_NUC_26.L_CORE X_NUC_155.L_CORE 0.002832
K_3930 X_NUC_26.L_CORE X_NUC_156.L_CORE 0.001630
K_3931 X_NUC_26.L_CORE X_NUC_157.L_CORE 0.002552
K_3932 X_NUC_26.L_CORE X_NUC_158.L_CORE 0.001965
K_3933 X_NUC_26.L_CORE X_NUC_159.L_CORE 0.001719
K_3934 X_NUC_26.L_CORE X_NUC_160.L_CORE 0.002532
K_3935 X_NUC_26.L_CORE X_NUC_161.L_CORE 0.001668
K_3936 X_NUC_26.L_CORE X_NUC_162.L_CORE 0.001955
K_3937 X_NUC_26.L_CORE X_NUC_163.L_CORE 0.002006
K_3938 X_NUC_26.L_CORE X_NUC_164.L_CORE 0.001677
K_3939 X_NUC_26.L_CORE X_NUC_165.L_CORE 0.001927
K_3940 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_3941 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.002250
K_3942 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.002265
K_3943 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.002248
K_3944 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.002267
K_3945 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.002990
K_3946 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.003031
K_3947 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.003015
K_3948 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.002999
K_3949 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.004457
K_3950 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.004438
K_3951 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.004388
K_3952 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.004478
K_3953 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.001969
K_3954 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.001985
K_3955 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.001971
K_3956 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.001979
K_3957 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.005723
K_3958 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.005789
K_3959 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.005760
K_3960 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.005642
K_3961 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.002373
K_3962 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.002381
K_3963 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.002360
K_3964 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.002384
K_3965 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.002158
K_3966 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.002180
K_3967 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.002166
K_3968 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.002164
K_3969 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.005787
K_3970 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.005710
K_3971 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.005632
K_3972 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.005688
K_3973 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.001862
K_3974 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.001874
K_3975 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.001859
K_3976 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.001870
K_3977 X_NUC_27.L_CORE X_NUC_65.L_CORE 0.002965
K_3978 X_NUC_27.L_CORE X_NUC_66.L_CORE 0.002994
K_3979 X_NUC_27.L_CORE X_NUC_67.L_CORE 0.002975
K_3980 X_NUC_27.L_CORE X_NUC_68.L_CORE 0.002952
K_3981 X_NUC_27.L_CORE X_NUC_69.L_CORE 0.002738
K_3982 X_NUC_27.L_CORE X_NUC_70.L_CORE 0.002737
K_3983 X_NUC_27.L_CORE X_NUC_71.L_CORE 0.002709
K_3984 X_NUC_27.L_CORE X_NUC_72.L_CORE 0.002739
K_3985 X_NUC_27.L_CORE X_NUC_73.L_CORE 0.001826
K_3986 X_NUC_27.L_CORE X_NUC_74.L_CORE 0.001841
K_3987 X_NUC_27.L_CORE X_NUC_75.L_CORE 0.001827
K_3988 X_NUC_27.L_CORE X_NUC_76.L_CORE 0.001831
K_3989 X_NUC_27.L_CORE X_NUC_77.L_CORE 0.004159
K_3990 X_NUC_27.L_CORE X_NUC_78.L_CORE 0.004155
K_3991 X_NUC_27.L_CORE X_NUC_79.L_CORE 0.004116
K_3992 X_NUC_27.L_CORE X_NUC_80.L_CORE 0.004089
K_3993 X_NUC_27.L_CORE X_NUC_81.L_CORE 0.001929
K_3994 X_NUC_27.L_CORE X_NUC_82.L_CORE 0.001937
K_3995 X_NUC_27.L_CORE X_NUC_83.L_CORE 0.001920
K_3996 X_NUC_27.L_CORE X_NUC_84.L_CORE 0.001934
K_3997 X_NUC_27.L_CORE X_NUC_85.L_CORE 0.002137
K_3998 X_NUC_27.L_CORE X_NUC_86.L_CORE 0.002155
K_3999 X_NUC_27.L_CORE X_NUC_87.L_CORE 0.002140
K_4000 X_NUC_27.L_CORE X_NUC_88.L_CORE 0.002135
K_4001 X_NUC_27.L_CORE X_NUC_89.L_CORE 0.003036
K_4002 X_NUC_27.L_CORE X_NUC_90.L_CORE 0.003027
K_4003 X_NUC_27.L_CORE X_NUC_91.L_CORE 0.002995
K_4004 X_NUC_27.L_CORE X_NUC_92.L_CORE 0.003016
K_4005 X_NUC_27.L_CORE X_NUC_93.L_CORE 0.001726
K_4006 X_NUC_27.L_CORE X_NUC_94.L_CORE 0.001736
K_4007 X_NUC_27.L_CORE X_NUC_95.L_CORE 0.001722
K_4008 X_NUC_27.L_CORE X_NUC_96.L_CORE 0.001729
K_4009 X_NUC_27.L_CORE X_NUC_97.L_CORE 0.002715
K_4010 X_NUC_27.L_CORE X_NUC_98.L_CORE 0.002728
K_4011 X_NUC_27.L_CORE X_NUC_99.L_CORE 0.002706
K_4012 X_NUC_27.L_CORE X_NUC_100.L_CORE 0.002694
K_4013 X_NUC_27.L_CORE X_NUC_101.L_CORE 0.002091
K_4014 X_NUC_27.L_CORE X_NUC_102.L_CORE 0.002095
K_4015 X_NUC_27.L_CORE X_NUC_103.L_CORE 0.002076
K_4016 X_NUC_27.L_CORE X_NUC_104.L_CORE 0.002090
K_4017 X_NUC_27.L_CORE X_NUC_105.L_CORE 0.001821
K_4018 X_NUC_27.L_CORE X_NUC_106.L_CORE 0.001833
K_4019 X_NUC_27.L_CORE X_NUC_107.L_CORE 0.001819
K_4020 X_NUC_27.L_CORE X_NUC_108.L_CORE 0.001820
K_4021 X_NUC_27.L_CORE X_NUC_109.L_CORE 0.002706
K_4022 X_NUC_27.L_CORE X_NUC_110.L_CORE 0.002706
K_4023 X_NUC_27.L_CORE X_NUC_111.L_CORE 0.002680
K_4024 X_NUC_27.L_CORE X_NUC_112.L_CORE 0.002683
K_4025 X_NUC_27.L_CORE X_NUC_113.L_CORE 0.001769
K_4026 X_NUC_27.L_CORE X_NUC_114.L_CORE 0.001777
K_4027 X_NUC_27.L_CORE X_NUC_115.L_CORE 0.001762
K_4028 X_NUC_27.L_CORE X_NUC_116.L_CORE 0.001770
K_4029 X_NUC_27.L_CORE X_NUC_117.L_CORE 0.002075
K_4030 X_NUC_27.L_CORE X_NUC_118.L_CORE 0.002086
K_4031 X_NUC_27.L_CORE X_NUC_119.L_CORE 0.002069
K_4032 X_NUC_27.L_CORE X_NUC_120.L_CORE 0.002067
K_4033 X_NUC_27.L_CORE X_NUC_121.L_CORE 0.002137
K_4034 X_NUC_27.L_CORE X_NUC_122.L_CORE 0.002140
K_4035 X_NUC_27.L_CORE X_NUC_123.L_CORE 0.002120
K_4036 X_NUC_27.L_CORE X_NUC_124.L_CORE 0.002129
K_4037 X_NUC_27.L_CORE X_NUC_125.L_CORE 0.001779
K_4038 X_NUC_27.L_CORE X_NUC_126.L_CORE 0.001787
K_4039 X_NUC_27.L_CORE X_NUC_127.L_CORE 0.001773
K_4040 X_NUC_27.L_CORE X_NUC_128.L_CORE 0.001776
K_4041 X_NUC_27.L_CORE X_NUC_129.L_CORE 0.002050
K_4042 X_NUC_27.L_CORE X_NUC_130.L_CORE 0.002056
K_4043 X_NUC_27.L_CORE X_NUC_131.L_CORE 0.002039
K_4044 X_NUC_27.L_CORE X_NUC_132.L_CORE 0.002041
K_4045 X_NUC_27.L_CORE X_NUC_133.L_CORE 0.003366
K_4046 X_NUC_27.L_CORE X_NUC_134.L_CORE 0.005532
K_4047 X_NUC_27.L_CORE X_NUC_135.L_CORE 0.002427
K_4048 X_NUC_27.L_CORE X_NUC_136.L_CORE 0.004774
K_4049 X_NUC_27.L_CORE X_NUC_137.L_CORE 0.003226
K_4050 X_NUC_27.L_CORE X_NUC_138.L_CORE 0.002262
K_4051 X_NUC_27.L_CORE X_NUC_139.L_CORE 0.030621
K_4052 X_NUC_27.L_CORE X_NUC_140.L_CORE 0.002143
K_4053 X_NUC_27.L_CORE X_NUC_141.L_CORE 0.002850
K_4054 X_NUC_27.L_CORE X_NUC_142.L_CORE 0.004185
K_4055 X_NUC_27.L_CORE X_NUC_143.L_CORE 0.001877
K_4056 X_NUC_27.L_CORE X_NUC_144.L_CORE 0.005366
K_4057 X_NUC_27.L_CORE X_NUC_145.L_CORE 0.002253
K_4058 X_NUC_27.L_CORE X_NUC_146.L_CORE 0.002057
K_4059 X_NUC_27.L_CORE X_NUC_147.L_CORE 0.005344
K_4060 X_NUC_27.L_CORE X_NUC_148.L_CORE 0.001772
K_4061 X_NUC_27.L_CORE X_NUC_149.L_CORE 0.002815
K_4062 X_NUC_27.L_CORE X_NUC_150.L_CORE 0.002589
K_4063 X_NUC_27.L_CORE X_NUC_151.L_CORE 0.001739
K_4064 X_NUC_27.L_CORE X_NUC_152.L_CORE 0.003897
K_4065 X_NUC_27.L_CORE X_NUC_153.L_CORE 0.001833
K_4066 X_NUC_27.L_CORE X_NUC_154.L_CORE 0.002033
K_4067 X_NUC_27.L_CORE X_NUC_155.L_CORE 0.002860
K_4068 X_NUC_27.L_CORE X_NUC_156.L_CORE 0.001642
K_4069 X_NUC_27.L_CORE X_NUC_157.L_CORE 0.002570
K_4070 X_NUC_27.L_CORE X_NUC_158.L_CORE 0.001982
K_4071 X_NUC_27.L_CORE X_NUC_159.L_CORE 0.001732
K_4072 X_NUC_27.L_CORE X_NUC_160.L_CORE 0.002554
K_4073 X_NUC_27.L_CORE X_NUC_161.L_CORE 0.001681
K_4074 X_NUC_27.L_CORE X_NUC_162.L_CORE 0.001969
K_4075 X_NUC_27.L_CORE X_NUC_163.L_CORE 0.002023
K_4076 X_NUC_27.L_CORE X_NUC_164.L_CORE 0.001690
K_4077 X_NUC_27.L_CORE X_NUC_165.L_CORE 0.001943
K_4078 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.002231
K_4079 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.002246
K_4080 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.002229
K_4081 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.002248
K_4082 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.003005
K_4083 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.003046
K_4084 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.003030
K_4085 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.003015
K_4086 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.004367
K_4087 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.004350
K_4088 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.004301
K_4089 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.004388
K_4090 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.001961
K_4091 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.001978
K_4092 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.001964
K_4093 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.001971
K_4094 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.005844
K_4095 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.005915
K_4096 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.005882
K_4097 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.005760
K_4098 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.002348
K_4099 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.002356
K_4100 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.002335
K_4101 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.002360
K_4102 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.002160
K_4103 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.002182
K_4104 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.002168
K_4105 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.002166
K_4106 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.005726
K_4107 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.005652
K_4108 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.005574
K_4109 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.005632
K_4110 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.001851
K_4111 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.001863
K_4112 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.001848
K_4113 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.001859
K_4114 X_NUC_28.L_CORE X_NUC_65.L_CORE 0.002987
K_4115 X_NUC_28.L_CORE X_NUC_66.L_CORE 0.003016
K_4116 X_NUC_28.L_CORE X_NUC_67.L_CORE 0.002997
K_4117 X_NUC_28.L_CORE X_NUC_68.L_CORE 0.002975
K_4118 X_NUC_28.L_CORE X_NUC_69.L_CORE 0.002708
K_4119 X_NUC_28.L_CORE X_NUC_70.L_CORE 0.002706
K_4120 X_NUC_28.L_CORE X_NUC_71.L_CORE 0.002679
K_4121 X_NUC_28.L_CORE X_NUC_72.L_CORE 0.002709
K_4122 X_NUC_28.L_CORE X_NUC_73.L_CORE 0.001823
K_4123 X_NUC_28.L_CORE X_NUC_74.L_CORE 0.001837
K_4124 X_NUC_28.L_CORE X_NUC_75.L_CORE 0.001824
K_4125 X_NUC_28.L_CORE X_NUC_76.L_CORE 0.001827
K_4126 X_NUC_28.L_CORE X_NUC_77.L_CORE 0.004186
K_4127 X_NUC_28.L_CORE X_NUC_78.L_CORE 0.004182
K_4128 X_NUC_28.L_CORE X_NUC_79.L_CORE 0.004141
K_4129 X_NUC_28.L_CORE X_NUC_80.L_CORE 0.004116
K_4130 X_NUC_28.L_CORE X_NUC_81.L_CORE 0.001915
K_4131 X_NUC_28.L_CORE X_NUC_82.L_CORE 0.001923
K_4132 X_NUC_28.L_CORE X_NUC_83.L_CORE 0.001907
K_4133 X_NUC_28.L_CORE X_NUC_84.L_CORE 0.001920
K_4134 X_NUC_28.L_CORE X_NUC_85.L_CORE 0.002142
K_4135 X_NUC_28.L_CORE X_NUC_86.L_CORE 0.002160
K_4136 X_NUC_28.L_CORE X_NUC_87.L_CORE 0.002145
K_4137 X_NUC_28.L_CORE X_NUC_88.L_CORE 0.002140
K_4138 X_NUC_28.L_CORE X_NUC_89.L_CORE 0.003015
K_4139 X_NUC_28.L_CORE X_NUC_90.L_CORE 0.003006
K_4140 X_NUC_28.L_CORE X_NUC_91.L_CORE 0.002974
K_4141 X_NUC_28.L_CORE X_NUC_92.L_CORE 0.002995
K_4142 X_NUC_28.L_CORE X_NUC_93.L_CORE 0.001719
K_4143 X_NUC_28.L_CORE X_NUC_94.L_CORE 0.001730
K_4144 X_NUC_28.L_CORE X_NUC_95.L_CORE 0.001716
K_4145 X_NUC_28.L_CORE X_NUC_96.L_CORE 0.001722
K_4146 X_NUC_28.L_CORE X_NUC_97.L_CORE 0.002728
K_4147 X_NUC_28.L_CORE X_NUC_98.L_CORE 0.002741
K_4148 X_NUC_28.L_CORE X_NUC_99.L_CORE 0.002719
K_4149 X_NUC_28.L_CORE X_NUC_100.L_CORE 0.002706
K_4150 X_NUC_28.L_CORE X_NUC_101.L_CORE 0.002077
K_4151 X_NUC_28.L_CORE X_NUC_102.L_CORE 0.002081
K_4152 X_NUC_28.L_CORE X_NUC_103.L_CORE 0.002061
K_4153 X_NUC_28.L_CORE X_NUC_104.L_CORE 0.002076
K_4154 X_NUC_28.L_CORE X_NUC_105.L_CORE 0.001820
K_4155 X_NUC_28.L_CORE X_NUC_106.L_CORE 0.001832
K_4156 X_NUC_28.L_CORE X_NUC_107.L_CORE 0.001818
K_4157 X_NUC_28.L_CORE X_NUC_108.L_CORE 0.001819
K_4158 X_NUC_28.L_CORE X_NUC_109.L_CORE 0.002703
K_4159 X_NUC_28.L_CORE X_NUC_110.L_CORE 0.002703
K_4160 X_NUC_28.L_CORE X_NUC_111.L_CORE 0.002677
K_4161 X_NUC_28.L_CORE X_NUC_112.L_CORE 0.002680
K_4162 X_NUC_28.L_CORE X_NUC_113.L_CORE 0.001762
K_4163 X_NUC_28.L_CORE X_NUC_114.L_CORE 0.001769
K_4164 X_NUC_28.L_CORE X_NUC_115.L_CORE 0.001754
K_4165 X_NUC_28.L_CORE X_NUC_116.L_CORE 0.001762
K_4166 X_NUC_28.L_CORE X_NUC_117.L_CORE 0.002077
K_4167 X_NUC_28.L_CORE X_NUC_118.L_CORE 0.002088
K_4168 X_NUC_28.L_CORE X_NUC_119.L_CORE 0.002071
K_4169 X_NUC_28.L_CORE X_NUC_120.L_CORE 0.002069
K_4170 X_NUC_28.L_CORE X_NUC_121.L_CORE 0.002128
K_4171 X_NUC_28.L_CORE X_NUC_122.L_CORE 0.002131
K_4172 X_NUC_28.L_CORE X_NUC_123.L_CORE 0.002111
K_4173 X_NUC_28.L_CORE X_NUC_124.L_CORE 0.002120
K_4174 X_NUC_28.L_CORE X_NUC_125.L_CORE 0.001775
K_4175 X_NUC_28.L_CORE X_NUC_126.L_CORE 0.001783
K_4176 X_NUC_28.L_CORE X_NUC_127.L_CORE 0.001769
K_4177 X_NUC_28.L_CORE X_NUC_128.L_CORE 0.001773
K_4178 X_NUC_28.L_CORE X_NUC_129.L_CORE 0.002047
K_4179 X_NUC_28.L_CORE X_NUC_130.L_CORE 0.002054
K_4180 X_NUC_28.L_CORE X_NUC_131.L_CORE 0.002036
K_4181 X_NUC_28.L_CORE X_NUC_132.L_CORE 0.002039
K_4182 X_NUC_28.L_CORE X_NUC_133.L_CORE 0.003355
K_4183 X_NUC_28.L_CORE X_NUC_134.L_CORE 0.005436
K_4184 X_NUC_28.L_CORE X_NUC_135.L_CORE 0.002412
K_4185 X_NUC_28.L_CORE X_NUC_136.L_CORE 0.004817
K_4186 X_NUC_28.L_CORE X_NUC_137.L_CORE 0.003179
K_4187 X_NUC_28.L_CORE X_NUC_138.L_CORE 0.002259
K_4188 X_NUC_28.L_CORE X_NUC_139.L_CORE 0.032450
K_4189 X_NUC_28.L_CORE X_NUC_140.L_CORE 0.002125
K_4190 X_NUC_28.L_CORE X_NUC_141.L_CORE 0.002866
K_4191 X_NUC_28.L_CORE X_NUC_142.L_CORE 0.004107
K_4192 X_NUC_28.L_CORE X_NUC_143.L_CORE 0.001870
K_4193 X_NUC_28.L_CORE X_NUC_144.L_CORE 0.005487
K_4194 X_NUC_28.L_CORE X_NUC_145.L_CORE 0.002230
K_4195 X_NUC_28.L_CORE X_NUC_146.L_CORE 0.002059
K_4196 X_NUC_28.L_CORE X_NUC_147.L_CORE 0.005300
K_4197 X_NUC_28.L_CORE X_NUC_148.L_CORE 0.001763
K_4198 X_NUC_28.L_CORE X_NUC_149.L_CORE 0.002837
K_4199 X_NUC_28.L_CORE X_NUC_150.L_CORE 0.002561
K_4200 X_NUC_28.L_CORE X_NUC_151.L_CORE 0.001736
K_4201 X_NUC_28.L_CORE X_NUC_152.L_CORE 0.003925
K_4202 X_NUC_28.L_CORE X_NUC_153.L_CORE 0.001820
K_4203 X_NUC_28.L_CORE X_NUC_154.L_CORE 0.002038
K_4204 X_NUC_28.L_CORE X_NUC_155.L_CORE 0.002841
K_4205 X_NUC_28.L_CORE X_NUC_156.L_CORE 0.001636
K_4206 X_NUC_28.L_CORE X_NUC_157.L_CORE 0.002583
K_4207 X_NUC_28.L_CORE X_NUC_158.L_CORE 0.001969
K_4208 X_NUC_28.L_CORE X_NUC_159.L_CORE 0.001731
K_4209 X_NUC_28.L_CORE X_NUC_160.L_CORE 0.002552
K_4210 X_NUC_28.L_CORE X_NUC_161.L_CORE 0.001674
K_4211 X_NUC_28.L_CORE X_NUC_162.L_CORE 0.001972
K_4212 X_NUC_28.L_CORE X_NUC_163.L_CORE 0.002015
K_4213 X_NUC_28.L_CORE X_NUC_164.L_CORE 0.001686
K_4214 X_NUC_28.L_CORE X_NUC_165.L_CORE 0.001941
K_4215 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_4216 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_4217 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_4218 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.002144
K_4219 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.002145
K_4220 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.002155
K_4221 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.002133
K_4222 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.002890
K_4223 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.002854
K_4224 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.002876
K_4225 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.002861
K_4226 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.004238
K_4227 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.004305
K_4228 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.004283
K_4229 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.004231
K_4230 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.001902
K_4231 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.001895
K_4232 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.001905
K_4233 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.001889
K_4234 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.005682
K_4235 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.005555
K_4236 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.005547
K_4237 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.005580
K_4238 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.002294
K_4239 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.002303
K_4240 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.002305
K_4241 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.002283
K_4242 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.002110
K_4243 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.002094
K_4244 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.002104
K_4245 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.002092
K_4246 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.005691
K_4247 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.005783
K_4248 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.005648
K_4249 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.005646
K_4250 X_NUC_29.L_CORE X_NUC_65.L_CORE 0.001818
K_4251 X_NUC_29.L_CORE X_NUC_66.L_CORE 0.001816
K_4252 X_NUC_29.L_CORE X_NUC_67.L_CORE 0.001821
K_4253 X_NUC_29.L_CORE X_NUC_68.L_CORE 0.001806
K_4254 X_NUC_29.L_CORE X_NUC_69.L_CORE 0.002940
K_4255 X_NUC_29.L_CORE X_NUC_70.L_CORE 0.002905
K_4256 X_NUC_29.L_CORE X_NUC_71.L_CORE 0.002910
K_4257 X_NUC_29.L_CORE X_NUC_72.L_CORE 0.002905
K_4258 X_NUC_29.L_CORE X_NUC_73.L_CORE 0.002679
K_4259 X_NUC_29.L_CORE X_NUC_74.L_CORE 0.002699
K_4260 X_NUC_29.L_CORE X_NUC_75.L_CORE 0.002687
K_4261 X_NUC_29.L_CORE X_NUC_76.L_CORE 0.002665
K_4262 X_NUC_29.L_CORE X_NUC_77.L_CORE 0.001799
K_4263 X_NUC_29.L_CORE X_NUC_78.L_CORE 0.001791
K_4264 X_NUC_29.L_CORE X_NUC_79.L_CORE 0.001797
K_4265 X_NUC_29.L_CORE X_NUC_80.L_CORE 0.001785
K_4266 X_NUC_29.L_CORE X_NUC_81.L_CORE 0.004165
K_4267 X_NUC_29.L_CORE X_NUC_82.L_CORE 0.004148
K_4268 X_NUC_29.L_CORE X_NUC_83.L_CORE 0.004093
K_4269 X_NUC_29.L_CORE X_NUC_84.L_CORE 0.004109
K_4270 X_NUC_29.L_CORE X_NUC_85.L_CORE 0.001900
K_4271 X_NUC_29.L_CORE X_NUC_86.L_CORE 0.001903
K_4272 X_NUC_29.L_CORE X_NUC_87.L_CORE 0.001903
K_4273 X_NUC_29.L_CORE X_NUC_88.L_CORE 0.001888
K_4274 X_NUC_29.L_CORE X_NUC_89.L_CORE 0.002125
K_4275 X_NUC_29.L_CORE X_NUC_90.L_CORE 0.002109
K_4276 X_NUC_29.L_CORE X_NUC_91.L_CORE 0.002113
K_4277 X_NUC_29.L_CORE X_NUC_92.L_CORE 0.002105
K_4278 X_NUC_29.L_CORE X_NUC_93.L_CORE 0.003001
K_4279 X_NUC_29.L_CORE X_NUC_94.L_CORE 0.003021
K_4280 X_NUC_29.L_CORE X_NUC_95.L_CORE 0.002991
K_4281 X_NUC_29.L_CORE X_NUC_96.L_CORE 0.002979
K_4282 X_NUC_29.L_CORE X_NUC_97.L_CORE 0.001714
K_4283 X_NUC_29.L_CORE X_NUC_98.L_CORE 0.001710
K_4284 X_NUC_29.L_CORE X_NUC_99.L_CORE 0.001713
K_4285 X_NUC_29.L_CORE X_NUC_100.L_CORE 0.001701
K_4286 X_NUC_29.L_CORE X_NUC_101.L_CORE 0.002708
K_4287 X_NUC_29.L_CORE X_NUC_102.L_CORE 0.002691
K_4288 X_NUC_29.L_CORE X_NUC_103.L_CORE 0.002679
K_4289 X_NUC_29.L_CORE X_NUC_104.L_CORE 0.002678
K_4290 X_NUC_29.L_CORE X_NUC_105.L_CORE 0.002076
K_4291 X_NUC_29.L_CORE X_NUC_106.L_CORE 0.002082
K_4292 X_NUC_29.L_CORE X_NUC_107.L_CORE 0.002075
K_4293 X_NUC_29.L_CORE X_NUC_108.L_CORE 0.002062
K_4294 X_NUC_29.L_CORE X_NUC_109.L_CORE 0.001823
K_4295 X_NUC_29.L_CORE X_NUC_110.L_CORE 0.001815
K_4296 X_NUC_29.L_CORE X_NUC_111.L_CORE 0.001817
K_4297 X_NUC_29.L_CORE X_NUC_112.L_CORE 0.001808
K_4298 X_NUC_29.L_CORE X_NUC_113.L_CORE 0.002664
K_4299 X_NUC_29.L_CORE X_NUC_114.L_CORE 0.002665
K_4300 X_NUC_29.L_CORE X_NUC_115.L_CORE 0.002643
K_4301 X_NUC_29.L_CORE X_NUC_116.L_CORE 0.002638
K_4302 X_NUC_29.L_CORE X_NUC_117.L_CORE 0.001779
K_4303 X_NUC_29.L_CORE X_NUC_118.L_CORE 0.001778
K_4304 X_NUC_29.L_CORE X_NUC_119.L_CORE 0.001777
K_4305 X_NUC_29.L_CORE X_NUC_120.L_CORE 0.001766
K_4306 X_NUC_29.L_CORE X_NUC_121.L_CORE 0.002073
K_4307 X_NUC_29.L_CORE X_NUC_122.L_CORE 0.002064
K_4308 X_NUC_29.L_CORE X_NUC_123.L_CORE 0.002059
K_4309 X_NUC_29.L_CORE X_NUC_124.L_CORE 0.002053
K_4310 X_NUC_29.L_CORE X_NUC_125.L_CORE 0.002106
K_4311 X_NUC_29.L_CORE X_NUC_126.L_CORE 0.002108
K_4312 X_NUC_29.L_CORE X_NUC_127.L_CORE 0.002098
K_4313 X_NUC_29.L_CORE X_NUC_128.L_CORE 0.002089
K_4314 X_NUC_29.L_CORE X_NUC_129.L_CORE 0.001844
K_4315 X_NUC_29.L_CORE X_NUC_130.L_CORE 0.001841
K_4316 X_NUC_29.L_CORE X_NUC_131.L_CORE 0.001838
K_4317 X_NUC_29.L_CORE X_NUC_132.L_CORE 0.001829
K_4318 X_NUC_29.L_CORE X_NUC_133.L_CORE 0.003057
K_4319 X_NUC_29.L_CORE X_NUC_134.L_CORE 0.002968
K_4320 X_NUC_29.L_CORE X_NUC_135.L_CORE 0.005682
K_4321 X_NUC_29.L_CORE X_NUC_136.L_CORE 0.002213
K_4322 X_NUC_29.L_CORE X_NUC_137.L_CORE 0.004501
K_4323 X_NUC_29.L_CORE X_NUC_138.L_CORE 0.003021
K_4324 X_NUC_29.L_CORE X_NUC_139.L_CORE 0.002127
K_4325 X_NUC_29.L_CORE X_NUC_140.L_CORE 0.034278
K_4326 X_NUC_29.L_CORE X_NUC_141.L_CORE 0.002037
K_4327 X_NUC_29.L_CORE X_NUC_142.L_CORE 0.002722
K_4328 X_NUC_29.L_CORE X_NUC_143.L_CORE 0.004029
K_4329 X_NUC_29.L_CORE X_NUC_144.L_CORE 0.001803
K_4330 X_NUC_29.L_CORE X_NUC_145.L_CORE 0.005257
K_4331 X_NUC_29.L_CORE X_NUC_146.L_CORE 0.002180
K_4332 X_NUC_29.L_CORE X_NUC_147.L_CORE 0.001995
K_4333 X_NUC_29.L_CORE X_NUC_148.L_CORE 0.005349
K_4334 X_NUC_29.L_CORE X_NUC_149.L_CORE 0.001725
K_4335 X_NUC_29.L_CORE X_NUC_150.L_CORE 0.002764
K_4336 X_NUC_29.L_CORE X_NUC_151.L_CORE 0.002545
K_4337 X_NUC_29.L_CORE X_NUC_152.L_CORE 0.001704
K_4338 X_NUC_29.L_CORE X_NUC_153.L_CORE 0.003903
K_4339 X_NUC_29.L_CORE X_NUC_154.L_CORE 0.001804
K_4340 X_NUC_29.L_CORE X_NUC_155.L_CORE 0.002007
K_4341 X_NUC_29.L_CORE X_NUC_156.L_CORE 0.002843
K_4342 X_NUC_29.L_CORE X_NUC_157.L_CORE 0.001625
K_4343 X_NUC_29.L_CORE X_NUC_158.L_CORE 0.002551
K_4344 X_NUC_29.L_CORE X_NUC_159.L_CORE 0.001970
K_4345 X_NUC_29.L_CORE X_NUC_160.L_CORE 0.001725
K_4346 X_NUC_29.L_CORE X_NUC_161.L_CORE 0.002517
K_4347 X_NUC_29.L_CORE X_NUC_162.L_CORE 0.001687
K_4348 X_NUC_29.L_CORE X_NUC_163.L_CORE 0.001959
K_4349 X_NUC_29.L_CORE X_NUC_164.L_CORE 0.001995
K_4350 X_NUC_29.L_CORE X_NUC_165.L_CORE 0.001746
K_4351 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_4352 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_4353 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.002142
K_4354 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.002144
K_4355 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.002153
K_4356 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.002131
K_4357 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.002927
K_4358 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.002890
K_4359 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.002913
K_4360 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.002898
K_4361 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.004172
K_4362 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.004238
K_4363 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.004216
K_4364 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.004166
K_4365 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.001909
K_4366 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.001902
K_4367 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.001912
K_4368 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.001896
K_4369 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.005814
K_4370 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.005682
K_4371 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.005671
K_4372 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.005707
K_4373 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.002284
K_4374 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.002294
K_4375 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.002296
K_4376 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.002273
K_4377 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.002126
K_4378 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.002110
K_4379 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.002121
K_4380 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.002108
K_4381 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.005599
K_4382 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.005691
K_4383 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.005560
K_4384 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.005558
K_4385 X_NUC_30.L_CORE X_NUC_65.L_CORE 0.001819
K_4386 X_NUC_30.L_CORE X_NUC_66.L_CORE 0.001818
K_4387 X_NUC_30.L_CORE X_NUC_67.L_CORE 0.001823
K_4388 X_NUC_30.L_CORE X_NUC_68.L_CORE 0.001808
K_4389 X_NUC_30.L_CORE X_NUC_69.L_CORE 0.002976
K_4390 X_NUC_30.L_CORE X_NUC_70.L_CORE 0.002940
K_4391 X_NUC_30.L_CORE X_NUC_71.L_CORE 0.002944
K_4392 X_NUC_30.L_CORE X_NUC_72.L_CORE 0.002940
K_4393 X_NUC_30.L_CORE X_NUC_73.L_CORE 0.002659
K_4394 X_NUC_30.L_CORE X_NUC_74.L_CORE 0.002679
K_4395 X_NUC_30.L_CORE X_NUC_75.L_CORE 0.002667
K_4396 X_NUC_30.L_CORE X_NUC_76.L_CORE 0.002646
K_4397 X_NUC_30.L_CORE X_NUC_77.L_CORE 0.001807
K_4398 X_NUC_30.L_CORE X_NUC_78.L_CORE 0.001799
K_4399 X_NUC_30.L_CORE X_NUC_79.L_CORE 0.001805
K_4400 X_NUC_30.L_CORE X_NUC_80.L_CORE 0.001793
K_4401 X_NUC_30.L_CORE X_NUC_81.L_CORE 0.004181
K_4402 X_NUC_30.L_CORE X_NUC_82.L_CORE 0.004165
K_4403 X_NUC_30.L_CORE X_NUC_83.L_CORE 0.004109
K_4404 X_NUC_30.L_CORE X_NUC_84.L_CORE 0.004125
K_4405 X_NUC_30.L_CORE X_NUC_85.L_CORE 0.001897
K_4406 X_NUC_30.L_CORE X_NUC_86.L_CORE 0.001900
K_4407 X_NUC_30.L_CORE X_NUC_87.L_CORE 0.001900
K_4408 X_NUC_30.L_CORE X_NUC_88.L_CORE 0.001885
K_4409 X_NUC_30.L_CORE X_NUC_89.L_CORE 0.002141
K_4410 X_NUC_30.L_CORE X_NUC_90.L_CORE 0.002125
K_4411 X_NUC_30.L_CORE X_NUC_91.L_CORE 0.002129
K_4412 X_NUC_30.L_CORE X_NUC_92.L_CORE 0.002120
K_4413 X_NUC_30.L_CORE X_NUC_93.L_CORE 0.002982
K_4414 X_NUC_30.L_CORE X_NUC_94.L_CORE 0.003001
K_4415 X_NUC_30.L_CORE X_NUC_95.L_CORE 0.002972
K_4416 X_NUC_30.L_CORE X_NUC_96.L_CORE 0.002960
K_4417 X_NUC_30.L_CORE X_NUC_97.L_CORE 0.001717
K_4418 X_NUC_30.L_CORE X_NUC_98.L_CORE 0.001714
K_4419 X_NUC_30.L_CORE X_NUC_99.L_CORE 0.001716
K_4420 X_NUC_30.L_CORE X_NUC_100.L_CORE 0.001705
K_4421 X_NUC_30.L_CORE X_NUC_101.L_CORE 0.002726
K_4422 X_NUC_30.L_CORE X_NUC_102.L_CORE 0.002708
K_4423 X_NUC_30.L_CORE X_NUC_103.L_CORE 0.002696
K_4424 X_NUC_30.L_CORE X_NUC_104.L_CORE 0.002695
K_4425 X_NUC_30.L_CORE X_NUC_105.L_CORE 0.002069
K_4426 X_NUC_30.L_CORE X_NUC_106.L_CORE 0.002076
K_4427 X_NUC_30.L_CORE X_NUC_107.L_CORE 0.002069
K_4428 X_NUC_30.L_CORE X_NUC_108.L_CORE 0.002056
K_4429 X_NUC_30.L_CORE X_NUC_109.L_CORE 0.001831
K_4430 X_NUC_30.L_CORE X_NUC_110.L_CORE 0.001823
K_4431 X_NUC_30.L_CORE X_NUC_111.L_CORE 0.001825
K_4432 X_NUC_30.L_CORE X_NUC_112.L_CORE 0.001816
K_4433 X_NUC_30.L_CORE X_NUC_113.L_CORE 0.002663
K_4434 X_NUC_30.L_CORE X_NUC_114.L_CORE 0.002664
K_4435 X_NUC_30.L_CORE X_NUC_115.L_CORE 0.002642
K_4436 X_NUC_30.L_CORE X_NUC_116.L_CORE 0.002637
K_4437 X_NUC_30.L_CORE X_NUC_117.L_CORE 0.001779
K_4438 X_NUC_30.L_CORE X_NUC_118.L_CORE 0.001779
K_4439 X_NUC_30.L_CORE X_NUC_119.L_CORE 0.001777
K_4440 X_NUC_30.L_CORE X_NUC_120.L_CORE 0.001766
K_4441 X_NUC_30.L_CORE X_NUC_121.L_CORE 0.002081
K_4442 X_NUC_30.L_CORE X_NUC_122.L_CORE 0.002073
K_4443 X_NUC_30.L_CORE X_NUC_123.L_CORE 0.002068
K_4444 X_NUC_30.L_CORE X_NUC_124.L_CORE 0.002061
K_4445 X_NUC_30.L_CORE X_NUC_125.L_CORE 0.002104
K_4446 X_NUC_30.L_CORE X_NUC_126.L_CORE 0.002106
K_4447 X_NUC_30.L_CORE X_NUC_127.L_CORE 0.002096
K_4448 X_NUC_30.L_CORE X_NUC_128.L_CORE 0.002087
K_4449 X_NUC_30.L_CORE X_NUC_129.L_CORE 0.001848
K_4450 X_NUC_30.L_CORE X_NUC_130.L_CORE 0.001844
K_4451 X_NUC_30.L_CORE X_NUC_131.L_CORE 0.001841
K_4452 X_NUC_30.L_CORE X_NUC_132.L_CORE 0.001832
K_4453 X_NUC_30.L_CORE X_NUC_133.L_CORE 0.003059
K_4454 X_NUC_30.L_CORE X_NUC_134.L_CORE 0.002994
K_4455 X_NUC_30.L_CORE X_NUC_135.L_CORE 0.005632
K_4456 X_NUC_30.L_CORE X_NUC_136.L_CORE 0.002218
K_4457 X_NUC_30.L_CORE X_NUC_137.L_CORE 0.004591
K_4458 X_NUC_30.L_CORE X_NUC_138.L_CORE 0.003000
K_4459 X_NUC_30.L_CORE X_NUC_139.L_CORE 0.002141
K_4460 X_NUC_30.L_CORE X_NUC_140.L_CORE 0.032871
K_4461 X_NUC_30.L_CORE X_NUC_141.L_CORE 0.002035
K_4462 X_NUC_30.L_CORE X_NUC_142.L_CORE 0.002756
K_4463 X_NUC_30.L_CORE X_NUC_143.L_CORE 0.003965
K_4464 X_NUC_30.L_CORE X_NUC_144.L_CORE 0.001809
K_4465 X_NUC_30.L_CORE X_NUC_145.L_CORE 0.005368
K_4466 X_NUC_30.L_CORE X_NUC_146.L_CORE 0.002171
K_4467 X_NUC_30.L_CORE X_NUC_147.L_CORE 0.002010
K_4468 X_NUC_30.L_CORE X_NUC_148.L_CORE 0.005261
K_4469 X_NUC_30.L_CORE X_NUC_149.L_CORE 0.001726
K_4470 X_NUC_30.L_CORE X_NUC_150.L_CORE 0.002797
K_4471 X_NUC_30.L_CORE X_NUC_151.L_CORE 0.002526
K_4472 X_NUC_30.L_CORE X_NUC_152.L_CORE 0.001711
K_4473 X_NUC_30.L_CORE X_NUC_153.L_CORE 0.003916
K_4474 X_NUC_30.L_CORE X_NUC_154.L_CORE 0.001801
K_4475 X_NUC_30.L_CORE X_NUC_155.L_CORE 0.002021
K_4476 X_NUC_30.L_CORE X_NUC_156.L_CORE 0.002824
K_4477 X_NUC_30.L_CORE X_NUC_157.L_CORE 0.001628
K_4478 X_NUC_30.L_CORE X_NUC_158.L_CORE 0.002567
K_4479 X_NUC_30.L_CORE X_NUC_159.L_CORE 0.001963
K_4480 X_NUC_30.L_CORE X_NUC_160.L_CORE 0.001733
K_4481 X_NUC_30.L_CORE X_NUC_161.L_CORE 0.002515
K_4482 X_NUC_30.L_CORE X_NUC_162.L_CORE 0.001687
K_4483 X_NUC_30.L_CORE X_NUC_163.L_CORE 0.001967
K_4484 X_NUC_30.L_CORE X_NUC_164.L_CORE 0.001993
K_4485 X_NUC_30.L_CORE X_NUC_165.L_CORE 0.001749
K_4486 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_4487 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.002133
K_4488 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.002134
K_4489 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.002144
K_4490 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.002122
K_4491 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.002904
K_4492 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.002867
K_4493 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.002890
K_4494 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.002875
K_4495 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.004192
K_4496 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.004258
K_4497 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.004238
K_4498 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.004186
K_4499 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.001899
K_4500 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.001892
K_4501 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.001902
K_4502 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.001886
K_4503 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.005822
K_4504 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.005688
K_4505 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.005682
K_4506 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.005716
K_4507 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.002282
K_4508 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.002292
K_4509 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.002294
K_4510 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.002271
K_4511 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.002116
K_4512 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.002099
K_4513 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.002110
K_4514 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.002097
K_4515 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.005731
K_4516 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.005827
K_4517 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.005691
K_4518 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.005686
K_4519 X_NUC_31.L_CORE X_NUC_65.L_CORE 0.001814
K_4520 X_NUC_31.L_CORE X_NUC_66.L_CORE 0.001813
K_4521 X_NUC_31.L_CORE X_NUC_67.L_CORE 0.001818
K_4522 X_NUC_31.L_CORE X_NUC_68.L_CORE 0.001803
K_4523 X_NUC_31.L_CORE X_NUC_69.L_CORE 0.002971
K_4524 X_NUC_31.L_CORE X_NUC_70.L_CORE 0.002935
K_4525 X_NUC_31.L_CORE X_NUC_71.L_CORE 0.002940
K_4526 X_NUC_31.L_CORE X_NUC_72.L_CORE 0.002936
K_4527 X_NUC_31.L_CORE X_NUC_73.L_CORE 0.002671
K_4528 X_NUC_31.L_CORE X_NUC_74.L_CORE 0.002691
K_4529 X_NUC_31.L_CORE X_NUC_75.L_CORE 0.002679
K_4530 X_NUC_31.L_CORE X_NUC_76.L_CORE 0.002658
K_4531 X_NUC_31.L_CORE X_NUC_77.L_CORE 0.001801
K_4532 X_NUC_31.L_CORE X_NUC_78.L_CORE 0.001793
K_4533 X_NUC_31.L_CORE X_NUC_79.L_CORE 0.001799
K_4534 X_NUC_31.L_CORE X_NUC_80.L_CORE 0.001787
K_4535 X_NUC_31.L_CORE X_NUC_81.L_CORE 0.004240
K_4536 X_NUC_31.L_CORE X_NUC_82.L_CORE 0.004222
K_4537 X_NUC_31.L_CORE X_NUC_83.L_CORE 0.004165
K_4538 X_NUC_31.L_CORE X_NUC_84.L_CORE 0.004181
K_4539 X_NUC_31.L_CORE X_NUC_85.L_CORE 0.001897
K_4540 X_NUC_31.L_CORE X_NUC_86.L_CORE 0.001900
K_4541 X_NUC_31.L_CORE X_NUC_87.L_CORE 0.001900
K_4542 X_NUC_31.L_CORE X_NUC_88.L_CORE 0.001885
K_4543 X_NUC_31.L_CORE X_NUC_89.L_CORE 0.002137
K_4544 X_NUC_31.L_CORE X_NUC_90.L_CORE 0.002122
K_4545 X_NUC_31.L_CORE X_NUC_91.L_CORE 0.002125
K_4546 X_NUC_31.L_CORE X_NUC_92.L_CORE 0.002117
K_4547 X_NUC_31.L_CORE X_NUC_93.L_CORE 0.003012
K_4548 X_NUC_31.L_CORE X_NUC_94.L_CORE 0.003031
K_4549 X_NUC_31.L_CORE X_NUC_95.L_CORE 0.003001
K_4550 X_NUC_31.L_CORE X_NUC_96.L_CORE 0.002989
K_4551 X_NUC_31.L_CORE X_NUC_97.L_CORE 0.001715
K_4552 X_NUC_31.L_CORE X_NUC_98.L_CORE 0.001711
K_4553 X_NUC_31.L_CORE X_NUC_99.L_CORE 0.001714
K_4554 X_NUC_31.L_CORE X_NUC_100.L_CORE 0.001702
K_4555 X_NUC_31.L_CORE X_NUC_101.L_CORE 0.002738
K_4556 X_NUC_31.L_CORE X_NUC_102.L_CORE 0.002720
K_4557 X_NUC_31.L_CORE X_NUC_103.L_CORE 0.002708
K_4558 X_NUC_31.L_CORE X_NUC_104.L_CORE 0.002707
K_4559 X_NUC_31.L_CORE X_NUC_105.L_CORE 0.002076
K_4560 X_NUC_31.L_CORE X_NUC_106.L_CORE 0.002082
K_4561 X_NUC_31.L_CORE X_NUC_107.L_CORE 0.002076
K_4562 X_NUC_31.L_CORE X_NUC_108.L_CORE 0.002062
K_4563 X_NUC_31.L_CORE X_NUC_109.L_CORE 0.001830
K_4564 X_NUC_31.L_CORE X_NUC_110.L_CORE 0.001822
K_4565 X_NUC_31.L_CORE X_NUC_111.L_CORE 0.001823
K_4566 X_NUC_31.L_CORE X_NUC_112.L_CORE 0.001814
K_4567 X_NUC_31.L_CORE X_NUC_113.L_CORE 0.002685
K_4568 X_NUC_31.L_CORE X_NUC_114.L_CORE 0.002686
K_4569 X_NUC_31.L_CORE X_NUC_115.L_CORE 0.002664
K_4570 X_NUC_31.L_CORE X_NUC_116.L_CORE 0.002659
K_4571 X_NUC_31.L_CORE X_NUC_117.L_CORE 0.001781
K_4572 X_NUC_31.L_CORE X_NUC_118.L_CORE 0.001781
K_4573 X_NUC_31.L_CORE X_NUC_119.L_CORE 0.001779
K_4574 X_NUC_31.L_CORE X_NUC_120.L_CORE 0.001768
K_4575 X_NUC_31.L_CORE X_NUC_121.L_CORE 0.002086
K_4576 X_NUC_31.L_CORE X_NUC_122.L_CORE 0.002077
K_4577 X_NUC_31.L_CORE X_NUC_123.L_CORE 0.002073
K_4578 X_NUC_31.L_CORE X_NUC_124.L_CORE 0.002066
K_4579 X_NUC_31.L_CORE X_NUC_125.L_CORE 0.002114
K_4580 X_NUC_31.L_CORE X_NUC_126.L_CORE 0.002116
K_4581 X_NUC_31.L_CORE X_NUC_127.L_CORE 0.002106
K_4582 X_NUC_31.L_CORE X_NUC_128.L_CORE 0.002097
K_4583 X_NUC_31.L_CORE X_NUC_129.L_CORE 0.001851
K_4584 X_NUC_31.L_CORE X_NUC_130.L_CORE 0.001848
K_4585 X_NUC_31.L_CORE X_NUC_131.L_CORE 0.001844
K_4586 X_NUC_31.L_CORE X_NUC_132.L_CORE 0.001836
K_4587 X_NUC_31.L_CORE X_NUC_133.L_CORE 0.003024
K_4588 X_NUC_31.L_CORE X_NUC_134.L_CORE 0.002955
K_4589 X_NUC_31.L_CORE X_NUC_135.L_CORE 0.005537
K_4590 X_NUC_31.L_CORE X_NUC_136.L_CORE 0.002201
K_4591 X_NUC_31.L_CORE X_NUC_137.L_CORE 0.004510
K_4592 X_NUC_31.L_CORE X_NUC_138.L_CORE 0.002987
K_4593 X_NUC_31.L_CORE X_NUC_139.L_CORE 0.002125
K_4594 X_NUC_31.L_CORE X_NUC_140.L_CORE 0.033630
K_4595 X_NUC_31.L_CORE X_NUC_141.L_CORE 0.002026
K_4596 X_NUC_31.L_CORE X_NUC_142.L_CORE 0.002735
K_4597 X_NUC_31.L_CORE X_NUC_143.L_CORE 0.003986
K_4598 X_NUC_31.L_CORE X_NUC_144.L_CORE 0.001800
K_4599 X_NUC_31.L_CORE X_NUC_145.L_CORE 0.005379
K_4600 X_NUC_31.L_CORE X_NUC_146.L_CORE 0.002169
K_4601 X_NUC_31.L_CORE X_NUC_147.L_CORE 0.002000
K_4602 X_NUC_31.L_CORE X_NUC_148.L_CORE 0.005385
K_4603 X_NUC_31.L_CORE X_NUC_149.L_CORE 0.001722
K_4604 X_NUC_31.L_CORE X_NUC_150.L_CORE 0.002793
K_4605 X_NUC_31.L_CORE X_NUC_151.L_CORE 0.002537
K_4606 X_NUC_31.L_CORE X_NUC_152.L_CORE 0.001706
K_4607 X_NUC_31.L_CORE X_NUC_153.L_CORE 0.003970
K_4608 X_NUC_31.L_CORE X_NUC_154.L_CORE 0.001801
K_4609 X_NUC_31.L_CORE X_NUC_155.L_CORE 0.002018
K_4610 X_NUC_31.L_CORE X_NUC_156.L_CORE 0.002852
K_4611 X_NUC_31.L_CORE X_NUC_157.L_CORE 0.001626
K_4612 X_NUC_31.L_CORE X_NUC_158.L_CORE 0.002579
K_4613 X_NUC_31.L_CORE X_NUC_159.L_CORE 0.001970
K_4614 X_NUC_31.L_CORE X_NUC_160.L_CORE 0.001732
K_4615 X_NUC_31.L_CORE X_NUC_161.L_CORE 0.002536
K_4616 X_NUC_31.L_CORE X_NUC_162.L_CORE 0.001689
K_4617 X_NUC_31.L_CORE X_NUC_163.L_CORE 0.001971
K_4618 X_NUC_31.L_CORE X_NUC_164.L_CORE 0.002002
K_4619 X_NUC_31.L_CORE X_NUC_165.L_CORE 0.001753
K_4620 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.002155
K_4621 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.002156
K_4622 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.002166
K_4623 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.002144
K_4624 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.002919
K_4625 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.002882
K_4626 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.002905
K_4627 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.002890
K_4628 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.004243
K_4629 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.004311
K_4630 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.004289
K_4631 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.004238
K_4632 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.001915
K_4633 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.001908
K_4634 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.001918
K_4635 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.001902
K_4636 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.005784
K_4637 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.005653
K_4638 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.005644
K_4639 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.005682
K_4640 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.002304
K_4641 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.002314
K_4642 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.002316
K_4643 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.002294
K_4644 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.002129
K_4645 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.002112
K_4646 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.002123
K_4647 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.002110
K_4648 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.005733
K_4649 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.005829
K_4650 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.005691
K_4651 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.005691
K_4652 X_NUC_32.L_CORE X_NUC_65.L_CORE 0.001829
K_4653 X_NUC_32.L_CORE X_NUC_66.L_CORE 0.001828
K_4654 X_NUC_32.L_CORE X_NUC_67.L_CORE 0.001833
K_4655 X_NUC_32.L_CORE X_NUC_68.L_CORE 0.001818
K_4656 X_NUC_32.L_CORE X_NUC_69.L_CORE 0.002976
K_4657 X_NUC_32.L_CORE X_NUC_70.L_CORE 0.002940
K_4658 X_NUC_32.L_CORE X_NUC_71.L_CORE 0.002944
K_4659 X_NUC_32.L_CORE X_NUC_72.L_CORE 0.002940
K_4660 X_NUC_32.L_CORE X_NUC_73.L_CORE 0.002693
K_4661 X_NUC_32.L_CORE X_NUC_74.L_CORE 0.002713
K_4662 X_NUC_32.L_CORE X_NUC_75.L_CORE 0.002701
K_4663 X_NUC_32.L_CORE X_NUC_76.L_CORE 0.002679
K_4664 X_NUC_32.L_CORE X_NUC_77.L_CORE 0.001813
K_4665 X_NUC_32.L_CORE X_NUC_78.L_CORE 0.001805
K_4666 X_NUC_32.L_CORE X_NUC_79.L_CORE 0.001811
K_4667 X_NUC_32.L_CORE X_NUC_80.L_CORE 0.001799
K_4668 X_NUC_32.L_CORE X_NUC_81.L_CORE 0.004222
K_4669 X_NUC_32.L_CORE X_NUC_82.L_CORE 0.004205
K_4670 X_NUC_32.L_CORE X_NUC_83.L_CORE 0.004148
K_4671 X_NUC_32.L_CORE X_NUC_84.L_CORE 0.004165
K_4672 X_NUC_32.L_CORE X_NUC_85.L_CORE 0.001912
K_4673 X_NUC_32.L_CORE X_NUC_86.L_CORE 0.001915
K_4674 X_NUC_32.L_CORE X_NUC_87.L_CORE 0.001915
K_4675 X_NUC_32.L_CORE X_NUC_88.L_CORE 0.001900
K_4676 X_NUC_32.L_CORE X_NUC_89.L_CORE 0.002146
K_4677 X_NUC_32.L_CORE X_NUC_90.L_CORE 0.002130
K_4678 X_NUC_32.L_CORE X_NUC_91.L_CORE 0.002134
K_4679 X_NUC_32.L_CORE X_NUC_92.L_CORE 0.002125
K_4680 X_NUC_32.L_CORE X_NUC_93.L_CORE 0.003024
K_4681 X_NUC_32.L_CORE X_NUC_94.L_CORE 0.003044
K_4682 X_NUC_32.L_CORE X_NUC_95.L_CORE 0.003013
K_4683 X_NUC_32.L_CORE X_NUC_96.L_CORE 0.003001
K_4684 X_NUC_32.L_CORE X_NUC_97.L_CORE 0.001727
K_4685 X_NUC_32.L_CORE X_NUC_98.L_CORE 0.001723
K_4686 X_NUC_32.L_CORE X_NUC_99.L_CORE 0.001725
K_4687 X_NUC_32.L_CORE X_NUC_100.L_CORE 0.001714
K_4688 X_NUC_32.L_CORE X_NUC_101.L_CORE 0.002740
K_4689 X_NUC_32.L_CORE X_NUC_102.L_CORE 0.002722
K_4690 X_NUC_32.L_CORE X_NUC_103.L_CORE 0.002710
K_4691 X_NUC_32.L_CORE X_NUC_104.L_CORE 0.002708
K_4692 X_NUC_32.L_CORE X_NUC_105.L_CORE 0.002090
K_4693 X_NUC_32.L_CORE X_NUC_106.L_CORE 0.002096
K_4694 X_NUC_32.L_CORE X_NUC_107.L_CORE 0.002089
K_4695 X_NUC_32.L_CORE X_NUC_108.L_CORE 0.002076
K_4696 X_NUC_32.L_CORE X_NUC_109.L_CORE 0.001840
K_4697 X_NUC_32.L_CORE X_NUC_110.L_CORE 0.001831
K_4698 X_NUC_32.L_CORE X_NUC_111.L_CORE 0.001833
K_4699 X_NUC_32.L_CORE X_NUC_112.L_CORE 0.001823
K_4700 X_NUC_32.L_CORE X_NUC_113.L_CORE 0.002690
K_4701 X_NUC_32.L_CORE X_NUC_114.L_CORE 0.002691
K_4702 X_NUC_32.L_CORE X_NUC_115.L_CORE 0.002668
K_4703 X_NUC_32.L_CORE X_NUC_116.L_CORE 0.002664
K_4704 X_NUC_32.L_CORE X_NUC_117.L_CORE 0.001792
K_4705 X_NUC_32.L_CORE X_NUC_118.L_CORE 0.001792
K_4706 X_NUC_32.L_CORE X_NUC_119.L_CORE 0.001790
K_4707 X_NUC_32.L_CORE X_NUC_120.L_CORE 0.001779
K_4708 X_NUC_32.L_CORE X_NUC_121.L_CORE 0.002093
K_4709 X_NUC_32.L_CORE X_NUC_122.L_CORE 0.002084
K_4710 X_NUC_32.L_CORE X_NUC_123.L_CORE 0.002079
K_4711 X_NUC_32.L_CORE X_NUC_124.L_CORE 0.002073
K_4712 X_NUC_32.L_CORE X_NUC_125.L_CORE 0.002123
K_4713 X_NUC_32.L_CORE X_NUC_126.L_CORE 0.002125
K_4714 X_NUC_32.L_CORE X_NUC_127.L_CORE 0.002115
K_4715 X_NUC_32.L_CORE X_NUC_128.L_CORE 0.002106
K_4716 X_NUC_32.L_CORE X_NUC_129.L_CORE 0.001860
K_4717 X_NUC_32.L_CORE X_NUC_130.L_CORE 0.001857
K_4718 X_NUC_32.L_CORE X_NUC_131.L_CORE 0.001853
K_4719 X_NUC_32.L_CORE X_NUC_132.L_CORE 0.001844
K_4720 X_NUC_32.L_CORE X_NUC_133.L_CORE 0.003063
K_4721 X_NUC_32.L_CORE X_NUC_134.L_CORE 0.002983
K_4722 X_NUC_32.L_CORE X_NUC_135.L_CORE 0.005641
K_4723 X_NUC_32.L_CORE X_NUC_136.L_CORE 0.002223
K_4724 X_NUC_32.L_CORE X_NUC_137.L_CORE 0.004533
K_4725 X_NUC_32.L_CORE X_NUC_138.L_CORE 0.003024
K_4726 X_NUC_32.L_CORE X_NUC_139.L_CORE 0.002142
K_4727 X_NUC_32.L_CORE X_NUC_140.L_CORE 0.029889
K_4728 X_NUC_32.L_CORE X_NUC_141.L_CORE 0.002046
K_4729 X_NUC_32.L_CORE X_NUC_142.L_CORE 0.002747
K_4730 X_NUC_32.L_CORE X_NUC_143.L_CORE 0.004026
K_4731 X_NUC_32.L_CORE X_NUC_144.L_CORE 0.001815
K_4732 X_NUC_32.L_CORE X_NUC_145.L_CORE 0.005328
K_4733 X_NUC_32.L_CORE X_NUC_146.L_CORE 0.002189
K_4734 X_NUC_32.L_CORE X_NUC_147.L_CORE 0.002011
K_4735 X_NUC_32.L_CORE X_NUC_148.L_CORE 0.005369
K_4736 X_NUC_32.L_CORE X_NUC_149.L_CORE 0.001735
K_4737 X_NUC_32.L_CORE X_NUC_150.L_CORE 0.002794
K_4738 X_NUC_32.L_CORE X_NUC_151.L_CORE 0.002556
K_4739 X_NUC_32.L_CORE X_NUC_152.L_CORE 0.001716
K_4740 X_NUC_32.L_CORE X_NUC_153.L_CORE 0.003947
K_4741 X_NUC_32.L_CORE X_NUC_154.L_CORE 0.001814
K_4742 X_NUC_32.L_CORE X_NUC_155.L_CORE 0.002025
K_4743 X_NUC_32.L_CORE X_NUC_156.L_CORE 0.002861
K_4744 X_NUC_32.L_CORE X_NUC_157.L_CORE 0.001636
K_4745 X_NUC_32.L_CORE X_NUC_158.L_CORE 0.002578
K_4746 X_NUC_32.L_CORE X_NUC_159.L_CORE 0.001982
K_4747 X_NUC_32.L_CORE X_NUC_160.L_CORE 0.001740
K_4748 X_NUC_32.L_CORE X_NUC_161.L_CORE 0.002539
K_4749 X_NUC_32.L_CORE X_NUC_162.L_CORE 0.001698
K_4750 X_NUC_32.L_CORE X_NUC_163.L_CORE 0.001977
K_4751 X_NUC_32.L_CORE X_NUC_164.L_CORE 0.002010
K_4752 X_NUC_32.L_CORE X_NUC_165.L_CORE 0.001760
K_4753 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_4754 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_4755 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_4756 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.002063
K_4757 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.002048
K_4758 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.002048
K_4759 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.002062
K_4760 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.002792
K_4761 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.002807
K_4762 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.002780
K_4763 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.002814
K_4764 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.004117
K_4765 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.004040
K_4766 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.004068
K_4767 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.004063
K_4768 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.001848
K_4769 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.001842
K_4770 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.001836
K_4771 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.001851
K_4772 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.005612
K_4773 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.005728
K_4774 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.005582
K_4775 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.005647
K_4776 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.002242
K_4777 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.002221
K_4778 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.002223
K_4779 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.002232
K_4780 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.002067
K_4781 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.002070
K_4782 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.002055
K_4783 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.002074
K_4784 X_NUC_33.L_CORE X_NUC_65.L_CORE 0.005733
K_4785 X_NUC_33.L_CORE X_NUC_66.L_CORE 0.005657
K_4786 X_NUC_33.L_CORE X_NUC_67.L_CORE 0.005632
K_4787 X_NUC_33.L_CORE X_NUC_68.L_CORE 0.005582
K_4788 X_NUC_33.L_CORE X_NUC_69.L_CORE 0.001787
K_4789 X_NUC_33.L_CORE X_NUC_70.L_CORE 0.001778
K_4790 X_NUC_33.L_CORE X_NUC_71.L_CORE 0.001774
K_4791 X_NUC_33.L_CORE X_NUC_72.L_CORE 0.001785
K_4792 X_NUC_33.L_CORE X_NUC_73.L_CORE 0.002914
K_4793 X_NUC_33.L_CORE X_NUC_74.L_CORE 0.002935
K_4794 X_NUC_33.L_CORE X_NUC_75.L_CORE 0.002896
K_4795 X_NUC_33.L_CORE X_NUC_76.L_CORE 0.002923
K_4796 X_NUC_33.L_CORE X_NUC_77.L_CORE 0.002657
K_4797 X_NUC_33.L_CORE X_NUC_78.L_CORE 0.002628
K_4798 X_NUC_33.L_CORE X_NUC_79.L_CORE 0.002629
K_4799 X_NUC_33.L_CORE X_NUC_80.L_CORE 0.002632
K_4800 X_NUC_33.L_CORE X_NUC_81.L_CORE 0.001780
K_4801 X_NUC_33.L_CORE X_NUC_82.L_CORE 0.001777
K_4802 X_NUC_33.L_CORE X_NUC_83.L_CORE 0.001768
K_4803 X_NUC_33.L_CORE X_NUC_84.L_CORE 0.001781
K_4804 X_NUC_33.L_CORE X_NUC_85.L_CORE 0.004197
K_4805 X_NUC_33.L_CORE X_NUC_86.L_CORE 0.004219
K_4806 X_NUC_33.L_CORE X_NUC_87.L_CORE 0.004149
K_4807 X_NUC_33.L_CORE X_NUC_88.L_CORE 0.004152
K_4808 X_NUC_33.L_CORE X_NUC_89.L_CORE 0.001888
K_4809 X_NUC_33.L_CORE X_NUC_90.L_CORE 0.001876
K_4810 X_NUC_33.L_CORE X_NUC_91.L_CORE 0.001872
K_4811 X_NUC_33.L_CORE X_NUC_92.L_CORE 0.001881
K_4812 X_NUC_33.L_CORE X_NUC_93.L_CORE 0.002118
K_4813 X_NUC_33.L_CORE X_NUC_94.L_CORE 0.002123
K_4814 X_NUC_33.L_CORE X_NUC_95.L_CORE 0.002104
K_4815 X_NUC_33.L_CORE X_NUC_96.L_CORE 0.002120
K_4816 X_NUC_33.L_CORE X_NUC_97.L_CORE 0.003003
K_4817 X_NUC_33.L_CORE X_NUC_98.L_CORE 0.002981
K_4818 X_NUC_33.L_CORE X_NUC_99.L_CORE 0.002967
K_4819 X_NUC_33.L_CORE X_NUC_100.L_CORE 0.002965
K_4820 X_NUC_33.L_CORE X_NUC_101.L_CORE 0.001714
K_4821 X_NUC_33.L_CORE X_NUC_102.L_CORE 0.001708
K_4822 X_NUC_33.L_CORE X_NUC_103.L_CORE 0.001701
K_4823 X_NUC_33.L_CORE X_NUC_104.L_CORE 0.001711
K_4824 X_NUC_33.L_CORE X_NUC_105.L_CORE 0.002706
K_4825 X_NUC_33.L_CORE X_NUC_106.L_CORE 0.002717
K_4826 X_NUC_33.L_CORE X_NUC_107.L_CORE 0.002683
K_4827 X_NUC_33.L_CORE X_NUC_108.L_CORE 0.002697
K_4828 X_NUC_33.L_CORE X_NUC_109.L_CORE 0.002082
K_4829 X_NUC_33.L_CORE X_NUC_110.L_CORE 0.002068
K_4830 X_NUC_33.L_CORE X_NUC_111.L_CORE 0.002062
K_4831 X_NUC_33.L_CORE X_NUC_112.L_CORE 0.002068
K_4832 X_NUC_33.L_CORE X_NUC_113.L_CORE 0.001837
K_4833 X_NUC_33.L_CORE X_NUC_114.L_CORE 0.001837
K_4834 X_NUC_33.L_CORE X_NUC_115.L_CORE 0.001824
K_4835 X_NUC_33.L_CORE X_NUC_116.L_CORE 0.001836
K_4836 X_NUC_33.L_CORE X_NUC_117.L_CORE 0.002630
K_4837 X_NUC_33.L_CORE X_NUC_118.L_CORE 0.002625
K_4838 X_NUC_33.L_CORE X_NUC_119.L_CORE 0.002602
K_4839 X_NUC_33.L_CORE X_NUC_120.L_CORE 0.002607
K_4840 X_NUC_33.L_CORE X_NUC_121.L_CORE 0.001809
K_4841 X_NUC_33.L_CORE X_NUC_122.L_CORE 0.001803
K_4842 X_NUC_33.L_CORE X_NUC_123.L_CORE 0.001794
K_4843 X_NUC_33.L_CORE X_NUC_124.L_CORE 0.001803
K_4844 X_NUC_33.L_CORE X_NUC_125.L_CORE 0.002076
K_4845 X_NUC_33.L_CORE X_NUC_126.L_CORE 0.002076
K_4846 X_NUC_33.L_CORE X_NUC_127.L_CORE 0.002059
K_4847 X_NUC_33.L_CORE X_NUC_128.L_CORE 0.002069
K_4848 X_NUC_33.L_CORE X_NUC_129.L_CORE 0.002074
K_4849 X_NUC_33.L_CORE X_NUC_130.L_CORE 0.002067
K_4850 X_NUC_33.L_CORE X_NUC_131.L_CORE 0.002054
K_4851 X_NUC_33.L_CORE X_NUC_132.L_CORE 0.002061
K_4852 X_NUC_33.L_CORE X_NUC_133.L_CORE 0.003996
K_4853 X_NUC_33.L_CORE X_NUC_134.L_CORE 0.002686
K_4854 X_NUC_33.L_CORE X_NUC_135.L_CORE 0.002733
K_4855 X_NUC_33.L_CORE X_NUC_136.L_CORE 0.005589
K_4856 X_NUC_33.L_CORE X_NUC_137.L_CORE 0.002063
K_4857 X_NUC_33.L_CORE X_NUC_138.L_CORE 0.004350
K_4858 X_NUC_33.L_CORE X_NUC_139.L_CORE 0.002841
K_4859 X_NUC_33.L_CORE X_NUC_140.L_CORE 0.002036
K_4860 X_NUC_33.L_CORE X_NUC_141.L_CORE 0.034497
K_4861 X_NUC_33.L_CORE X_NUC_142.L_CORE 0.001952
K_4862 X_NUC_33.L_CORE X_NUC_143.L_CORE 0.002654
K_4863 X_NUC_33.L_CORE X_NUC_144.L_CORE 0.003850
K_4864 X_NUC_33.L_CORE X_NUC_145.L_CORE 0.001752
K_4865 X_NUC_33.L_CORE X_NUC_146.L_CORE 0.005305
K_4866 X_NUC_33.L_CORE X_NUC_147.L_CORE 0.002117
K_4867 X_NUC_33.L_CORE X_NUC_148.L_CORE 0.001963
K_4868 X_NUC_33.L_CORE X_NUC_149.L_CORE 0.005313
K_4869 X_NUC_33.L_CORE X_NUC_150.L_CORE 0.001693
K_4870 X_NUC_33.L_CORE X_NUC_151.L_CORE 0.002766
K_4871 X_NUC_33.L_CORE X_NUC_152.L_CORE 0.002502
K_4872 X_NUC_33.L_CORE X_NUC_153.L_CORE 0.001688
K_4873 X_NUC_33.L_CORE X_NUC_154.L_CORE 0.003950
K_4874 X_NUC_33.L_CORE X_NUC_155.L_CORE 0.001786
K_4875 X_NUC_33.L_CORE X_NUC_156.L_CORE 0.002010
K_4876 X_NUC_33.L_CORE X_NUC_157.L_CORE 0.002825
K_4877 X_NUC_33.L_CORE X_NUC_158.L_CORE 0.001624
K_4878 X_NUC_33.L_CORE X_NUC_159.L_CORE 0.002563
K_4879 X_NUC_33.L_CORE X_NUC_160.L_CORE 0.001966
K_4880 X_NUC_33.L_CORE X_NUC_161.L_CORE 0.001742
K_4881 X_NUC_33.L_CORE X_NUC_162.L_CORE 0.002482
K_4882 X_NUC_33.L_CORE X_NUC_163.L_CORE 0.001712
K_4883 X_NUC_33.L_CORE X_NUC_164.L_CORE 0.001966
K_4884 X_NUC_33.L_CORE X_NUC_165.L_CORE 0.001961
K_4885 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_4886 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_4887 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.002078
K_4888 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.002063
K_4889 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.002063
K_4890 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.002077
K_4891 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.002776
K_4892 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.002792
K_4893 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.002765
K_4894 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.002798
K_4895 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.004198
K_4896 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.004117
K_4897 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.004147
K_4898 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.004141
K_4899 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.001853
K_4900 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.001848
K_4901 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.001841
K_4902 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.001857
K_4903 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.005500
K_4904 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.005612
K_4905 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.005473
K_4906 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.005534
K_4907 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.002264
K_4908 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.002242
K_4909 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.002244
K_4910 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.002254
K_4911 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.002064
K_4912 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.002067
K_4913 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.002052
K_4914 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.002071
K_4915 X_NUC_34.L_CORE X_NUC_65.L_CORE 0.005807
K_4916 X_NUC_34.L_CORE X_NUC_66.L_CORE 0.005733
K_4917 X_NUC_34.L_CORE X_NUC_67.L_CORE 0.005704
K_4918 X_NUC_34.L_CORE X_NUC_68.L_CORE 0.005652
K_4919 X_NUC_34.L_CORE X_NUC_69.L_CORE 0.001796
K_4920 X_NUC_34.L_CORE X_NUC_70.L_CORE 0.001787
K_4921 X_NUC_34.L_CORE X_NUC_71.L_CORE 0.001783
K_4922 X_NUC_34.L_CORE X_NUC_72.L_CORE 0.001794
K_4923 X_NUC_34.L_CORE X_NUC_73.L_CORE 0.002892
K_4924 X_NUC_34.L_CORE X_NUC_74.L_CORE 0.002914
K_4925 X_NUC_34.L_CORE X_NUC_75.L_CORE 0.002875
K_4926 X_NUC_34.L_CORE X_NUC_76.L_CORE 0.002902
K_4927 X_NUC_34.L_CORE X_NUC_77.L_CORE 0.002686
K_4928 X_NUC_34.L_CORE X_NUC_78.L_CORE 0.002657
K_4929 X_NUC_34.L_CORE X_NUC_79.L_CORE 0.002657
K_4930 X_NUC_34.L_CORE X_NUC_80.L_CORE 0.002661
K_4931 X_NUC_34.L_CORE X_NUC_81.L_CORE 0.001782
K_4932 X_NUC_34.L_CORE X_NUC_82.L_CORE 0.001780
K_4933 X_NUC_34.L_CORE X_NUC_83.L_CORE 0.001770
K_4934 X_NUC_34.L_CORE X_NUC_84.L_CORE 0.001784
K_4935 X_NUC_34.L_CORE X_NUC_85.L_CORE 0.004175
K_4936 X_NUC_34.L_CORE X_NUC_86.L_CORE 0.004197
K_4937 X_NUC_34.L_CORE X_NUC_87.L_CORE 0.004128
K_4938 X_NUC_34.L_CORE X_NUC_88.L_CORE 0.004131
K_4939 X_NUC_34.L_CORE X_NUC_89.L_CORE 0.001900
K_4940 X_NUC_34.L_CORE X_NUC_90.L_CORE 0.001888
K_4941 X_NUC_34.L_CORE X_NUC_91.L_CORE 0.001884
K_4942 X_NUC_34.L_CORE X_NUC_92.L_CORE 0.001893
K_4943 X_NUC_34.L_CORE X_NUC_93.L_CORE 0.002113
K_4944 X_NUC_34.L_CORE X_NUC_94.L_CORE 0.002118
K_4945 X_NUC_34.L_CORE X_NUC_95.L_CORE 0.002098
K_4946 X_NUC_34.L_CORE X_NUC_96.L_CORE 0.002115
K_4947 X_NUC_34.L_CORE X_NUC_97.L_CORE 0.003026
K_4948 X_NUC_34.L_CORE X_NUC_98.L_CORE 0.003003
K_4949 X_NUC_34.L_CORE X_NUC_99.L_CORE 0.002990
K_4950 X_NUC_34.L_CORE X_NUC_100.L_CORE 0.002988
K_4951 X_NUC_34.L_CORE X_NUC_101.L_CORE 0.001719
K_4952 X_NUC_34.L_CORE X_NUC_102.L_CORE 0.001714
K_4953 X_NUC_34.L_CORE X_NUC_103.L_CORE 0.001706
K_4954 X_NUC_34.L_CORE X_NUC_104.L_CORE 0.001717
K_4955 X_NUC_34.L_CORE X_NUC_105.L_CORE 0.002696
K_4956 X_NUC_34.L_CORE X_NUC_106.L_CORE 0.002706
K_4957 X_NUC_34.L_CORE X_NUC_107.L_CORE 0.002673
K_4958 X_NUC_34.L_CORE X_NUC_108.L_CORE 0.002687
K_4959 X_NUC_34.L_CORE X_NUC_109.L_CORE 0.002095
K_4960 X_NUC_34.L_CORE X_NUC_110.L_CORE 0.002082
K_4961 X_NUC_34.L_CORE X_NUC_111.L_CORE 0.002075
K_4962 X_NUC_34.L_CORE X_NUC_112.L_CORE 0.002081
K_4963 X_NUC_34.L_CORE X_NUC_113.L_CORE 0.001838
K_4964 X_NUC_34.L_CORE X_NUC_114.L_CORE 0.001837
K_4965 X_NUC_34.L_CORE X_NUC_115.L_CORE 0.001824
K_4966 X_NUC_34.L_CORE X_NUC_116.L_CORE 0.001836
K_4967 X_NUC_34.L_CORE X_NUC_117.L_CORE 0.002634
K_4968 X_NUC_34.L_CORE X_NUC_118.L_CORE 0.002630
K_4969 X_NUC_34.L_CORE X_NUC_119.L_CORE 0.002606
K_4970 X_NUC_34.L_CORE X_NUC_120.L_CORE 0.002612
K_4971 X_NUC_34.L_CORE X_NUC_121.L_CORE 0.001816
K_4972 X_NUC_34.L_CORE X_NUC_122.L_CORE 0.001809
K_4973 X_NUC_34.L_CORE X_NUC_123.L_CORE 0.001801
K_4974 X_NUC_34.L_CORE X_NUC_124.L_CORE 0.001809
K_4975 X_NUC_34.L_CORE X_NUC_125.L_CORE 0.002075
K_4976 X_NUC_34.L_CORE X_NUC_126.L_CORE 0.002076
K_4977 X_NUC_34.L_CORE X_NUC_127.L_CORE 0.002058
K_4978 X_NUC_34.L_CORE X_NUC_128.L_CORE 0.002069
K_4979 X_NUC_34.L_CORE X_NUC_129.L_CORE 0.002080
K_4980 X_NUC_34.L_CORE X_NUC_130.L_CORE 0.002074
K_4981 X_NUC_34.L_CORE X_NUC_131.L_CORE 0.002060
K_4982 X_NUC_34.L_CORE X_NUC_132.L_CORE 0.002068
K_4983 X_NUC_34.L_CORE X_NUC_133.L_CORE 0.004012
K_4984 X_NUC_34.L_CORE X_NUC_134.L_CORE 0.002709
K_4985 X_NUC_34.L_CORE X_NUC_135.L_CORE 0.002731
K_4986 X_NUC_34.L_CORE X_NUC_136.L_CORE 0.005705
K_4987 X_NUC_34.L_CORE X_NUC_137.L_CORE 0.002073
K_4988 X_NUC_34.L_CORE X_NUC_138.L_CORE 0.004300
K_4989 X_NUC_34.L_CORE X_NUC_139.L_CORE 0.002878
K_4990 X_NUC_34.L_CORE X_NUC_140.L_CORE 0.002037
K_4991 X_NUC_34.L_CORE X_NUC_141.L_CORE 0.032464
K_4992 X_NUC_34.L_CORE X_NUC_142.L_CORE 0.001966
K_4993 X_NUC_34.L_CORE X_NUC_143.L_CORE 0.002639
K_4994 X_NUC_34.L_CORE X_NUC_144.L_CORE 0.003921
K_4995 X_NUC_34.L_CORE X_NUC_145.L_CORE 0.001757
K_4996 X_NUC_34.L_CORE X_NUC_146.L_CORE 0.005194
K_4997 X_NUC_34.L_CORE X_NUC_147.L_CORE 0.002137
K_4998 X_NUC_34.L_CORE X_NUC_148.L_CORE 0.001960
K_4999 X_NUC_34.L_CORE X_NUC_149.L_CORE 0.005371
K_5000 X_NUC_34.L_CORE X_NUC_150.L_CORE 0.001701
K_5001 X_NUC_34.L_CORE X_NUC_151.L_CORE 0.002745
K_5002 X_NUC_34.L_CORE X_NUC_152.L_CORE 0.002528
K_5003 X_NUC_34.L_CORE X_NUC_153.L_CORE 0.001690
K_5004 X_NUC_34.L_CORE X_NUC_154.L_CORE 0.003927
K_5005 X_NUC_34.L_CORE X_NUC_155.L_CORE 0.001797
K_5006 X_NUC_34.L_CORE X_NUC_156.L_CORE 0.002005
K_5007 X_NUC_34.L_CORE X_NUC_157.L_CORE 0.002845
K_5008 X_NUC_34.L_CORE X_NUC_158.L_CORE 0.001629
K_5009 X_NUC_34.L_CORE X_NUC_159.L_CORE 0.002552
K_5010 X_NUC_34.L_CORE X_NUC_160.L_CORE 0.001978
K_5011 X_NUC_34.L_CORE X_NUC_161.L_CORE 0.001742
K_5012 X_NUC_34.L_CORE X_NUC_162.L_CORE 0.002486
K_5013 X_NUC_34.L_CORE X_NUC_163.L_CORE 0.001719
K_5014 X_NUC_34.L_CORE X_NUC_164.L_CORE 0.001965
K_5015 X_NUC_34.L_CORE X_NUC_165.L_CORE 0.001966
K_5016 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_5017 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.002078
K_5018 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.002063
K_5019 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.002063
K_5020 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.002077
K_5021 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.002804
K_5022 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.002819
K_5023 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.002792
K_5024 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.002826
K_5025 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.004167
K_5026 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.004087
K_5027 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.004117
K_5028 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.004112
K_5029 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.001860
K_5030 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.001854
K_5031 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.001848
K_5032 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.001863
K_5033 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.005639
K_5034 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.005759
K_5035 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.005612
K_5036 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.005677
K_5037 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.002262
K_5038 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.002240
K_5039 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.002242
K_5040 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.002252
K_5041 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.002079
K_5042 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.002082
K_5043 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.002067
K_5044 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.002087
K_5045 X_NUC_35.L_CORE X_NUC_65.L_CORE 0.005834
K_5046 X_NUC_35.L_CORE X_NUC_66.L_CORE 0.005757
K_5047 X_NUC_35.L_CORE X_NUC_67.L_CORE 0.005733
K_5048 X_NUC_35.L_CORE X_NUC_68.L_CORE 0.005677
K_5049 X_NUC_35.L_CORE X_NUC_69.L_CORE 0.001801
K_5050 X_NUC_35.L_CORE X_NUC_70.L_CORE 0.001792
K_5051 X_NUC_35.L_CORE X_NUC_71.L_CORE 0.001787
K_5052 X_NUC_35.L_CORE X_NUC_72.L_CORE 0.001799
K_5053 X_NUC_35.L_CORE X_NUC_73.L_CORE 0.002931
K_5054 X_NUC_35.L_CORE X_NUC_74.L_CORE 0.002954
K_5055 X_NUC_35.L_CORE X_NUC_75.L_CORE 0.002914
K_5056 X_NUC_35.L_CORE X_NUC_76.L_CORE 0.002941
K_5057 X_NUC_35.L_CORE X_NUC_77.L_CORE 0.002686
K_5058 X_NUC_35.L_CORE X_NUC_78.L_CORE 0.002657
K_5059 X_NUC_35.L_CORE X_NUC_79.L_CORE 0.002657
K_5060 X_NUC_35.L_CORE X_NUC_80.L_CORE 0.002660
K_5061 X_NUC_35.L_CORE X_NUC_81.L_CORE 0.001792
K_5062 X_NUC_35.L_CORE X_NUC_82.L_CORE 0.001790
K_5063 X_NUC_35.L_CORE X_NUC_83.L_CORE 0.001780
K_5064 X_NUC_35.L_CORE X_NUC_84.L_CORE 0.001794
K_5065 X_NUC_35.L_CORE X_NUC_85.L_CORE 0.004246
K_5066 X_NUC_35.L_CORE X_NUC_86.L_CORE 0.004269
K_5067 X_NUC_35.L_CORE X_NUC_87.L_CORE 0.004197
K_5068 X_NUC_35.L_CORE X_NUC_88.L_CORE 0.004200
K_5069 X_NUC_35.L_CORE X_NUC_89.L_CORE 0.001905
K_5070 X_NUC_35.L_CORE X_NUC_90.L_CORE 0.001892
K_5071 X_NUC_35.L_CORE X_NUC_91.L_CORE 0.001888
K_5072 X_NUC_35.L_CORE X_NUC_92.L_CORE 0.001897
K_5073 X_NUC_35.L_CORE X_NUC_93.L_CORE 0.002132
K_5074 X_NUC_35.L_CORE X_NUC_94.L_CORE 0.002138
K_5075 X_NUC_35.L_CORE X_NUC_95.L_CORE 0.002118
K_5076 X_NUC_35.L_CORE X_NUC_96.L_CORE 0.002135
K_5077 X_NUC_35.L_CORE X_NUC_97.L_CORE 0.003040
K_5078 X_NUC_35.L_CORE X_NUC_98.L_CORE 0.003017
K_5079 X_NUC_35.L_CORE X_NUC_99.L_CORE 0.003003
K_5080 X_NUC_35.L_CORE X_NUC_100.L_CORE 0.003001
K_5081 X_NUC_35.L_CORE X_NUC_101.L_CORE 0.001727
K_5082 X_NUC_35.L_CORE X_NUC_102.L_CORE 0.001722
K_5083 X_NUC_35.L_CORE X_NUC_103.L_CORE 0.001714
K_5084 X_NUC_35.L_CORE X_NUC_104.L_CORE 0.001725
K_5085 X_NUC_35.L_CORE X_NUC_105.L_CORE 0.002730
K_5086 X_NUC_35.L_CORE X_NUC_106.L_CORE 0.002741
K_5087 X_NUC_35.L_CORE X_NUC_107.L_CORE 0.002706
K_5088 X_NUC_35.L_CORE X_NUC_108.L_CORE 0.002721
K_5089 X_NUC_35.L_CORE X_NUC_109.L_CORE 0.002102
K_5090 X_NUC_35.L_CORE X_NUC_110.L_CORE 0.002089
K_5091 X_NUC_35.L_CORE X_NUC_111.L_CORE 0.002082
K_5092 X_NUC_35.L_CORE X_NUC_112.L_CORE 0.002088
K_5093 X_NUC_35.L_CORE X_NUC_113.L_CORE 0.001851
K_5094 X_NUC_35.L_CORE X_NUC_114.L_CORE 0.001851
K_5095 X_NUC_35.L_CORE X_NUC_115.L_CORE 0.001837
K_5096 X_NUC_35.L_CORE X_NUC_116.L_CORE 0.001850
K_5097 X_NUC_35.L_CORE X_NUC_117.L_CORE 0.002658
K_5098 X_NUC_35.L_CORE X_NUC_118.L_CORE 0.002653
K_5099 X_NUC_35.L_CORE X_NUC_119.L_CORE 0.002630
K_5100 X_NUC_35.L_CORE X_NUC_120.L_CORE 0.002635
K_5101 X_NUC_35.L_CORE X_NUC_121.L_CORE 0.001825
K_5102 X_NUC_35.L_CORE X_NUC_122.L_CORE 0.001818
K_5103 X_NUC_35.L_CORE X_NUC_123.L_CORE 0.001809
K_5104 X_NUC_35.L_CORE X_NUC_124.L_CORE 0.001818
K_5105 X_NUC_35.L_CORE X_NUC_125.L_CORE 0.002094
K_5106 X_NUC_35.L_CORE X_NUC_126.L_CORE 0.002094
K_5107 X_NUC_35.L_CORE X_NUC_127.L_CORE 0.002076
K_5108 X_NUC_35.L_CORE X_NUC_128.L_CORE 0.002087
K_5109 X_NUC_35.L_CORE X_NUC_129.L_CORE 0.002094
K_5110 X_NUC_35.L_CORE X_NUC_130.L_CORE 0.002087
K_5111 X_NUC_35.L_CORE X_NUC_131.L_CORE 0.002074
K_5112 X_NUC_35.L_CORE X_NUC_132.L_CORE 0.002081
K_5113 X_NUC_35.L_CORE X_NUC_133.L_CORE 0.003994
K_5114 X_NUC_35.L_CORE X_NUC_134.L_CORE 0.002699
K_5115 X_NUC_35.L_CORE X_NUC_135.L_CORE 0.002739
K_5116 X_NUC_35.L_CORE X_NUC_136.L_CORE 0.005593
K_5117 X_NUC_35.L_CORE X_NUC_137.L_CORE 0.002074
K_5118 X_NUC_35.L_CORE X_NUC_138.L_CORE 0.004340
K_5119 X_NUC_35.L_CORE X_NUC_139.L_CORE 0.002861
K_5120 X_NUC_35.L_CORE X_NUC_140.L_CORE 0.002045
K_5121 X_NUC_35.L_CORE X_NUC_141.L_CORE 0.029986
K_5122 X_NUC_35.L_CORE X_NUC_142.L_CORE 0.001965
K_5123 X_NUC_35.L_CORE X_NUC_143.L_CORE 0.002663
K_5124 X_NUC_35.L_CORE X_NUC_144.L_CORE 0.003888
K_5125 X_NUC_35.L_CORE X_NUC_145.L_CORE 0.001763
K_5126 X_NUC_35.L_CORE X_NUC_146.L_CORE 0.005312
K_5127 X_NUC_35.L_CORE X_NUC_147.L_CORE 0.002134
K_5128 X_NUC_35.L_CORE X_NUC_148.L_CORE 0.001973
K_5129 X_NUC_35.L_CORE X_NUC_149.L_CORE 0.005383
K_5130 X_NUC_35.L_CORE X_NUC_150.L_CORE 0.001705
K_5131 X_NUC_35.L_CORE X_NUC_151.L_CORE 0.002780
K_5132 X_NUC_35.L_CORE X_NUC_152.L_CORE 0.002526
K_5133 X_NUC_35.L_CORE X_NUC_153.L_CORE 0.001699
K_5134 X_NUC_35.L_CORE X_NUC_154.L_CORE 0.003987
K_5135 X_NUC_35.L_CORE X_NUC_155.L_CORE 0.001800
K_5136 X_NUC_35.L_CORE X_NUC_156.L_CORE 0.002023
K_5137 X_NUC_35.L_CORE X_NUC_157.L_CORE 0.002856
K_5138 X_NUC_35.L_CORE X_NUC_158.L_CORE 0.001636
K_5139 X_NUC_35.L_CORE X_NUC_159.L_CORE 0.002582
K_5140 X_NUC_35.L_CORE X_NUC_160.L_CORE 0.001984
K_5141 X_NUC_35.L_CORE X_NUC_161.L_CORE 0.001755
K_5142 X_NUC_35.L_CORE X_NUC_162.L_CORE 0.002506
K_5143 X_NUC_35.L_CORE X_NUC_163.L_CORE 0.001727
K_5144 X_NUC_35.L_CORE X_NUC_164.L_CORE 0.001982
K_5145 X_NUC_35.L_CORE X_NUC_165.L_CORE 0.001978
K_5146 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.002064
K_5147 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.002049
K_5148 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.002049
K_5149 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.002063
K_5150 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.002770
K_5151 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.002785
K_5152 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.002758
K_5153 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.002792
K_5154 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.004173
K_5155 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.004092
K_5156 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.004122
K_5157 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.004117
K_5158 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.001844
K_5159 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.001839
K_5160 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.001832
K_5161 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.001848
K_5162 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.005574
K_5163 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.005689
K_5164 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.005546
K_5165 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.005612
K_5166 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.002252
K_5167 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.002231
K_5168 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.002232
K_5169 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.002242
K_5170 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.002059
K_5171 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.002062
K_5172 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.002047
K_5173 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.002067
K_5174 X_NUC_36.L_CORE X_NUC_65.L_CORE 0.005892
K_5175 X_NUC_36.L_CORE X_NUC_66.L_CORE 0.005812
K_5176 X_NUC_36.L_CORE X_NUC_67.L_CORE 0.005785
K_5177 X_NUC_36.L_CORE X_NUC_68.L_CORE 0.005733
K_5178 X_NUC_36.L_CORE X_NUC_69.L_CORE 0.001789
K_5179 X_NUC_36.L_CORE X_NUC_70.L_CORE 0.001780
K_5180 X_NUC_36.L_CORE X_NUC_71.L_CORE 0.001775
K_5181 X_NUC_36.L_CORE X_NUC_72.L_CORE 0.001787
K_5182 X_NUC_36.L_CORE X_NUC_73.L_CORE 0.002904
K_5183 X_NUC_36.L_CORE X_NUC_74.L_CORE 0.002926
K_5184 X_NUC_36.L_CORE X_NUC_75.L_CORE 0.002886
K_5185 X_NUC_36.L_CORE X_NUC_76.L_CORE 0.002914
K_5186 X_NUC_36.L_CORE X_NUC_77.L_CORE 0.002682
K_5187 X_NUC_36.L_CORE X_NUC_78.L_CORE 0.002653
K_5188 X_NUC_36.L_CORE X_NUC_79.L_CORE 0.002653
K_5189 X_NUC_36.L_CORE X_NUC_80.L_CORE 0.002657
K_5190 X_NUC_36.L_CORE X_NUC_81.L_CORE 0.001778
K_5191 X_NUC_36.L_CORE X_NUC_82.L_CORE 0.001776
K_5192 X_NUC_36.L_CORE X_NUC_83.L_CORE 0.001766
K_5193 X_NUC_36.L_CORE X_NUC_84.L_CORE 0.001780
K_5194 X_NUC_36.L_CORE X_NUC_85.L_CORE 0.004242
K_5195 X_NUC_36.L_CORE X_NUC_86.L_CORE 0.004265
K_5196 X_NUC_36.L_CORE X_NUC_87.L_CORE 0.004193
K_5197 X_NUC_36.L_CORE X_NUC_88.L_CORE 0.004197
K_5198 X_NUC_36.L_CORE X_NUC_89.L_CORE 0.001895
K_5199 X_NUC_36.L_CORE X_NUC_90.L_CORE 0.001883
K_5200 X_NUC_36.L_CORE X_NUC_91.L_CORE 0.001879
K_5201 X_NUC_36.L_CORE X_NUC_92.L_CORE 0.001888
K_5202 X_NUC_36.L_CORE X_NUC_93.L_CORE 0.002115
K_5203 X_NUC_36.L_CORE X_NUC_94.L_CORE 0.002121
K_5204 X_NUC_36.L_CORE X_NUC_95.L_CORE 0.002101
K_5205 X_NUC_36.L_CORE X_NUC_96.L_CORE 0.002118
K_5206 X_NUC_36.L_CORE X_NUC_97.L_CORE 0.003042
K_5207 X_NUC_36.L_CORE X_NUC_98.L_CORE 0.003019
K_5208 X_NUC_36.L_CORE X_NUC_99.L_CORE 0.003005
K_5209 X_NUC_36.L_CORE X_NUC_100.L_CORE 0.003003
K_5210 X_NUC_36.L_CORE X_NUC_101.L_CORE 0.001716
K_5211 X_NUC_36.L_CORE X_NUC_102.L_CORE 0.001711
K_5212 X_NUC_36.L_CORE X_NUC_103.L_CORE 0.001703
K_5213 X_NUC_36.L_CORE X_NUC_104.L_CORE 0.001714
K_5214 X_NUC_36.L_CORE X_NUC_105.L_CORE 0.002715
K_5215 X_NUC_36.L_CORE X_NUC_106.L_CORE 0.002726
K_5216 X_NUC_36.L_CORE X_NUC_107.L_CORE 0.002692
K_5217 X_NUC_36.L_CORE X_NUC_108.L_CORE 0.002706
K_5218 X_NUC_36.L_CORE X_NUC_109.L_CORE 0.002096
K_5219 X_NUC_36.L_CORE X_NUC_110.L_CORE 0.002082
K_5220 X_NUC_36.L_CORE X_NUC_111.L_CORE 0.002075
K_5221 X_NUC_36.L_CORE X_NUC_112.L_CORE 0.002082
K_5222 X_NUC_36.L_CORE X_NUC_113.L_CORE 0.001839
K_5223 X_NUC_36.L_CORE X_NUC_114.L_CORE 0.001838
K_5224 X_NUC_36.L_CORE X_NUC_115.L_CORE 0.001825
K_5225 X_NUC_36.L_CORE X_NUC_116.L_CORE 0.001837
K_5226 X_NUC_36.L_CORE X_NUC_117.L_CORE 0.002652
K_5227 X_NUC_36.L_CORE X_NUC_118.L_CORE 0.002648
K_5228 X_NUC_36.L_CORE X_NUC_119.L_CORE 0.002624
K_5229 X_NUC_36.L_CORE X_NUC_120.L_CORE 0.002630
K_5230 X_NUC_36.L_CORE X_NUC_121.L_CORE 0.001816
K_5231 X_NUC_36.L_CORE X_NUC_122.L_CORE 0.001809
K_5232 X_NUC_36.L_CORE X_NUC_123.L_CORE 0.001801
K_5233 X_NUC_36.L_CORE X_NUC_124.L_CORE 0.001809
K_5234 X_NUC_36.L_CORE X_NUC_125.L_CORE 0.002083
K_5235 X_NUC_36.L_CORE X_NUC_126.L_CORE 0.002083
K_5236 X_NUC_36.L_CORE X_NUC_127.L_CORE 0.002065
K_5237 X_NUC_36.L_CORE X_NUC_128.L_CORE 0.002076
K_5238 X_NUC_36.L_CORE X_NUC_129.L_CORE 0.002086
K_5239 X_NUC_36.L_CORE X_NUC_130.L_CORE 0.002080
K_5240 X_NUC_36.L_CORE X_NUC_131.L_CORE 0.002066
K_5241 X_NUC_36.L_CORE X_NUC_132.L_CORE 0.002074
K_5242 X_NUC_36.L_CORE X_NUC_133.L_CORE 0.003941
K_5243 X_NUC_36.L_CORE X_NUC_134.L_CORE 0.002677
K_5244 X_NUC_36.L_CORE X_NUC_135.L_CORE 0.002706
K_5245 X_NUC_36.L_CORE X_NUC_136.L_CORE 0.005564
K_5246 X_NUC_36.L_CORE X_NUC_137.L_CORE 0.002056
K_5247 X_NUC_36.L_CORE X_NUC_138.L_CORE 0.004271
K_5248 X_NUC_36.L_CORE X_NUC_139.L_CORE 0.002849
K_5249 X_NUC_36.L_CORE X_NUC_140.L_CORE 0.002025
K_5250 X_NUC_36.L_CORE X_NUC_141.L_CORE 0.033733
K_5251 X_NUC_36.L_CORE X_NUC_142.L_CORE 0.001953
K_5252 X_NUC_36.L_CORE X_NUC_143.L_CORE 0.002633
K_5253 X_NUC_36.L_CORE X_NUC_144.L_CORE 0.003899
K_5254 X_NUC_36.L_CORE X_NUC_145.L_CORE 0.001749
K_5255 X_NUC_36.L_CORE X_NUC_146.L_CORE 0.005268
K_5256 X_NUC_36.L_CORE X_NUC_147.L_CORE 0.002126
K_5257 X_NUC_36.L_CORE X_NUC_148.L_CORE 0.001956
K_5258 X_NUC_36.L_CORE X_NUC_149.L_CORE 0.005451
K_5259 X_NUC_36.L_CORE X_NUC_150.L_CORE 0.001694
K_5260 X_NUC_36.L_CORE X_NUC_151.L_CORE 0.002757
K_5261 X_NUC_36.L_CORE X_NUC_152.L_CORE 0.002525
K_5262 X_NUC_36.L_CORE X_NUC_153.L_CORE 0.001686
K_5263 X_NUC_36.L_CORE X_NUC_154.L_CORE 0.003991
K_5264 X_NUC_36.L_CORE X_NUC_155.L_CORE 0.001792
K_5265 X_NUC_36.L_CORE X_NUC_156.L_CORE 0.002007
K_5266 X_NUC_36.L_CORE X_NUC_157.L_CORE 0.002861
K_5267 X_NUC_36.L_CORE X_NUC_158.L_CORE 0.001626
K_5268 X_NUC_36.L_CORE X_NUC_159.L_CORE 0.002571
K_5269 X_NUC_36.L_CORE X_NUC_160.L_CORE 0.001979
K_5270 X_NUC_36.L_CORE X_NUC_161.L_CORE 0.001743
K_5271 X_NUC_36.L_CORE X_NUC_162.L_CORE 0.002503
K_5272 X_NUC_36.L_CORE X_NUC_163.L_CORE 0.001719
K_5273 X_NUC_36.L_CORE X_NUC_164.L_CORE 0.001972
K_5274 X_NUC_36.L_CORE X_NUC_165.L_CORE 0.001972
K_5275 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_5276 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_5277 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_5278 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.001999
K_5279 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.002018
K_5280 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.002008
K_5281 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.002008
K_5282 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.002714
K_5283 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.002725
K_5284 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.002734
K_5285 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.002701
K_5286 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.004022
K_5287 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.004076
K_5288 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.004009
K_5289 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.004064
K_5290 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.001805
K_5291 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.001819
K_5292 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.001814
K_5293 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.001807
K_5294 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.005554
K_5295 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.005518
K_5296 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.005546
K_5297 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.005426
K_5298 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.002203
K_5299 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.002224
K_5300 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.002206
K_5301 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.002213
K_5302 X_NUC_37.L_CORE X_NUC_65.L_CORE 0.002034
K_5303 X_NUC_37.L_CORE X_NUC_66.L_CORE 0.002045
K_5304 X_NUC_37.L_CORE X_NUC_67.L_CORE 0.002044
K_5305 X_NUC_37.L_CORE X_NUC_68.L_CORE 0.002028
K_5306 X_NUC_37.L_CORE X_NUC_69.L_CORE 0.005762
K_5307 X_NUC_37.L_CORE X_NUC_70.L_CORE 0.005787
K_5308 X_NUC_37.L_CORE X_NUC_71.L_CORE 0.005641
K_5309 X_NUC_37.L_CORE X_NUC_72.L_CORE 0.005726
K_5310 X_NUC_37.L_CORE X_NUC_73.L_CORE 0.001765
K_5311 X_NUC_37.L_CORE X_NUC_74.L_CORE 0.001779
K_5312 X_NUC_37.L_CORE X_NUC_75.L_CORE 0.001771
K_5313 X_NUC_37.L_CORE X_NUC_76.L_CORE 0.001768
K_5314 X_NUC_37.L_CORE X_NUC_77.L_CORE 0.002895
K_5315 X_NUC_37.L_CORE X_NUC_78.L_CORE 0.002899
K_5316 X_NUC_37.L_CORE X_NUC_79.L_CORE 0.002899
K_5317 X_NUC_37.L_CORE X_NUC_80.L_CORE 0.002865
K_5318 X_NUC_37.L_CORE X_NUC_81.L_CORE 0.002643
K_5319 X_NUC_37.L_CORE X_NUC_82.L_CORE 0.002667
K_5320 X_NUC_37.L_CORE X_NUC_83.L_CORE 0.002634
K_5321 X_NUC_37.L_CORE X_NUC_84.L_CORE 0.002650
K_5322 X_NUC_37.L_CORE X_NUC_85.L_CORE 0.001769
K_5323 X_NUC_37.L_CORE X_NUC_86.L_CORE 0.001780
K_5324 X_NUC_37.L_CORE X_NUC_87.L_CORE 0.001774
K_5325 X_NUC_37.L_CORE X_NUC_88.L_CORE 0.001766
K_5326 X_NUC_37.L_CORE X_NUC_89.L_CORE 0.004213
K_5327 X_NUC_37.L_CORE X_NUC_90.L_CORE 0.004204
K_5328 X_NUC_37.L_CORE X_NUC_91.L_CORE 0.004160
K_5329 X_NUC_37.L_CORE X_NUC_92.L_CORE 0.004142
K_5330 X_NUC_37.L_CORE X_NUC_93.L_CORE 0.001884
K_5331 X_NUC_37.L_CORE X_NUC_94.L_CORE 0.001900
K_5332 X_NUC_37.L_CORE X_NUC_95.L_CORE 0.001886
K_5333 X_NUC_37.L_CORE X_NUC_96.L_CORE 0.001887
K_5334 X_NUC_37.L_CORE X_NUC_97.L_CORE 0.002118
K_5335 X_NUC_37.L_CORE X_NUC_98.L_CORE 0.002126
K_5336 X_NUC_37.L_CORE X_NUC_99.L_CORE 0.002121
K_5337 X_NUC_37.L_CORE X_NUC_100.L_CORE 0.002106
K_5338 X_NUC_37.L_CORE X_NUC_101.L_CORE 0.003001
K_5339 X_NUC_37.L_CORE X_NUC_102.L_CORE 0.003018
K_5340 X_NUC_37.L_CORE X_NUC_103.L_CORE 0.002976
K_5341 X_NUC_37.L_CORE X_NUC_104.L_CORE 0.002991
K_5342 X_NUC_37.L_CORE X_NUC_105.L_CORE 0.001722
K_5343 X_NUC_37.L_CORE X_NUC_106.L_CORE 0.001734
K_5344 X_NUC_37.L_CORE X_NUC_107.L_CORE 0.001725
K_5345 X_NUC_37.L_CORE X_NUC_108.L_CORE 0.001721
K_5346 X_NUC_37.L_CORE X_NUC_109.L_CORE 0.002700
K_5347 X_NUC_37.L_CORE X_NUC_110.L_CORE 0.002704
K_5348 X_NUC_37.L_CORE X_NUC_111.L_CORE 0.002689
K_5349 X_NUC_37.L_CORE X_NUC_112.L_CORE 0.002672
K_5350 X_NUC_37.L_CORE X_NUC_113.L_CORE 0.002094
K_5351 X_NUC_37.L_CORE X_NUC_114.L_CORE 0.002109
K_5352 X_NUC_37.L_CORE X_NUC_115.L_CORE 0.002089
K_5353 X_NUC_37.L_CORE X_NUC_116.L_CORE 0.002093
K_5354 X_NUC_37.L_CORE X_NUC_117.L_CORE 0.001862
K_5355 X_NUC_37.L_CORE X_NUC_118.L_CORE 0.001871
K_5356 X_NUC_37.L_CORE X_NUC_119.L_CORE 0.001863
K_5357 X_NUC_37.L_CORE X_NUC_120.L_CORE 0.001855
K_5358 X_NUC_37.L_CORE X_NUC_121.L_CORE 0.002574
K_5359 X_NUC_37.L_CORE X_NUC_122.L_CORE 0.002583
K_5360 X_NUC_37.L_CORE X_NUC_123.L_CORE 0.002558
K_5361 X_NUC_37.L_CORE X_NUC_124.L_CORE 0.002556
K_5362 X_NUC_37.L_CORE X_NUC_125.L_CORE 0.001860
K_5363 X_NUC_37.L_CORE X_NUC_126.L_CORE 0.001871
K_5364 X_NUC_37.L_CORE X_NUC_127.L_CORE 0.001858
K_5365 X_NUC_37.L_CORE X_NUC_128.L_CORE 0.001856
K_5366 X_NUC_37.L_CORE X_NUC_129.L_CORE 0.002075
K_5367 X_NUC_37.L_CORE X_NUC_130.L_CORE 0.002083
K_5368 X_NUC_37.L_CORE X_NUC_131.L_CORE 0.002070
K_5369 X_NUC_37.L_CORE X_NUC_132.L_CORE 0.002063
K_5370 X_NUC_37.L_CORE X_NUC_133.L_CORE 0.002597
K_5371 X_NUC_37.L_CORE X_NUC_134.L_CORE 0.004526
K_5372 X_NUC_37.L_CORE X_NUC_135.L_CORE 0.002494
K_5373 X_NUC_37.L_CORE X_NUC_136.L_CORE 0.002564
K_5374 X_NUC_37.L_CORE X_NUC_137.L_CORE 0.005637
K_5375 X_NUC_37.L_CORE X_NUC_138.L_CORE 0.001966
K_5376 X_NUC_37.L_CORE X_NUC_139.L_CORE 0.004153
K_5377 X_NUC_37.L_CORE X_NUC_140.L_CORE 0.002758
K_5378 X_NUC_37.L_CORE X_NUC_141.L_CORE 0.001966
K_5379 X_NUC_37.L_CORE X_NUC_142.L_CORE 0.031251
K_5380 X_NUC_37.L_CORE X_NUC_143.L_CORE 0.001907
K_5381 X_NUC_37.L_CORE X_NUC_144.L_CORE 0.002578
K_5382 X_NUC_37.L_CORE X_NUC_145.L_CORE 0.003817
K_5383 X_NUC_37.L_CORE X_NUC_146.L_CORE 0.001721
K_5384 X_NUC_37.L_CORE X_NUC_147.L_CORE 0.005171
K_5385 X_NUC_37.L_CORE X_NUC_148.L_CORE 0.002099
K_5386 X_NUC_37.L_CORE X_NUC_149.L_CORE 0.001935
K_5387 X_NUC_37.L_CORE X_NUC_150.L_CORE 0.005370
K_5388 X_NUC_37.L_CORE X_NUC_151.L_CORE 0.001682
K_5389 X_NUC_37.L_CORE X_NUC_152.L_CORE 0.002739
K_5390 X_NUC_37.L_CORE X_NUC_153.L_CORE 0.002512
K_5391 X_NUC_37.L_CORE X_NUC_154.L_CORE 0.001683
K_5392 X_NUC_37.L_CORE X_NUC_155.L_CORE 0.003945
K_5393 X_NUC_37.L_CORE X_NUC_156.L_CORE 0.001794
K_5394 X_NUC_37.L_CORE X_NUC_157.L_CORE 0.002011
K_5395 X_NUC_37.L_CORE X_NUC_158.L_CORE 0.002840
K_5396 X_NUC_37.L_CORE X_NUC_159.L_CORE 0.001639
K_5397 X_NUC_37.L_CORE X_NUC_160.L_CORE 0.002552
K_5398 X_NUC_37.L_CORE X_NUC_161.L_CORE 0.001990
K_5399 X_NUC_37.L_CORE X_NUC_162.L_CORE 0.001769
K_5400 X_NUC_37.L_CORE X_NUC_163.L_CORE 0.002436
K_5401 X_NUC_37.L_CORE X_NUC_164.L_CORE 0.001768
K_5402 X_NUC_37.L_CORE X_NUC_165.L_CORE 0.001968
K_5403 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_5404 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_5405 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.001980
K_5406 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.001999
K_5407 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.001989
K_5408 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.001989
K_5409 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.002703
K_5410 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.002714
K_5411 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.002723
K_5412 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.002690
K_5413 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.003969
K_5414 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.004022
K_5415 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.003957
K_5416 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.004009
K_5417 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.001792
K_5418 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.001805
K_5419 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.001801
K_5420 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.001793
K_5421 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.005586
K_5422 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.005554
K_5423 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.005580
K_5424 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.005458
K_5425 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.002181
K_5426 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.002203
K_5427 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.002185
K_5428 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.002191
K_5429 X_NUC_38.L_CORE X_NUC_65.L_CORE 0.002023
K_5430 X_NUC_38.L_CORE X_NUC_66.L_CORE 0.002034
K_5431 X_NUC_38.L_CORE X_NUC_67.L_CORE 0.002033
K_5432 X_NUC_38.L_CORE X_NUC_68.L_CORE 0.002017
K_5433 X_NUC_38.L_CORE X_NUC_69.L_CORE 0.005732
K_5434 X_NUC_38.L_CORE X_NUC_70.L_CORE 0.005762
K_5435 X_NUC_38.L_CORE X_NUC_71.L_CORE 0.005615
K_5436 X_NUC_38.L_CORE X_NUC_72.L_CORE 0.005699
K_5437 X_NUC_38.L_CORE X_NUC_73.L_CORE 0.001751
K_5438 X_NUC_38.L_CORE X_NUC_74.L_CORE 0.001765
K_5439 X_NUC_38.L_CORE X_NUC_75.L_CORE 0.001757
K_5440 X_NUC_38.L_CORE X_NUC_76.L_CORE 0.001754
K_5441 X_NUC_38.L_CORE X_NUC_77.L_CORE 0.002891
K_5442 X_NUC_38.L_CORE X_NUC_78.L_CORE 0.002895
K_5443 X_NUC_38.L_CORE X_NUC_79.L_CORE 0.002896
K_5444 X_NUC_38.L_CORE X_NUC_80.L_CORE 0.002862
K_5445 X_NUC_38.L_CORE X_NUC_81.L_CORE 0.002619
K_5446 X_NUC_38.L_CORE X_NUC_82.L_CORE 0.002643
K_5447 X_NUC_38.L_CORE X_NUC_83.L_CORE 0.002611
K_5448 X_NUC_38.L_CORE X_NUC_84.L_CORE 0.002626
K_5449 X_NUC_38.L_CORE X_NUC_85.L_CORE 0.001758
K_5450 X_NUC_38.L_CORE X_NUC_86.L_CORE 0.001769
K_5451 X_NUC_38.L_CORE X_NUC_87.L_CORE 0.001763
K_5452 X_NUC_38.L_CORE X_NUC_88.L_CORE 0.001755
K_5453 X_NUC_38.L_CORE X_NUC_89.L_CORE 0.004221
K_5454 X_NUC_38.L_CORE X_NUC_90.L_CORE 0.004213
K_5455 X_NUC_38.L_CORE X_NUC_91.L_CORE 0.004169
K_5456 X_NUC_38.L_CORE X_NUC_92.L_CORE 0.004150
K_5457 X_NUC_38.L_CORE X_NUC_93.L_CORE 0.001870
K_5458 X_NUC_38.L_CORE X_NUC_94.L_CORE 0.001884
K_5459 X_NUC_38.L_CORE X_NUC_95.L_CORE 0.001871
K_5460 X_NUC_38.L_CORE X_NUC_96.L_CORE 0.001872
K_5461 X_NUC_38.L_CORE X_NUC_97.L_CORE 0.002110
K_5462 X_NUC_38.L_CORE X_NUC_98.L_CORE 0.002118
K_5463 X_NUC_38.L_CORE X_NUC_99.L_CORE 0.002113
K_5464 X_NUC_38.L_CORE X_NUC_100.L_CORE 0.002098
K_5465 X_NUC_38.L_CORE X_NUC_101.L_CORE 0.002984
K_5466 X_NUC_38.L_CORE X_NUC_102.L_CORE 0.003001
K_5467 X_NUC_38.L_CORE X_NUC_103.L_CORE 0.002960
K_5468 X_NUC_38.L_CORE X_NUC_104.L_CORE 0.002974
K_5469 X_NUC_38.L_CORE X_NUC_105.L_CORE 0.001711
K_5470 X_NUC_38.L_CORE X_NUC_106.L_CORE 0.001722
K_5471 X_NUC_38.L_CORE X_NUC_107.L_CORE 0.001714
K_5472 X_NUC_38.L_CORE X_NUC_108.L_CORE 0.001709
K_5473 X_NUC_38.L_CORE X_NUC_109.L_CORE 0.002696
K_5474 X_NUC_38.L_CORE X_NUC_110.L_CORE 0.002700
K_5475 X_NUC_38.L_CORE X_NUC_111.L_CORE 0.002686
K_5476 X_NUC_38.L_CORE X_NUC_112.L_CORE 0.002669
K_5477 X_NUC_38.L_CORE X_NUC_113.L_CORE 0.002080
K_5478 X_NUC_38.L_CORE X_NUC_114.L_CORE 0.002094
K_5479 X_NUC_38.L_CORE X_NUC_115.L_CORE 0.002075
K_5480 X_NUC_38.L_CORE X_NUC_116.L_CORE 0.002078
K_5481 X_NUC_38.L_CORE X_NUC_117.L_CORE 0.001853
K_5482 X_NUC_38.L_CORE X_NUC_118.L_CORE 0.001862
K_5483 X_NUC_38.L_CORE X_NUC_119.L_CORE 0.001854
K_5484 X_NUC_38.L_CORE X_NUC_120.L_CORE 0.001846
K_5485 X_NUC_38.L_CORE X_NUC_121.L_CORE 0.002565
K_5486 X_NUC_38.L_CORE X_NUC_122.L_CORE 0.002574
K_5487 X_NUC_38.L_CORE X_NUC_123.L_CORE 0.002549
K_5488 X_NUC_38.L_CORE X_NUC_124.L_CORE 0.002548
K_5489 X_NUC_38.L_CORE X_NUC_125.L_CORE 0.001849
K_5490 X_NUC_38.L_CORE X_NUC_126.L_CORE 0.001860
K_5491 X_NUC_38.L_CORE X_NUC_127.L_CORE 0.001847
K_5492 X_NUC_38.L_CORE X_NUC_128.L_CORE 0.001845
K_5493 X_NUC_38.L_CORE X_NUC_129.L_CORE 0.002066
K_5494 X_NUC_38.L_CORE X_NUC_130.L_CORE 0.002075
K_5495 X_NUC_38.L_CORE X_NUC_131.L_CORE 0.002061
K_5496 X_NUC_38.L_CORE X_NUC_132.L_CORE 0.002055
K_5497 X_NUC_38.L_CORE X_NUC_133.L_CORE 0.002572
K_5498 X_NUC_38.L_CORE X_NUC_134.L_CORE 0.004478
K_5499 X_NUC_38.L_CORE X_NUC_135.L_CORE 0.002466
K_5500 X_NUC_38.L_CORE X_NUC_136.L_CORE 0.002546
K_5501 X_NUC_38.L_CORE X_NUC_137.L_CORE 0.005539
K_5502 X_NUC_38.L_CORE X_NUC_138.L_CORE 0.001949
K_5503 X_NUC_38.L_CORE X_NUC_139.L_CORE 0.004146
K_5504 X_NUC_38.L_CORE X_NUC_140.L_CORE 0.002726
K_5505 X_NUC_38.L_CORE X_NUC_141.L_CORE 0.001953
K_5506 X_NUC_38.L_CORE X_NUC_142.L_CORE 0.035855
K_5507 X_NUC_38.L_CORE X_NUC_143.L_CORE 0.001890
K_5508 X_NUC_38.L_CORE X_NUC_144.L_CORE 0.002569
K_5509 X_NUC_38.L_CORE X_NUC_145.L_CORE 0.003774
K_5510 X_NUC_38.L_CORE X_NUC_146.L_CORE 0.001708
K_5511 X_NUC_38.L_CORE X_NUC_147.L_CORE 0.005219
K_5512 X_NUC_38.L_CORE X_NUC_148.L_CORE 0.002080
K_5513 X_NUC_38.L_CORE X_NUC_149.L_CORE 0.001926
K_5514 X_NUC_38.L_CORE X_NUC_150.L_CORE 0.005365
K_5515 X_NUC_38.L_CORE X_NUC_151.L_CORE 0.001670
K_5516 X_NUC_38.L_CORE X_NUC_152.L_CORE 0.002738
K_5517 X_NUC_38.L_CORE X_NUC_153.L_CORE 0.002491
K_5518 X_NUC_38.L_CORE X_NUC_154.L_CORE 0.001674
K_5519 X_NUC_38.L_CORE X_NUC_155.L_CORE 0.003961
K_5520 X_NUC_38.L_CORE X_NUC_156.L_CORE 0.001781
K_5521 X_NUC_38.L_CORE X_NUC_157.L_CORE 0.002004
K_5522 X_NUC_38.L_CORE X_NUC_158.L_CORE 0.002826
K_5523 X_NUC_38.L_CORE X_NUC_159.L_CORE 0.001629
K_5524 X_NUC_38.L_CORE X_NUC_160.L_CORE 0.002551
K_5525 X_NUC_38.L_CORE X_NUC_161.L_CORE 0.001978
K_5526 X_NUC_38.L_CORE X_NUC_162.L_CORE 0.001761
K_5527 X_NUC_38.L_CORE X_NUC_163.L_CORE 0.002429
K_5528 X_NUC_38.L_CORE X_NUC_164.L_CORE 0.001758
K_5529 X_NUC_38.L_CORE X_NUC_165.L_CORE 0.001961
K_5530 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_5531 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.001990
K_5532 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.002009
K_5533 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.001999
K_5534 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.001999
K_5535 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.002695
K_5536 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.002705
K_5537 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.002714
K_5538 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.002681
K_5539 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.004033
K_5540 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.004088
K_5541 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.004022
K_5542 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.004076
K_5543 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.001796
K_5544 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.001810
K_5545 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.001805
K_5546 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.001798
K_5547 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.005558
K_5548 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.005524
K_5549 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.005554
K_5550 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.005431
K_5551 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.002199
K_5552 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.002221
K_5553 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.002203
K_5554 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.002209
K_5555 X_NUC_39.L_CORE X_NUC_65.L_CORE 0.002024
K_5556 X_NUC_39.L_CORE X_NUC_66.L_CORE 0.002035
K_5557 X_NUC_39.L_CORE X_NUC_67.L_CORE 0.002034
K_5558 X_NUC_39.L_CORE X_NUC_68.L_CORE 0.002018
K_5559 X_NUC_39.L_CORE X_NUC_69.L_CORE 0.005886
K_5560 X_NUC_39.L_CORE X_NUC_70.L_CORE 0.005915
K_5561 X_NUC_39.L_CORE X_NUC_71.L_CORE 0.005762
K_5562 X_NUC_39.L_CORE X_NUC_72.L_CORE 0.005850
K_5563 X_NUC_39.L_CORE X_NUC_73.L_CORE 0.001760
K_5564 X_NUC_39.L_CORE X_NUC_74.L_CORE 0.001774
K_5565 X_NUC_39.L_CORE X_NUC_75.L_CORE 0.001765
K_5566 X_NUC_39.L_CORE X_NUC_76.L_CORE 0.001762
K_5567 X_NUC_39.L_CORE X_NUC_77.L_CORE 0.002890
K_5568 X_NUC_39.L_CORE X_NUC_78.L_CORE 0.002894
K_5569 X_NUC_39.L_CORE X_NUC_79.L_CORE 0.002895
K_5570 X_NUC_39.L_CORE X_NUC_80.L_CORE 0.002861
K_5571 X_NUC_39.L_CORE X_NUC_81.L_CORE 0.002651
K_5572 X_NUC_39.L_CORE X_NUC_82.L_CORE 0.002675
K_5573 X_NUC_39.L_CORE X_NUC_83.L_CORE 0.002643
K_5574 X_NUC_39.L_CORE X_NUC_84.L_CORE 0.002658
K_5575 X_NUC_39.L_CORE X_NUC_85.L_CORE 0.001763
K_5576 X_NUC_39.L_CORE X_NUC_86.L_CORE 0.001774
K_5577 X_NUC_39.L_CORE X_NUC_87.L_CORE 0.001769
K_5578 X_NUC_39.L_CORE X_NUC_88.L_CORE 0.001760
K_5579 X_NUC_39.L_CORE X_NUC_89.L_CORE 0.004267
K_5580 X_NUC_39.L_CORE X_NUC_90.L_CORE 0.004258
K_5581 X_NUC_39.L_CORE X_NUC_91.L_CORE 0.004213
K_5582 X_NUC_39.L_CORE X_NUC_92.L_CORE 0.004193
K_5583 X_NUC_39.L_CORE X_NUC_93.L_CORE 0.001883
K_5584 X_NUC_39.L_CORE X_NUC_94.L_CORE 0.001898
K_5585 X_NUC_39.L_CORE X_NUC_95.L_CORE 0.001884
K_5586 X_NUC_39.L_CORE X_NUC_96.L_CORE 0.001886
K_5587 X_NUC_39.L_CORE X_NUC_97.L_CORE 0.002114
K_5588 X_NUC_39.L_CORE X_NUC_98.L_CORE 0.002123
K_5589 X_NUC_39.L_CORE X_NUC_99.L_CORE 0.002118
K_5590 X_NUC_39.L_CORE X_NUC_100.L_CORE 0.002102
K_5591 X_NUC_39.L_CORE X_NUC_101.L_CORE 0.003026
K_5592 X_NUC_39.L_CORE X_NUC_102.L_CORE 0.003044
K_5593 X_NUC_39.L_CORE X_NUC_103.L_CORE 0.003001
K_5594 X_NUC_39.L_CORE X_NUC_104.L_CORE 0.003016
K_5595 X_NUC_39.L_CORE X_NUC_105.L_CORE 0.001720
K_5596 X_NUC_39.L_CORE X_NUC_106.L_CORE 0.001731
K_5597 X_NUC_39.L_CORE X_NUC_107.L_CORE 0.001722
K_5598 X_NUC_39.L_CORE X_NUC_108.L_CORE 0.001718
K_5599 X_NUC_39.L_CORE X_NUC_109.L_CORE 0.002711
K_5600 X_NUC_39.L_CORE X_NUC_110.L_CORE 0.002715
K_5601 X_NUC_39.L_CORE X_NUC_111.L_CORE 0.002700
K_5602 X_NUC_39.L_CORE X_NUC_112.L_CORE 0.002683
K_5603 X_NUC_39.L_CORE X_NUC_113.L_CORE 0.002099
K_5604 X_NUC_39.L_CORE X_NUC_114.L_CORE 0.002114
K_5605 X_NUC_39.L_CORE X_NUC_115.L_CORE 0.002094
K_5606 X_NUC_39.L_CORE X_NUC_116.L_CORE 0.002098
K_5607 X_NUC_39.L_CORE X_NUC_117.L_CORE 0.001861
K_5608 X_NUC_39.L_CORE X_NUC_118.L_CORE 0.001870
K_5609 X_NUC_39.L_CORE X_NUC_119.L_CORE 0.001862
K_5610 X_NUC_39.L_CORE X_NUC_120.L_CORE 0.001854
K_5611 X_NUC_39.L_CORE X_NUC_121.L_CORE 0.002590
K_5612 X_NUC_39.L_CORE X_NUC_122.L_CORE 0.002600
K_5613 X_NUC_39.L_CORE X_NUC_123.L_CORE 0.002574
K_5614 X_NUC_39.L_CORE X_NUC_124.L_CORE 0.002572
K_5615 X_NUC_39.L_CORE X_NUC_125.L_CORE 0.001862
K_5616 X_NUC_39.L_CORE X_NUC_126.L_CORE 0.001873
K_5617 X_NUC_39.L_CORE X_NUC_127.L_CORE 0.001860
K_5618 X_NUC_39.L_CORE X_NUC_128.L_CORE 0.001858
K_5619 X_NUC_39.L_CORE X_NUC_129.L_CORE 0.002079
K_5620 X_NUC_39.L_CORE X_NUC_130.L_CORE 0.002088
K_5621 X_NUC_39.L_CORE X_NUC_131.L_CORE 0.002075
K_5622 X_NUC_39.L_CORE X_NUC_132.L_CORE 0.002068
K_5623 X_NUC_39.L_CORE X_NUC_133.L_CORE 0.002567
K_5624 X_NUC_39.L_CORE X_NUC_134.L_CORE 0.004430
K_5625 X_NUC_39.L_CORE X_NUC_135.L_CORE 0.002472
K_5626 X_NUC_39.L_CORE X_NUC_136.L_CORE 0.002536
K_5627 X_NUC_39.L_CORE X_NUC_137.L_CORE 0.005555
K_5628 X_NUC_39.L_CORE X_NUC_138.L_CORE 0.001953
K_5629 X_NUC_39.L_CORE X_NUC_139.L_CORE 0.004094
K_5630 X_NUC_39.L_CORE X_NUC_140.L_CORE 0.002746
K_5631 X_NUC_39.L_CORE X_NUC_141.L_CORE 0.001952
K_5632 X_NUC_39.L_CORE X_NUC_142.L_CORE 0.032651
K_5633 X_NUC_39.L_CORE X_NUC_143.L_CORE 0.001899
K_5634 X_NUC_39.L_CORE X_NUC_144.L_CORE 0.002560
K_5635 X_NUC_39.L_CORE X_NUC_145.L_CORE 0.003831
K_5636 X_NUC_39.L_CORE X_NUC_146.L_CORE 0.001712
K_5637 X_NUC_39.L_CORE X_NUC_147.L_CORE 0.005183
K_5638 X_NUC_39.L_CORE X_NUC_148.L_CORE 0.002096
K_5639 X_NUC_39.L_CORE X_NUC_149.L_CORE 0.001926
K_5640 X_NUC_39.L_CORE X_NUC_150.L_CORE 0.005490
K_5641 X_NUC_39.L_CORE X_NUC_151.L_CORE 0.001677
K_5642 X_NUC_39.L_CORE X_NUC_152.L_CORE 0.002735
K_5643 X_NUC_39.L_CORE X_NUC_153.L_CORE 0.002520
K_5644 X_NUC_39.L_CORE X_NUC_154.L_CORE 0.001678
K_5645 X_NUC_39.L_CORE X_NUC_155.L_CORE 0.003997
K_5646 X_NUC_39.L_CORE X_NUC_156.L_CORE 0.001793
K_5647 X_NUC_39.L_CORE X_NUC_157.L_CORE 0.002008
K_5648 X_NUC_39.L_CORE X_NUC_158.L_CORE 0.002864
K_5649 X_NUC_39.L_CORE X_NUC_159.L_CORE 0.001637
K_5650 X_NUC_39.L_CORE X_NUC_160.L_CORE 0.002563
K_5651 X_NUC_39.L_CORE X_NUC_161.L_CORE 0.001995
K_5652 X_NUC_39.L_CORE X_NUC_162.L_CORE 0.001769
K_5653 X_NUC_39.L_CORE X_NUC_163.L_CORE 0.002452
K_5654 X_NUC_39.L_CORE X_NUC_164.L_CORE 0.001770
K_5655 X_NUC_39.L_CORE X_NUC_165.L_CORE 0.001973
K_5656 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.001990
K_5657 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.002009
K_5658 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.001999
K_5659 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.001999
K_5660 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.002728
K_5661 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.002739
K_5662 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.002748
K_5663 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.002714
K_5664 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.003980
K_5665 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.004033
K_5666 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.003968
K_5667 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.004022
K_5668 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.001803
K_5669 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.001817
K_5670 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.001812
K_5671 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.001805
K_5672 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.005687
K_5673 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.005651
K_5674 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.005681
K_5675 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.005554
K_5676 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.002192
K_5677 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.002214
K_5678 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.002196
K_5679 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.002203
K_5680 X_NUC_40.L_CORE X_NUC_65.L_CORE 0.002040
K_5681 X_NUC_40.L_CORE X_NUC_66.L_CORE 0.002051
K_5682 X_NUC_40.L_CORE X_NUC_67.L_CORE 0.002050
K_5683 X_NUC_40.L_CORE X_NUC_68.L_CORE 0.002034
K_5684 X_NUC_40.L_CORE X_NUC_69.L_CORE 0.005794
K_5685 X_NUC_40.L_CORE X_NUC_70.L_CORE 0.005822
K_5686 X_NUC_40.L_CORE X_NUC_71.L_CORE 0.005673
K_5687 X_NUC_40.L_CORE X_NUC_72.L_CORE 0.005762
K_5688 X_NUC_40.L_CORE X_NUC_73.L_CORE 0.001762
K_5689 X_NUC_40.L_CORE X_NUC_74.L_CORE 0.001777
K_5690 X_NUC_40.L_CORE X_NUC_75.L_CORE 0.001768
K_5691 X_NUC_40.L_CORE X_NUC_76.L_CORE 0.001765
K_5692 X_NUC_40.L_CORE X_NUC_77.L_CORE 0.002925
K_5693 X_NUC_40.L_CORE X_NUC_78.L_CORE 0.002929
K_5694 X_NUC_40.L_CORE X_NUC_79.L_CORE 0.002930
K_5695 X_NUC_40.L_CORE X_NUC_80.L_CORE 0.002895
K_5696 X_NUC_40.L_CORE X_NUC_81.L_CORE 0.002635
K_5697 X_NUC_40.L_CORE X_NUC_82.L_CORE 0.002659
K_5698 X_NUC_40.L_CORE X_NUC_83.L_CORE 0.002626
K_5699 X_NUC_40.L_CORE X_NUC_84.L_CORE 0.002643
K_5700 X_NUC_40.L_CORE X_NUC_85.L_CORE 0.001771
K_5701 X_NUC_40.L_CORE X_NUC_86.L_CORE 0.001782
K_5702 X_NUC_40.L_CORE X_NUC_87.L_CORE 0.001777
K_5703 X_NUC_40.L_CORE X_NUC_88.L_CORE 0.001769
K_5704 X_NUC_40.L_CORE X_NUC_89.L_CORE 0.004287
K_5705 X_NUC_40.L_CORE X_NUC_90.L_CORE 0.004278
K_5706 X_NUC_40.L_CORE X_NUC_91.L_CORE 0.004232
K_5707 X_NUC_40.L_CORE X_NUC_92.L_CORE 0.004213
K_5708 X_NUC_40.L_CORE X_NUC_93.L_CORE 0.001882
K_5709 X_NUC_40.L_CORE X_NUC_94.L_CORE 0.001897
K_5710 X_NUC_40.L_CORE X_NUC_95.L_CORE 0.001883
K_5711 X_NUC_40.L_CORE X_NUC_96.L_CORE 0.001884
K_5712 X_NUC_40.L_CORE X_NUC_97.L_CORE 0.002130
K_5713 X_NUC_40.L_CORE X_NUC_98.L_CORE 0.002139
K_5714 X_NUC_40.L_CORE X_NUC_99.L_CORE 0.002134
K_5715 X_NUC_40.L_CORE X_NUC_100.L_CORE 0.002118
K_5716 X_NUC_40.L_CORE X_NUC_101.L_CORE 0.003011
K_5717 X_NUC_40.L_CORE X_NUC_102.L_CORE 0.003029
K_5718 X_NUC_40.L_CORE X_NUC_103.L_CORE 0.002986
K_5719 X_NUC_40.L_CORE X_NUC_104.L_CORE 0.003001
K_5720 X_NUC_40.L_CORE X_NUC_105.L_CORE 0.001724
K_5721 X_NUC_40.L_CORE X_NUC_106.L_CORE 0.001736
K_5722 X_NUC_40.L_CORE X_NUC_107.L_CORE 0.001727
K_5723 X_NUC_40.L_CORE X_NUC_108.L_CORE 0.001722
K_5724 X_NUC_40.L_CORE X_NUC_109.L_CORE 0.002728
K_5725 X_NUC_40.L_CORE X_NUC_110.L_CORE 0.002733
K_5726 X_NUC_40.L_CORE X_NUC_111.L_CORE 0.002718
K_5727 X_NUC_40.L_CORE X_NUC_112.L_CORE 0.002700
K_5728 X_NUC_40.L_CORE X_NUC_113.L_CORE 0.002096
K_5729 X_NUC_40.L_CORE X_NUC_114.L_CORE 0.002110
K_5730 X_NUC_40.L_CORE X_NUC_115.L_CORE 0.002091
K_5731 X_NUC_40.L_CORE X_NUC_116.L_CORE 0.002094
K_5732 X_NUC_40.L_CORE X_NUC_117.L_CORE 0.001869
K_5733 X_NUC_40.L_CORE X_NUC_118.L_CORE 0.001879
K_5734 X_NUC_40.L_CORE X_NUC_119.L_CORE 0.001871
K_5735 X_NUC_40.L_CORE X_NUC_120.L_CORE 0.001862
K_5736 X_NUC_40.L_CORE X_NUC_121.L_CORE 0.002592
K_5737 X_NUC_40.L_CORE X_NUC_122.L_CORE 0.002602
K_5738 X_NUC_40.L_CORE X_NUC_123.L_CORE 0.002576
K_5739 X_NUC_40.L_CORE X_NUC_124.L_CORE 0.002574
K_5740 X_NUC_40.L_CORE X_NUC_125.L_CORE 0.001864
K_5741 X_NUC_40.L_CORE X_NUC_126.L_CORE 0.001875
K_5742 X_NUC_40.L_CORE X_NUC_127.L_CORE 0.001862
K_5743 X_NUC_40.L_CORE X_NUC_128.L_CORE 0.001860
K_5744 X_NUC_40.L_CORE X_NUC_129.L_CORE 0.002086
K_5745 X_NUC_40.L_CORE X_NUC_130.L_CORE 0.002095
K_5746 X_NUC_40.L_CORE X_NUC_131.L_CORE 0.002081
K_5747 X_NUC_40.L_CORE X_NUC_132.L_CORE 0.002075
K_5748 X_NUC_40.L_CORE X_NUC_133.L_CORE 0.002580
K_5749 X_NUC_40.L_CORE X_NUC_134.L_CORE 0.004471
K_5750 X_NUC_40.L_CORE X_NUC_135.L_CORE 0.002472
K_5751 X_NUC_40.L_CORE X_NUC_136.L_CORE 0.002560
K_5752 X_NUC_40.L_CORE X_NUC_137.L_CORE 0.005491
K_5753 X_NUC_40.L_CORE X_NUC_138.L_CORE 0.001958
K_5754 X_NUC_40.L_CORE X_NUC_139.L_CORE 0.004171
K_5755 X_NUC_40.L_CORE X_NUC_140.L_CORE 0.002730
K_5756 X_NUC_40.L_CORE X_NUC_141.L_CORE 0.001965
K_5757 X_NUC_40.L_CORE X_NUC_142.L_CORE 0.031004
K_5758 X_NUC_40.L_CORE X_NUC_143.L_CORE 0.001899
K_5759 X_NUC_40.L_CORE X_NUC_144.L_CORE 0.002591
K_5760 X_NUC_40.L_CORE X_NUC_145.L_CORE 0.003778
K_5761 X_NUC_40.L_CORE X_NUC_146.L_CORE 0.001719
K_5762 X_NUC_40.L_CORE X_NUC_147.L_CORE 0.005291
K_5763 X_NUC_40.L_CORE X_NUC_148.L_CORE 0.002089
K_5764 X_NUC_40.L_CORE X_NUC_149.L_CORE 0.001941
K_5765 X_NUC_40.L_CORE X_NUC_150.L_CORE 0.005400
K_5766 X_NUC_40.L_CORE X_NUC_151.L_CORE 0.001680
K_5767 X_NUC_40.L_CORE X_NUC_152.L_CORE 0.002767
K_5768 X_NUC_40.L_CORE X_NUC_153.L_CORE 0.002504
K_5769 X_NUC_40.L_CORE X_NUC_154.L_CORE 0.001686
K_5770 X_NUC_40.L_CORE X_NUC_155.L_CORE 0.004012
K_5771 X_NUC_40.L_CORE X_NUC_156.L_CORE 0.001792
K_5772 X_NUC_40.L_CORE X_NUC_157.L_CORE 0.002022
K_5773 X_NUC_40.L_CORE X_NUC_158.L_CORE 0.002849
K_5774 X_NUC_40.L_CORE X_NUC_159.L_CORE 0.001641
K_5775 X_NUC_40.L_CORE X_NUC_160.L_CORE 0.002579
K_5776 X_NUC_40.L_CORE X_NUC_161.L_CORE 0.001992
K_5777 X_NUC_40.L_CORE X_NUC_162.L_CORE 0.001776
K_5778 X_NUC_40.L_CORE X_NUC_163.L_CORE 0.002453
K_5779 X_NUC_40.L_CORE X_NUC_164.L_CORE 0.001772
K_5780 X_NUC_40.L_CORE X_NUC_165.L_CORE 0.001979
K_5781 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_5782 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_5783 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_5784 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.001949
K_5785 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.001935
K_5786 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.001947
K_5787 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.001935
K_5788 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.002654
K_5789 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.002624
K_5790 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.002629
K_5791 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.002645
K_5792 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.003947
K_5793 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.003942
K_5794 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.003970
K_5795 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.003897
K_5796 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.001773
K_5797 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.001758
K_5798 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.001766
K_5799 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.001762
K_5800 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.005507
K_5801 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.005443
K_5802 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.005373
K_5803 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.005479
K_5804 X_NUC_41.L_CORE X_NUC_65.L_CORE 0.002173
K_5805 X_NUC_41.L_CORE X_NUC_66.L_CORE 0.002162
K_5806 X_NUC_41.L_CORE X_NUC_67.L_CORE 0.002173
K_5807 X_NUC_41.L_CORE X_NUC_68.L_CORE 0.002154
K_5808 X_NUC_41.L_CORE X_NUC_69.L_CORE 0.002011
K_5809 X_NUC_41.L_CORE X_NUC_70.L_CORE 0.001993
K_5810 X_NUC_41.L_CORE X_NUC_71.L_CORE 0.001996
K_5811 X_NUC_41.L_CORE X_NUC_72.L_CORE 0.002000
K_5812 X_NUC_41.L_CORE X_NUC_73.L_CORE 0.005781
K_5813 X_NUC_41.L_CORE X_NUC_74.L_CORE 0.005810
K_5814 X_NUC_41.L_CORE X_NUC_75.L_CORE 0.005745
K_5815 X_NUC_41.L_CORE X_NUC_76.L_CORE 0.005662
K_5816 X_NUC_41.L_CORE X_NUC_77.L_CORE 0.001751
K_5817 X_NUC_41.L_CORE X_NUC_78.L_CORE 0.001739
K_5818 X_NUC_41.L_CORE X_NUC_79.L_CORE 0.001746
K_5819 X_NUC_41.L_CORE X_NUC_80.L_CORE 0.001738
K_5820 X_NUC_41.L_CORE X_NUC_81.L_CORE 0.002884
K_5821 X_NUC_41.L_CORE X_NUC_82.L_CORE 0.002858
K_5822 X_NUC_41.L_CORE X_NUC_83.L_CORE 0.002846
K_5823 X_NUC_41.L_CORE X_NUC_84.L_CORE 0.002867
K_5824 X_NUC_41.L_CORE X_NUC_85.L_CORE 0.002635
K_5825 X_NUC_41.L_CORE X_NUC_86.L_CORE 0.002628
K_5826 X_NUC_41.L_CORE X_NUC_87.L_CORE 0.002633
K_5827 X_NUC_41.L_CORE X_NUC_88.L_CORE 0.002606
K_5828 X_NUC_41.L_CORE X_NUC_89.L_CORE 0.001765
K_5829 X_NUC_41.L_CORE X_NUC_90.L_CORE 0.001751
K_5830 X_NUC_41.L_CORE X_NUC_91.L_CORE 0.001755
K_5831 X_NUC_41.L_CORE X_NUC_92.L_CORE 0.001753
K_5832 X_NUC_41.L_CORE X_NUC_93.L_CORE 0.004213
K_5833 X_NUC_41.L_CORE X_NUC_94.L_CORE 0.004201
K_5834 X_NUC_41.L_CORE X_NUC_95.L_CORE 0.004141
K_5835 X_NUC_41.L_CORE X_NUC_96.L_CORE 0.004158
K_5836 X_NUC_41.L_CORE X_NUC_97.L_CORE 0.001888
K_5837 X_NUC_41.L_CORE X_NUC_98.L_CORE 0.001878
K_5838 X_NUC_41.L_CORE X_NUC_99.L_CORE 0.001883
K_5839 X_NUC_41.L_CORE X_NUC_100.L_CORE 0.001872
K_5840 X_NUC_41.L_CORE X_NUC_101.L_CORE 0.002125
K_5841 X_NUC_41.L_CORE X_NUC_102.L_CORE 0.002108
K_5842 X_NUC_41.L_CORE X_NUC_103.L_CORE 0.002105
K_5843 X_NUC_41.L_CORE X_NUC_104.L_CORE 0.002111
K_5844 X_NUC_41.L_CORE X_NUC_105.L_CORE 0.002995
K_5845 X_NUC_41.L_CORE X_NUC_106.L_CORE 0.002990
K_5846 X_NUC_41.L_CORE X_NUC_107.L_CORE 0.002978
K_5847 X_NUC_41.L_CORE X_NUC_108.L_CORE 0.002956
K_5848 X_NUC_41.L_CORE X_NUC_109.L_CORE 0.001740
K_5849 X_NUC_41.L_CORE X_NUC_110.L_CORE 0.001729
K_5850 X_NUC_41.L_CORE X_NUC_111.L_CORE 0.001732
K_5851 X_NUC_41.L_CORE X_NUC_112.L_CORE 0.001727
K_5852 X_NUC_41.L_CORE X_NUC_113.L_CORE 0.002689
K_5853 X_NUC_41.L_CORE X_NUC_114.L_CORE 0.002673
K_5854 X_NUC_41.L_CORE X_NUC_115.L_CORE 0.002656
K_5855 X_NUC_41.L_CORE X_NUC_116.L_CORE 0.002664
K_5856 X_NUC_41.L_CORE X_NUC_117.L_CORE 0.002114
K_5857 X_NUC_41.L_CORE X_NUC_118.L_CORE 0.002104
K_5858 X_NUC_41.L_CORE X_NUC_119.L_CORE 0.002104
K_5859 X_NUC_41.L_CORE X_NUC_120.L_CORE 0.002092
K_5860 X_NUC_41.L_CORE X_NUC_121.L_CORE 0.001900
K_5861 X_NUC_41.L_CORE X_NUC_122.L_CORE 0.001887
K_5862 X_NUC_41.L_CORE X_NUC_123.L_CORE 0.001886
K_5863 X_NUC_41.L_CORE X_NUC_124.L_CORE 0.001885
K_5864 X_NUC_41.L_CORE X_NUC_125.L_CORE 0.002490
K_5865 X_NUC_41.L_CORE X_NUC_126.L_CORE 0.002480
K_5866 X_NUC_41.L_CORE X_NUC_127.L_CORE 0.002468
K_5867 X_NUC_41.L_CORE X_NUC_128.L_CORE 0.002463
K_5868 X_NUC_41.L_CORE X_NUC_129.L_CORE 0.001952
K_5869 X_NUC_41.L_CORE X_NUC_130.L_CORE 0.001941
K_5870 X_NUC_41.L_CORE X_NUC_131.L_CORE 0.001939
K_5871 X_NUC_41.L_CORE X_NUC_132.L_CORE 0.001934
K_5872 X_NUC_41.L_CORE X_NUC_133.L_CORE 0.003086
K_5873 X_NUC_41.L_CORE X_NUC_134.L_CORE 0.002260
K_5874 X_NUC_41.L_CORE X_NUC_135.L_CORE 0.004768
K_5875 X_NUC_41.L_CORE X_NUC_136.L_CORE 0.002319
K_5876 X_NUC_41.L_CORE X_NUC_137.L_CORE 0.002410
K_5877 X_NUC_41.L_CORE X_NUC_138.L_CORE 0.005503
K_5878 X_NUC_41.L_CORE X_NUC_139.L_CORE 0.001866
K_5879 X_NUC_41.L_CORE X_NUC_140.L_CORE 0.003982
K_5880 X_NUC_41.L_CORE X_NUC_141.L_CORE 0.002643
K_5881 X_NUC_41.L_CORE X_NUC_142.L_CORE 0.001890
K_5882 X_NUC_41.L_CORE X_NUC_143.L_CORE 0.035844
K_5883 X_NUC_41.L_CORE X_NUC_144.L_CORE 0.001845
K_5884 X_NUC_41.L_CORE X_NUC_145.L_CORE 0.002504
K_5885 X_NUC_41.L_CORE X_NUC_146.L_CORE 0.003727
K_5886 X_NUC_41.L_CORE X_NUC_147.L_CORE 0.001677
K_5887 X_NUC_41.L_CORE X_NUC_148.L_CORE 0.005133
K_5888 X_NUC_41.L_CORE X_NUC_149.L_CORE 0.002057
K_5889 X_NUC_41.L_CORE X_NUC_150.L_CORE 0.001900
K_5890 X_NUC_41.L_CORE X_NUC_151.L_CORE 0.005408
K_5891 X_NUC_41.L_CORE X_NUC_152.L_CORE 0.001657
K_5892 X_NUC_41.L_CORE X_NUC_153.L_CORE 0.002717
K_5893 X_NUC_41.L_CORE X_NUC_154.L_CORE 0.002492
K_5894 X_NUC_41.L_CORE X_NUC_155.L_CORE 0.001669
K_5895 X_NUC_41.L_CORE X_NUC_156.L_CORE 0.003951
K_5896 X_NUC_41.L_CORE X_NUC_157.L_CORE 0.001787
K_5897 X_NUC_41.L_CORE X_NUC_158.L_CORE 0.002007
K_5898 X_NUC_41.L_CORE X_NUC_159.L_CORE 0.002826
K_5899 X_NUC_41.L_CORE X_NUC_160.L_CORE 0.001646
K_5900 X_NUC_41.L_CORE X_NUC_161.L_CORE 0.002534
K_5901 X_NUC_41.L_CORE X_NUC_162.L_CORE 0.001998
K_5902 X_NUC_41.L_CORE X_NUC_163.L_CORE 0.001796
K_5903 X_NUC_41.L_CORE X_NUC_164.L_CORE 0.002350
K_5904 X_NUC_41.L_CORE X_NUC_165.L_CORE 0.001845
K_5905 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_5906 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_5907 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.001963
K_5908 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.001949
K_5909 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.001961
K_5910 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.001949
K_5911 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.002684
K_5912 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.002654
K_5913 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.002658
K_5914 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.002674
K_5915 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.003950
K_5916 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.003947
K_5917 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.003974
K_5918 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.003901
K_5919 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.001787
K_5920 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.001773
K_5921 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.001780
K_5922 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.001777
K_5923 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.005568
K_5924 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.005507
K_5925 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.005432
K_5926 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.005542
K_5927 X_NUC_42.L_CORE X_NUC_65.L_CORE 0.002185
K_5928 X_NUC_42.L_CORE X_NUC_66.L_CORE 0.002173
K_5929 X_NUC_42.L_CORE X_NUC_67.L_CORE 0.002185
K_5930 X_NUC_42.L_CORE X_NUC_68.L_CORE 0.002166
K_5931 X_NUC_42.L_CORE X_NUC_69.L_CORE 0.002029
K_5932 X_NUC_42.L_CORE X_NUC_70.L_CORE 0.002011
K_5933 X_NUC_42.L_CORE X_NUC_71.L_CORE 0.002014
K_5934 X_NUC_42.L_CORE X_NUC_72.L_CORE 0.002019
K_5935 X_NUC_42.L_CORE X_NUC_73.L_CORE 0.005747
K_5936 X_NUC_42.L_CORE X_NUC_74.L_CORE 0.005781
K_5937 X_NUC_42.L_CORE X_NUC_75.L_CORE 0.005714
K_5938 X_NUC_42.L_CORE X_NUC_76.L_CORE 0.005632
K_5939 X_NUC_42.L_CORE X_NUC_77.L_CORE 0.001763
K_5940 X_NUC_42.L_CORE X_NUC_78.L_CORE 0.001751
K_5941 X_NUC_42.L_CORE X_NUC_79.L_CORE 0.001758
K_5942 X_NUC_42.L_CORE X_NUC_80.L_CORE 0.001750
K_5943 X_NUC_42.L_CORE X_NUC_81.L_CORE 0.002911
K_5944 X_NUC_42.L_CORE X_NUC_82.L_CORE 0.002884
K_5945 X_NUC_42.L_CORE X_NUC_83.L_CORE 0.002872
K_5946 X_NUC_42.L_CORE X_NUC_84.L_CORE 0.002894
K_5947 X_NUC_42.L_CORE X_NUC_85.L_CORE 0.002643
K_5948 X_NUC_42.L_CORE X_NUC_86.L_CORE 0.002635
K_5949 X_NUC_42.L_CORE X_NUC_87.L_CORE 0.002641
K_5950 X_NUC_42.L_CORE X_NUC_88.L_CORE 0.002613
K_5951 X_NUC_42.L_CORE X_NUC_89.L_CORE 0.001779
K_5952 X_NUC_42.L_CORE X_NUC_90.L_CORE 0.001765
K_5953 X_NUC_42.L_CORE X_NUC_91.L_CORE 0.001768
K_5954 X_NUC_42.L_CORE X_NUC_92.L_CORE 0.001767
K_5955 X_NUC_42.L_CORE X_NUC_93.L_CORE 0.004224
K_5956 X_NUC_42.L_CORE X_NUC_94.L_CORE 0.004213
K_5957 X_NUC_42.L_CORE X_NUC_95.L_CORE 0.004152
K_5958 X_NUC_42.L_CORE X_NUC_96.L_CORE 0.004169
K_5959 X_NUC_42.L_CORE X_NUC_97.L_CORE 0.001899
K_5960 X_NUC_42.L_CORE X_NUC_98.L_CORE 0.001888
K_5961 X_NUC_42.L_CORE X_NUC_99.L_CORE 0.001893
K_5962 X_NUC_42.L_CORE X_NUC_100.L_CORE 0.001882
K_5963 X_NUC_42.L_CORE X_NUC_101.L_CORE 0.002142
K_5964 X_NUC_42.L_CORE X_NUC_102.L_CORE 0.002125
K_5965 X_NUC_42.L_CORE X_NUC_103.L_CORE 0.002122
K_5966 X_NUC_42.L_CORE X_NUC_104.L_CORE 0.002128
K_5967 X_NUC_42.L_CORE X_NUC_105.L_CORE 0.003000
K_5968 X_NUC_42.L_CORE X_NUC_106.L_CORE 0.002995
K_5969 X_NUC_42.L_CORE X_NUC_107.L_CORE 0.002983
K_5970 X_NUC_42.L_CORE X_NUC_108.L_CORE 0.002961
K_5971 X_NUC_42.L_CORE X_NUC_109.L_CORE 0.001752
K_5972 X_NUC_42.L_CORE X_NUC_110.L_CORE 0.001740
K_5973 X_NUC_42.L_CORE X_NUC_111.L_CORE 0.001743
K_5974 X_NUC_42.L_CORE X_NUC_112.L_CORE 0.001739
K_5975 X_NUC_42.L_CORE X_NUC_113.L_CORE 0.002705
K_5976 X_NUC_42.L_CORE X_NUC_114.L_CORE 0.002689
K_5977 X_NUC_42.L_CORE X_NUC_115.L_CORE 0.002672
K_5978 X_NUC_42.L_CORE X_NUC_116.L_CORE 0.002680
K_5979 X_NUC_42.L_CORE X_NUC_117.L_CORE 0.002123
K_5980 X_NUC_42.L_CORE X_NUC_118.L_CORE 0.002114
K_5981 X_NUC_42.L_CORE X_NUC_119.L_CORE 0.002113
K_5982 X_NUC_42.L_CORE X_NUC_120.L_CORE 0.002101
K_5983 X_NUC_42.L_CORE X_NUC_121.L_CORE 0.001913
K_5984 X_NUC_42.L_CORE X_NUC_122.L_CORE 0.001900
K_5985 X_NUC_42.L_CORE X_NUC_123.L_CORE 0.001899
K_5986 X_NUC_42.L_CORE X_NUC_124.L_CORE 0.001898
K_5987 X_NUC_42.L_CORE X_NUC_125.L_CORE 0.002500
K_5988 X_NUC_42.L_CORE X_NUC_126.L_CORE 0.002490
K_5989 X_NUC_42.L_CORE X_NUC_127.L_CORE 0.002478
K_5990 X_NUC_42.L_CORE X_NUC_128.L_CORE 0.002473
K_5991 X_NUC_42.L_CORE X_NUC_129.L_CORE 0.001963
K_5992 X_NUC_42.L_CORE X_NUC_130.L_CORE 0.001952
K_5993 X_NUC_42.L_CORE X_NUC_131.L_CORE 0.001950
K_5994 X_NUC_42.L_CORE X_NUC_132.L_CORE 0.001945
K_5995 X_NUC_42.L_CORE X_NUC_133.L_CORE 0.003115
K_5996 X_NUC_42.L_CORE X_NUC_134.L_CORE 0.002282
K_5997 X_NUC_42.L_CORE X_NUC_135.L_CORE 0.004834
K_5998 X_NUC_42.L_CORE X_NUC_136.L_CORE 0.002336
K_5999 X_NUC_42.L_CORE X_NUC_137.L_CORE 0.002436
K_6000 X_NUC_42.L_CORE X_NUC_138.L_CORE 0.005520
K_6001 X_NUC_42.L_CORE X_NUC_139.L_CORE 0.001881
K_6002 X_NUC_42.L_CORE X_NUC_140.L_CORE 0.004036
K_6003 X_NUC_42.L_CORE X_NUC_141.L_CORE 0.002655
K_6004 X_NUC_42.L_CORE X_NUC_142.L_CORE 0.001908
K_6005 X_NUC_42.L_CORE X_NUC_143.L_CORE 0.031068
K_6006 X_NUC_42.L_CORE X_NUC_144.L_CORE 0.001857
K_6007 X_NUC_42.L_CORE X_NUC_145.L_CORE 0.002529
K_6008 X_NUC_42.L_CORE X_NUC_146.L_CORE 0.003724
K_6009 X_NUC_42.L_CORE X_NUC_147.L_CORE 0.001690
K_6010 X_NUC_42.L_CORE X_NUC_148.L_CORE 0.005172
K_6011 X_NUC_42.L_CORE X_NUC_149.L_CORE 0.002067
K_6012 X_NUC_42.L_CORE X_NUC_150.L_CORE 0.001917
K_6013 X_NUC_42.L_CORE X_NUC_151.L_CORE 0.005360
K_6014 X_NUC_42.L_CORE X_NUC_152.L_CORE 0.001668
K_6015 X_NUC_42.L_CORE X_NUC_153.L_CORE 0.002739
K_6016 X_NUC_42.L_CORE X_NUC_154.L_CORE 0.002497
K_6017 X_NUC_42.L_CORE X_NUC_155.L_CORE 0.001681
K_6018 X_NUC_42.L_CORE X_NUC_156.L_CORE 0.003954
K_6019 X_NUC_42.L_CORE X_NUC_157.L_CORE 0.001796
K_6020 X_NUC_42.L_CORE X_NUC_158.L_CORE 0.002022
K_6021 X_NUC_42.L_CORE X_NUC_159.L_CORE 0.002828
K_6022 X_NUC_42.L_CORE X_NUC_160.L_CORE 0.001656
K_6023 X_NUC_42.L_CORE X_NUC_161.L_CORE 0.002547
K_6024 X_NUC_42.L_CORE X_NUC_162.L_CORE 0.002006
K_6025 X_NUC_42.L_CORE X_NUC_163.L_CORE 0.001807
K_6026 X_NUC_42.L_CORE X_NUC_164.L_CORE 0.002358
K_6027 X_NUC_42.L_CORE X_NUC_165.L_CORE 0.001854
K_6028 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_6029 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.001950
K_6030 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.001936
K_6031 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.001949
K_6032 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.001937
K_6033 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.002679
K_6034 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.002649
K_6035 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.002654
K_6036 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.002670
K_6037 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.003923
K_6038 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.003919
K_6039 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.003947
K_6040 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.003875
K_6041 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.001779
K_6042 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.001765
K_6043 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.001773
K_6044 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.001769
K_6045 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.005647
K_6046 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.005581
K_6047 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.005507
K_6048 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.005619
K_6049 X_NUC_43.L_CORE X_NUC_65.L_CORE 0.002173
K_6050 X_NUC_43.L_CORE X_NUC_66.L_CORE 0.002162
K_6051 X_NUC_43.L_CORE X_NUC_67.L_CORE 0.002173
K_6052 X_NUC_43.L_CORE X_NUC_68.L_CORE 0.002154
K_6053 X_NUC_43.L_CORE X_NUC_69.L_CORE 0.002026
K_6054 X_NUC_43.L_CORE X_NUC_70.L_CORE 0.002007
K_6055 X_NUC_43.L_CORE X_NUC_71.L_CORE 0.002011
K_6056 X_NUC_43.L_CORE X_NUC_72.L_CORE 0.002015
K_6057 X_NUC_43.L_CORE X_NUC_73.L_CORE 0.005813
K_6058 X_NUC_43.L_CORE X_NUC_74.L_CORE 0.005845
K_6059 X_NUC_43.L_CORE X_NUC_75.L_CORE 0.005781
K_6060 X_NUC_43.L_CORE X_NUC_76.L_CORE 0.005694
K_6061 X_NUC_43.L_CORE X_NUC_77.L_CORE 0.001756
K_6062 X_NUC_43.L_CORE X_NUC_78.L_CORE 0.001744
K_6063 X_NUC_43.L_CORE X_NUC_79.L_CORE 0.001751
K_6064 X_NUC_43.L_CORE X_NUC_80.L_CORE 0.001744
K_6065 X_NUC_43.L_CORE X_NUC_81.L_CORE 0.002923
K_6066 X_NUC_43.L_CORE X_NUC_82.L_CORE 0.002896
K_6067 X_NUC_43.L_CORE X_NUC_83.L_CORE 0.002884
K_6068 X_NUC_43.L_CORE X_NUC_84.L_CORE 0.002906
K_6069 X_NUC_43.L_CORE X_NUC_85.L_CORE 0.002637
K_6070 X_NUC_43.L_CORE X_NUC_86.L_CORE 0.002630
K_6071 X_NUC_43.L_CORE X_NUC_87.L_CORE 0.002635
K_6072 X_NUC_43.L_CORE X_NUC_88.L_CORE 0.002608
K_6073 X_NUC_43.L_CORE X_NUC_89.L_CORE 0.001775
K_6074 X_NUC_43.L_CORE X_NUC_90.L_CORE 0.001761
K_6075 X_NUC_43.L_CORE X_NUC_91.L_CORE 0.001765
K_6076 X_NUC_43.L_CORE X_NUC_92.L_CORE 0.001764
K_6077 X_NUC_43.L_CORE X_NUC_93.L_CORE 0.004287
K_6078 X_NUC_43.L_CORE X_NUC_94.L_CORE 0.004275
K_6079 X_NUC_43.L_CORE X_NUC_95.L_CORE 0.004213
K_6080 X_NUC_43.L_CORE X_NUC_96.L_CORE 0.004230
K_6081 X_NUC_43.L_CORE X_NUC_97.L_CORE 0.001894
K_6082 X_NUC_43.L_CORE X_NUC_98.L_CORE 0.001883
K_6083 X_NUC_43.L_CORE X_NUC_99.L_CORE 0.001888
K_6084 X_NUC_43.L_CORE X_NUC_100.L_CORE 0.001877
K_6085 X_NUC_43.L_CORE X_NUC_101.L_CORE 0.002145
K_6086 X_NUC_43.L_CORE X_NUC_102.L_CORE 0.002128
K_6087 X_NUC_43.L_CORE X_NUC_103.L_CORE 0.002125
K_6088 X_NUC_43.L_CORE X_NUC_104.L_CORE 0.002131
K_6089 X_NUC_43.L_CORE X_NUC_105.L_CORE 0.003012
K_6090 X_NUC_43.L_CORE X_NUC_106.L_CORE 0.003007
K_6091 X_NUC_43.L_CORE X_NUC_107.L_CORE 0.002995
K_6092 X_NUC_43.L_CORE X_NUC_108.L_CORE 0.002973
K_6093 X_NUC_43.L_CORE X_NUC_109.L_CORE 0.001749
K_6094 X_NUC_43.L_CORE X_NUC_110.L_CORE 0.001738
K_6095 X_NUC_43.L_CORE X_NUC_111.L_CORE 0.001740
K_6096 X_NUC_43.L_CORE X_NUC_112.L_CORE 0.001736
K_6097 X_NUC_43.L_CORE X_NUC_113.L_CORE 0.002722
K_6098 X_NUC_43.L_CORE X_NUC_114.L_CORE 0.002706
K_6099 X_NUC_43.L_CORE X_NUC_115.L_CORE 0.002689
K_6100 X_NUC_43.L_CORE X_NUC_116.L_CORE 0.002697
K_6101 X_NUC_43.L_CORE X_NUC_117.L_CORE 0.002123
K_6102 X_NUC_43.L_CORE X_NUC_118.L_CORE 0.002114
K_6103 X_NUC_43.L_CORE X_NUC_119.L_CORE 0.002114
K_6104 X_NUC_43.L_CORE X_NUC_120.L_CORE 0.002102
K_6105 X_NUC_43.L_CORE X_NUC_121.L_CORE 0.001915
K_6106 X_NUC_43.L_CORE X_NUC_122.L_CORE 0.001902
K_6107 X_NUC_43.L_CORE X_NUC_123.L_CORE 0.001900
K_6108 X_NUC_43.L_CORE X_NUC_124.L_CORE 0.001900
K_6109 X_NUC_43.L_CORE X_NUC_125.L_CORE 0.002512
K_6110 X_NUC_43.L_CORE X_NUC_126.L_CORE 0.002502
K_6111 X_NUC_43.L_CORE X_NUC_127.L_CORE 0.002490
K_6112 X_NUC_43.L_CORE X_NUC_128.L_CORE 0.002485
K_6113 X_NUC_43.L_CORE X_NUC_129.L_CORE 0.001964
K_6114 X_NUC_43.L_CORE X_NUC_130.L_CORE 0.001954
K_6115 X_NUC_43.L_CORE X_NUC_131.L_CORE 0.001952
K_6116 X_NUC_43.L_CORE X_NUC_132.L_CORE 0.001946
K_6117 X_NUC_43.L_CORE X_NUC_133.L_CORE 0.003069
K_6118 X_NUC_43.L_CORE X_NUC_134.L_CORE 0.002261
K_6119 X_NUC_43.L_CORE X_NUC_135.L_CORE 0.004743
K_6120 X_NUC_43.L_CORE X_NUC_136.L_CORE 0.002312
K_6121 X_NUC_43.L_CORE X_NUC_137.L_CORE 0.002420
K_6122 X_NUC_43.L_CORE X_NUC_138.L_CORE 0.005395
K_6123 X_NUC_43.L_CORE X_NUC_139.L_CORE 0.001868
K_6124 X_NUC_43.L_CORE X_NUC_140.L_CORE 0.004019
K_6125 X_NUC_43.L_CORE X_NUC_141.L_CORE 0.002630
K_6126 X_NUC_43.L_CORE X_NUC_142.L_CORE 0.001899
K_6127 X_NUC_43.L_CORE X_NUC_143.L_CORE 0.032683
K_6128 X_NUC_43.L_CORE X_NUC_144.L_CORE 0.001846
K_6129 X_NUC_43.L_CORE X_NUC_145.L_CORE 0.002526
K_6130 X_NUC_43.L_CORE X_NUC_146.L_CORE 0.003702
K_6131 X_NUC_43.L_CORE X_NUC_147.L_CORE 0.001683
K_6132 X_NUC_43.L_CORE X_NUC_148.L_CORE 0.005248
K_6133 X_NUC_43.L_CORE X_NUC_149.L_CORE 0.002056
K_6134 X_NUC_43.L_CORE X_NUC_150.L_CORE 0.001913
K_6135 X_NUC_43.L_CORE X_NUC_151.L_CORE 0.005426
K_6136 X_NUC_43.L_CORE X_NUC_152.L_CORE 0.001662
K_6137 X_NUC_43.L_CORE X_NUC_153.L_CORE 0.002752
K_6138 X_NUC_43.L_CORE X_NUC_154.L_CORE 0.002493
K_6139 X_NUC_43.L_CORE X_NUC_155.L_CORE 0.001678
K_6140 X_NUC_43.L_CORE X_NUC_156.L_CORE 0.004015
K_6141 X_NUC_43.L_CORE X_NUC_157.L_CORE 0.001791
K_6142 X_NUC_43.L_CORE X_NUC_158.L_CORE 0.002025
K_6143 X_NUC_43.L_CORE X_NUC_159.L_CORE 0.002840
K_6144 X_NUC_43.L_CORE X_NUC_160.L_CORE 0.001654
K_6145 X_NUC_43.L_CORE X_NUC_161.L_CORE 0.002564
K_6146 X_NUC_43.L_CORE X_NUC_162.L_CORE 0.002006
K_6147 X_NUC_43.L_CORE X_NUC_163.L_CORE 0.001809
K_6148 X_NUC_43.L_CORE X_NUC_164.L_CORE 0.002370
K_6149 X_NUC_43.L_CORE X_NUC_165.L_CORE 0.001856
K_6150 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.001962
K_6151 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.001948
K_6152 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.001961
K_6153 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.001949
K_6154 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.002662
K_6155 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.002633
K_6156 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.002637
K_6157 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.002654
K_6158 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.003997
K_6159 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.003992
K_6160 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.004021
K_6161 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.003947
K_6162 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.001783
K_6163 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.001769
K_6164 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.001776
K_6165 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.001773
K_6166 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.005531
K_6167 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.005469
K_6168 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.005397
K_6169 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.005507
K_6170 X_NUC_44.L_CORE X_NUC_65.L_CORE 0.002192
K_6171 X_NUC_44.L_CORE X_NUC_66.L_CORE 0.002181
K_6172 X_NUC_44.L_CORE X_NUC_67.L_CORE 0.002192
K_6173 X_NUC_44.L_CORE X_NUC_68.L_CORE 0.002173
K_6174 X_NUC_44.L_CORE X_NUC_69.L_CORE 0.002021
K_6175 X_NUC_44.L_CORE X_NUC_70.L_CORE 0.002003
K_6176 X_NUC_44.L_CORE X_NUC_71.L_CORE 0.002007
K_6177 X_NUC_44.L_CORE X_NUC_72.L_CORE 0.002011
K_6178 X_NUC_44.L_CORE X_NUC_73.L_CORE 0.005903
K_6179 X_NUC_44.L_CORE X_NUC_74.L_CORE 0.005937
K_6180 X_NUC_44.L_CORE X_NUC_75.L_CORE 0.005867
K_6181 X_NUC_44.L_CORE X_NUC_76.L_CORE 0.005781
K_6182 X_NUC_44.L_CORE X_NUC_77.L_CORE 0.001764
K_6183 X_NUC_44.L_CORE X_NUC_78.L_CORE 0.001752
K_6184 X_NUC_44.L_CORE X_NUC_79.L_CORE 0.001758
K_6185 X_NUC_44.L_CORE X_NUC_80.L_CORE 0.001751
K_6186 X_NUC_44.L_CORE X_NUC_81.L_CORE 0.002901
K_6187 X_NUC_44.L_CORE X_NUC_82.L_CORE 0.002874
K_6188 X_NUC_44.L_CORE X_NUC_83.L_CORE 0.002862
K_6189 X_NUC_44.L_CORE X_NUC_84.L_CORE 0.002884
K_6190 X_NUC_44.L_CORE X_NUC_85.L_CORE 0.002665
K_6191 X_NUC_44.L_CORE X_NUC_86.L_CORE 0.002658
K_6192 X_NUC_44.L_CORE X_NUC_87.L_CORE 0.002663
K_6193 X_NUC_44.L_CORE X_NUC_88.L_CORE 0.002635
K_6194 X_NUC_44.L_CORE X_NUC_89.L_CORE 0.001776
K_6195 X_NUC_44.L_CORE X_NUC_90.L_CORE 0.001762
K_6196 X_NUC_44.L_CORE X_NUC_91.L_CORE 0.001766
K_6197 X_NUC_44.L_CORE X_NUC_92.L_CORE 0.001765
K_6198 X_NUC_44.L_CORE X_NUC_93.L_CORE 0.004269
K_6199 X_NUC_44.L_CORE X_NUC_94.L_CORE 0.004257
K_6200 X_NUC_44.L_CORE X_NUC_95.L_CORE 0.004195
K_6201 X_NUC_44.L_CORE X_NUC_96.L_CORE 0.004213
K_6202 X_NUC_44.L_CORE X_NUC_97.L_CORE 0.001905
K_6203 X_NUC_44.L_CORE X_NUC_98.L_CORE 0.001894
K_6204 X_NUC_44.L_CORE X_NUC_99.L_CORE 0.001899
K_6205 X_NUC_44.L_CORE X_NUC_100.L_CORE 0.001888
K_6206 X_NUC_44.L_CORE X_NUC_101.L_CORE 0.002139
K_6207 X_NUC_44.L_CORE X_NUC_102.L_CORE 0.002122
K_6208 X_NUC_44.L_CORE X_NUC_103.L_CORE 0.002119
K_6209 X_NUC_44.L_CORE X_NUC_104.L_CORE 0.002125
K_6210 X_NUC_44.L_CORE X_NUC_105.L_CORE 0.003035
K_6211 X_NUC_44.L_CORE X_NUC_106.L_CORE 0.003030
K_6212 X_NUC_44.L_CORE X_NUC_107.L_CORE 0.003017
K_6213 X_NUC_44.L_CORE X_NUC_108.L_CORE 0.002995
K_6214 X_NUC_44.L_CORE X_NUC_109.L_CORE 0.001754
K_6215 X_NUC_44.L_CORE X_NUC_110.L_CORE 0.001742
K_6216 X_NUC_44.L_CORE X_NUC_111.L_CORE 0.001745
K_6217 X_NUC_44.L_CORE X_NUC_112.L_CORE 0.001740
K_6218 X_NUC_44.L_CORE X_NUC_113.L_CORE 0.002714
K_6219 X_NUC_44.L_CORE X_NUC_114.L_CORE 0.002698
K_6220 X_NUC_44.L_CORE X_NUC_115.L_CORE 0.002680
K_6221 X_NUC_44.L_CORE X_NUC_116.L_CORE 0.002689
K_6222 X_NUC_44.L_CORE X_NUC_117.L_CORE 0.002135
K_6223 X_NUC_44.L_CORE X_NUC_118.L_CORE 0.002126
K_6224 X_NUC_44.L_CORE X_NUC_119.L_CORE 0.002126
K_6225 X_NUC_44.L_CORE X_NUC_120.L_CORE 0.002114
K_6226 X_NUC_44.L_CORE X_NUC_121.L_CORE 0.001915
K_6227 X_NUC_44.L_CORE X_NUC_122.L_CORE 0.001902
K_6228 X_NUC_44.L_CORE X_NUC_123.L_CORE 0.001901
K_6229 X_NUC_44.L_CORE X_NUC_124.L_CORE 0.001900
K_6230 X_NUC_44.L_CORE X_NUC_125.L_CORE 0.002517
K_6231 X_NUC_44.L_CORE X_NUC_126.L_CORE 0.002507
K_6232 X_NUC_44.L_CORE X_NUC_127.L_CORE 0.002495
K_6233 X_NUC_44.L_CORE X_NUC_128.L_CORE 0.002490
K_6234 X_NUC_44.L_CORE X_NUC_129.L_CORE 0.001970
K_6235 X_NUC_44.L_CORE X_NUC_130.L_CORE 0.001959
K_6236 X_NUC_44.L_CORE X_NUC_131.L_CORE 0.001957
K_6237 X_NUC_44.L_CORE X_NUC_132.L_CORE 0.001952
K_6238 X_NUC_44.L_CORE X_NUC_133.L_CORE 0.003090
K_6239 X_NUC_44.L_CORE X_NUC_134.L_CORE 0.002266
K_6240 X_NUC_44.L_CORE X_NUC_135.L_CORE 0.004734
K_6241 X_NUC_44.L_CORE X_NUC_136.L_CORE 0.002330
K_6242 X_NUC_44.L_CORE X_NUC_137.L_CORE 0.002414
K_6243 X_NUC_44.L_CORE X_NUC_138.L_CORE 0.005508
K_6244 X_NUC_44.L_CORE X_NUC_139.L_CORE 0.001875
K_6245 X_NUC_44.L_CORE X_NUC_140.L_CORE 0.003968
K_6246 X_NUC_44.L_CORE X_NUC_141.L_CORE 0.002661
K_6247 X_NUC_44.L_CORE X_NUC_142.L_CORE 0.001898
K_6248 X_NUC_44.L_CORE X_NUC_143.L_CORE 0.031165
K_6249 X_NUC_44.L_CORE X_NUC_144.L_CORE 0.001857
K_6250 X_NUC_44.L_CORE X_NUC_145.L_CORE 0.002510
K_6251 X_NUC_44.L_CORE X_NUC_146.L_CORE 0.003768
K_6252 X_NUC_44.L_CORE X_NUC_147.L_CORE 0.001686
K_6253 X_NUC_44.L_CORE X_NUC_148.L_CORE 0.005139
K_6254 X_NUC_44.L_CORE X_NUC_149.L_CORE 0.002074
K_6255 X_NUC_44.L_CORE X_NUC_150.L_CORE 0.001909
K_6256 X_NUC_44.L_CORE X_NUC_151.L_CORE 0.005500
K_6257 X_NUC_44.L_CORE X_NUC_152.L_CORE 0.001668
K_6258 X_NUC_44.L_CORE X_NUC_153.L_CORE 0.002730
K_6259 X_NUC_44.L_CORE X_NUC_154.L_CORE 0.002518
K_6260 X_NUC_44.L_CORE X_NUC_155.L_CORE 0.001679
K_6261 X_NUC_44.L_CORE X_NUC_156.L_CORE 0.003995
K_6262 X_NUC_44.L_CORE X_NUC_157.L_CORE 0.001801
K_6263 X_NUC_44.L_CORE X_NUC_158.L_CORE 0.002019
K_6264 X_NUC_44.L_CORE X_NUC_159.L_CORE 0.002861
K_6265 X_NUC_44.L_CORE X_NUC_160.L_CORE 0.001658
K_6266 X_NUC_44.L_CORE X_NUC_161.L_CORE 0.002556
K_6267 X_NUC_44.L_CORE X_NUC_162.L_CORE 0.002017
K_6268 X_NUC_44.L_CORE X_NUC_163.L_CORE 0.001809
K_6269 X_NUC_44.L_CORE X_NUC_164.L_CORE 0.002374
K_6270 X_NUC_44.L_CORE X_NUC_165.L_CORE 0.001861
K_6271 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_6272 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_6273 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_6274 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.001910
K_6275 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.001911
K_6276 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.001901
K_6277 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.001919
K_6278 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.002607
K_6279 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.002639
K_6280 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.002617
K_6281 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.002625
K_6282 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.003889
K_6283 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.003845
K_6284 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.003830
K_6285 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.003884
K_6286 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.001749
K_6287 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.001756
K_6288 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.001745
K_6289 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.001757
K_6290 X_NUC_45.L_CORE X_NUC_65.L_CORE 0.005471
K_6291 X_NUC_45.L_CORE X_NUC_66.L_CORE 0.005595
K_6292 X_NUC_45.L_CORE X_NUC_67.L_CORE 0.005498
K_6293 X_NUC_45.L_CORE X_NUC_68.L_CORE 0.005463
K_6294 X_NUC_45.L_CORE X_NUC_69.L_CORE 0.002153
K_6295 X_NUC_45.L_CORE X_NUC_70.L_CORE 0.002149
K_6296 X_NUC_45.L_CORE X_NUC_71.L_CORE 0.002137
K_6297 X_NUC_45.L_CORE X_NUC_72.L_CORE 0.002158
K_6298 X_NUC_45.L_CORE X_NUC_73.L_CORE 0.001996
K_6299 X_NUC_45.L_CORE X_NUC_74.L_CORE 0.002012
K_6300 X_NUC_45.L_CORE X_NUC_75.L_CORE 0.001995
K_6301 X_NUC_45.L_CORE X_NUC_76.L_CORE 0.002005
K_6302 X_NUC_45.L_CORE X_NUC_77.L_CORE 0.005792
K_6303 X_NUC_45.L_CORE X_NUC_78.L_CORE 0.005713
K_6304 X_NUC_45.L_CORE X_NUC_79.L_CORE 0.005638
K_6305 X_NUC_45.L_CORE X_NUC_80.L_CORE 0.005685
K_6306 X_NUC_45.L_CORE X_NUC_81.L_CORE 0.001744
K_6307 X_NUC_45.L_CORE X_NUC_82.L_CORE 0.001748
K_6308 X_NUC_45.L_CORE X_NUC_83.L_CORE 0.001736
K_6309 X_NUC_45.L_CORE X_NUC_84.L_CORE 0.001750
K_6310 X_NUC_45.L_CORE X_NUC_85.L_CORE 0.002880
K_6311 X_NUC_45.L_CORE X_NUC_86.L_CORE 0.002915
K_6312 X_NUC_45.L_CORE X_NUC_87.L_CORE 0.002881
K_6313 X_NUC_45.L_CORE X_NUC_88.L_CORE 0.002884
K_6314 X_NUC_45.L_CORE X_NUC_89.L_CORE 0.002635
K_6315 X_NUC_45.L_CORE X_NUC_90.L_CORE 0.002623
K_6316 X_NUC_45.L_CORE X_NUC_91.L_CORE 0.002604
K_6317 X_NUC_45.L_CORE X_NUC_92.L_CORE 0.002630
K_6318 X_NUC_45.L_CORE X_NUC_93.L_CORE 0.001769
K_6319 X_NUC_45.L_CORE X_NUC_94.L_CORE 0.001778
K_6320 X_NUC_45.L_CORE X_NUC_95.L_CORE 0.001764
K_6321 X_NUC_45.L_CORE X_NUC_96.L_CORE 0.001774
K_6322 X_NUC_45.L_CORE X_NUC_97.L_CORE 0.004197
K_6323 X_NUC_45.L_CORE X_NUC_98.L_CORE 0.004219
K_6324 X_NUC_45.L_CORE X_NUC_99.L_CORE 0.004151
K_6325 X_NUC_45.L_CORE X_NUC_100.L_CORE 0.004151
K_6326 X_NUC_45.L_CORE X_NUC_101.L_CORE 0.001900
K_6327 X_NUC_45.L_CORE X_NUC_102.L_CORE 0.001900
K_6328 X_NUC_45.L_CORE X_NUC_103.L_CORE 0.001887
K_6329 X_NUC_45.L_CORE X_NUC_104.L_CORE 0.001902
K_6330 X_NUC_45.L_CORE X_NUC_105.L_CORE 0.002140
K_6331 X_NUC_45.L_CORE X_NUC_106.L_CORE 0.002156
K_6332 X_NUC_45.L_CORE X_NUC_107.L_CORE 0.002135
K_6333 X_NUC_45.L_CORE X_NUC_108.L_CORE 0.002143
K_6334 X_NUC_45.L_CORE X_NUC_109.L_CORE 0.002984
K_6335 X_NUC_45.L_CORE X_NUC_110.L_CORE 0.002974
K_6336 X_NUC_45.L_CORE X_NUC_111.L_CORE 0.002943
K_6337 X_NUC_45.L_CORE X_NUC_112.L_CORE 0.002964
K_6338 X_NUC_45.L_CORE X_NUC_113.L_CORE 0.001769
K_6339 X_NUC_45.L_CORE X_NUC_114.L_CORE 0.001775
K_6340 X_NUC_45.L_CORE X_NUC_115.L_CORE 0.001761
K_6341 X_NUC_45.L_CORE X_NUC_116.L_CORE 0.001772
K_6342 X_NUC_45.L_CORE X_NUC_117.L_CORE 0.002670
K_6343 X_NUC_45.L_CORE X_NUC_118.L_CORE 0.002687
K_6344 X_NUC_45.L_CORE X_NUC_119.L_CORE 0.002654
K_6345 X_NUC_45.L_CORE X_NUC_120.L_CORE 0.002661
K_6346 X_NUC_45.L_CORE X_NUC_121.L_CORE 0.002140
K_6347 X_NUC_45.L_CORE X_NUC_122.L_CORE 0.002140
K_6348 X_NUC_45.L_CORE X_NUC_123.L_CORE 0.002121
K_6349 X_NUC_45.L_CORE X_NUC_124.L_CORE 0.002136
K_6350 X_NUC_45.L_CORE X_NUC_125.L_CORE 0.001958
K_6351 X_NUC_45.L_CORE X_NUC_126.L_CORE 0.001967
K_6352 X_NUC_45.L_CORE X_NUC_127.L_CORE 0.001949
K_6353 X_NUC_45.L_CORE X_NUC_128.L_CORE 0.001958
K_6354 X_NUC_45.L_CORE X_NUC_129.L_CORE 0.002349
K_6355 X_NUC_45.L_CORE X_NUC_130.L_CORE 0.002354
K_6356 X_NUC_45.L_CORE X_NUC_131.L_CORE 0.002329
K_6357 X_NUC_45.L_CORE X_NUC_132.L_CORE 0.002341
K_6358 X_NUC_45.L_CORE X_NUC_133.L_CORE 0.002897
K_6359 X_NUC_45.L_CORE X_NUC_134.L_CORE 0.003085
K_6360 X_NUC_45.L_CORE X_NUC_135.L_CORE 0.002100
K_6361 X_NUC_45.L_CORE X_NUC_136.L_CORE 0.005035
K_6362 X_NUC_45.L_CORE X_NUC_137.L_CORE 0.002214
K_6363 X_NUC_45.L_CORE X_NUC_138.L_CORE 0.002332
K_6364 X_NUC_45.L_CORE X_NUC_139.L_CORE 0.005397
K_6365 X_NUC_45.L_CORE X_NUC_140.L_CORE 0.001811
K_6366 X_NUC_45.L_CORE X_NUC_141.L_CORE 0.003932
K_6367 X_NUC_45.L_CORE X_NUC_142.L_CORE 0.002570
K_6368 X_NUC_45.L_CORE X_NUC_143.L_CORE 0.001858
K_6369 X_NUC_45.L_CORE X_NUC_144.L_CORE 0.031969
K_6370 X_NUC_45.L_CORE X_NUC_145.L_CORE 0.001815
K_6371 X_NUC_45.L_CORE X_NUC_146.L_CORE 0.002487
K_6372 X_NUC_45.L_CORE X_NUC_147.L_CORE 0.003650
K_6373 X_NUC_45.L_CORE X_NUC_148.L_CORE 0.001664
K_6374 X_NUC_45.L_CORE X_NUC_149.L_CORE 0.005171
K_6375 X_NUC_45.L_CORE X_NUC_150.L_CORE 0.002040
K_6376 X_NUC_45.L_CORE X_NUC_151.L_CORE 0.001901
K_6377 X_NUC_45.L_CORE X_NUC_152.L_CORE 0.005354
K_6378 X_NUC_45.L_CORE X_NUC_153.L_CORE 0.001658
K_6379 X_NUC_45.L_CORE X_NUC_154.L_CORE 0.002740
K_6380 X_NUC_45.L_CORE X_NUC_155.L_CORE 0.002488
K_6381 X_NUC_45.L_CORE X_NUC_156.L_CORE 0.001683
K_6382 X_NUC_45.L_CORE X_NUC_157.L_CORE 0.003946
K_6383 X_NUC_45.L_CORE X_NUC_158.L_CORE 0.001802
K_6384 X_NUC_45.L_CORE X_NUC_159.L_CORE 0.002035
K_6385 X_NUC_45.L_CORE X_NUC_160.L_CORE 0.002811
K_6386 X_NUC_45.L_CORE X_NUC_161.L_CORE 0.001681
K_6387 X_NUC_45.L_CORE X_NUC_162.L_CORE 0.002530
K_6388 X_NUC_45.L_CORE X_NUC_163.L_CORE 0.002027
K_6389 X_NUC_45.L_CORE X_NUC_164.L_CORE 0.001860
K_6390 X_NUC_45.L_CORE X_NUC_165.L_CORE 0.002224
K_6391 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_6392 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_6393 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.001908
K_6394 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.001910
K_6395 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.001900
K_6396 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.001917
K_6397 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.002576
K_6398 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.002607
K_6399 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.002585
K_6400 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.002593
K_6401 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.003934
K_6402 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.003889
K_6403 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.003873
K_6404 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.003929
K_6405 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.001741
K_6406 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.001749
K_6407 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.001737
K_6408 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.001749
K_6409 X_NUC_46.L_CORE X_NUC_65.L_CORE 0.005353
K_6410 X_NUC_46.L_CORE X_NUC_66.L_CORE 0.005471
K_6411 X_NUC_46.L_CORE X_NUC_67.L_CORE 0.005380
K_6412 X_NUC_46.L_CORE X_NUC_68.L_CORE 0.005347
K_6413 X_NUC_46.L_CORE X_NUC_69.L_CORE 0.002157
K_6414 X_NUC_46.L_CORE X_NUC_70.L_CORE 0.002153
K_6415 X_NUC_46.L_CORE X_NUC_71.L_CORE 0.002141
K_6416 X_NUC_46.L_CORE X_NUC_72.L_CORE 0.002162
K_6417 X_NUC_46.L_CORE X_NUC_73.L_CORE 0.001980
K_6418 X_NUC_46.L_CORE X_NUC_74.L_CORE 0.001996
K_6419 X_NUC_46.L_CORE X_NUC_75.L_CORE 0.001980
K_6420 X_NUC_46.L_CORE X_NUC_76.L_CORE 0.001989
K_6421 X_NUC_46.L_CORE X_NUC_77.L_CORE 0.005869
K_6422 X_NUC_46.L_CORE X_NUC_78.L_CORE 0.005792
K_6423 X_NUC_46.L_CORE X_NUC_79.L_CORE 0.005712
K_6424 X_NUC_46.L_CORE X_NUC_80.L_CORE 0.005760
K_6425 X_NUC_46.L_CORE X_NUC_81.L_CORE 0.001740
K_6426 X_NUC_46.L_CORE X_NUC_82.L_CORE 0.001744
K_6427 X_NUC_46.L_CORE X_NUC_83.L_CORE 0.001733
K_6428 X_NUC_46.L_CORE X_NUC_84.L_CORE 0.001746
K_6429 X_NUC_46.L_CORE X_NUC_85.L_CORE 0.002847
K_6430 X_NUC_46.L_CORE X_NUC_86.L_CORE 0.002880
K_6431 X_NUC_46.L_CORE X_NUC_87.L_CORE 0.002848
K_6432 X_NUC_46.L_CORE X_NUC_88.L_CORE 0.002851
K_6433 X_NUC_46.L_CORE X_NUC_89.L_CORE 0.002647
K_6434 X_NUC_46.L_CORE X_NUC_90.L_CORE 0.002635
K_6435 X_NUC_46.L_CORE X_NUC_91.L_CORE 0.002616
K_6436 X_NUC_46.L_CORE X_NUC_92.L_CORE 0.002642
K_6437 X_NUC_46.L_CORE X_NUC_93.L_CORE 0.001759
K_6438 X_NUC_46.L_CORE X_NUC_94.L_CORE 0.001769
K_6439 X_NUC_46.L_CORE X_NUC_95.L_CORE 0.001755
K_6440 X_NUC_46.L_CORE X_NUC_96.L_CORE 0.001765
K_6441 X_NUC_46.L_CORE X_NUC_97.L_CORE 0.004175
K_6442 X_NUC_46.L_CORE X_NUC_98.L_CORE 0.004197
K_6443 X_NUC_46.L_CORE X_NUC_99.L_CORE 0.004129
K_6444 X_NUC_46.L_CORE X_NUC_100.L_CORE 0.004129
K_6445 X_NUC_46.L_CORE X_NUC_101.L_CORE 0.001899
K_6446 X_NUC_46.L_CORE X_NUC_102.L_CORE 0.001900
K_6447 X_NUC_46.L_CORE X_NUC_103.L_CORE 0.001886
K_6448 X_NUC_46.L_CORE X_NUC_104.L_CORE 0.001902
K_6449 X_NUC_46.L_CORE X_NUC_105.L_CORE 0.002123
K_6450 X_NUC_46.L_CORE X_NUC_106.L_CORE 0.002140
K_6451 X_NUC_46.L_CORE X_NUC_107.L_CORE 0.002119
K_6452 X_NUC_46.L_CORE X_NUC_108.L_CORE 0.002127
K_6453 X_NUC_46.L_CORE X_NUC_109.L_CORE 0.002993
K_6454 X_NUC_46.L_CORE X_NUC_110.L_CORE 0.002984
K_6455 X_NUC_46.L_CORE X_NUC_111.L_CORE 0.002952
K_6456 X_NUC_46.L_CORE X_NUC_112.L_CORE 0.002973
K_6457 X_NUC_46.L_CORE X_NUC_113.L_CORE 0.001763
K_6458 X_NUC_46.L_CORE X_NUC_114.L_CORE 0.001769
K_6459 X_NUC_46.L_CORE X_NUC_115.L_CORE 0.001755
K_6460 X_NUC_46.L_CORE X_NUC_116.L_CORE 0.001766
K_6461 X_NUC_46.L_CORE X_NUC_117.L_CORE 0.002653
K_6462 X_NUC_46.L_CORE X_NUC_118.L_CORE 0.002670
K_6463 X_NUC_46.L_CORE X_NUC_119.L_CORE 0.002638
K_6464 X_NUC_46.L_CORE X_NUC_120.L_CORE 0.002645
K_6465 X_NUC_46.L_CORE X_NUC_121.L_CORE 0.002140
K_6466 X_NUC_46.L_CORE X_NUC_122.L_CORE 0.002140
K_6467 X_NUC_46.L_CORE X_NUC_123.L_CORE 0.002122
K_6468 X_NUC_46.L_CORE X_NUC_124.L_CORE 0.002137
K_6469 X_NUC_46.L_CORE X_NUC_125.L_CORE 0.001949
K_6470 X_NUC_46.L_CORE X_NUC_126.L_CORE 0.001958
K_6471 X_NUC_46.L_CORE X_NUC_127.L_CORE 0.001940
K_6472 X_NUC_46.L_CORE X_NUC_128.L_CORE 0.001949
K_6473 X_NUC_46.L_CORE X_NUC_129.L_CORE 0.002343
K_6474 X_NUC_46.L_CORE X_NUC_130.L_CORE 0.002349
K_6475 X_NUC_46.L_CORE X_NUC_131.L_CORE 0.002324
K_6476 X_NUC_46.L_CORE X_NUC_132.L_CORE 0.002336
K_6477 X_NUC_46.L_CORE X_NUC_133.L_CORE 0.002875
K_6478 X_NUC_46.L_CORE X_NUC_134.L_CORE 0.003086
K_6479 X_NUC_46.L_CORE X_NUC_135.L_CORE 0.002088
K_6480 X_NUC_46.L_CORE X_NUC_136.L_CORE 0.004973
K_6481 X_NUC_46.L_CORE X_NUC_137.L_CORE 0.002214
K_6482 X_NUC_46.L_CORE X_NUC_138.L_CORE 0.002311
K_6483 X_NUC_46.L_CORE X_NUC_139.L_CORE 0.005469
K_6484 X_NUC_46.L_CORE X_NUC_140.L_CORE 0.001805
K_6485 X_NUC_46.L_CORE X_NUC_141.L_CORE 0.003861
K_6486 X_NUC_46.L_CORE X_NUC_142.L_CORE 0.002582
K_6487 X_NUC_46.L_CORE X_NUC_143.L_CORE 0.001845
K_6488 X_NUC_46.L_CORE X_NUC_144.L_CORE 0.034329
K_6489 X_NUC_46.L_CORE X_NUC_145.L_CORE 0.001813
K_6490 X_NUC_46.L_CORE X_NUC_146.L_CORE 0.002458
K_6491 X_NUC_46.L_CORE X_NUC_147.L_CORE 0.003695
K_6492 X_NUC_46.L_CORE X_NUC_148.L_CORE 0.001657
K_6493 X_NUC_46.L_CORE X_NUC_149.L_CORE 0.005070
K_6494 X_NUC_46.L_CORE X_NUC_150.L_CORE 0.002045
K_6495 X_NUC_46.L_CORE X_NUC_151.L_CORE 0.001887
K_6496 X_NUC_46.L_CORE X_NUC_152.L_CORE 0.005433
K_6497 X_NUC_46.L_CORE X_NUC_153.L_CORE 0.001654
K_6498 X_NUC_46.L_CORE X_NUC_154.L_CORE 0.002709
K_6499 X_NUC_46.L_CORE X_NUC_155.L_CORE 0.002501
K_6500 X_NUC_46.L_CORE X_NUC_156.L_CORE 0.001674
K_6501 X_NUC_46.L_CORE X_NUC_157.L_CORE 0.003930
K_6502 X_NUC_46.L_CORE X_NUC_158.L_CORE 0.001802
K_6503 X_NUC_46.L_CORE X_NUC_159.L_CORE 0.002020
K_6504 X_NUC_46.L_CORE X_NUC_160.L_CORE 0.002821
K_6505 X_NUC_46.L_CORE X_NUC_161.L_CORE 0.001676
K_6506 X_NUC_46.L_CORE X_NUC_162.L_CORE 0.002516
K_6507 X_NUC_46.L_CORE X_NUC_163.L_CORE 0.002027
K_6508 X_NUC_46.L_CORE X_NUC_164.L_CORE 0.001852
K_6509 X_NUC_46.L_CORE X_NUC_165.L_CORE 0.002220
K_6510 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_6511 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.001918
K_6512 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.001920
K_6513 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.001910
K_6514 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.001927
K_6515 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.002597
K_6516 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.002629
K_6517 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.002607
K_6518 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.002615
K_6519 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.003951
K_6520 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.003905
K_6521 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.003889
K_6522 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.003946
K_6523 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.001752
K_6524 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.001760
K_6525 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.001749
K_6526 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.001761
K_6527 X_NUC_47.L_CORE X_NUC_65.L_CORE 0.005441
K_6528 X_NUC_47.L_CORE X_NUC_66.L_CORE 0.005564
K_6529 X_NUC_47.L_CORE X_NUC_67.L_CORE 0.005471
K_6530 X_NUC_47.L_CORE X_NUC_68.L_CORE 0.005435
K_6531 X_NUC_47.L_CORE X_NUC_69.L_CORE 0.002169
K_6532 X_NUC_47.L_CORE X_NUC_70.L_CORE 0.002165
K_6533 X_NUC_47.L_CORE X_NUC_71.L_CORE 0.002153
K_6534 X_NUC_47.L_CORE X_NUC_72.L_CORE 0.002174
K_6535 X_NUC_47.L_CORE X_NUC_73.L_CORE 0.001996
K_6536 X_NUC_47.L_CORE X_NUC_74.L_CORE 0.002012
K_6537 X_NUC_47.L_CORE X_NUC_75.L_CORE 0.001996
K_6538 X_NUC_47.L_CORE X_NUC_76.L_CORE 0.002005
K_6539 X_NUC_47.L_CORE X_NUC_77.L_CORE 0.005953
K_6540 X_NUC_47.L_CORE X_NUC_78.L_CORE 0.005870
K_6541 X_NUC_47.L_CORE X_NUC_79.L_CORE 0.005792
K_6542 X_NUC_47.L_CORE X_NUC_80.L_CORE 0.005840
K_6543 X_NUC_47.L_CORE X_NUC_81.L_CORE 0.001752
K_6544 X_NUC_47.L_CORE X_NUC_82.L_CORE 0.001756
K_6545 X_NUC_47.L_CORE X_NUC_83.L_CORE 0.001744
K_6546 X_NUC_47.L_CORE X_NUC_84.L_CORE 0.001758
K_6547 X_NUC_47.L_CORE X_NUC_85.L_CORE 0.002879
K_6548 X_NUC_47.L_CORE X_NUC_86.L_CORE 0.002914
K_6549 X_NUC_47.L_CORE X_NUC_87.L_CORE 0.002880
K_6550 X_NUC_47.L_CORE X_NUC_88.L_CORE 0.002883
K_6551 X_NUC_47.L_CORE X_NUC_89.L_CORE 0.002667
K_6552 X_NUC_47.L_CORE X_NUC_90.L_CORE 0.002654
K_6553 X_NUC_47.L_CORE X_NUC_91.L_CORE 0.002635
K_6554 X_NUC_47.L_CORE X_NUC_92.L_CORE 0.002661
K_6555 X_NUC_47.L_CORE X_NUC_93.L_CORE 0.001773
K_6556 X_NUC_47.L_CORE X_NUC_94.L_CORE 0.001782
K_6557 X_NUC_47.L_CORE X_NUC_95.L_CORE 0.001769
K_6558 X_NUC_47.L_CORE X_NUC_96.L_CORE 0.001779
K_6559 X_NUC_47.L_CORE X_NUC_97.L_CORE 0.004244
K_6560 X_NUC_47.L_CORE X_NUC_98.L_CORE 0.004267
K_6561 X_NUC_47.L_CORE X_NUC_99.L_CORE 0.004197
K_6562 X_NUC_47.L_CORE X_NUC_100.L_CORE 0.004197
K_6563 X_NUC_47.L_CORE X_NUC_101.L_CORE 0.001913
K_6564 X_NUC_47.L_CORE X_NUC_102.L_CORE 0.001914
K_6565 X_NUC_47.L_CORE X_NUC_103.L_CORE 0.001900
K_6566 X_NUC_47.L_CORE X_NUC_104.L_CORE 0.001915
K_6567 X_NUC_47.L_CORE X_NUC_105.L_CORE 0.002144
K_6568 X_NUC_47.L_CORE X_NUC_106.L_CORE 0.002161
K_6569 X_NUC_47.L_CORE X_NUC_107.L_CORE 0.002140
K_6570 X_NUC_47.L_CORE X_NUC_108.L_CORE 0.002147
K_6571 X_NUC_47.L_CORE X_NUC_109.L_CORE 0.003025
K_6572 X_NUC_47.L_CORE X_NUC_110.L_CORE 0.003015
K_6573 X_NUC_47.L_CORE X_NUC_111.L_CORE 0.002984
K_6574 X_NUC_47.L_CORE X_NUC_112.L_CORE 0.003004
K_6575 X_NUC_47.L_CORE X_NUC_113.L_CORE 0.001778
K_6576 X_NUC_47.L_CORE X_NUC_114.L_CORE 0.001783
K_6577 X_NUC_47.L_CORE X_NUC_115.L_CORE 0.001769
K_6578 X_NUC_47.L_CORE X_NUC_116.L_CORE 0.001781
K_6579 X_NUC_47.L_CORE X_NUC_117.L_CORE 0.002686
K_6580 X_NUC_47.L_CORE X_NUC_118.L_CORE 0.002703
K_6581 X_NUC_47.L_CORE X_NUC_119.L_CORE 0.002670
K_6582 X_NUC_47.L_CORE X_NUC_120.L_CORE 0.002677
K_6583 X_NUC_47.L_CORE X_NUC_121.L_CORE 0.002159
K_6584 X_NUC_47.L_CORE X_NUC_122.L_CORE 0.002159
K_6585 X_NUC_47.L_CORE X_NUC_123.L_CORE 0.002140
K_6586 X_NUC_47.L_CORE X_NUC_124.L_CORE 0.002156
K_6587 X_NUC_47.L_CORE X_NUC_125.L_CORE 0.001967
K_6588 X_NUC_47.L_CORE X_NUC_126.L_CORE 0.001977
K_6589 X_NUC_47.L_CORE X_NUC_127.L_CORE 0.001958
K_6590 X_NUC_47.L_CORE X_NUC_128.L_CORE 0.001968
K_6591 X_NUC_47.L_CORE X_NUC_129.L_CORE 0.002368
K_6592 X_NUC_47.L_CORE X_NUC_130.L_CORE 0.002374
K_6593 X_NUC_47.L_CORE X_NUC_131.L_CORE 0.002349
K_6594 X_NUC_47.L_CORE X_NUC_132.L_CORE 0.002361
K_6595 X_NUC_47.L_CORE X_NUC_133.L_CORE 0.002879
K_6596 X_NUC_47.L_CORE X_NUC_134.L_CORE 0.003083
K_6597 X_NUC_47.L_CORE X_NUC_135.L_CORE 0.002096
K_6598 X_NUC_47.L_CORE X_NUC_136.L_CORE 0.004949
K_6599 X_NUC_47.L_CORE X_NUC_137.L_CORE 0.002219
K_6600 X_NUC_47.L_CORE X_NUC_138.L_CORE 0.002322
K_6601 X_NUC_47.L_CORE X_NUC_139.L_CORE 0.005420
K_6602 X_NUC_47.L_CORE X_NUC_140.L_CORE 0.001813
K_6603 X_NUC_47.L_CORE X_NUC_141.L_CORE 0.003881
K_6604 X_NUC_47.L_CORE X_NUC_142.L_CORE 0.002588
K_6605 X_NUC_47.L_CORE X_NUC_143.L_CORE 0.001856
K_6606 X_NUC_47.L_CORE X_NUC_144.L_CORE 0.030140
K_6607 X_NUC_47.L_CORE X_NUC_145.L_CORE 0.001822
K_6608 X_NUC_47.L_CORE X_NUC_146.L_CORE 0.002477
K_6609 X_NUC_47.L_CORE X_NUC_147.L_CORE 0.003704
K_6610 X_NUC_47.L_CORE X_NUC_148.L_CORE 0.001667
K_6611 X_NUC_47.L_CORE X_NUC_149.L_CORE 0.005136
K_6612 X_NUC_47.L_CORE X_NUC_150.L_CORE 0.002055
K_6613 X_NUC_47.L_CORE X_NUC_151.L_CORE 0.001901
K_6614 X_NUC_47.L_CORE X_NUC_152.L_CORE 0.005486
K_6615 X_NUC_47.L_CORE X_NUC_153.L_CORE 0.001665
K_6616 X_NUC_47.L_CORE X_NUC_154.L_CORE 0.002737
K_6617 X_NUC_47.L_CORE X_NUC_155.L_CORE 0.002517
K_6618 X_NUC_47.L_CORE X_NUC_156.L_CORE 0.001687
K_6619 X_NUC_47.L_CORE X_NUC_157.L_CORE 0.003986
K_6620 X_NUC_47.L_CORE X_NUC_158.L_CORE 0.001814
K_6621 X_NUC_47.L_CORE X_NUC_159.L_CORE 0.002039
K_6622 X_NUC_47.L_CORE X_NUC_160.L_CORE 0.002848
K_6623 X_NUC_47.L_CORE X_NUC_161.L_CORE 0.001689
K_6624 X_NUC_47.L_CORE X_NUC_162.L_CORE 0.002544
K_6625 X_NUC_47.L_CORE X_NUC_163.L_CORE 0.002044
K_6626 X_NUC_47.L_CORE X_NUC_164.L_CORE 0.001868
K_6627 X_NUC_47.L_CORE X_NUC_165.L_CORE 0.002242
K_6628 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.001900
K_6629 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.001902
K_6630 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.001892
K_6631 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.001910
K_6632 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.002589
K_6633 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.002621
K_6634 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.002599
K_6635 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.002607
K_6636 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.003894
K_6637 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.003850
K_6638 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.003834
K_6639 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.003889
K_6640 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.001740
K_6641 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.001748
K_6642 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.001736
K_6643 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.001749
K_6644 X_NUC_48.L_CORE X_NUC_65.L_CORE 0.005476
K_6645 X_NUC_48.L_CORE X_NUC_66.L_CORE 0.005601
K_6646 X_NUC_48.L_CORE X_NUC_67.L_CORE 0.005505
K_6647 X_NUC_48.L_CORE X_NUC_68.L_CORE 0.005471
K_6648 X_NUC_48.L_CORE X_NUC_69.L_CORE 0.002148
K_6649 X_NUC_48.L_CORE X_NUC_70.L_CORE 0.002144
K_6650 X_NUC_48.L_CORE X_NUC_71.L_CORE 0.002132
K_6651 X_NUC_48.L_CORE X_NUC_72.L_CORE 0.002153
K_6652 X_NUC_48.L_CORE X_NUC_73.L_CORE 0.001986
K_6653 X_NUC_48.L_CORE X_NUC_74.L_CORE 0.002002
K_6654 X_NUC_48.L_CORE X_NUC_75.L_CORE 0.001986
K_6655 X_NUC_48.L_CORE X_NUC_76.L_CORE 0.001996
K_6656 X_NUC_48.L_CORE X_NUC_77.L_CORE 0.005900
K_6657 X_NUC_48.L_CORE X_NUC_78.L_CORE 0.005819
K_6658 X_NUC_48.L_CORE X_NUC_79.L_CORE 0.005740
K_6659 X_NUC_48.L_CORE X_NUC_80.L_CORE 0.005792
K_6660 X_NUC_48.L_CORE X_NUC_81.L_CORE 0.001738
K_6661 X_NUC_48.L_CORE X_NUC_82.L_CORE 0.001742
K_6662 X_NUC_48.L_CORE X_NUC_83.L_CORE 0.001731
K_6663 X_NUC_48.L_CORE X_NUC_84.L_CORE 0.001744
K_6664 X_NUC_48.L_CORE X_NUC_85.L_CORE 0.002876
K_6665 X_NUC_48.L_CORE X_NUC_86.L_CORE 0.002911
K_6666 X_NUC_48.L_CORE X_NUC_87.L_CORE 0.002877
K_6667 X_NUC_48.L_CORE X_NUC_88.L_CORE 0.002880
K_6668 X_NUC_48.L_CORE X_NUC_89.L_CORE 0.002640
K_6669 X_NUC_48.L_CORE X_NUC_90.L_CORE 0.002628
K_6670 X_NUC_48.L_CORE X_NUC_91.L_CORE 0.002610
K_6671 X_NUC_48.L_CORE X_NUC_92.L_CORE 0.002635
K_6672 X_NUC_48.L_CORE X_NUC_93.L_CORE 0.001763
K_6673 X_NUC_48.L_CORE X_NUC_94.L_CORE 0.001772
K_6674 X_NUC_48.L_CORE X_NUC_95.L_CORE 0.001758
K_6675 X_NUC_48.L_CORE X_NUC_96.L_CORE 0.001769
K_6676 X_NUC_48.L_CORE X_NUC_97.L_CORE 0.004244
K_6677 X_NUC_48.L_CORE X_NUC_98.L_CORE 0.004267
K_6678 X_NUC_48.L_CORE X_NUC_99.L_CORE 0.004197
K_6679 X_NUC_48.L_CORE X_NUC_100.L_CORE 0.004197
K_6680 X_NUC_48.L_CORE X_NUC_101.L_CORE 0.001898
K_6681 X_NUC_48.L_CORE X_NUC_102.L_CORE 0.001898
K_6682 X_NUC_48.L_CORE X_NUC_103.L_CORE 0.001885
K_6683 X_NUC_48.L_CORE X_NUC_104.L_CORE 0.001900
K_6684 X_NUC_48.L_CORE X_NUC_105.L_CORE 0.002136
K_6685 X_NUC_48.L_CORE X_NUC_106.L_CORE 0.002153
K_6686 X_NUC_48.L_CORE X_NUC_107.L_CORE 0.002132
K_6687 X_NUC_48.L_CORE X_NUC_108.L_CORE 0.002140
K_6688 X_NUC_48.L_CORE X_NUC_109.L_CORE 0.003003
K_6689 X_NUC_48.L_CORE X_NUC_110.L_CORE 0.002994
K_6690 X_NUC_48.L_CORE X_NUC_111.L_CORE 0.002963
K_6691 X_NUC_48.L_CORE X_NUC_112.L_CORE 0.002984
K_6692 X_NUC_48.L_CORE X_NUC_113.L_CORE 0.001766
K_6693 X_NUC_48.L_CORE X_NUC_114.L_CORE 0.001772
K_6694 X_NUC_48.L_CORE X_NUC_115.L_CORE 0.001758
K_6695 X_NUC_48.L_CORE X_NUC_116.L_CORE 0.001769
K_6696 X_NUC_48.L_CORE X_NUC_117.L_CORE 0.002679
K_6697 X_NUC_48.L_CORE X_NUC_118.L_CORE 0.002696
K_6698 X_NUC_48.L_CORE X_NUC_119.L_CORE 0.002663
K_6699 X_NUC_48.L_CORE X_NUC_120.L_CORE 0.002670
K_6700 X_NUC_48.L_CORE X_NUC_121.L_CORE 0.002144
K_6701 X_NUC_48.L_CORE X_NUC_122.L_CORE 0.002144
K_6702 X_NUC_48.L_CORE X_NUC_123.L_CORE 0.002125
K_6703 X_NUC_48.L_CORE X_NUC_124.L_CORE 0.002140
K_6704 X_NUC_48.L_CORE X_NUC_125.L_CORE 0.001958
K_6705 X_NUC_48.L_CORE X_NUC_126.L_CORE 0.001967
K_6706 X_NUC_48.L_CORE X_NUC_127.L_CORE 0.001948
K_6707 X_NUC_48.L_CORE X_NUC_128.L_CORE 0.001958
K_6708 X_NUC_48.L_CORE X_NUC_129.L_CORE 0.002356
K_6709 X_NUC_48.L_CORE X_NUC_130.L_CORE 0.002362
K_6710 X_NUC_48.L_CORE X_NUC_131.L_CORE 0.002337
K_6711 X_NUC_48.L_CORE X_NUC_132.L_CORE 0.002349
K_6712 X_NUC_48.L_CORE X_NUC_133.L_CORE 0.002857
K_6713 X_NUC_48.L_CORE X_NUC_134.L_CORE 0.003048
K_6714 X_NUC_48.L_CORE X_NUC_135.L_CORE 0.002080
K_6715 X_NUC_48.L_CORE X_NUC_136.L_CORE 0.004921
K_6716 X_NUC_48.L_CORE X_NUC_137.L_CORE 0.002197
K_6717 X_NUC_48.L_CORE X_NUC_138.L_CORE 0.002310
K_6718 X_NUC_48.L_CORE X_NUC_139.L_CORE 0.005332
K_6719 X_NUC_48.L_CORE X_NUC_140.L_CORE 0.001799
K_6720 X_NUC_48.L_CORE X_NUC_141.L_CORE 0.003884
K_6721 X_NUC_48.L_CORE X_NUC_142.L_CORE 0.002558
K_6722 X_NUC_48.L_CORE X_NUC_143.L_CORE 0.001845
K_6723 X_NUC_48.L_CORE X_NUC_144.L_CORE 0.034254
K_6724 X_NUC_48.L_CORE X_NUC_145.L_CORE 0.001806
K_6725 X_NUC_48.L_CORE X_NUC_146.L_CORE 0.002471
K_6726 X_NUC_48.L_CORE X_NUC_147.L_CORE 0.003658
K_6727 X_NUC_48.L_CORE X_NUC_148.L_CORE 0.001656
K_6728 X_NUC_48.L_CORE X_NUC_149.L_CORE 0.005186
K_6729 X_NUC_48.L_CORE X_NUC_150.L_CORE 0.002036
K_6730 X_NUC_48.L_CORE X_NUC_151.L_CORE 0.001893
K_6731 X_NUC_48.L_CORE X_NUC_152.L_CORE 0.005460
K_6732 X_NUC_48.L_CORE X_NUC_153.L_CORE 0.001652
K_6733 X_NUC_48.L_CORE X_NUC_154.L_CORE 0.002737
K_6734 X_NUC_48.L_CORE X_NUC_155.L_CORE 0.002494
K_6735 X_NUC_48.L_CORE X_NUC_156.L_CORE 0.001678
K_6736 X_NUC_48.L_CORE X_NUC_157.L_CORE 0.003994
K_6737 X_NUC_48.L_CORE X_NUC_158.L_CORE 0.001801
K_6738 X_NUC_48.L_CORE X_NUC_159.L_CORE 0.002033
K_6739 X_NUC_48.L_CORE X_NUC_160.L_CORE 0.002831
K_6740 X_NUC_48.L_CORE X_NUC_161.L_CORE 0.001678
K_6741 X_NUC_48.L_CORE X_NUC_162.L_CORE 0.002540
K_6742 X_NUC_48.L_CORE X_NUC_163.L_CORE 0.002031
K_6743 X_NUC_48.L_CORE X_NUC_164.L_CORE 0.001860
K_6744 X_NUC_48.L_CORE X_NUC_165.L_CORE 0.002232
K_6745 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_6746 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_6747 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_6748 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.001880
K_6749 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.001890
K_6750 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.001892
K_6751 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.001878
K_6752 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.002572
K_6753 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.002555
K_6754 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.002575
K_6755 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.002548
K_6756 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.003848
K_6757 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.003918
K_6758 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.003878
K_6759 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.003866
K_6760 X_NUC_49.L_CORE X_NUC_65.L_CORE 0.001732
K_6761 X_NUC_49.L_CORE X_NUC_66.L_CORE 0.001734
K_6762 X_NUC_49.L_CORE X_NUC_67.L_CORE 0.001739
K_6763 X_NUC_49.L_CORE X_NUC_68.L_CORE 0.001725
K_6764 X_NUC_49.L_CORE X_NUC_69.L_CORE 0.005448
K_6765 X_NUC_49.L_CORE X_NUC_70.L_CORE 0.005339
K_6766 X_NUC_49.L_CORE X_NUC_71.L_CORE 0.005374
K_6767 X_NUC_49.L_CORE X_NUC_72.L_CORE 0.005318
K_6768 X_NUC_49.L_CORE X_NUC_73.L_CORE 0.002141
K_6769 X_NUC_49.L_CORE X_NUC_74.L_CORE 0.002158
K_6770 X_NUC_49.L_CORE X_NUC_75.L_CORE 0.002153
K_6771 X_NUC_49.L_CORE X_NUC_76.L_CORE 0.002140
K_6772 X_NUC_49.L_CORE X_NUC_77.L_CORE 0.001988
K_6773 X_NUC_49.L_CORE X_NUC_78.L_CORE 0.001983
K_6774 X_NUC_49.L_CORE X_NUC_79.L_CORE 0.001991
K_6775 X_NUC_49.L_CORE X_NUC_80.L_CORE 0.001973
K_6776 X_NUC_49.L_CORE X_NUC_81.L_CORE 0.005795
K_6777 X_NUC_49.L_CORE X_NUC_82.L_CORE 0.005887
K_6778 X_NUC_49.L_CORE X_NUC_83.L_CORE 0.005742
K_6779 X_NUC_49.L_CORE X_NUC_84.L_CORE 0.005750
K_6780 X_NUC_49.L_CORE X_NUC_85.L_CORE 0.001744
K_6781 X_NUC_49.L_CORE X_NUC_86.L_CORE 0.001750
K_6782 X_NUC_49.L_CORE X_NUC_87.L_CORE 0.001751
K_6783 X_NUC_49.L_CORE X_NUC_88.L_CORE 0.001738
K_6784 X_NUC_49.L_CORE X_NUC_89.L_CORE 0.002884
K_6785 X_NUC_49.L_CORE X_NUC_90.L_CORE 0.002862
K_6786 X_NUC_49.L_CORE X_NUC_91.L_CORE 0.002871
K_6787 X_NUC_49.L_CORE X_NUC_92.L_CORE 0.002846
K_6788 X_NUC_49.L_CORE X_NUC_93.L_CORE 0.002643
K_6789 X_NUC_49.L_CORE X_NUC_94.L_CORE 0.002669
K_6790 X_NUC_49.L_CORE X_NUC_95.L_CORE 0.002649
K_6791 X_NUC_49.L_CORE X_NUC_96.L_CORE 0.002637
K_6792 X_NUC_49.L_CORE X_NUC_97.L_CORE 0.001780
K_6793 X_NUC_49.L_CORE X_NUC_98.L_CORE 0.001780
K_6794 X_NUC_49.L_CORE X_NUC_99.L_CORE 0.001783
K_6795 X_NUC_49.L_CORE X_NUC_100.L_CORE 0.001769
K_6796 X_NUC_49.L_CORE X_NUC_101.L_CORE 0.004165
K_6797 X_NUC_49.L_CORE X_NUC_102.L_CORE 0.004151
K_6798 X_NUC_49.L_CORE X_NUC_103.L_CORE 0.004112
K_6799 X_NUC_49.L_CORE X_NUC_104.L_CORE 0.004093
K_6800 X_NUC_49.L_CORE X_NUC_105.L_CORE 0.001920
K_6801 X_NUC_49.L_CORE X_NUC_106.L_CORE 0.001930
K_6802 X_NUC_49.L_CORE X_NUC_107.L_CORE 0.001925
K_6803 X_NUC_49.L_CORE X_NUC_108.L_CORE 0.001913
K_6804 X_NUC_49.L_CORE X_NUC_109.L_CORE 0.002162
K_6805 X_NUC_49.L_CORE X_NUC_110.L_CORE 0.002156
K_6806 X_NUC_49.L_CORE X_NUC_111.L_CORE 0.002159
K_6807 X_NUC_49.L_CORE X_NUC_112.L_CORE 0.002141
K_6808 X_NUC_49.L_CORE X_NUC_113.L_CORE 0.002965
K_6809 X_NUC_49.L_CORE X_NUC_114.L_CORE 0.002985
K_6810 X_NUC_49.L_CORE X_NUC_115.L_CORE 0.002955
K_6811 X_NUC_49.L_CORE X_NUC_116.L_CORE 0.002944
K_6812 X_NUC_49.L_CORE X_NUC_117.L_CORE 0.001811
K_6813 X_NUC_49.L_CORE X_NUC_118.L_CORE 0.001815
K_6814 X_NUC_49.L_CORE X_NUC_119.L_CORE 0.001813
K_6815 X_NUC_49.L_CORE X_NUC_120.L_CORE 0.001801
K_6816 X_NUC_49.L_CORE X_NUC_121.L_CORE 0.002640
K_6817 X_NUC_49.L_CORE X_NUC_122.L_CORE 0.002634
K_6818 X_NUC_49.L_CORE X_NUC_123.L_CORE 0.002626
K_6819 X_NUC_49.L_CORE X_NUC_124.L_CORE 0.002609
K_6820 X_NUC_49.L_CORE X_NUC_125.L_CORE 0.002176
K_6821 X_NUC_49.L_CORE X_NUC_126.L_CORE 0.002185
K_6822 X_NUC_49.L_CORE X_NUC_127.L_CORE 0.002175
K_6823 X_NUC_49.L_CORE X_NUC_128.L_CORE 0.002163
K_6824 X_NUC_49.L_CORE X_NUC_129.L_CORE 0.002056
K_6825 X_NUC_49.L_CORE X_NUC_130.L_CORE 0.002058
K_6826 X_NUC_49.L_CORE X_NUC_131.L_CORE 0.002053
K_6827 X_NUC_49.L_CORE X_NUC_132.L_CORE 0.002040
K_6828 X_NUC_49.L_CORE X_NUC_133.L_CORE 0.002343
K_6829 X_NUC_49.L_CORE X_NUC_134.L_CORE 0.002834
K_6830 X_NUC_49.L_CORE X_NUC_135.L_CORE 0.003044
K_6831 X_NUC_49.L_CORE X_NUC_136.L_CORE 0.001974
K_6832 X_NUC_49.L_CORE X_NUC_137.L_CORE 0.005131
K_6833 X_NUC_49.L_CORE X_NUC_138.L_CORE 0.002134
K_6834 X_NUC_49.L_CORE X_NUC_139.L_CORE 0.002238
K_6835 X_NUC_49.L_CORE X_NUC_140.L_CORE 0.005418
K_6836 X_NUC_49.L_CORE X_NUC_141.L_CORE 0.001759
K_6837 X_NUC_49.L_CORE X_NUC_142.L_CORE 0.003780
K_6838 X_NUC_49.L_CORE X_NUC_143.L_CORE 0.002532
K_6839 X_NUC_49.L_CORE X_NUC_144.L_CORE 0.001813
K_6840 X_NUC_49.L_CORE X_NUC_145.L_CORE 0.032333
K_6841 X_NUC_49.L_CORE X_NUC_146.L_CORE 0.001791
K_6842 X_NUC_49.L_CORE X_NUC_147.L_CORE 0.002431
K_6843 X_NUC_49.L_CORE X_NUC_148.L_CORE 0.003665
K_6844 X_NUC_49.L_CORE X_NUC_149.L_CORE 0.001646
K_6845 X_NUC_49.L_CORE X_NUC_150.L_CORE 0.005047
K_6846 X_NUC_49.L_CORE X_NUC_151.L_CORE 0.002039
K_6847 X_NUC_49.L_CORE X_NUC_152.L_CORE 0.001884
K_6848 X_NUC_49.L_CORE X_NUC_153.L_CORE 0.005434
K_6849 X_NUC_49.L_CORE X_NUC_154.L_CORE 0.001659
K_6850 X_NUC_49.L_CORE X_NUC_155.L_CORE 0.002717
K_6851 X_NUC_49.L_CORE X_NUC_156.L_CORE 0.002513
K_6852 X_NUC_49.L_CORE X_NUC_157.L_CORE 0.001689
K_6853 X_NUC_49.L_CORE X_NUC_158.L_CORE 0.003901
K_6854 X_NUC_49.L_CORE X_NUC_159.L_CORE 0.001826
K_6855 X_NUC_49.L_CORE X_NUC_160.L_CORE 0.002046
K_6856 X_NUC_49.L_CORE X_NUC_161.L_CORE 0.002808
K_6857 X_NUC_49.L_CORE X_NUC_162.L_CORE 0.001720
K_6858 X_NUC_49.L_CORE X_NUC_163.L_CORE 0.002492
K_6859 X_NUC_49.L_CORE X_NUC_164.L_CORE 0.002065
K_6860 X_NUC_49.L_CORE X_NUC_165.L_CORE 0.001949
K_6861 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_6862 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_6863 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.001870
K_6864 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.001880
K_6865 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.001881
K_6866 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.001868
K_6867 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.002590
K_6868 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.002572
K_6869 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.002592
K_6870 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.002566
K_6871 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.003780
K_6872 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.003848
K_6873 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.003809
K_6874 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.003798
K_6875 X_NUC_50.L_CORE X_NUC_65.L_CORE 0.001729
K_6876 X_NUC_50.L_CORE X_NUC_66.L_CORE 0.001732
K_6877 X_NUC_50.L_CORE X_NUC_67.L_CORE 0.001736
K_6878 X_NUC_50.L_CORE X_NUC_68.L_CORE 0.001722
K_6879 X_NUC_50.L_CORE X_NUC_69.L_CORE 0.005559
K_6880 X_NUC_50.L_CORE X_NUC_70.L_CORE 0.005448
K_6881 X_NUC_50.L_CORE X_NUC_71.L_CORE 0.005482
K_6882 X_NUC_50.L_CORE X_NUC_72.L_CORE 0.005423
K_6883 X_NUC_50.L_CORE X_NUC_73.L_CORE 0.002124
K_6884 X_NUC_50.L_CORE X_NUC_74.L_CORE 0.002141
K_6885 X_NUC_50.L_CORE X_NUC_75.L_CORE 0.002135
K_6886 X_NUC_50.L_CORE X_NUC_76.L_CORE 0.002123
K_6887 X_NUC_50.L_CORE X_NUC_77.L_CORE 0.001993
K_6888 X_NUC_50.L_CORE X_NUC_78.L_CORE 0.001988
K_6889 X_NUC_50.L_CORE X_NUC_79.L_CORE 0.001996
K_6890 X_NUC_50.L_CORE X_NUC_80.L_CORE 0.001979
K_6891 X_NUC_50.L_CORE X_NUC_81.L_CORE 0.005703
K_6892 X_NUC_50.L_CORE X_NUC_82.L_CORE 0.005795
K_6893 X_NUC_50.L_CORE X_NUC_83.L_CORE 0.005654
K_6894 X_NUC_50.L_CORE X_NUC_84.L_CORE 0.005662
K_6895 X_NUC_50.L_CORE X_NUC_85.L_CORE 0.001738
K_6896 X_NUC_50.L_CORE X_NUC_86.L_CORE 0.001744
K_6897 X_NUC_50.L_CORE X_NUC_87.L_CORE 0.001744
K_6898 X_NUC_50.L_CORE X_NUC_88.L_CORE 0.001732
K_6899 X_NUC_50.L_CORE X_NUC_89.L_CORE 0.002907
K_6900 X_NUC_50.L_CORE X_NUC_90.L_CORE 0.002884
K_6901 X_NUC_50.L_CORE X_NUC_91.L_CORE 0.002894
K_6902 X_NUC_50.L_CORE X_NUC_92.L_CORE 0.002868
K_6903 X_NUC_50.L_CORE X_NUC_93.L_CORE 0.002616
K_6904 X_NUC_50.L_CORE X_NUC_94.L_CORE 0.002643
K_6905 X_NUC_50.L_CORE X_NUC_95.L_CORE 0.002623
K_6906 X_NUC_50.L_CORE X_NUC_96.L_CORE 0.002612
K_6907 X_NUC_50.L_CORE X_NUC_97.L_CORE 0.001780
K_6908 X_NUC_50.L_CORE X_NUC_98.L_CORE 0.001780
K_6909 X_NUC_50.L_CORE X_NUC_99.L_CORE 0.001783
K_6910 X_NUC_50.L_CORE X_NUC_100.L_CORE 0.001769
K_6911 X_NUC_50.L_CORE X_NUC_101.L_CORE 0.004178
K_6912 X_NUC_50.L_CORE X_NUC_102.L_CORE 0.004165
K_6913 X_NUC_50.L_CORE X_NUC_103.L_CORE 0.004125
K_6914 X_NUC_50.L_CORE X_NUC_104.L_CORE 0.004106
K_6915 X_NUC_50.L_CORE X_NUC_105.L_CORE 0.001910
K_6916 X_NUC_50.L_CORE X_NUC_106.L_CORE 0.001920
K_6917 X_NUC_50.L_CORE X_NUC_107.L_CORE 0.001915
K_6918 X_NUC_50.L_CORE X_NUC_108.L_CORE 0.001903
K_6919 X_NUC_50.L_CORE X_NUC_109.L_CORE 0.002168
K_6920 X_NUC_50.L_CORE X_NUC_110.L_CORE 0.002162
K_6921 X_NUC_50.L_CORE X_NUC_111.L_CORE 0.002165
K_6922 X_NUC_50.L_CORE X_NUC_112.L_CORE 0.002148
K_6923 X_NUC_50.L_CORE X_NUC_113.L_CORE 0.002945
K_6924 X_NUC_50.L_CORE X_NUC_114.L_CORE 0.002965
K_6925 X_NUC_50.L_CORE X_NUC_115.L_CORE 0.002936
K_6926 X_NUC_50.L_CORE X_NUC_116.L_CORE 0.002925
K_6927 X_NUC_50.L_CORE X_NUC_117.L_CORE 0.001808
K_6928 X_NUC_50.L_CORE X_NUC_118.L_CORE 0.001811
K_6929 X_NUC_50.L_CORE X_NUC_119.L_CORE 0.001810
K_6930 X_NUC_50.L_CORE X_NUC_120.L_CORE 0.001797
K_6931 X_NUC_50.L_CORE X_NUC_121.L_CORE 0.002645
K_6932 X_NUC_50.L_CORE X_NUC_122.L_CORE 0.002640
K_6933 X_NUC_50.L_CORE X_NUC_123.L_CORE 0.002631
K_6934 X_NUC_50.L_CORE X_NUC_124.L_CORE 0.002614
K_6935 X_NUC_50.L_CORE X_NUC_125.L_CORE 0.002166
K_6936 X_NUC_50.L_CORE X_NUC_126.L_CORE 0.002176
K_6937 X_NUC_50.L_CORE X_NUC_127.L_CORE 0.002165
K_6938 X_NUC_50.L_CORE X_NUC_128.L_CORE 0.002153
K_6939 X_NUC_50.L_CORE X_NUC_129.L_CORE 0.002055
K_6940 X_NUC_50.L_CORE X_NUC_130.L_CORE 0.002056
K_6941 X_NUC_50.L_CORE X_NUC_131.L_CORE 0.002052
K_6942 X_NUC_50.L_CORE X_NUC_132.L_CORE 0.002038
K_6943 X_NUC_50.L_CORE X_NUC_133.L_CORE 0.002335
K_6944 X_NUC_50.L_CORE X_NUC_134.L_CORE 0.002840
K_6945 X_NUC_50.L_CORE X_NUC_135.L_CORE 0.003017
K_6946 X_NUC_50.L_CORE X_NUC_136.L_CORE 0.001973
K_6947 X_NUC_50.L_CORE X_NUC_137.L_CORE 0.005166
K_6948 X_NUC_50.L_CORE X_NUC_138.L_CORE 0.002119
K_6949 X_NUC_50.L_CORE X_NUC_139.L_CORE 0.002246
K_6950 X_NUC_50.L_CORE X_NUC_140.L_CORE 0.005304
K_6951 X_NUC_50.L_CORE X_NUC_141.L_CORE 0.001754
K_6952 X_NUC_50.L_CORE X_NUC_142.L_CORE 0.003833
K_6953 X_NUC_50.L_CORE X_NUC_143.L_CORE 0.002505
K_6954 X_NUC_50.L_CORE X_NUC_144.L_CORE 0.001815
K_6955 X_NUC_50.L_CORE X_NUC_145.L_CORE 0.033651
K_6956 X_NUC_50.L_CORE X_NUC_146.L_CORE 0.001781
K_6957 X_NUC_50.L_CORE X_NUC_147.L_CORE 0.002448
K_6958 X_NUC_50.L_CORE X_NUC_148.L_CORE 0.003603
K_6959 X_NUC_50.L_CORE X_NUC_149.L_CORE 0.001644
K_6960 X_NUC_50.L_CORE X_NUC_150.L_CORE 0.005151
K_6961 X_NUC_50.L_CORE X_NUC_151.L_CORE 0.002024
K_6962 X_NUC_50.L_CORE X_NUC_152.L_CORE 0.001889
K_6963 X_NUC_50.L_CORE X_NUC_153.L_CORE 0.005358
K_6964 X_NUC_50.L_CORE X_NUC_154.L_CORE 0.001653
K_6965 X_NUC_50.L_CORE X_NUC_155.L_CORE 0.002739
K_6966 X_NUC_50.L_CORE X_NUC_156.L_CORE 0.002489
K_6967 X_NUC_50.L_CORE X_NUC_157.L_CORE 0.001689
K_6968 X_NUC_50.L_CORE X_NUC_158.L_CORE 0.003916
K_6969 X_NUC_50.L_CORE X_NUC_159.L_CORE 0.001817
K_6970 X_NUC_50.L_CORE X_NUC_160.L_CORE 0.002052
K_6971 X_NUC_50.L_CORE X_NUC_161.L_CORE 0.002790
K_6972 X_NUC_50.L_CORE X_NUC_162.L_CORE 0.001716
K_6973 X_NUC_50.L_CORE X_NUC_163.L_CORE 0.002498
K_6974 X_NUC_50.L_CORE X_NUC_164.L_CORE 0.002056
K_6975 X_NUC_50.L_CORE X_NUC_165.L_CORE 0.001948
K_6976 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_6977 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.001869
K_6978 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.001879
K_6979 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.001880
K_6980 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.001866
K_6981 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.002570
K_6982 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.002552
K_6983 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.002572
K_6984 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.002546
K_6985 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.003818
K_6986 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.003887
K_6987 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.003848
K_6988 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.003836
K_6989 X_NUC_51.L_CORE X_NUC_65.L_CORE 0.001725
K_6990 X_NUC_51.L_CORE X_NUC_66.L_CORE 0.001727
K_6991 X_NUC_51.L_CORE X_NUC_67.L_CORE 0.001732
K_6992 X_NUC_51.L_CORE X_NUC_68.L_CORE 0.001718
K_6993 X_NUC_51.L_CORE X_NUC_69.L_CORE 0.005522
K_6994 X_NUC_51.L_CORE X_NUC_70.L_CORE 0.005410
K_6995 X_NUC_51.L_CORE X_NUC_71.L_CORE 0.005448
K_6996 X_NUC_51.L_CORE X_NUC_72.L_CORE 0.005388
K_6997 X_NUC_51.L_CORE X_NUC_73.L_CORE 0.002130
K_6998 X_NUC_51.L_CORE X_NUC_74.L_CORE 0.002147
K_6999 X_NUC_51.L_CORE X_NUC_75.L_CORE 0.002141
K_7000 X_NUC_51.L_CORE X_NUC_76.L_CORE 0.002128
K_7001 X_NUC_51.L_CORE X_NUC_77.L_CORE 0.001985
K_7002 X_NUC_51.L_CORE X_NUC_78.L_CORE 0.001980
K_7003 X_NUC_51.L_CORE X_NUC_79.L_CORE 0.001988
K_7004 X_NUC_51.L_CORE X_NUC_80.L_CORE 0.001971
K_7005 X_NUC_51.L_CORE X_NUC_81.L_CORE 0.005845
K_7006 X_NUC_51.L_CORE X_NUC_82.L_CORE 0.005942
K_7007 X_NUC_51.L_CORE X_NUC_83.L_CORE 0.005795
K_7008 X_NUC_51.L_CORE X_NUC_84.L_CORE 0.005801
K_7009 X_NUC_51.L_CORE X_NUC_85.L_CORE 0.001738
K_7010 X_NUC_51.L_CORE X_NUC_86.L_CORE 0.001744
K_7011 X_NUC_51.L_CORE X_NUC_87.L_CORE 0.001744
K_7012 X_NUC_51.L_CORE X_NUC_88.L_CORE 0.001732
K_7013 X_NUC_51.L_CORE X_NUC_89.L_CORE 0.002897
K_7014 X_NUC_51.L_CORE X_NUC_90.L_CORE 0.002874
K_7015 X_NUC_51.L_CORE X_NUC_91.L_CORE 0.002884
K_7016 X_NUC_51.L_CORE X_NUC_92.L_CORE 0.002858
K_7017 X_NUC_51.L_CORE X_NUC_93.L_CORE 0.002636
K_7018 X_NUC_51.L_CORE X_NUC_94.L_CORE 0.002662
K_7019 X_NUC_51.L_CORE X_NUC_95.L_CORE 0.002643
K_7020 X_NUC_51.L_CORE X_NUC_96.L_CORE 0.002631
K_7021 X_NUC_51.L_CORE X_NUC_97.L_CORE 0.001777
K_7022 X_NUC_51.L_CORE X_NUC_98.L_CORE 0.001777
K_7023 X_NUC_51.L_CORE X_NUC_99.L_CORE 0.001780
K_7024 X_NUC_51.L_CORE X_NUC_100.L_CORE 0.001766
K_7025 X_NUC_51.L_CORE X_NUC_101.L_CORE 0.004219
K_7026 X_NUC_51.L_CORE X_NUC_102.L_CORE 0.004205
K_7027 X_NUC_51.L_CORE X_NUC_103.L_CORE 0.004165
K_7028 X_NUC_51.L_CORE X_NUC_104.L_CORE 0.004145
K_7029 X_NUC_51.L_CORE X_NUC_105.L_CORE 0.001915
K_7030 X_NUC_51.L_CORE X_NUC_106.L_CORE 0.001925
K_7031 X_NUC_51.L_CORE X_NUC_107.L_CORE 0.001920
K_7032 X_NUC_51.L_CORE X_NUC_108.L_CORE 0.001908
K_7033 X_NUC_51.L_CORE X_NUC_109.L_CORE 0.002166
K_7034 X_NUC_51.L_CORE X_NUC_110.L_CORE 0.002159
K_7035 X_NUC_51.L_CORE X_NUC_111.L_CORE 0.002162
K_7036 X_NUC_51.L_CORE X_NUC_112.L_CORE 0.002145
K_7037 X_NUC_51.L_CORE X_NUC_113.L_CORE 0.002974
K_7038 X_NUC_51.L_CORE X_NUC_114.L_CORE 0.002994
K_7039 X_NUC_51.L_CORE X_NUC_115.L_CORE 0.002965
K_7040 X_NUC_51.L_CORE X_NUC_116.L_CORE 0.002953
K_7041 X_NUC_51.L_CORE X_NUC_117.L_CORE 0.001809
K_7042 X_NUC_51.L_CORE X_NUC_118.L_CORE 0.001813
K_7043 X_NUC_51.L_CORE X_NUC_119.L_CORE 0.001811
K_7044 X_NUC_51.L_CORE X_NUC_120.L_CORE 0.001799
K_7045 X_NUC_51.L_CORE X_NUC_121.L_CORE 0.002653
K_7046 X_NUC_51.L_CORE X_NUC_122.L_CORE 0.002648
K_7047 X_NUC_51.L_CORE X_NUC_123.L_CORE 0.002640
K_7048 X_NUC_51.L_CORE X_NUC_124.L_CORE 0.002622
K_7049 X_NUC_51.L_CORE X_NUC_125.L_CORE 0.002176
K_7050 X_NUC_51.L_CORE X_NUC_126.L_CORE 0.002186
K_7051 X_NUC_51.L_CORE X_NUC_127.L_CORE 0.002176
K_7052 X_NUC_51.L_CORE X_NUC_128.L_CORE 0.002163
K_7053 X_NUC_51.L_CORE X_NUC_129.L_CORE 0.002059
K_7054 X_NUC_51.L_CORE X_NUC_130.L_CORE 0.002061
K_7055 X_NUC_51.L_CORE X_NUC_131.L_CORE 0.002056
K_7056 X_NUC_51.L_CORE X_NUC_132.L_CORE 0.002043
K_7057 X_NUC_51.L_CORE X_NUC_133.L_CORE 0.002318
K_7058 X_NUC_51.L_CORE X_NUC_134.L_CORE 0.002805
K_7059 X_NUC_51.L_CORE X_NUC_135.L_CORE 0.003001
K_7060 X_NUC_51.L_CORE X_NUC_136.L_CORE 0.001960
K_7061 X_NUC_51.L_CORE X_NUC_137.L_CORE 0.005045
K_7062 X_NUC_51.L_CORE X_NUC_138.L_CORE 0.002114
K_7063 X_NUC_51.L_CORE X_NUC_139.L_CORE 0.002226
K_7064 X_NUC_51.L_CORE X_NUC_140.L_CORE 0.005300
K_7065 X_NUC_51.L_CORE X_NUC_141.L_CORE 0.001748
K_7066 X_NUC_51.L_CORE X_NUC_142.L_CORE 0.003773
K_7067 X_NUC_51.L_CORE X_NUC_143.L_CORE 0.002509
K_7068 X_NUC_51.L_CORE X_NUC_144.L_CORE 0.001806
K_7069 X_NUC_51.L_CORE X_NUC_145.L_CORE 0.034662
K_7070 X_NUC_51.L_CORE X_NUC_146.L_CORE 0.001780
K_7071 X_NUC_51.L_CORE X_NUC_147.L_CORE 0.002430
K_7072 X_NUC_51.L_CORE X_NUC_148.L_CORE 0.003640
K_7073 X_NUC_51.L_CORE X_NUC_149.L_CORE 0.001640
K_7074 X_NUC_51.L_CORE X_NUC_150.L_CORE 0.005121
K_7075 X_NUC_51.L_CORE X_NUC_151.L_CORE 0.002029
K_7076 X_NUC_51.L_CORE X_NUC_152.L_CORE 0.001882
K_7077 X_NUC_51.L_CORE X_NUC_153.L_CORE 0.005492
K_7078 X_NUC_51.L_CORE X_NUC_154.L_CORE 0.001653
K_7079 X_NUC_51.L_CORE X_NUC_155.L_CORE 0.002730
K_7080 X_NUC_51.L_CORE X_NUC_156.L_CORE 0.002508
K_7081 X_NUC_51.L_CORE X_NUC_157.L_CORE 0.001686
K_7082 X_NUC_51.L_CORE X_NUC_158.L_CORE 0.003955
K_7083 X_NUC_51.L_CORE X_NUC_159.L_CORE 0.001821
K_7084 X_NUC_51.L_CORE X_NUC_160.L_CORE 0.002050
K_7085 X_NUC_51.L_CORE X_NUC_161.L_CORE 0.002818
K_7086 X_NUC_51.L_CORE X_NUC_162.L_CORE 0.001718
K_7087 X_NUC_51.L_CORE X_NUC_163.L_CORE 0.002506
K_7088 X_NUC_51.L_CORE X_NUC_164.L_CORE 0.002066
K_7089 X_NUC_51.L_CORE X_NUC_165.L_CORE 0.001952
K_7090 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.001882
K_7091 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.001892
K_7092 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.001894
K_7093 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.001880
K_7094 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.002596
K_7095 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.002579
K_7096 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.002599
K_7097 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.002572
K_7098 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.003829
K_7099 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.003899
K_7100 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.003859
K_7101 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.003848
K_7102 X_NUC_52.L_CORE X_NUC_65.L_CORE 0.001739
K_7103 X_NUC_52.L_CORE X_NUC_66.L_CORE 0.001741
K_7104 X_NUC_52.L_CORE X_NUC_67.L_CORE 0.001746
K_7105 X_NUC_52.L_CORE X_NUC_68.L_CORE 0.001732
K_7106 X_NUC_52.L_CORE X_NUC_69.L_CORE 0.005584
K_7107 X_NUC_52.L_CORE X_NUC_70.L_CORE 0.005470
K_7108 X_NUC_52.L_CORE X_NUC_71.L_CORE 0.005506
K_7109 X_NUC_52.L_CORE X_NUC_72.L_CORE 0.005448
K_7110 X_NUC_52.L_CORE X_NUC_73.L_CORE 0.002142
K_7111 X_NUC_52.L_CORE X_NUC_74.L_CORE 0.002160
K_7112 X_NUC_52.L_CORE X_NUC_75.L_CORE 0.002154
K_7113 X_NUC_52.L_CORE X_NUC_76.L_CORE 0.002141
K_7114 X_NUC_52.L_CORE X_NUC_77.L_CORE 0.002003
K_7115 X_NUC_52.L_CORE X_NUC_78.L_CORE 0.001998
K_7116 X_NUC_52.L_CORE X_NUC_79.L_CORE 0.002006
K_7117 X_NUC_52.L_CORE X_NUC_80.L_CORE 0.001988
K_7118 X_NUC_52.L_CORE X_NUC_81.L_CORE 0.005837
K_7119 X_NUC_52.L_CORE X_NUC_82.L_CORE 0.005933
K_7120 X_NUC_52.L_CORE X_NUC_83.L_CORE 0.005785
K_7121 X_NUC_52.L_CORE X_NUC_84.L_CORE 0.005795
K_7122 X_NUC_52.L_CORE X_NUC_85.L_CORE 0.001750
K_7123 X_NUC_52.L_CORE X_NUC_86.L_CORE 0.001756
K_7124 X_NUC_52.L_CORE X_NUC_87.L_CORE 0.001757
K_7125 X_NUC_52.L_CORE X_NUC_88.L_CORE 0.001744
K_7126 X_NUC_52.L_CORE X_NUC_89.L_CORE 0.002923
K_7127 X_NUC_52.L_CORE X_NUC_90.L_CORE 0.002900
K_7128 X_NUC_52.L_CORE X_NUC_91.L_CORE 0.002910
K_7129 X_NUC_52.L_CORE X_NUC_92.L_CORE 0.002884
K_7130 X_NUC_52.L_CORE X_NUC_93.L_CORE 0.002647
K_7131 X_NUC_52.L_CORE X_NUC_94.L_CORE 0.002674
K_7132 X_NUC_52.L_CORE X_NUC_95.L_CORE 0.002654
K_7133 X_NUC_52.L_CORE X_NUC_96.L_CORE 0.002643
K_7134 X_NUC_52.L_CORE X_NUC_97.L_CORE 0.001791
K_7135 X_NUC_52.L_CORE X_NUC_98.L_CORE 0.001791
K_7136 X_NUC_52.L_CORE X_NUC_99.L_CORE 0.001794
K_7137 X_NUC_52.L_CORE X_NUC_100.L_CORE 0.001780
K_7138 X_NUC_52.L_CORE X_NUC_101.L_CORE 0.004240
K_7139 X_NUC_52.L_CORE X_NUC_102.L_CORE 0.004225
K_7140 X_NUC_52.L_CORE X_NUC_103.L_CORE 0.004184
K_7141 X_NUC_52.L_CORE X_NUC_104.L_CORE 0.004165
K_7142 X_NUC_52.L_CORE X_NUC_105.L_CORE 0.001927
K_7143 X_NUC_52.L_CORE X_NUC_106.L_CORE 0.001937
K_7144 X_NUC_52.L_CORE X_NUC_107.L_CORE 0.001932
K_7145 X_NUC_52.L_CORE X_NUC_108.L_CORE 0.001920
K_7146 X_NUC_52.L_CORE X_NUC_109.L_CORE 0.002183
K_7147 X_NUC_52.L_CORE X_NUC_110.L_CORE 0.002177
K_7148 X_NUC_52.L_CORE X_NUC_111.L_CORE 0.002180
K_7149 X_NUC_52.L_CORE X_NUC_112.L_CORE 0.002162
K_7150 X_NUC_52.L_CORE X_NUC_113.L_CORE 0.002986
K_7151 X_NUC_52.L_CORE X_NUC_114.L_CORE 0.003006
K_7152 X_NUC_52.L_CORE X_NUC_115.L_CORE 0.002976
K_7153 X_NUC_52.L_CORE X_NUC_116.L_CORE 0.002965
K_7154 X_NUC_52.L_CORE X_NUC_117.L_CORE 0.001822
K_7155 X_NUC_52.L_CORE X_NUC_118.L_CORE 0.001826
K_7156 X_NUC_52.L_CORE X_NUC_119.L_CORE 0.001824
K_7157 X_NUC_52.L_CORE X_NUC_120.L_CORE 0.001811
K_7158 X_NUC_52.L_CORE X_NUC_121.L_CORE 0.002671
K_7159 X_NUC_52.L_CORE X_NUC_122.L_CORE 0.002666
K_7160 X_NUC_52.L_CORE X_NUC_123.L_CORE 0.002657
K_7161 X_NUC_52.L_CORE X_NUC_124.L_CORE 0.002640
K_7162 X_NUC_52.L_CORE X_NUC_125.L_CORE 0.002189
K_7163 X_NUC_52.L_CORE X_NUC_126.L_CORE 0.002199
K_7164 X_NUC_52.L_CORE X_NUC_127.L_CORE 0.002188
K_7165 X_NUC_52.L_CORE X_NUC_128.L_CORE 0.002176
K_7166 X_NUC_52.L_CORE X_NUC_129.L_CORE 0.002073
K_7167 X_NUC_52.L_CORE X_NUC_130.L_CORE 0.002075
K_7168 X_NUC_52.L_CORE X_NUC_131.L_CORE 0.002070
K_7169 X_NUC_52.L_CORE X_NUC_132.L_CORE 0.002056
K_7170 X_NUC_52.L_CORE X_NUC_133.L_CORE 0.002338
K_7171 X_NUC_52.L_CORE X_NUC_134.L_CORE 0.002834
K_7172 X_NUC_52.L_CORE X_NUC_135.L_CORE 0.003022
K_7173 X_NUC_52.L_CORE X_NUC_136.L_CORE 0.001977
K_7174 X_NUC_52.L_CORE X_NUC_137.L_CORE 0.005103
K_7175 X_NUC_52.L_CORE X_NUC_138.L_CORE 0.002129
K_7176 X_NUC_52.L_CORE X_NUC_139.L_CORE 0.002248
K_7177 X_NUC_52.L_CORE X_NUC_140.L_CORE 0.005311
K_7178 X_NUC_52.L_CORE X_NUC_141.L_CORE 0.001761
K_7179 X_NUC_52.L_CORE X_NUC_142.L_CORE 0.003815
K_7180 X_NUC_52.L_CORE X_NUC_143.L_CORE 0.002523
K_7181 X_NUC_52.L_CORE X_NUC_144.L_CORE 0.001822
K_7182 X_NUC_52.L_CORE X_NUC_145.L_CORE 0.030039
K_7183 X_NUC_52.L_CORE X_NUC_146.L_CORE 0.001792
K_7184 X_NUC_52.L_CORE X_NUC_147.L_CORE 0.002453
K_7185 X_NUC_52.L_CORE X_NUC_148.L_CORE 0.003644
K_7186 X_NUC_52.L_CORE X_NUC_149.L_CORE 0.001653
K_7187 X_NUC_52.L_CORE X_NUC_150.L_CORE 0.005158
K_7188 X_NUC_52.L_CORE X_NUC_151.L_CORE 0.002040
K_7189 X_NUC_52.L_CORE X_NUC_152.L_CORE 0.001898
K_7190 X_NUC_52.L_CORE X_NUC_153.L_CORE 0.005462
K_7191 X_NUC_52.L_CORE X_NUC_154.L_CORE 0.001664
K_7192 X_NUC_52.L_CORE X_NUC_155.L_CORE 0.002752
K_7193 X_NUC_52.L_CORE X_NUC_156.L_CORE 0.002517
K_7194 X_NUC_52.L_CORE X_NUC_157.L_CORE 0.001699
K_7195 X_NUC_52.L_CORE X_NUC_158.L_CORE 0.003964
K_7196 X_NUC_52.L_CORE X_NUC_159.L_CORE 0.001832
K_7197 X_NUC_52.L_CORE X_NUC_160.L_CORE 0.002065
K_7198 X_NUC_52.L_CORE X_NUC_161.L_CORE 0.002826
K_7199 X_NUC_52.L_CORE X_NUC_162.L_CORE 0.001729
K_7200 X_NUC_52.L_CORE X_NUC_163.L_CORE 0.002520
K_7201 X_NUC_52.L_CORE X_NUC_164.L_CORE 0.002076
K_7202 X_NUC_52.L_CORE X_NUC_165.L_CORE 0.001964
K_7203 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_7204 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_7205 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_7206 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.001859
K_7207 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.001843
K_7208 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.001849
K_7209 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.001852
K_7210 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.002548
K_7211 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.002543
K_7212 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.002528
K_7213 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.002559
K_7214 X_NUC_53.L_CORE X_NUC_65.L_CORE 0.003821
K_7215 X_NUC_53.L_CORE X_NUC_66.L_CORE 0.003764
K_7216 X_NUC_53.L_CORE X_NUC_67.L_CORE 0.003800
K_7217 X_NUC_53.L_CORE X_NUC_68.L_CORE 0.003764
K_7218 X_NUC_53.L_CORE X_NUC_69.L_CORE 0.001722
K_7219 X_NUC_53.L_CORE X_NUC_70.L_CORE 0.001711
K_7220 X_NUC_53.L_CORE X_NUC_71.L_CORE 0.001711
K_7221 X_NUC_53.L_CORE X_NUC_72.L_CORE 0.001720
K_7222 X_NUC_53.L_CORE X_NUC_73.L_CORE 0.005436
K_7223 X_NUC_53.L_CORE X_NUC_74.L_CORE 0.005472
K_7224 X_NUC_53.L_CORE X_NUC_75.L_CORE 0.005347
K_7225 X_NUC_53.L_CORE X_NUC_76.L_CORE 0.005464
K_7226 X_NUC_53.L_CORE X_NUC_77.L_CORE 0.002137
K_7227 X_NUC_53.L_CORE X_NUC_78.L_CORE 0.002116
K_7228 X_NUC_53.L_CORE X_NUC_79.L_CORE 0.002124
K_7229 X_NUC_53.L_CORE X_NUC_80.L_CORE 0.002122
K_7230 X_NUC_53.L_CORE X_NUC_81.L_CORE 0.001988
K_7231 X_NUC_53.L_CORE X_NUC_82.L_CORE 0.001980
K_7232 X_NUC_53.L_CORE X_NUC_83.L_CORE 0.001973
K_7233 X_NUC_53.L_CORE X_NUC_84.L_CORE 0.001989
K_7234 X_NUC_53.L_CORE X_NUC_85.L_CORE 0.005792
K_7235 X_NUC_53.L_CORE X_NUC_86.L_CORE 0.005722
K_7236 X_NUC_53.L_CORE X_NUC_87.L_CORE 0.005695
K_7237 X_NUC_53.L_CORE X_NUC_88.L_CORE 0.005637
K_7238 X_NUC_53.L_CORE X_NUC_89.L_CORE 0.001751
K_7239 X_NUC_53.L_CORE X_NUC_90.L_CORE 0.001738
K_7240 X_NUC_53.L_CORE X_NUC_91.L_CORE 0.001739
K_7241 X_NUC_53.L_CORE X_NUC_92.L_CORE 0.001744
K_7242 X_NUC_53.L_CORE X_NUC_93.L_CORE 0.002895
K_7243 X_NUC_53.L_CORE X_NUC_94.L_CORE 0.002893
K_7244 X_NUC_53.L_CORE X_NUC_95.L_CORE 0.002863
K_7245 X_NUC_53.L_CORE X_NUC_96.L_CORE 0.002897
K_7246 X_NUC_53.L_CORE X_NUC_97.L_CORE 0.002657
K_7247 X_NUC_53.L_CORE X_NUC_98.L_CORE 0.002629
K_7248 X_NUC_53.L_CORE X_NUC_99.L_CORE 0.002635
K_7249 X_NUC_53.L_CORE X_NUC_100.L_CORE 0.002627
K_7250 X_NUC_53.L_CORE X_NUC_101.L_CORE 0.001799
K_7251 X_NUC_53.L_CORE X_NUC_102.L_CORE 0.001789
K_7252 X_NUC_53.L_CORE X_NUC_103.L_CORE 0.001785
K_7253 X_NUC_53.L_CORE X_NUC_104.L_CORE 0.001795
K_7254 X_NUC_53.L_CORE X_NUC_105.L_CORE 0.004116
K_7255 X_NUC_53.L_CORE X_NUC_106.L_CORE 0.004107
K_7256 X_NUC_53.L_CORE X_NUC_107.L_CORE 0.004046
K_7257 X_NUC_53.L_CORE X_NUC_108.L_CORE 0.004069
K_7258 X_NUC_53.L_CORE X_NUC_109.L_CORE 0.001950
K_7259 X_NUC_53.L_CORE X_NUC_110.L_CORE 0.001934
K_7260 X_NUC_53.L_CORE X_NUC_111.L_CORE 0.001934
K_7261 X_NUC_53.L_CORE X_NUC_112.L_CORE 0.001937
K_7262 X_NUC_53.L_CORE X_NUC_113.L_CORE 0.002194
K_7263 X_NUC_53.L_CORE X_NUC_114.L_CORE 0.002186
K_7264 X_NUC_53.L_CORE X_NUC_115.L_CORE 0.002172
K_7265 X_NUC_53.L_CORE X_NUC_116.L_CORE 0.002188
K_7266 X_NUC_53.L_CORE X_NUC_117.L_CORE 0.002936
K_7267 X_NUC_53.L_CORE X_NUC_118.L_CORE 0.002913
K_7268 X_NUC_53.L_CORE X_NUC_119.L_CORE 0.002902
K_7269 X_NUC_53.L_CORE X_NUC_120.L_CORE 0.002900
K_7270 X_NUC_53.L_CORE X_NUC_121.L_CORE 0.001872
K_7271 X_NUC_53.L_CORE X_NUC_122.L_CORE 0.001860
K_7272 X_NUC_53.L_CORE X_NUC_123.L_CORE 0.001856
K_7273 X_NUC_53.L_CORE X_NUC_124.L_CORE 0.001863
K_7274 X_NUC_53.L_CORE X_NUC_125.L_CORE 0.002589
K_7275 X_NUC_53.L_CORE X_NUC_126.L_CORE 0.002579
K_7276 X_NUC_53.L_CORE X_NUC_127.L_CORE 0.002558
K_7277 X_NUC_53.L_CORE X_NUC_128.L_CORE 0.002573
K_7278 X_NUC_53.L_CORE X_NUC_129.L_CORE 0.002222
K_7279 X_NUC_53.L_CORE X_NUC_130.L_CORE 0.002208
K_7280 X_NUC_53.L_CORE X_NUC_131.L_CORE 0.002200
K_7281 X_NUC_53.L_CORE X_NUC_132.L_CORE 0.002205
K_7282 X_NUC_53.L_CORE X_NUC_133.L_CORE 0.002989
K_7283 X_NUC_53.L_CORE X_NUC_134.L_CORE 0.002104
K_7284 X_NUC_53.L_CORE X_NUC_135.L_CORE 0.002766
K_7285 X_NUC_53.L_CORE X_NUC_136.L_CORE 0.002954
K_7286 X_NUC_53.L_CORE X_NUC_137.L_CORE 0.001880
K_7287 X_NUC_53.L_CORE X_NUC_138.L_CORE 0.005250
K_7288 X_NUC_53.L_CORE X_NUC_139.L_CORE 0.002049
K_7289 X_NUC_53.L_CORE X_NUC_140.L_CORE 0.002176
K_7290 X_NUC_53.L_CORE X_NUC_141.L_CORE 0.005252
K_7291 X_NUC_53.L_CORE X_NUC_142.L_CORE 0.001710
K_7292 X_NUC_53.L_CORE X_NUC_143.L_CORE 0.003741
K_7293 X_NUC_53.L_CORE X_NUC_144.L_CORE 0.002460
K_7294 X_NUC_53.L_CORE X_NUC_145.L_CORE 0.001782
K_7295 X_NUC_53.L_CORE X_NUC_146.L_CORE 0.035262
K_7296 X_NUC_53.L_CORE X_NUC_147.L_CORE 0.001758
K_7297 X_NUC_53.L_CORE X_NUC_148.L_CORE 0.002415
K_7298 X_NUC_53.L_CORE X_NUC_149.L_CORE 0.003585
K_7299 X_NUC_53.L_CORE X_NUC_150.L_CORE 0.001631
K_7300 X_NUC_53.L_CORE X_NUC_151.L_CORE 0.005112
K_7301 X_NUC_53.L_CORE X_NUC_152.L_CORE 0.002018
K_7302 X_NUC_53.L_CORE X_NUC_153.L_CORE 0.001883
K_7303 X_NUC_53.L_CORE X_NUC_154.L_CORE 0.005371
K_7304 X_NUC_53.L_CORE X_NUC_155.L_CORE 0.001657
K_7305 X_NUC_53.L_CORE X_NUC_156.L_CORE 0.002738
K_7306 X_NUC_53.L_CORE X_NUC_157.L_CORE 0.002503
K_7307 X_NUC_53.L_CORE X_NUC_158.L_CORE 0.001703
K_7308 X_NUC_53.L_CORE X_NUC_159.L_CORE 0.003863
K_7309 X_NUC_53.L_CORE X_NUC_160.L_CORE 0.001842
K_7310 X_NUC_53.L_CORE X_NUC_161.L_CORE 0.002075
K_7311 X_NUC_53.L_CORE X_NUC_162.L_CORE 0.002763
K_7312 X_NUC_53.L_CORE X_NUC_163.L_CORE 0.001770
K_7313 X_NUC_53.L_CORE X_NUC_164.L_CORE 0.002444
K_7314 X_NUC_53.L_CORE X_NUC_165.L_CORE 0.002098
K_7315 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_7316 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_7317 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.001875
K_7318 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.001859
K_7319 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.001865
K_7320 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.001868
K_7321 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.002553
K_7322 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.002548
K_7323 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.002533
K_7324 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.002564
K_7325 X_NUC_54.L_CORE X_NUC_65.L_CORE 0.003880
K_7326 X_NUC_54.L_CORE X_NUC_66.L_CORE 0.003821
K_7327 X_NUC_54.L_CORE X_NUC_67.L_CORE 0.003858
K_7328 X_NUC_54.L_CORE X_NUC_68.L_CORE 0.003821
K_7329 X_NUC_54.L_CORE X_NUC_69.L_CORE 0.001733
K_7330 X_NUC_54.L_CORE X_NUC_70.L_CORE 0.001722
K_7331 X_NUC_54.L_CORE X_NUC_71.L_CORE 0.001722
K_7332 X_NUC_54.L_CORE X_NUC_72.L_CORE 0.001731
K_7333 X_NUC_54.L_CORE X_NUC_73.L_CORE 0.005398
K_7334 X_NUC_54.L_CORE X_NUC_74.L_CORE 0.005436
K_7335 X_NUC_54.L_CORE X_NUC_75.L_CORE 0.005312
K_7336 X_NUC_54.L_CORE X_NUC_76.L_CORE 0.005427
K_7337 X_NUC_54.L_CORE X_NUC_77.L_CORE 0.002159
K_7338 X_NUC_54.L_CORE X_NUC_78.L_CORE 0.002137
K_7339 X_NUC_54.L_CORE X_NUC_79.L_CORE 0.002145
K_7340 X_NUC_54.L_CORE X_NUC_80.L_CORE 0.002143
K_7341 X_NUC_54.L_CORE X_NUC_81.L_CORE 0.001996
K_7342 X_NUC_54.L_CORE X_NUC_82.L_CORE 0.001988
K_7343 X_NUC_54.L_CORE X_NUC_83.L_CORE 0.001981
K_7344 X_NUC_54.L_CORE X_NUC_84.L_CORE 0.001997
K_7345 X_NUC_54.L_CORE X_NUC_85.L_CORE 0.005859
K_7346 X_NUC_54.L_CORE X_NUC_86.L_CORE 0.005792
K_7347 X_NUC_54.L_CORE X_NUC_87.L_CORE 0.005761
K_7348 X_NUC_54.L_CORE X_NUC_88.L_CORE 0.005701
K_7349 X_NUC_54.L_CORE X_NUC_89.L_CORE 0.001764
K_7350 X_NUC_54.L_CORE X_NUC_90.L_CORE 0.001751
K_7351 X_NUC_54.L_CORE X_NUC_91.L_CORE 0.001752
K_7352 X_NUC_54.L_CORE X_NUC_92.L_CORE 0.001757
K_7353 X_NUC_54.L_CORE X_NUC_93.L_CORE 0.002897
K_7354 X_NUC_54.L_CORE X_NUC_94.L_CORE 0.002895
K_7355 X_NUC_54.L_CORE X_NUC_95.L_CORE 0.002865
K_7356 X_NUC_54.L_CORE X_NUC_96.L_CORE 0.002899
K_7357 X_NUC_54.L_CORE X_NUC_97.L_CORE 0.002685
K_7358 X_NUC_54.L_CORE X_NUC_98.L_CORE 0.002657
K_7359 X_NUC_54.L_CORE X_NUC_99.L_CORE 0.002663
K_7360 X_NUC_54.L_CORE X_NUC_100.L_CORE 0.002654
K_7361 X_NUC_54.L_CORE X_NUC_101.L_CORE 0.001809
K_7362 X_NUC_54.L_CORE X_NUC_102.L_CORE 0.001799
K_7363 X_NUC_54.L_CORE X_NUC_103.L_CORE 0.001794
K_7364 X_NUC_54.L_CORE X_NUC_104.L_CORE 0.001805
K_7365 X_NUC_54.L_CORE X_NUC_105.L_CORE 0.004123
K_7366 X_NUC_54.L_CORE X_NUC_106.L_CORE 0.004116
K_7367 X_NUC_54.L_CORE X_NUC_107.L_CORE 0.004053
K_7368 X_NUC_54.L_CORE X_NUC_108.L_CORE 0.004077
K_7369 X_NUC_54.L_CORE X_NUC_109.L_CORE 0.001966
K_7370 X_NUC_54.L_CORE X_NUC_110.L_CORE 0.001950
K_7371 X_NUC_54.L_CORE X_NUC_111.L_CORE 0.001950
K_7372 X_NUC_54.L_CORE X_NUC_112.L_CORE 0.001953
K_7373 X_NUC_54.L_CORE X_NUC_113.L_CORE 0.002201
K_7374 X_NUC_54.L_CORE X_NUC_114.L_CORE 0.002194
K_7375 X_NUC_54.L_CORE X_NUC_115.L_CORE 0.002179
K_7376 X_NUC_54.L_CORE X_NUC_116.L_CORE 0.002196
K_7377 X_NUC_54.L_CORE X_NUC_117.L_CORE 0.002959
K_7378 X_NUC_54.L_CORE X_NUC_118.L_CORE 0.002936
K_7379 X_NUC_54.L_CORE X_NUC_119.L_CORE 0.002924
K_7380 X_NUC_54.L_CORE X_NUC_120.L_CORE 0.002922
K_7381 X_NUC_54.L_CORE X_NUC_121.L_CORE 0.001884
K_7382 X_NUC_54.L_CORE X_NUC_122.L_CORE 0.001872
K_7383 X_NUC_54.L_CORE X_NUC_123.L_CORE 0.001867
K_7384 X_NUC_54.L_CORE X_NUC_124.L_CORE 0.001874
K_7385 X_NUC_54.L_CORE X_NUC_125.L_CORE 0.002599
K_7386 X_NUC_54.L_CORE X_NUC_126.L_CORE 0.002589
K_7387 X_NUC_54.L_CORE X_NUC_127.L_CORE 0.002568
K_7388 X_NUC_54.L_CORE X_NUC_128.L_CORE 0.002583
K_7389 X_NUC_54.L_CORE X_NUC_129.L_CORE 0.002237
K_7390 X_NUC_54.L_CORE X_NUC_130.L_CORE 0.002222
K_7391 X_NUC_54.L_CORE X_NUC_131.L_CORE 0.002215
K_7392 X_NUC_54.L_CORE X_NUC_132.L_CORE 0.002220
K_7393 X_NUC_54.L_CORE X_NUC_133.L_CORE 0.003013
K_7394 X_NUC_54.L_CORE X_NUC_134.L_CORE 0.002121
K_7395 X_NUC_54.L_CORE X_NUC_135.L_CORE 0.002777
K_7396 X_NUC_54.L_CORE X_NUC_136.L_CORE 0.002988
K_7397 X_NUC_54.L_CORE X_NUC_137.L_CORE 0.001891
K_7398 X_NUC_54.L_CORE X_NUC_138.L_CORE 0.005255
K_7399 X_NUC_54.L_CORE X_NUC_139.L_CORE 0.002068
K_7400 X_NUC_54.L_CORE X_NUC_140.L_CORE 0.002184
K_7401 X_NUC_54.L_CORE X_NUC_141.L_CORE 0.005339
K_7402 X_NUC_54.L_CORE X_NUC_142.L_CORE 0.001722
K_7403 X_NUC_54.L_CORE X_NUC_143.L_CORE 0.003731
K_7404 X_NUC_54.L_CORE X_NUC_144.L_CORE 0.002488
K_7405 X_NUC_54.L_CORE X_NUC_145.L_CORE 0.001791
K_7406 X_NUC_54.L_CORE X_NUC_146.L_CORE 0.030890
K_7407 X_NUC_54.L_CORE X_NUC_147.L_CORE 0.001773
K_7408 X_NUC_54.L_CORE X_NUC_148.L_CORE 0.002418
K_7409 X_NUC_54.L_CORE X_NUC_149.L_CORE 0.003633
K_7410 X_NUC_54.L_CORE X_NUC_150.L_CORE 0.001641
K_7411 X_NUC_54.L_CORE X_NUC_151.L_CORE 0.005062
K_7412 X_NUC_54.L_CORE X_NUC_152.L_CORE 0.002037
K_7413 X_NUC_54.L_CORE X_NUC_153.L_CORE 0.001890
K_7414 X_NUC_54.L_CORE X_NUC_154.L_CORE 0.005413
K_7415 X_NUC_54.L_CORE X_NUC_155.L_CORE 0.001668
K_7416 X_NUC_54.L_CORE X_NUC_156.L_CORE 0.002738
K_7417 X_NUC_54.L_CORE X_NUC_157.L_CORE 0.002527
K_7418 X_NUC_54.L_CORE X_NUC_158.L_CORE 0.001712
K_7419 X_NUC_54.L_CORE X_NUC_159.L_CORE 0.003863
K_7420 X_NUC_54.L_CORE X_NUC_160.L_CORE 0.001856
K_7421 X_NUC_54.L_CORE X_NUC_161.L_CORE 0.002081
K_7422 X_NUC_54.L_CORE X_NUC_162.L_CORE 0.002782
K_7423 X_NUC_54.L_CORE X_NUC_163.L_CORE 0.001780
K_7424 X_NUC_54.L_CORE X_NUC_164.L_CORE 0.002451
K_7425 X_NUC_54.L_CORE X_NUC_165.L_CORE 0.002111
K_7426 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_7427 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.001869
K_7428 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.001853
K_7429 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.001859
K_7430 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.001862
K_7431 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.002568
K_7432 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.002563
K_7433 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.002548
K_7434 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.002579
K_7435 X_NUC_55.L_CORE X_NUC_65.L_CORE 0.003842
K_7436 X_NUC_55.L_CORE X_NUC_66.L_CORE 0.003784
K_7437 X_NUC_55.L_CORE X_NUC_67.L_CORE 0.003821
K_7438 X_NUC_55.L_CORE X_NUC_68.L_CORE 0.003784
K_7439 X_NUC_55.L_CORE X_NUC_69.L_CORE 0.001733
K_7440 X_NUC_55.L_CORE X_NUC_70.L_CORE 0.001722
K_7441 X_NUC_55.L_CORE X_NUC_71.L_CORE 0.001722
K_7442 X_NUC_55.L_CORE X_NUC_72.L_CORE 0.001731
K_7443 X_NUC_55.L_CORE X_NUC_73.L_CORE 0.005526
K_7444 X_NUC_55.L_CORE X_NUC_74.L_CORE 0.005565
K_7445 X_NUC_55.L_CORE X_NUC_75.L_CORE 0.005436
K_7446 X_NUC_55.L_CORE X_NUC_76.L_CORE 0.005557
K_7447 X_NUC_55.L_CORE X_NUC_77.L_CORE 0.002150
K_7448 X_NUC_55.L_CORE X_NUC_78.L_CORE 0.002129
K_7449 X_NUC_55.L_CORE X_NUC_79.L_CORE 0.002137
K_7450 X_NUC_55.L_CORE X_NUC_80.L_CORE 0.002135
K_7451 X_NUC_55.L_CORE X_NUC_81.L_CORE 0.002004
K_7452 X_NUC_55.L_CORE X_NUC_82.L_CORE 0.001996
K_7453 X_NUC_55.L_CORE X_NUC_83.L_CORE 0.001988
K_7454 X_NUC_55.L_CORE X_NUC_84.L_CORE 0.002005
K_7455 X_NUC_55.L_CORE X_NUC_85.L_CORE 0.005888
K_7456 X_NUC_55.L_CORE X_NUC_86.L_CORE 0.005818
K_7457 X_NUC_55.L_CORE X_NUC_87.L_CORE 0.005792
K_7458 X_NUC_55.L_CORE X_NUC_88.L_CORE 0.005728
K_7459 X_NUC_55.L_CORE X_NUC_89.L_CORE 0.001763
K_7460 X_NUC_55.L_CORE X_NUC_90.L_CORE 0.001750
K_7461 X_NUC_55.L_CORE X_NUC_91.L_CORE 0.001751
K_7462 X_NUC_55.L_CORE X_NUC_92.L_CORE 0.001756
K_7463 X_NUC_55.L_CORE X_NUC_93.L_CORE 0.002928
K_7464 X_NUC_55.L_CORE X_NUC_94.L_CORE 0.002926
K_7465 X_NUC_55.L_CORE X_NUC_95.L_CORE 0.002895
K_7466 X_NUC_55.L_CORE X_NUC_96.L_CORE 0.002930
K_7467 X_NUC_55.L_CORE X_NUC_97.L_CORE 0.002679
K_7468 X_NUC_55.L_CORE X_NUC_98.L_CORE 0.002651
K_7469 X_NUC_55.L_CORE X_NUC_99.L_CORE 0.002657
K_7470 X_NUC_55.L_CORE X_NUC_100.L_CORE 0.002649
K_7471 X_NUC_55.L_CORE X_NUC_101.L_CORE 0.001813
K_7472 X_NUC_55.L_CORE X_NUC_102.L_CORE 0.001803
K_7473 X_NUC_55.L_CORE X_NUC_103.L_CORE 0.001799
K_7474 X_NUC_55.L_CORE X_NUC_104.L_CORE 0.001809
K_7475 X_NUC_55.L_CORE X_NUC_105.L_CORE 0.004188
K_7476 X_NUC_55.L_CORE X_NUC_106.L_CORE 0.004179
K_7477 X_NUC_55.L_CORE X_NUC_107.L_CORE 0.004116
K_7478 X_NUC_55.L_CORE X_NUC_108.L_CORE 0.004140
K_7479 X_NUC_55.L_CORE X_NUC_109.L_CORE 0.001965
K_7480 X_NUC_55.L_CORE X_NUC_110.L_CORE 0.001949
K_7481 X_NUC_55.L_CORE X_NUC_111.L_CORE 0.001950
K_7482 X_NUC_55.L_CORE X_NUC_112.L_CORE 0.001952
K_7483 X_NUC_55.L_CORE X_NUC_113.L_CORE 0.002216
K_7484 X_NUC_55.L_CORE X_NUC_114.L_CORE 0.002208
K_7485 X_NUC_55.L_CORE X_NUC_115.L_CORE 0.002194
K_7486 X_NUC_55.L_CORE X_NUC_116.L_CORE 0.002211
K_7487 X_NUC_55.L_CORE X_NUC_117.L_CORE 0.002972
K_7488 X_NUC_55.L_CORE X_NUC_118.L_CORE 0.002948
K_7489 X_NUC_55.L_CORE X_NUC_119.L_CORE 0.002936
K_7490 X_NUC_55.L_CORE X_NUC_120.L_CORE 0.002934
K_7491 X_NUC_55.L_CORE X_NUC_121.L_CORE 0.001888
K_7492 X_NUC_55.L_CORE X_NUC_122.L_CORE 0.001876
K_7493 X_NUC_55.L_CORE X_NUC_123.L_CORE 0.001872
K_7494 X_NUC_55.L_CORE X_NUC_124.L_CORE 0.001879
K_7495 X_NUC_55.L_CORE X_NUC_125.L_CORE 0.002621
K_7496 X_NUC_55.L_CORE X_NUC_126.L_CORE 0.002610
K_7497 X_NUC_55.L_CORE X_NUC_127.L_CORE 0.002589
K_7498 X_NUC_55.L_CORE X_NUC_128.L_CORE 0.002604
K_7499 X_NUC_55.L_CORE X_NUC_129.L_CORE 0.002245
K_7500 X_NUC_55.L_CORE X_NUC_130.L_CORE 0.002230
K_7501 X_NUC_55.L_CORE X_NUC_131.L_CORE 0.002222
K_7502 X_NUC_55.L_CORE X_NUC_132.L_CORE 0.002227
K_7503 X_NUC_55.L_CORE X_NUC_133.L_CORE 0.002984
K_7504 X_NUC_55.L_CORE X_NUC_134.L_CORE 0.002108
K_7505 X_NUC_55.L_CORE X_NUC_135.L_CORE 0.002769
K_7506 X_NUC_55.L_CORE X_NUC_136.L_CORE 0.002951
K_7507 X_NUC_55.L_CORE X_NUC_137.L_CORE 0.001887
K_7508 X_NUC_55.L_CORE X_NUC_138.L_CORE 0.005209
K_7509 X_NUC_55.L_CORE X_NUC_139.L_CORE 0.002055
K_7510 X_NUC_55.L_CORE X_NUC_140.L_CORE 0.002185
K_7511 X_NUC_55.L_CORE X_NUC_141.L_CORE 0.005209
K_7512 X_NUC_55.L_CORE X_NUC_142.L_CORE 0.001718
K_7513 X_NUC_55.L_CORE X_NUC_143.L_CORE 0.003757
K_7514 X_NUC_55.L_CORE X_NUC_144.L_CORE 0.002468
K_7515 X_NUC_55.L_CORE X_NUC_145.L_CORE 0.001792
K_7516 X_NUC_55.L_CORE X_NUC_146.L_CORE 0.030980
K_7517 X_NUC_55.L_CORE X_NUC_147.L_CORE 0.001767
K_7518 X_NUC_55.L_CORE X_NUC_148.L_CORE 0.002433
K_7519 X_NUC_55.L_CORE X_NUC_149.L_CORE 0.003598
K_7520 X_NUC_55.L_CORE X_NUC_150.L_CORE 0.001641
K_7521 X_NUC_55.L_CORE X_NUC_151.L_CORE 0.005179
K_7522 X_NUC_55.L_CORE X_NUC_152.L_CORE 0.002030
K_7523 X_NUC_55.L_CORE X_NUC_153.L_CORE 0.001897
K_7524 X_NUC_55.L_CORE X_NUC_154.L_CORE 0.005439
K_7525 X_NUC_55.L_CORE X_NUC_155.L_CORE 0.001667
K_7526 X_NUC_55.L_CORE X_NUC_156.L_CORE 0.002767
K_7527 X_NUC_55.L_CORE X_NUC_157.L_CORE 0.002521
K_7528 X_NUC_55.L_CORE X_NUC_158.L_CORE 0.001716
K_7529 X_NUC_55.L_CORE X_NUC_159.L_CORE 0.003922
K_7530 X_NUC_55.L_CORE X_NUC_160.L_CORE 0.001856
K_7531 X_NUC_55.L_CORE X_NUC_161.L_CORE 0.002095
K_7532 X_NUC_55.L_CORE X_NUC_162.L_CORE 0.002793
K_7533 X_NUC_55.L_CORE X_NUC_163.L_CORE 0.001784
K_7534 X_NUC_55.L_CORE X_NUC_164.L_CORE 0.002472
K_7535 X_NUC_55.L_CORE X_NUC_165.L_CORE 0.002118
K_7536 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.001866
K_7537 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.001849
K_7538 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.001855
K_7539 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.001859
K_7540 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.002537
K_7541 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.002532
K_7542 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.002518
K_7543 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.002548
K_7544 X_NUC_56.L_CORE X_NUC_65.L_CORE 0.003879
K_7545 X_NUC_56.L_CORE X_NUC_66.L_CORE 0.003820
K_7546 X_NUC_56.L_CORE X_NUC_67.L_CORE 0.003858
K_7547 X_NUC_56.L_CORE X_NUC_68.L_CORE 0.003821
K_7548 X_NUC_56.L_CORE X_NUC_69.L_CORE 0.001725
K_7549 X_NUC_56.L_CORE X_NUC_70.L_CORE 0.001713
K_7550 X_NUC_56.L_CORE X_NUC_71.L_CORE 0.001714
K_7551 X_NUC_56.L_CORE X_NUC_72.L_CORE 0.001722
K_7552 X_NUC_56.L_CORE X_NUC_73.L_CORE 0.005405
K_7553 X_NUC_56.L_CORE X_NUC_74.L_CORE 0.005442
K_7554 X_NUC_56.L_CORE X_NUC_75.L_CORE 0.005319
K_7555 X_NUC_56.L_CORE X_NUC_76.L_CORE 0.005436
K_7556 X_NUC_56.L_CORE X_NUC_77.L_CORE 0.002152
K_7557 X_NUC_56.L_CORE X_NUC_78.L_CORE 0.002131
K_7558 X_NUC_56.L_CORE X_NUC_79.L_CORE 0.002139
K_7559 X_NUC_56.L_CORE X_NUC_80.L_CORE 0.002137
K_7560 X_NUC_56.L_CORE X_NUC_81.L_CORE 0.001987
K_7561 X_NUC_56.L_CORE X_NUC_82.L_CORE 0.001979
K_7562 X_NUC_56.L_CORE X_NUC_83.L_CORE 0.001972
K_7563 X_NUC_56.L_CORE X_NUC_84.L_CORE 0.001988
K_7564 X_NUC_56.L_CORE X_NUC_85.L_CORE 0.005955
K_7565 X_NUC_56.L_CORE X_NUC_86.L_CORE 0.005882
K_7566 X_NUC_56.L_CORE X_NUC_87.L_CORE 0.005852
K_7567 X_NUC_56.L_CORE X_NUC_88.L_CORE 0.005792
K_7568 X_NUC_56.L_CORE X_NUC_89.L_CORE 0.001758
K_7569 X_NUC_56.L_CORE X_NUC_90.L_CORE 0.001745
K_7570 X_NUC_56.L_CORE X_NUC_91.L_CORE 0.001746
K_7571 X_NUC_56.L_CORE X_NUC_92.L_CORE 0.001751
K_7572 X_NUC_56.L_CORE X_NUC_93.L_CORE 0.002893
K_7573 X_NUC_56.L_CORE X_NUC_94.L_CORE 0.002891
K_7574 X_NUC_56.L_CORE X_NUC_95.L_CORE 0.002861
K_7575 X_NUC_56.L_CORE X_NUC_96.L_CORE 0.002895
K_7576 X_NUC_56.L_CORE X_NUC_97.L_CORE 0.002688
K_7577 X_NUC_56.L_CORE X_NUC_98.L_CORE 0.002659
K_7578 X_NUC_56.L_CORE X_NUC_99.L_CORE 0.002665
K_7579 X_NUC_56.L_CORE X_NUC_100.L_CORE 0.002657
K_7580 X_NUC_56.L_CORE X_NUC_101.L_CORE 0.001803
K_7581 X_NUC_56.L_CORE X_NUC_102.L_CORE 0.001793
K_7582 X_NUC_56.L_CORE X_NUC_103.L_CORE 0.001789
K_7583 X_NUC_56.L_CORE X_NUC_104.L_CORE 0.001799
K_7584 X_NUC_56.L_CORE X_NUC_105.L_CORE 0.004162
K_7585 X_NUC_56.L_CORE X_NUC_106.L_CORE 0.004153
K_7586 X_NUC_56.L_CORE X_NUC_107.L_CORE 0.004090
K_7587 X_NUC_56.L_CORE X_NUC_108.L_CORE 0.004116
K_7588 X_NUC_56.L_CORE X_NUC_109.L_CORE 0.001963
K_7589 X_NUC_56.L_CORE X_NUC_110.L_CORE 0.001947
K_7590 X_NUC_56.L_CORE X_NUC_111.L_CORE 0.001947
K_7591 X_NUC_56.L_CORE X_NUC_112.L_CORE 0.001950
K_7592 X_NUC_56.L_CORE X_NUC_113.L_CORE 0.002198
K_7593 X_NUC_56.L_CORE X_NUC_114.L_CORE 0.002190
K_7594 X_NUC_56.L_CORE X_NUC_115.L_CORE 0.002177
K_7595 X_NUC_56.L_CORE X_NUC_116.L_CORE 0.002194
K_7596 X_NUC_56.L_CORE X_NUC_117.L_CORE 0.002974
K_7597 X_NUC_56.L_CORE X_NUC_118.L_CORE 0.002950
K_7598 X_NUC_56.L_CORE X_NUC_119.L_CORE 0.002938
K_7599 X_NUC_56.L_CORE X_NUC_120.L_CORE 0.002936
K_7600 X_NUC_56.L_CORE X_NUC_121.L_CORE 0.001881
K_7601 X_NUC_56.L_CORE X_NUC_122.L_CORE 0.001869
K_7602 X_NUC_56.L_CORE X_NUC_123.L_CORE 0.001864
K_7603 X_NUC_56.L_CORE X_NUC_124.L_CORE 0.001872
K_7604 X_NUC_56.L_CORE X_NUC_125.L_CORE 0.002605
K_7605 X_NUC_56.L_CORE X_NUC_126.L_CORE 0.002595
K_7606 X_NUC_56.L_CORE X_NUC_127.L_CORE 0.002574
K_7607 X_NUC_56.L_CORE X_NUC_128.L_CORE 0.002589
K_7608 X_NUC_56.L_CORE X_NUC_129.L_CORE 0.002240
K_7609 X_NUC_56.L_CORE X_NUC_130.L_CORE 0.002225
K_7610 X_NUC_56.L_CORE X_NUC_131.L_CORE 0.002217
K_7611 X_NUC_56.L_CORE X_NUC_132.L_CORE 0.002222
K_7612 X_NUC_56.L_CORE X_NUC_133.L_CORE 0.002971
K_7613 X_NUC_56.L_CORE X_NUC_134.L_CORE 0.002101
K_7614 X_NUC_56.L_CORE X_NUC_135.L_CORE 0.002743
K_7615 X_NUC_56.L_CORE X_NUC_136.L_CORE 0.002956
K_7616 X_NUC_56.L_CORE X_NUC_137.L_CORE 0.001876
K_7617 X_NUC_56.L_CORE X_NUC_138.L_CORE 0.005141
K_7618 X_NUC_56.L_CORE X_NUC_139.L_CORE 0.002054
K_7619 X_NUC_56.L_CORE X_NUC_140.L_CORE 0.002165
K_7620 X_NUC_56.L_CORE X_NUC_141.L_CORE 0.005279
K_7621 X_NUC_56.L_CORE X_NUC_142.L_CORE 0.001711
K_7622 X_NUC_56.L_CORE X_NUC_143.L_CORE 0.003693
K_7623 X_NUC_56.L_CORE X_NUC_144.L_CORE 0.002476
K_7624 X_NUC_56.L_CORE X_NUC_145.L_CORE 0.001779
K_7625 X_NUC_56.L_CORE X_NUC_146.L_CORE 0.033596
K_7626 X_NUC_56.L_CORE X_NUC_147.L_CORE 0.001765
K_7627 X_NUC_56.L_CORE X_NUC_148.L_CORE 0.002405
K_7628 X_NUC_56.L_CORE X_NUC_149.L_CORE 0.003636
K_7629 X_NUC_56.L_CORE X_NUC_150.L_CORE 0.001633
K_7630 X_NUC_56.L_CORE X_NUC_151.L_CORE 0.005080
K_7631 X_NUC_56.L_CORE X_NUC_152.L_CORE 0.002032
K_7632 X_NUC_56.L_CORE X_NUC_153.L_CORE 0.001882
K_7633 X_NUC_56.L_CORE X_NUC_154.L_CORE 0.005510
K_7634 X_NUC_56.L_CORE X_NUC_155.L_CORE 0.001663
K_7635 X_NUC_56.L_CORE X_NUC_156.L_CORE 0.002736
K_7636 X_NUC_56.L_CORE X_NUC_157.L_CORE 0.002531
K_7637 X_NUC_56.L_CORE X_NUC_158.L_CORE 0.001706
K_7638 X_NUC_56.L_CORE X_NUC_159.L_CORE 0.003903
K_7639 X_NUC_56.L_CORE X_NUC_160.L_CORE 0.001854
K_7640 X_NUC_56.L_CORE X_NUC_161.L_CORE 0.002079
K_7641 X_NUC_56.L_CORE X_NUC_162.L_CORE 0.002797
K_7642 X_NUC_56.L_CORE X_NUC_163.L_CORE 0.001778
K_7643 X_NUC_56.L_CORE X_NUC_164.L_CORE 0.002458
K_7644 X_NUC_56.L_CORE X_NUC_165.L_CORE 0.002114
K_7645 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.207973
K_7646 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.207973
K_7647 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.207973
K_7648 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.001845
K_7649 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.001859
K_7650 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.001847
K_7651 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.001856
K_7652 X_NUC_57.L_CORE X_NUC_65.L_CORE 0.002534
K_7653 X_NUC_57.L_CORE X_NUC_66.L_CORE 0.002559
K_7654 X_NUC_57.L_CORE X_NUC_67.L_CORE 0.002554
K_7655 X_NUC_57.L_CORE X_NUC_68.L_CORE 0.002535
K_7656 X_NUC_57.L_CORE X_NUC_69.L_CORE 0.003808
K_7657 X_NUC_57.L_CORE X_NUC_70.L_CORE 0.003826
K_7658 X_NUC_57.L_CORE X_NUC_71.L_CORE 0.003774
K_7659 X_NUC_57.L_CORE X_NUC_72.L_CORE 0.003840
K_7660 X_NUC_57.L_CORE X_NUC_73.L_CORE 0.001719
K_7661 X_NUC_57.L_CORE X_NUC_74.L_CORE 0.001733
K_7662 X_NUC_57.L_CORE X_NUC_75.L_CORE 0.001724
K_7663 X_NUC_57.L_CORE X_NUC_76.L_CORE 0.001725
K_7664 X_NUC_57.L_CORE X_NUC_77.L_CORE 0.005436
K_7665 X_NUC_57.L_CORE X_NUC_78.L_CORE 0.005492
K_7666 X_NUC_57.L_CORE X_NUC_79.L_CORE 0.005470
K_7667 X_NUC_57.L_CORE X_NUC_80.L_CORE 0.005361
K_7668 X_NUC_57.L_CORE X_NUC_81.L_CORE 0.002141
K_7669 X_NUC_57.L_CORE X_NUC_82.L_CORE 0.002156
K_7670 X_NUC_57.L_CORE X_NUC_83.L_CORE 0.002137
K_7671 X_NUC_57.L_CORE X_NUC_84.L_CORE 0.002153
K_7672 X_NUC_57.L_CORE X_NUC_85.L_CORE 0.001996
K_7673 X_NUC_57.L_CORE X_NUC_86.L_CORE 0.002013
K_7674 X_NUC_57.L_CORE X_NUC_87.L_CORE 0.002004
K_7675 X_NUC_57.L_CORE X_NUC_88.L_CORE 0.001998
K_7676 X_NUC_57.L_CORE X_NUC_89.L_CORE 0.005781
K_7677 X_NUC_57.L_CORE X_NUC_90.L_CORE 0.005795
K_7678 X_NUC_57.L_CORE X_NUC_91.L_CORE 0.005653
K_7679 X_NUC_57.L_CORE X_NUC_92.L_CORE 0.005740
K_7680 X_NUC_57.L_CORE X_NUC_93.L_CORE 0.001765
K_7681 X_NUC_57.L_CORE X_NUC_94.L_CORE 0.001779
K_7682 X_NUC_57.L_CORE X_NUC_95.L_CORE 0.001766
K_7683 X_NUC_57.L_CORE X_NUC_96.L_CORE 0.001771
K_7684 X_NUC_57.L_CORE X_NUC_97.L_CORE 0.002914
K_7685 X_NUC_57.L_CORE X_NUC_98.L_CORE 0.002940
K_7686 X_NUC_57.L_CORE X_NUC_99.L_CORE 0.002923
K_7687 X_NUC_57.L_CORE X_NUC_100.L_CORE 0.002900
K_7688 X_NUC_57.L_CORE X_NUC_101.L_CORE 0.002679
K_7689 X_NUC_57.L_CORE X_NUC_102.L_CORE 0.002695
K_7690 X_NUC_57.L_CORE X_NUC_103.L_CORE 0.002662
K_7691 X_NUC_57.L_CORE X_NUC_104.L_CORE 0.002687
K_7692 X_NUC_57.L_CORE X_NUC_105.L_CORE 0.001827
K_7693 X_NUC_57.L_CORE X_NUC_106.L_CORE 0.001842
K_7694 X_NUC_57.L_CORE X_NUC_107.L_CORE 0.001831
K_7695 X_NUC_57.L_CORE X_NUC_108.L_CORE 0.001830
K_7696 X_NUC_57.L_CORE X_NUC_109.L_CORE 0.004046
K_7697 X_NUC_57.L_CORE X_NUC_110.L_CORE 0.004073
K_7698 X_NUC_57.L_CORE X_NUC_111.L_CORE 0.004013
K_7699 X_NUC_57.L_CORE X_NUC_112.L_CORE 0.004003
K_7700 X_NUC_57.L_CORE X_NUC_113.L_CORE 0.001991
K_7701 X_NUC_57.L_CORE X_NUC_114.L_CORE 0.002005
K_7702 X_NUC_57.L_CORE X_NUC_115.L_CORE 0.001987
K_7703 X_NUC_57.L_CORE X_NUC_116.L_CORE 0.001995
K_7704 X_NUC_57.L_CORE X_NUC_117.L_CORE 0.002235
K_7705 X_NUC_57.L_CORE X_NUC_118.L_CORE 0.002253
K_7706 X_NUC_57.L_CORE X_NUC_119.L_CORE 0.002237
K_7707 X_NUC_57.L_CORE X_NUC_120.L_CORE 0.002231
K_7708 X_NUC_57.L_CORE X_NUC_121.L_CORE 0.002892
K_7709 X_NUC_57.L_CORE X_NUC_122.L_CORE 0.002910
K_7710 X_NUC_57.L_CORE X_NUC_123.L_CORE 0.002870
K_7711 X_NUC_57.L_CORE X_NUC_124.L_CORE 0.002885
K_7712 X_NUC_57.L_CORE X_NUC_125.L_CORE 0.001962
K_7713 X_NUC_57.L_CORE X_NUC_126.L_CORE 0.001977
K_7714 X_NUC_57.L_CORE X_NUC_127.L_CORE 0.001960
K_7715 X_NUC_57.L_CORE X_NUC_128.L_CORE 0.001963
K_7716 X_NUC_57.L_CORE X_NUC_129.L_CORE 0.002490
K_7717 X_NUC_57.L_CORE X_NUC_130.L_CORE 0.002509
K_7718 X_NUC_57.L_CORE X_NUC_131.L_CORE 0.002483
K_7719 X_NUC_57.L_CORE X_NUC_132.L_CORE 0.002482
K_7720 X_NUC_57.L_CORE X_NUC_133.L_CORE 0.002289
K_7721 X_NUC_57.L_CORE X_NUC_134.L_CORE 0.003317
K_7722 X_NUC_57.L_CORE X_NUC_135.L_CORE 0.001989
K_7723 X_NUC_57.L_CORE X_NUC_136.L_CORE 0.002723
K_7724 X_NUC_57.L_CORE X_NUC_137.L_CORE 0.002925
K_7725 X_NUC_57.L_CORE X_NUC_138.L_CORE 0.001826
K_7726 X_NUC_57.L_CORE X_NUC_139.L_CORE 0.005351
K_7727 X_NUC_57.L_CORE X_NUC_140.L_CORE 0.002013
K_7728 X_NUC_57.L_CORE X_NUC_141.L_CORE 0.002140
K_7729 X_NUC_57.L_CORE X_NUC_142.L_CORE 0.005246
K_7730 X_NUC_57.L_CORE X_NUC_143.L_CORE 0.001691
K_7731 X_NUC_57.L_CORE X_NUC_144.L_CORE 0.003699
K_7732 X_NUC_57.L_CORE X_NUC_145.L_CORE 0.002449
K_7733 X_NUC_57.L_CORE X_NUC_146.L_CORE 0.001773
K_7734 X_NUC_57.L_CORE X_NUC_147.L_CORE 0.030481
K_7735 X_NUC_57.L_CORE X_NUC_148.L_CORE 0.001759
K_7736 X_NUC_57.L_CORE X_NUC_149.L_CORE 0.002414
K_7737 X_NUC_57.L_CORE X_NUC_150.L_CORE 0.003602
K_7738 X_NUC_57.L_CORE X_NUC_151.L_CORE 0.001639
K_7739 X_NUC_57.L_CORE X_NUC_152.L_CORE 0.005103
K_7740 X_NUC_57.L_CORE X_NUC_153.L_CORE 0.002038
K_7741 X_NUC_57.L_CORE X_NUC_154.L_CORE 0.001902
K_7742 X_NUC_57.L_CORE X_NUC_155.L_CORE 0.005378
K_7743 X_NUC_57.L_CORE X_NUC_156.L_CORE 0.001682
K_7744 X_NUC_57.L_CORE X_NUC_157.L_CORE 0.002766
K_7745 X_NUC_57.L_CORE X_NUC_158.L_CORE 0.002542
K_7746 X_NUC_57.L_CORE X_NUC_159.L_CORE 0.001741
K_7747 X_NUC_57.L_CORE X_NUC_160.L_CORE 0.003808
K_7748 X_NUC_57.L_CORE X_NUC_161.L_CORE 0.001894
K_7749 X_NUC_57.L_CORE X_NUC_162.L_CORE 0.002125
K_7750 X_NUC_57.L_CORE X_NUC_163.L_CORE 0.002738
K_7751 X_NUC_57.L_CORE X_NUC_164.L_CORE 0.001867
K_7752 X_NUC_57.L_CORE X_NUC_165.L_CORE 0.002363
K_7753 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.207973
K_7754 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.207973
K_7755 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.001831
K_7756 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.001845
K_7757 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.001833
K_7758 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.001842
K_7759 X_NUC_58.L_CORE X_NUC_65.L_CORE 0.002510
K_7760 X_NUC_58.L_CORE X_NUC_66.L_CORE 0.002534
K_7761 X_NUC_58.L_CORE X_NUC_67.L_CORE 0.002529
K_7762 X_NUC_58.L_CORE X_NUC_68.L_CORE 0.002511
K_7763 X_NUC_58.L_CORE X_NUC_69.L_CORE 0.003788
K_7764 X_NUC_58.L_CORE X_NUC_70.L_CORE 0.003808
K_7765 X_NUC_58.L_CORE X_NUC_71.L_CORE 0.003756
K_7766 X_NUC_58.L_CORE X_NUC_72.L_CORE 0.003821
K_7767 X_NUC_58.L_CORE X_NUC_73.L_CORE 0.001705
K_7768 X_NUC_58.L_CORE X_NUC_74.L_CORE 0.001719
K_7769 X_NUC_58.L_CORE X_NUC_75.L_CORE 0.001710
K_7770 X_NUC_58.L_CORE X_NUC_76.L_CORE 0.001711
K_7771 X_NUC_58.L_CORE X_NUC_77.L_CORE 0.005379
K_7772 X_NUC_58.L_CORE X_NUC_78.L_CORE 0.005436
K_7773 X_NUC_58.L_CORE X_NUC_79.L_CORE 0.005413
K_7774 X_NUC_58.L_CORE X_NUC_80.L_CORE 0.005307
K_7775 X_NUC_58.L_CORE X_NUC_81.L_CORE 0.002126
K_7776 X_NUC_58.L_CORE X_NUC_82.L_CORE 0.002141
K_7777 X_NUC_58.L_CORE X_NUC_83.L_CORE 0.002123
K_7778 X_NUC_58.L_CORE X_NUC_84.L_CORE 0.002138
K_7779 X_NUC_58.L_CORE X_NUC_85.L_CORE 0.001978
K_7780 X_NUC_58.L_CORE X_NUC_86.L_CORE 0.001996
K_7781 X_NUC_58.L_CORE X_NUC_87.L_CORE 0.001987
K_7782 X_NUC_58.L_CORE X_NUC_88.L_CORE 0.001980
K_7783 X_NUC_58.L_CORE X_NUC_89.L_CORE 0.005762
K_7784 X_NUC_58.L_CORE X_NUC_90.L_CORE 0.005781
K_7785 X_NUC_58.L_CORE X_NUC_91.L_CORE 0.005637
K_7786 X_NUC_58.L_CORE X_NUC_92.L_CORE 0.005724
K_7787 X_NUC_58.L_CORE X_NUC_93.L_CORE 0.001752
K_7788 X_NUC_58.L_CORE X_NUC_94.L_CORE 0.001765
K_7789 X_NUC_58.L_CORE X_NUC_95.L_CORE 0.001753
K_7790 X_NUC_58.L_CORE X_NUC_96.L_CORE 0.001758
K_7791 X_NUC_58.L_CORE X_NUC_97.L_CORE 0.002888
K_7792 X_NUC_58.L_CORE X_NUC_98.L_CORE 0.002914
K_7793 X_NUC_58.L_CORE X_NUC_99.L_CORE 0.002897
K_7794 X_NUC_58.L_CORE X_NUC_100.L_CORE 0.002875
K_7795 X_NUC_58.L_CORE X_NUC_101.L_CORE 0.002663
K_7796 X_NUC_58.L_CORE X_NUC_102.L_CORE 0.002679
K_7797 X_NUC_58.L_CORE X_NUC_103.L_CORE 0.002646
K_7798 X_NUC_58.L_CORE X_NUC_104.L_CORE 0.002671
K_7799 X_NUC_58.L_CORE X_NUC_105.L_CORE 0.001813
K_7800 X_NUC_58.L_CORE X_NUC_106.L_CORE 0.001827
K_7801 X_NUC_58.L_CORE X_NUC_107.L_CORE 0.001816
K_7802 X_NUC_58.L_CORE X_NUC_108.L_CORE 0.001815
K_7803 X_NUC_58.L_CORE X_NUC_109.L_CORE 0.004019
K_7804 X_NUC_58.L_CORE X_NUC_110.L_CORE 0.004046
K_7805 X_NUC_58.L_CORE X_NUC_111.L_CORE 0.003987
K_7806 X_NUC_58.L_CORE X_NUC_112.L_CORE 0.003977
K_7807 X_NUC_58.L_CORE X_NUC_113.L_CORE 0.001977
K_7808 X_NUC_58.L_CORE X_NUC_114.L_CORE 0.001991
K_7809 X_NUC_58.L_CORE X_NUC_115.L_CORE 0.001973
K_7810 X_NUC_58.L_CORE X_NUC_116.L_CORE 0.001981
K_7811 X_NUC_58.L_CORE X_NUC_117.L_CORE 0.002217
K_7812 X_NUC_58.L_CORE X_NUC_118.L_CORE 0.002235
K_7813 X_NUC_58.L_CORE X_NUC_119.L_CORE 0.002219
K_7814 X_NUC_58.L_CORE X_NUC_120.L_CORE 0.002213
K_7815 X_NUC_58.L_CORE X_NUC_121.L_CORE 0.002874
K_7816 X_NUC_58.L_CORE X_NUC_122.L_CORE 0.002892
K_7817 X_NUC_58.L_CORE X_NUC_123.L_CORE 0.002853
K_7818 X_NUC_58.L_CORE X_NUC_124.L_CORE 0.002868
K_7819 X_NUC_58.L_CORE X_NUC_125.L_CORE 0.001948
K_7820 X_NUC_58.L_CORE X_NUC_126.L_CORE 0.001962
K_7821 X_NUC_58.L_CORE X_NUC_127.L_CORE 0.001946
K_7822 X_NUC_58.L_CORE X_NUC_128.L_CORE 0.001949
K_7823 X_NUC_58.L_CORE X_NUC_129.L_CORE 0.002472
K_7824 X_NUC_58.L_CORE X_NUC_130.L_CORE 0.002490
K_7825 X_NUC_58.L_CORE X_NUC_131.L_CORE 0.002465
K_7826 X_NUC_58.L_CORE X_NUC_132.L_CORE 0.002465
K_7827 X_NUC_58.L_CORE X_NUC_133.L_CORE 0.002270
K_7828 X_NUC_58.L_CORE X_NUC_134.L_CORE 0.003291
K_7829 X_NUC_58.L_CORE X_NUC_135.L_CORE 0.001974
K_7830 X_NUC_58.L_CORE X_NUC_136.L_CORE 0.002698
K_7831 X_NUC_58.L_CORE X_NUC_137.L_CORE 0.002906
K_7832 X_NUC_58.L_CORE X_NUC_138.L_CORE 0.001811
K_7833 X_NUC_58.L_CORE X_NUC_139.L_CORE 0.005305
K_7834 X_NUC_58.L_CORE X_NUC_140.L_CORE 0.001998
K_7835 X_NUC_58.L_CORE X_NUC_141.L_CORE 0.002121
K_7836 X_NUC_58.L_CORE X_NUC_142.L_CORE 0.005235
K_7837 X_NUC_58.L_CORE X_NUC_143.L_CORE 0.001678
K_7838 X_NUC_58.L_CORE X_NUC_144.L_CORE 0.003665
K_7839 X_NUC_58.L_CORE X_NUC_145.L_CORE 0.002434
K_7840 X_NUC_58.L_CORE X_NUC_146.L_CORE 0.001759
K_7841 X_NUC_58.L_CORE X_NUC_147.L_CORE 0.035611
K_7842 X_NUC_58.L_CORE X_NUC_148.L_CORE 0.001746
K_7843 X_NUC_58.L_CORE X_NUC_149.L_CORE 0.002393
K_7844 X_NUC_58.L_CORE X_NUC_150.L_CORE 0.003591
K_7845 X_NUC_58.L_CORE X_NUC_151.L_CORE 0.001626
K_7846 X_NUC_58.L_CORE X_NUC_152.L_CORE 0.005071
K_7847 X_NUC_58.L_CORE X_NUC_153.L_CORE 0.002025
K_7848 X_NUC_58.L_CORE X_NUC_154.L_CORE 0.001886
K_7849 X_NUC_58.L_CORE X_NUC_155.L_CORE 0.005386
K_7850 X_NUC_58.L_CORE X_NUC_156.L_CORE 0.001670
K_7851 X_NUC_58.L_CORE X_NUC_157.L_CORE 0.002745
K_7852 X_NUC_58.L_CORE X_NUC_158.L_CORE 0.002529
K_7853 X_NUC_58.L_CORE X_NUC_159.L_CORE 0.001727
K_7854 X_NUC_58.L_CORE X_NUC_160.L_CORE 0.003791
K_7855 X_NUC_58.L_CORE X_NUC_161.L_CORE 0.001882
K_7856 X_NUC_58.L_CORE X_NUC_162.L_CORE 0.002109
K_7857 X_NUC_58.L_CORE X_NUC_163.L_CORE 0.002724
K_7858 X_NUC_58.L_CORE X_NUC_164.L_CORE 0.001854
K_7859 X_NUC_58.L_CORE X_NUC_165.L_CORE 0.002348
K_7860 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.207973
K_7861 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.001842
K_7862 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.001857
K_7863 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.001845
K_7864 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.001853
K_7865 X_NUC_59.L_CORE X_NUC_65.L_CORE 0.002515
K_7866 X_NUC_59.L_CORE X_NUC_66.L_CORE 0.002539
K_7867 X_NUC_59.L_CORE X_NUC_67.L_CORE 0.002534
K_7868 X_NUC_59.L_CORE X_NUC_68.L_CORE 0.002515
K_7869 X_NUC_59.L_CORE X_NUC_69.L_CORE 0.003841
K_7870 X_NUC_59.L_CORE X_NUC_70.L_CORE 0.003860
K_7871 X_NUC_59.L_CORE X_NUC_71.L_CORE 0.003808
K_7872 X_NUC_59.L_CORE X_NUC_72.L_CORE 0.003875
K_7873 X_NUC_59.L_CORE X_NUC_73.L_CORE 0.001714
K_7874 X_NUC_59.L_CORE X_NUC_74.L_CORE 0.001728
K_7875 X_NUC_59.L_CORE X_NUC_75.L_CORE 0.001719
K_7876 X_NUC_59.L_CORE X_NUC_76.L_CORE 0.001720
K_7877 X_NUC_59.L_CORE X_NUC_77.L_CORE 0.005399
K_7878 X_NUC_59.L_CORE X_NUC_78.L_CORE 0.005456
K_7879 X_NUC_59.L_CORE X_NUC_79.L_CORE 0.005436
K_7880 X_NUC_59.L_CORE X_NUC_80.L_CORE 0.005327
K_7881 X_NUC_59.L_CORE X_NUC_81.L_CORE 0.002145
K_7882 X_NUC_59.L_CORE X_NUC_82.L_CORE 0.002160
K_7883 X_NUC_59.L_CORE X_NUC_83.L_CORE 0.002141
K_7884 X_NUC_59.L_CORE X_NUC_84.L_CORE 0.002157
K_7885 X_NUC_59.L_CORE X_NUC_85.L_CORE 0.001987
K_7886 X_NUC_59.L_CORE X_NUC_86.L_CORE 0.002004
K_7887 X_NUC_59.L_CORE X_NUC_87.L_CORE 0.001996
K_7888 X_NUC_59.L_CORE X_NUC_88.L_CORE 0.001989
K_7889 X_NUC_59.L_CORE X_NUC_89.L_CORE 0.005913
K_7890 X_NUC_59.L_CORE X_NUC_90.L_CORE 0.005931
K_7891 X_NUC_59.L_CORE X_NUC_91.L_CORE 0.005781
K_7892 X_NUC_59.L_CORE X_NUC_92.L_CORE 0.005871
K_7893 X_NUC_59.L_CORE X_NUC_93.L_CORE 0.001764
K_7894 X_NUC_59.L_CORE X_NUC_94.L_CORE 0.001778
K_7895 X_NUC_59.L_CORE X_NUC_95.L_CORE 0.001765
K_7896 X_NUC_59.L_CORE X_NUC_96.L_CORE 0.001770
K_7897 X_NUC_59.L_CORE X_NUC_97.L_CORE 0.002904
K_7898 X_NUC_59.L_CORE X_NUC_98.L_CORE 0.002930
K_7899 X_NUC_59.L_CORE X_NUC_99.L_CORE 0.002914
K_7900 X_NUC_59.L_CORE X_NUC_100.L_CORE 0.002890
K_7901 X_NUC_59.L_CORE X_NUC_101.L_CORE 0.002696
K_7902 X_NUC_59.L_CORE X_NUC_102.L_CORE 0.002713
K_7903 X_NUC_59.L_CORE X_NUC_103.L_CORE 0.002679
K_7904 X_NUC_59.L_CORE X_NUC_104.L_CORE 0.002704
K_7905 X_NUC_59.L_CORE X_NUC_105.L_CORE 0.001824
K_7906 X_NUC_59.L_CORE X_NUC_106.L_CORE 0.001839
K_7907 X_NUC_59.L_CORE X_NUC_107.L_CORE 0.001827
K_7908 X_NUC_59.L_CORE X_NUC_108.L_CORE 0.001826
K_7909 X_NUC_59.L_CORE X_NUC_109.L_CORE 0.004079
K_7910 X_NUC_59.L_CORE X_NUC_110.L_CORE 0.004107
K_7911 X_NUC_59.L_CORE X_NUC_111.L_CORE 0.004046
K_7912 X_NUC_59.L_CORE X_NUC_112.L_CORE 0.004035
K_7913 X_NUC_59.L_CORE X_NUC_113.L_CORE 0.001995
K_7914 X_NUC_59.L_CORE X_NUC_114.L_CORE 0.002009
K_7915 X_NUC_59.L_CORE X_NUC_115.L_CORE 0.001991
K_7916 X_NUC_59.L_CORE X_NUC_116.L_CORE 0.001999
K_7917 X_NUC_59.L_CORE X_NUC_117.L_CORE 0.002233
K_7918 X_NUC_59.L_CORE X_NUC_118.L_CORE 0.002251
K_7919 X_NUC_59.L_CORE X_NUC_119.L_CORE 0.002235
K_7920 X_NUC_59.L_CORE X_NUC_120.L_CORE 0.002228
K_7921 X_NUC_59.L_CORE X_NUC_121.L_CORE 0.002914
K_7922 X_NUC_59.L_CORE X_NUC_122.L_CORE 0.002932
K_7923 X_NUC_59.L_CORE X_NUC_123.L_CORE 0.002892
K_7924 X_NUC_59.L_CORE X_NUC_124.L_CORE 0.002907
K_7925 X_NUC_59.L_CORE X_NUC_125.L_CORE 0.001964
K_7926 X_NUC_59.L_CORE X_NUC_126.L_CORE 0.001979
K_7927 X_NUC_59.L_CORE X_NUC_127.L_CORE 0.001962
K_7928 X_NUC_59.L_CORE X_NUC_128.L_CORE 0.001965
K_7929 X_NUC_59.L_CORE X_NUC_129.L_CORE 0.002498
K_7930 X_NUC_59.L_CORE X_NUC_130.L_CORE 0.002516
K_7931 X_NUC_59.L_CORE X_NUC_131.L_CORE 0.002490
K_7932 X_NUC_59.L_CORE X_NUC_132.L_CORE 0.002490
K_7933 X_NUC_59.L_CORE X_NUC_133.L_CORE 0.002268
K_7934 X_NUC_59.L_CORE X_NUC_134.L_CORE 0.003278
K_7935 X_NUC_59.L_CORE X_NUC_135.L_CORE 0.001978
K_7936 X_NUC_59.L_CORE X_NUC_136.L_CORE 0.002689
K_7937 X_NUC_59.L_CORE X_NUC_137.L_CORE 0.002913
K_7938 X_NUC_59.L_CORE X_NUC_138.L_CORE 0.001815
K_7939 X_NUC_59.L_CORE X_NUC_139.L_CORE 0.005220
K_7940 X_NUC_59.L_CORE X_NUC_140.L_CORE 0.002008
K_7941 X_NUC_59.L_CORE X_NUC_141.L_CORE 0.002122
K_7942 X_NUC_59.L_CORE X_NUC_142.L_CORE 0.005247
K_7943 X_NUC_59.L_CORE X_NUC_143.L_CORE 0.001685
K_7944 X_NUC_59.L_CORE X_NUC_144.L_CORE 0.003645
K_7945 X_NUC_59.L_CORE X_NUC_145.L_CORE 0.002452
K_7946 X_NUC_59.L_CORE X_NUC_146.L_CORE 0.001764
K_7947 X_NUC_59.L_CORE X_NUC_147.L_CORE 0.031899
K_7948 X_NUC_59.L_CORE X_NUC_148.L_CORE 0.001757
K_7949 X_NUC_59.L_CORE X_NUC_149.L_CORE 0.002396
K_7950 X_NUC_59.L_CORE X_NUC_150.L_CORE 0.003635
K_7951 X_NUC_59.L_CORE X_NUC_151.L_CORE 0.001634
K_7952 X_NUC_59.L_CORE X_NUC_152.L_CORE 0.005077
K_7953 X_NUC_59.L_CORE X_NUC_153.L_CORE 0.002042
K_7954 X_NUC_59.L_CORE X_NUC_154.L_CORE 0.001894
K_7955 X_NUC_59.L_CORE X_NUC_155.L_CORE 0.005505
K_7956 X_NUC_59.L_CORE X_NUC_156.L_CORE 0.001681
K_7957 X_NUC_59.L_CORE X_NUC_157.L_CORE 0.002758
K_7958 X_NUC_59.L_CORE X_NUC_158.L_CORE 0.002559
K_7959 X_NUC_59.L_CORE X_NUC_159.L_CORE 0.001738
K_7960 X_NUC_59.L_CORE X_NUC_160.L_CORE 0.003841
K_7961 X_NUC_59.L_CORE X_NUC_161.L_CORE 0.001898
K_7962 X_NUC_59.L_CORE X_NUC_162.L_CORE 0.002123
K_7963 X_NUC_59.L_CORE X_NUC_163.L_CORE 0.002760
K_7964 X_NUC_59.L_CORE X_NUC_164.L_CORE 0.001869
K_7965 X_NUC_59.L_CORE X_NUC_165.L_CORE 0.002370
K_7966 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.001834
K_7967 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.001848
K_7968 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.001836
K_7969 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.001845
K_7970 X_NUC_60.L_CORE X_NUC_65.L_CORE 0.002533
K_7971 X_NUC_60.L_CORE X_NUC_66.L_CORE 0.002558
K_7972 X_NUC_60.L_CORE X_NUC_67.L_CORE 0.002553
K_7973 X_NUC_60.L_CORE X_NUC_68.L_CORE 0.002534
K_7974 X_NUC_60.L_CORE X_NUC_69.L_CORE 0.003775
K_7975 X_NUC_60.L_CORE X_NUC_70.L_CORE 0.003794
K_7976 X_NUC_60.L_CORE X_NUC_71.L_CORE 0.003743
K_7977 X_NUC_60.L_CORE X_NUC_72.L_CORE 0.003808
K_7978 X_NUC_60.L_CORE X_NUC_73.L_CORE 0.001713
K_7979 X_NUC_60.L_CORE X_NUC_74.L_CORE 0.001727
K_7980 X_NUC_60.L_CORE X_NUC_75.L_CORE 0.001718
K_7981 X_NUC_60.L_CORE X_NUC_76.L_CORE 0.001719
K_7982 X_NUC_60.L_CORE X_NUC_77.L_CORE 0.005511
K_7983 X_NUC_60.L_CORE X_NUC_78.L_CORE 0.005571
K_7984 X_NUC_60.L_CORE X_NUC_79.L_CORE 0.005549
K_7985 X_NUC_60.L_CORE X_NUC_80.L_CORE 0.005436
K_7986 X_NUC_60.L_CORE X_NUC_81.L_CORE 0.002129
K_7987 X_NUC_60.L_CORE X_NUC_82.L_CORE 0.002144
K_7988 X_NUC_60.L_CORE X_NUC_83.L_CORE 0.002126
K_7989 X_NUC_60.L_CORE X_NUC_84.L_CORE 0.002141
K_7990 X_NUC_60.L_CORE X_NUC_85.L_CORE 0.001993
K_7991 X_NUC_60.L_CORE X_NUC_86.L_CORE 0.002011
K_7992 X_NUC_60.L_CORE X_NUC_87.L_CORE 0.002002
K_7993 X_NUC_60.L_CORE X_NUC_88.L_CORE 0.001996
K_7994 X_NUC_60.L_CORE X_NUC_89.L_CORE 0.005818
K_7995 X_NUC_60.L_CORE X_NUC_90.L_CORE 0.005835
K_7996 X_NUC_60.L_CORE X_NUC_91.L_CORE 0.005690
K_7997 X_NUC_60.L_CORE X_NUC_92.L_CORE 0.005781
K_7998 X_NUC_60.L_CORE X_NUC_93.L_CORE 0.001759
K_7999 X_NUC_60.L_CORE X_NUC_94.L_CORE 0.001772
K_8000 X_NUC_60.L_CORE X_NUC_95.L_CORE 0.001760
K_8001 X_NUC_60.L_CORE X_NUC_96.L_CORE 0.001765
K_8002 X_NUC_60.L_CORE X_NUC_97.L_CORE 0.002927
K_8003 X_NUC_60.L_CORE X_NUC_98.L_CORE 0.002954
K_8004 X_NUC_60.L_CORE X_NUC_99.L_CORE 0.002937
K_8005 X_NUC_60.L_CORE X_NUC_100.L_CORE 0.002914
K_8006 X_NUC_60.L_CORE X_NUC_101.L_CORE 0.002671
K_8007 X_NUC_60.L_CORE X_NUC_102.L_CORE 0.002687
K_8008 X_NUC_60.L_CORE X_NUC_103.L_CORE 0.002655
K_8009 X_NUC_60.L_CORE X_NUC_104.L_CORE 0.002679
K_8010 X_NUC_60.L_CORE X_NUC_105.L_CORE 0.001825
K_8011 X_NUC_60.L_CORE X_NUC_106.L_CORE 0.001840
K_8012 X_NUC_60.L_CORE X_NUC_107.L_CORE 0.001828
K_8013 X_NUC_60.L_CORE X_NUC_108.L_CORE 0.001827
K_8014 X_NUC_60.L_CORE X_NUC_109.L_CORE 0.004090
K_8015 X_NUC_60.L_CORE X_NUC_110.L_CORE 0.004118
K_8016 X_NUC_60.L_CORE X_NUC_111.L_CORE 0.004056
K_8017 X_NUC_60.L_CORE X_NUC_112.L_CORE 0.004046
K_8018 X_NUC_60.L_CORE X_NUC_113.L_CORE 0.001986
K_8019 X_NUC_60.L_CORE X_NUC_114.L_CORE 0.002000
K_8020 X_NUC_60.L_CORE X_NUC_115.L_CORE 0.001982
K_8021 X_NUC_60.L_CORE X_NUC_116.L_CORE 0.001991
K_8022 X_NUC_60.L_CORE X_NUC_117.L_CORE 0.002239
K_8023 X_NUC_60.L_CORE X_NUC_118.L_CORE 0.002258
K_8024 X_NUC_60.L_CORE X_NUC_119.L_CORE 0.002242
K_8025 X_NUC_60.L_CORE X_NUC_120.L_CORE 0.002235
K_8026 X_NUC_60.L_CORE X_NUC_121.L_CORE 0.002899
K_8027 X_NUC_60.L_CORE X_NUC_122.L_CORE 0.002917
K_8028 X_NUC_60.L_CORE X_NUC_123.L_CORE 0.002877
K_8029 X_NUC_60.L_CORE X_NUC_124.L_CORE 0.002892
K_8030 X_NUC_60.L_CORE X_NUC_125.L_CORE 0.001961
K_8031 X_NUC_60.L_CORE X_NUC_126.L_CORE 0.001976
K_8032 X_NUC_60.L_CORE X_NUC_127.L_CORE 0.001959
K_8033 X_NUC_60.L_CORE X_NUC_128.L_CORE 0.001962
K_8034 X_NUC_60.L_CORE X_NUC_129.L_CORE 0.002498
K_8035 X_NUC_60.L_CORE X_NUC_130.L_CORE 0.002517
K_8036 X_NUC_60.L_CORE X_NUC_131.L_CORE 0.002491
K_8037 X_NUC_60.L_CORE X_NUC_132.L_CORE 0.002490
K_8038 X_NUC_60.L_CORE X_NUC_133.L_CORE 0.002268
K_8039 X_NUC_60.L_CORE X_NUC_134.L_CORE 0.003268
K_8040 X_NUC_60.L_CORE X_NUC_135.L_CORE 0.001972
K_8041 X_NUC_60.L_CORE X_NUC_136.L_CORE 0.002703
K_8042 X_NUC_60.L_CORE X_NUC_137.L_CORE 0.002886
K_8043 X_NUC_60.L_CORE X_NUC_138.L_CORE 0.001815
K_8044 X_NUC_60.L_CORE X_NUC_139.L_CORE 0.005275
K_8045 X_NUC_60.L_CORE X_NUC_140.L_CORE 0.001996
K_8046 X_NUC_60.L_CORE X_NUC_141.L_CORE 0.002131
K_8047 X_NUC_60.L_CORE X_NUC_142.L_CORE 0.005138
K_8048 X_NUC_60.L_CORE X_NUC_143.L_CORE 0.001682
K_8049 X_NUC_60.L_CORE X_NUC_144.L_CORE 0.003698
K_8050 X_NUC_60.L_CORE X_NUC_145.L_CORE 0.002427
K_8051 X_NUC_60.L_CORE X_NUC_146.L_CORE 0.001767
K_8052 X_NUC_60.L_CORE X_NUC_147.L_CORE 0.032746
K_8053 X_NUC_60.L_CORE X_NUC_148.L_CORE 0.001749
K_8054 X_NUC_60.L_CORE X_NUC_149.L_CORE 0.002414
K_8055 X_NUC_60.L_CORE X_NUC_150.L_CORE 0.003575
K_8056 X_NUC_60.L_CORE X_NUC_151.L_CORE 0.001633
K_8057 X_NUC_60.L_CORE X_NUC_152.L_CORE 0.005183
K_8058 X_NUC_60.L_CORE X_NUC_153.L_CORE 0.002027
K_8059 X_NUC_60.L_CORE X_NUC_154.L_CORE 0.001900
K_8060 X_NUC_60.L_CORE X_NUC_155.L_CORE 0.005425
K_8061 X_NUC_60.L_CORE X_NUC_156.L_CORE 0.001676
K_8062 X_NUC_60.L_CORE X_NUC_157.L_CORE 0.002780
K_8063 X_NUC_60.L_CORE X_NUC_158.L_CORE 0.002536
K_8064 X_NUC_60.L_CORE X_NUC_159.L_CORE 0.001739
K_8065 X_NUC_60.L_CORE X_NUC_160.L_CORE 0.003853
K_8066 X_NUC_60.L_CORE X_NUC_161.L_CORE 0.001890
K_8067 X_NUC_60.L_CORE X_NUC_162.L_CORE 0.002130
K_8068 X_NUC_60.L_CORE X_NUC_163.L_CORE 0.002746
K_8069 X_NUC_60.L_CORE X_NUC_164.L_CORE 0.001866
K_8070 X_NUC_60.L_CORE X_NUC_165.L_CORE 0.002371
K_8071 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.207973
K_8072 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.207973
K_8073 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.207973
K_8074 X_NUC_61.L_CORE X_NUC_65.L_CORE 0.001838
K_8075 X_NUC_61.L_CORE X_NUC_66.L_CORE 0.001833
K_8076 X_NUC_61.L_CORE X_NUC_67.L_CORE 0.001843
K_8077 X_NUC_61.L_CORE X_NUC_68.L_CORE 0.001828
K_8078 X_NUC_61.L_CORE X_NUC_69.L_CORE 0.002530
K_8079 X_NUC_61.L_CORE X_NUC_70.L_CORE 0.002499
K_8080 X_NUC_61.L_CORE X_NUC_71.L_CORE 0.002514
K_8081 X_NUC_61.L_CORE X_NUC_72.L_CORE 0.002511
K_8082 X_NUC_61.L_CORE X_NUC_73.L_CORE 0.003808
K_8083 X_NUC_61.L_CORE X_NUC_74.L_CORE 0.003837
K_8084 X_NUC_61.L_CORE X_NUC_75.L_CORE 0.003843
K_8085 X_NUC_61.L_CORE X_NUC_76.L_CORE 0.003782
K_8086 X_NUC_61.L_CORE X_NUC_77.L_CORE 0.001722
K_8087 X_NUC_61.L_CORE X_NUC_78.L_CORE 0.001713
K_8088 X_NUC_61.L_CORE X_NUC_79.L_CORE 0.001721
K_8089 X_NUC_61.L_CORE X_NUC_80.L_CORE 0.001711
K_8090 X_NUC_61.L_CORE X_NUC_81.L_CORE 0.005448
K_8091 X_NUC_61.L_CORE X_NUC_82.L_CORE 0.005331
K_8092 X_NUC_61.L_CORE X_NUC_83.L_CORE 0.005323
K_8093 X_NUC_61.L_CORE X_NUC_84.L_CORE 0.005360
K_8094 X_NUC_61.L_CORE X_NUC_85.L_CORE 0.002153
K_8095 X_NUC_61.L_CORE X_NUC_86.L_CORE 0.002152
K_8096 X_NUC_61.L_CORE X_NUC_87.L_CORE 0.002160
K_8097 X_NUC_61.L_CORE X_NUC_88.L_CORE 0.002138
K_8098 X_NUC_61.L_CORE X_NUC_89.L_CORE 0.002011
K_8099 X_NUC_61.L_CORE X_NUC_90.L_CORE 0.001993
K_8100 X_NUC_61.L_CORE X_NUC_91.L_CORE 0.002002
K_8101 X_NUC_61.L_CORE X_NUC_92.L_CORE 0.001995
K_8102 X_NUC_61.L_CORE X_NUC_93.L_CORE 0.005762
K_8103 X_NUC_61.L_CORE X_NUC_94.L_CORE 0.005802
K_8104 X_NUC_61.L_CORE X_NUC_95.L_CORE 0.005730
K_8105 X_NUC_61.L_CORE X_NUC_96.L_CORE 0.005651
K_8106 X_NUC_61.L_CORE X_NUC_97.L_CORE 0.001787
K_8107 X_NUC_61.L_CORE X_NUC_98.L_CORE 0.001780
K_8108 X_NUC_61.L_CORE X_NUC_99.L_CORE 0.001787
K_8109 X_NUC_61.L_CORE X_NUC_100.L_CORE 0.001774
K_8110 X_NUC_61.L_CORE X_NUC_101.L_CORE 0.002940
K_8111 X_NUC_61.L_CORE X_NUC_102.L_CORE 0.002905
K_8112 X_NUC_61.L_CORE X_NUC_103.L_CORE 0.002908
K_8113 X_NUC_61.L_CORE X_NUC_104.L_CORE 0.002907
K_8114 X_NUC_61.L_CORE X_NUC_105.L_CORE 0.002709
K_8115 X_NUC_61.L_CORE X_NUC_106.L_CORE 0.002713
K_8116 X_NUC_61.L_CORE X_NUC_107.L_CORE 0.002713
K_8117 X_NUC_61.L_CORE X_NUC_108.L_CORE 0.002683
K_8118 X_NUC_61.L_CORE X_NUC_109.L_CORE 0.001866
K_8119 X_NUC_61.L_CORE X_NUC_110.L_CORE 0.001854
K_8120 X_NUC_61.L_CORE X_NUC_111.L_CORE 0.001860
K_8121 X_NUC_61.L_CORE X_NUC_112.L_CORE 0.001851
K_8122 X_NUC_61.L_CORE X_NUC_113.L_CORE 0.003955
K_8123 X_NUC_61.L_CORE X_NUC_114.L_CORE 0.003927
K_8124 X_NUC_61.L_CORE X_NUC_115.L_CORE 0.003901
K_8125 X_NUC_61.L_CORE X_NUC_116.L_CORE 0.003887
K_8126 X_NUC_61.L_CORE X_NUC_117.L_CORE 0.002046
K_8127 X_NUC_61.L_CORE X_NUC_118.L_CORE 0.002041
K_8128 X_NUC_61.L_CORE X_NUC_119.L_CORE 0.002044
K_8129 X_NUC_61.L_CORE X_NUC_120.L_CORE 0.002028
K_8130 X_NUC_61.L_CORE X_NUC_121.L_CORE 0.002289
K_8131 X_NUC_61.L_CORE X_NUC_122.L_CORE 0.002271
K_8132 X_NUC_61.L_CORE X_NUC_123.L_CORE 0.002274
K_8133 X_NUC_61.L_CORE X_NUC_124.L_CORE 0.002265
K_8134 X_NUC_61.L_CORE X_NUC_125.L_CORE 0.002821
K_8135 X_NUC_61.L_CORE X_NUC_126.L_CORE 0.002814
K_8136 X_NUC_61.L_CORE X_NUC_127.L_CORE 0.002807
K_8137 X_NUC_61.L_CORE X_NUC_128.L_CORE 0.002785
K_8138 X_NUC_61.L_CORE X_NUC_129.L_CORE 0.002122
K_8139 X_NUC_61.L_CORE X_NUC_130.L_CORE 0.002112
K_8140 X_NUC_61.L_CORE X_NUC_131.L_CORE 0.002114
K_8141 X_NUC_61.L_CORE X_NUC_132.L_CORE 0.002101
K_8142 X_NUC_61.L_CORE X_NUC_133.L_CORE 0.002333
K_8143 X_NUC_61.L_CORE X_NUC_134.L_CORE 0.002110
K_8144 X_NUC_61.L_CORE X_NUC_135.L_CORE 0.003496
K_8145 X_NUC_61.L_CORE X_NUC_136.L_CORE 0.001888
K_8146 X_NUC_61.L_CORE X_NUC_137.L_CORE 0.002643
K_8147 X_NUC_61.L_CORE X_NUC_138.L_CORE 0.002871
K_8148 X_NUC_61.L_CORE X_NUC_139.L_CORE 0.001762
K_8149 X_NUC_61.L_CORE X_NUC_140.L_CORE 0.005346
K_8150 X_NUC_61.L_CORE X_NUC_141.L_CORE 0.001963
K_8151 X_NUC_61.L_CORE X_NUC_142.L_CORE 0.002083
K_8152 X_NUC_61.L_CORE X_NUC_143.L_CORE 0.005232
K_8153 X_NUC_61.L_CORE X_NUC_144.L_CORE 0.001658
K_8154 X_NUC_61.L_CORE X_NUC_145.L_CORE 0.003613
K_8155 X_NUC_61.L_CORE X_NUC_146.L_CORE 0.002422
K_8156 X_NUC_61.L_CORE X_NUC_147.L_CORE 0.001746
K_8157 X_NUC_61.L_CORE X_NUC_148.L_CORE 0.034318
K_8158 X_NUC_61.L_CORE X_NUC_149.L_CORE 0.001744
K_8159 X_NUC_61.L_CORE X_NUC_150.L_CORE 0.002386
K_8160 X_NUC_61.L_CORE X_NUC_151.L_CORE 0.003612
K_8161 X_NUC_61.L_CORE X_NUC_152.L_CORE 0.001631
K_8162 X_NUC_61.L_CORE X_NUC_153.L_CORE 0.005050
K_8163 X_NUC_61.L_CORE X_NUC_154.L_CORE 0.002043
K_8164 X_NUC_61.L_CORE X_NUC_155.L_CORE 0.001900
K_8165 X_NUC_61.L_CORE X_NUC_156.L_CORE 0.005390
K_8166 X_NUC_61.L_CORE X_NUC_157.L_CORE 0.001694
K_8167 X_NUC_61.L_CORE X_NUC_158.L_CORE 0.002764
K_8168 X_NUC_61.L_CORE X_NUC_159.L_CORE 0.002566
K_8169 X_NUC_61.L_CORE X_NUC_160.L_CORE 0.001765
K_8170 X_NUC_61.L_CORE X_NUC_161.L_CORE 0.003705
K_8171 X_NUC_61.L_CORE X_NUC_162.L_CORE 0.001937
K_8172 X_NUC_61.L_CORE X_NUC_163.L_CORE 0.002160
K_8173 X_NUC_61.L_CORE X_NUC_164.L_CORE 0.002662
K_8174 X_NUC_61.L_CORE X_NUC_165.L_CORE 0.002006
K_8175 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.207973
K_8176 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.207973
K_8177 X_NUC_62.L_CORE X_NUC_65.L_CORE 0.001843
K_8178 X_NUC_62.L_CORE X_NUC_66.L_CORE 0.001838
K_8179 X_NUC_62.L_CORE X_NUC_67.L_CORE 0.001848
K_8180 X_NUC_62.L_CORE X_NUC_68.L_CORE 0.001832
K_8181 X_NUC_62.L_CORE X_NUC_69.L_CORE 0.002561
K_8182 X_NUC_62.L_CORE X_NUC_70.L_CORE 0.002530
K_8183 X_NUC_62.L_CORE X_NUC_71.L_CORE 0.002544
K_8184 X_NUC_62.L_CORE X_NUC_72.L_CORE 0.002542
K_8185 X_NUC_62.L_CORE X_NUC_73.L_CORE 0.003778
K_8186 X_NUC_62.L_CORE X_NUC_74.L_CORE 0.003808
K_8187 X_NUC_62.L_CORE X_NUC_75.L_CORE 0.003813
K_8188 X_NUC_62.L_CORE X_NUC_76.L_CORE 0.003753
K_8189 X_NUC_62.L_CORE X_NUC_77.L_CORE 0.001732
K_8190 X_NUC_62.L_CORE X_NUC_78.L_CORE 0.001722
K_8191 X_NUC_62.L_CORE X_NUC_79.L_CORE 0.001731
K_8192 X_NUC_62.L_CORE X_NUC_80.L_CORE 0.001720
K_8193 X_NUC_62.L_CORE X_NUC_81.L_CORE 0.005568
K_8194 X_NUC_62.L_CORE X_NUC_82.L_CORE 0.005448
K_8195 X_NUC_62.L_CORE X_NUC_83.L_CORE 0.005437
K_8196 X_NUC_62.L_CORE X_NUC_84.L_CORE 0.005477
K_8197 X_NUC_62.L_CORE X_NUC_85.L_CORE 0.002153
K_8198 X_NUC_62.L_CORE X_NUC_86.L_CORE 0.002153
K_8199 X_NUC_62.L_CORE X_NUC_87.L_CORE 0.002160
K_8200 X_NUC_62.L_CORE X_NUC_88.L_CORE 0.002139
K_8201 X_NUC_62.L_CORE X_NUC_89.L_CORE 0.002028
K_8202 X_NUC_62.L_CORE X_NUC_90.L_CORE 0.002011
K_8203 X_NUC_62.L_CORE X_NUC_91.L_CORE 0.002020
K_8204 X_NUC_62.L_CORE X_NUC_92.L_CORE 0.002012
K_8205 X_NUC_62.L_CORE X_NUC_93.L_CORE 0.005718
K_8206 X_NUC_62.L_CORE X_NUC_94.L_CORE 0.005762
K_8207 X_NUC_62.L_CORE X_NUC_95.L_CORE 0.005689
K_8208 X_NUC_62.L_CORE X_NUC_96.L_CORE 0.005611
K_8209 X_NUC_62.L_CORE X_NUC_97.L_CORE 0.001794
K_8210 X_NUC_62.L_CORE X_NUC_98.L_CORE 0.001787
K_8211 X_NUC_62.L_CORE X_NUC_99.L_CORE 0.001794
K_8212 X_NUC_62.L_CORE X_NUC_100.L_CORE 0.001781
K_8213 X_NUC_62.L_CORE X_NUC_101.L_CORE 0.002976
K_8214 X_NUC_62.L_CORE X_NUC_102.L_CORE 0.002940
K_8215 X_NUC_62.L_CORE X_NUC_103.L_CORE 0.002943
K_8216 X_NUC_62.L_CORE X_NUC_104.L_CORE 0.002942
K_8217 X_NUC_62.L_CORE X_NUC_105.L_CORE 0.002705
K_8218 X_NUC_62.L_CORE X_NUC_106.L_CORE 0.002709
K_8219 X_NUC_62.L_CORE X_NUC_107.L_CORE 0.002709
K_8220 X_NUC_62.L_CORE X_NUC_108.L_CORE 0.002679
K_8221 X_NUC_62.L_CORE X_NUC_109.L_CORE 0.001878
K_8222 X_NUC_62.L_CORE X_NUC_110.L_CORE 0.001866
K_8223 X_NUC_62.L_CORE X_NUC_111.L_CORE 0.001872
K_8224 X_NUC_62.L_CORE X_NUC_112.L_CORE 0.001862
K_8225 X_NUC_62.L_CORE X_NUC_113.L_CORE 0.003982
K_8226 X_NUC_62.L_CORE X_NUC_114.L_CORE 0.003955
K_8227 X_NUC_62.L_CORE X_NUC_115.L_CORE 0.003927
K_8228 X_NUC_62.L_CORE X_NUC_116.L_CORE 0.003913
K_8229 X_NUC_62.L_CORE X_NUC_117.L_CORE 0.002051
K_8230 X_NUC_62.L_CORE X_NUC_118.L_CORE 0.002046
K_8231 X_NUC_62.L_CORE X_NUC_119.L_CORE 0.002049
K_8232 X_NUC_62.L_CORE X_NUC_120.L_CORE 0.002033
K_8233 X_NUC_62.L_CORE X_NUC_121.L_CORE 0.002307
K_8234 X_NUC_62.L_CORE X_NUC_122.L_CORE 0.002289
K_8235 X_NUC_62.L_CORE X_NUC_123.L_CORE 0.002292
K_8236 X_NUC_62.L_CORE X_NUC_124.L_CORE 0.002283
K_8237 X_NUC_62.L_CORE X_NUC_125.L_CORE 0.002827
K_8238 X_NUC_62.L_CORE X_NUC_126.L_CORE 0.002821
K_8239 X_NUC_62.L_CORE X_NUC_127.L_CORE 0.002813
K_8240 X_NUC_62.L_CORE X_NUC_128.L_CORE 0.002791
K_8241 X_NUC_62.L_CORE X_NUC_129.L_CORE 0.002132
K_8242 X_NUC_62.L_CORE X_NUC_130.L_CORE 0.002122
K_8243 X_NUC_62.L_CORE X_NUC_131.L_CORE 0.002124
K_8244 X_NUC_62.L_CORE X_NUC_132.L_CORE 0.002111
K_8245 X_NUC_62.L_CORE X_NUC_133.L_CORE 0.002340
K_8246 X_NUC_62.L_CORE X_NUC_134.L_CORE 0.002125
K_8247 X_NUC_62.L_CORE X_NUC_135.L_CORE 0.003506
K_8248 X_NUC_62.L_CORE X_NUC_136.L_CORE 0.001894
K_8249 X_NUC_62.L_CORE X_NUC_137.L_CORE 0.002671
K_8250 X_NUC_62.L_CORE X_NUC_138.L_CORE 0.002864
K_8251 X_NUC_62.L_CORE X_NUC_139.L_CORE 0.001773
K_8252 X_NUC_62.L_CORE X_NUC_140.L_CORE 0.005419
K_8253 X_NUC_62.L_CORE X_NUC_141.L_CORE 0.001966
K_8254 X_NUC_62.L_CORE X_NUC_142.L_CORE 0.002103
K_8255 X_NUC_62.L_CORE X_NUC_143.L_CORE 0.005161
K_8256 X_NUC_62.L_CORE X_NUC_144.L_CORE 0.001666
K_8257 X_NUC_62.L_CORE X_NUC_145.L_CORE 0.003673
K_8258 X_NUC_62.L_CORE X_NUC_146.L_CORE 0.002416
K_8259 X_NUC_62.L_CORE X_NUC_147.L_CORE 0.001759
K_8260 X_NUC_62.L_CORE X_NUC_148.L_CORE 0.031184
K_8261 X_NUC_62.L_CORE X_NUC_149.L_CORE 0.001748
K_8262 X_NUC_62.L_CORE X_NUC_150.L_CORE 0.002413
K_8263 X_NUC_62.L_CORE X_NUC_151.L_CORE 0.003580
K_8264 X_NUC_62.L_CORE X_NUC_152.L_CORE 0.001640
K_8265 X_NUC_62.L_CORE X_NUC_153.L_CORE 0.005145
K_8266 X_NUC_62.L_CORE X_NUC_154.L_CORE 0.002042
K_8267 X_NUC_62.L_CORE X_NUC_155.L_CORE 0.001916
K_8268 X_NUC_62.L_CORE X_NUC_156.L_CORE 0.005339
K_8269 X_NUC_62.L_CORE X_NUC_157.L_CORE 0.001699
K_8270 X_NUC_62.L_CORE X_NUC_158.L_CORE 0.002796
K_8271 X_NUC_62.L_CORE X_NUC_159.L_CORE 0.002561
K_8272 X_NUC_62.L_CORE X_NUC_160.L_CORE 0.001776
K_8273 X_NUC_62.L_CORE X_NUC_161.L_CORE 0.003726
K_8274 X_NUC_62.L_CORE X_NUC_162.L_CORE 0.001942
K_8275 X_NUC_62.L_CORE X_NUC_163.L_CORE 0.002176
K_8276 X_NUC_62.L_CORE X_NUC_164.L_CORE 0.002667
K_8277 X_NUC_62.L_CORE X_NUC_165.L_CORE 0.002015
K_8278 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.207973
K_8279 X_NUC_63.L_CORE X_NUC_65.L_CORE 0.001833
K_8280 X_NUC_63.L_CORE X_NUC_66.L_CORE 0.001828
K_8281 X_NUC_63.L_CORE X_NUC_67.L_CORE 0.001838
K_8282 X_NUC_63.L_CORE X_NUC_68.L_CORE 0.001823
K_8283 X_NUC_63.L_CORE X_NUC_69.L_CORE 0.002546
K_8284 X_NUC_63.L_CORE X_NUC_70.L_CORE 0.002515
K_8285 X_NUC_63.L_CORE X_NUC_71.L_CORE 0.002530
K_8286 X_NUC_63.L_CORE X_NUC_72.L_CORE 0.002527
K_8287 X_NUC_63.L_CORE X_NUC_73.L_CORE 0.003772
K_8288 X_NUC_63.L_CORE X_NUC_74.L_CORE 0.003801
K_8289 X_NUC_63.L_CORE X_NUC_75.L_CORE 0.003808
K_8290 X_NUC_63.L_CORE X_NUC_76.L_CORE 0.003747
K_8291 X_NUC_63.L_CORE X_NUC_77.L_CORE 0.001723
K_8292 X_NUC_63.L_CORE X_NUC_78.L_CORE 0.001713
K_8293 X_NUC_63.L_CORE X_NUC_79.L_CORE 0.001722
K_8294 X_NUC_63.L_CORE X_NUC_80.L_CORE 0.001712
K_8295 X_NUC_63.L_CORE X_NUC_81.L_CORE 0.005578
K_8296 X_NUC_63.L_CORE X_NUC_82.L_CORE 0.005455
K_8297 X_NUC_63.L_CORE X_NUC_83.L_CORE 0.005448
K_8298 X_NUC_63.L_CORE X_NUC_84.L_CORE 0.005486
K_8299 X_NUC_63.L_CORE X_NUC_85.L_CORE 0.002146
K_8300 X_NUC_63.L_CORE X_NUC_86.L_CORE 0.002145
K_8301 X_NUC_63.L_CORE X_NUC_87.L_CORE 0.002153
K_8302 X_NUC_63.L_CORE X_NUC_88.L_CORE 0.002132
K_8303 X_NUC_63.L_CORE X_NUC_89.L_CORE 0.002019
K_8304 X_NUC_63.L_CORE X_NUC_90.L_CORE 0.002002
K_8305 X_NUC_63.L_CORE X_NUC_91.L_CORE 0.002011
K_8306 X_NUC_63.L_CORE X_NUC_92.L_CORE 0.002004
K_8307 X_NUC_63.L_CORE X_NUC_93.L_CORE 0.005790
K_8308 X_NUC_63.L_CORE X_NUC_94.L_CORE 0.005833
K_8309 X_NUC_63.L_CORE X_NUC_95.L_CORE 0.005762
K_8310 X_NUC_63.L_CORE X_NUC_96.L_CORE 0.005679
K_8311 X_NUC_63.L_CORE X_NUC_97.L_CORE 0.001787
K_8312 X_NUC_63.L_CORE X_NUC_98.L_CORE 0.001780
K_8313 X_NUC_63.L_CORE X_NUC_99.L_CORE 0.001787
K_8314 X_NUC_63.L_CORE X_NUC_100.L_CORE 0.001774
K_8315 X_NUC_63.L_CORE X_NUC_101.L_CORE 0.002973
K_8316 X_NUC_63.L_CORE X_NUC_102.L_CORE 0.002937
K_8317 X_NUC_63.L_CORE X_NUC_103.L_CORE 0.002940
K_8318 X_NUC_63.L_CORE X_NUC_104.L_CORE 0.002938
K_8319 X_NUC_63.L_CORE X_NUC_105.L_CORE 0.002705
K_8320 X_NUC_63.L_CORE X_NUC_106.L_CORE 0.002709
K_8321 X_NUC_63.L_CORE X_NUC_107.L_CORE 0.002709
K_8322 X_NUC_63.L_CORE X_NUC_108.L_CORE 0.002680
K_8323 X_NUC_63.L_CORE X_NUC_109.L_CORE 0.001872
K_8324 X_NUC_63.L_CORE X_NUC_110.L_CORE 0.001860
K_8325 X_NUC_63.L_CORE X_NUC_111.L_CORE 0.001866
K_8326 X_NUC_63.L_CORE X_NUC_112.L_CORE 0.001856
K_8327 X_NUC_63.L_CORE X_NUC_113.L_CORE 0.004010
K_8328 X_NUC_63.L_CORE X_NUC_114.L_CORE 0.003982
K_8329 X_NUC_63.L_CORE X_NUC_115.L_CORE 0.003955
K_8330 X_NUC_63.L_CORE X_NUC_116.L_CORE 0.003940
K_8331 X_NUC_63.L_CORE X_NUC_117.L_CORE 0.002047
K_8332 X_NUC_63.L_CORE X_NUC_118.L_CORE 0.002042
K_8333 X_NUC_63.L_CORE X_NUC_119.L_CORE 0.002046
K_8334 X_NUC_63.L_CORE X_NUC_120.L_CORE 0.002029
K_8335 X_NUC_63.L_CORE X_NUC_121.L_CORE 0.002305
K_8336 X_NUC_63.L_CORE X_NUC_122.L_CORE 0.002286
K_8337 X_NUC_63.L_CORE X_NUC_123.L_CORE 0.002289
K_8338 X_NUC_63.L_CORE X_NUC_124.L_CORE 0.002280
K_8339 X_NUC_63.L_CORE X_NUC_125.L_CORE 0.002834
K_8340 X_NUC_63.L_CORE X_NUC_126.L_CORE 0.002828
K_8341 X_NUC_63.L_CORE X_NUC_127.L_CORE 0.002821
K_8342 X_NUC_63.L_CORE X_NUC_128.L_CORE 0.002799
K_8343 X_NUC_63.L_CORE X_NUC_129.L_CORE 0.002130
K_8344 X_NUC_63.L_CORE X_NUC_130.L_CORE 0.002120
K_8345 X_NUC_63.L_CORE X_NUC_131.L_CORE 0.002122
K_8346 X_NUC_63.L_CORE X_NUC_132.L_CORE 0.002109
K_8347 X_NUC_63.L_CORE X_NUC_133.L_CORE 0.002315
K_8348 X_NUC_63.L_CORE X_NUC_134.L_CORE 0.002104
K_8349 X_NUC_63.L_CORE X_NUC_135.L_CORE 0.003452
K_8350 X_NUC_63.L_CORE X_NUC_136.L_CORE 0.001879
K_8351 X_NUC_63.L_CORE X_NUC_137.L_CORE 0.002641
K_8352 X_NUC_63.L_CORE X_NUC_138.L_CORE 0.002836
K_8353 X_NUC_63.L_CORE X_NUC_139.L_CORE 0.001760
K_8354 X_NUC_63.L_CORE X_NUC_140.L_CORE 0.005310
K_8355 X_NUC_63.L_CORE X_NUC_141.L_CORE 0.001952
K_8356 X_NUC_63.L_CORE X_NUC_142.L_CORE 0.002087
K_8357 X_NUC_63.L_CORE X_NUC_143.L_CORE 0.005107
K_8358 X_NUC_63.L_CORE X_NUC_144.L_CORE 0.001655
K_8359 X_NUC_63.L_CORE X_NUC_145.L_CORE 0.003641
K_8360 X_NUC_63.L_CORE X_NUC_146.L_CORE 0.002403
K_8361 X_NUC_63.L_CORE X_NUC_147.L_CORE 0.001749
K_8362 X_NUC_63.L_CORE X_NUC_148.L_CORE 0.034606
K_8363 X_NUC_63.L_CORE X_NUC_149.L_CORE 0.001739
K_8364 X_NUC_63.L_CORE X_NUC_150.L_CORE 0.002401
K_8365 X_NUC_63.L_CORE X_NUC_151.L_CORE 0.003579
K_8366 X_NUC_63.L_CORE X_NUC_152.L_CORE 0.001632
K_8367 X_NUC_63.L_CORE X_NUC_153.L_CORE 0.005167
K_8368 X_NUC_63.L_CORE X_NUC_154.L_CORE 0.002036
K_8369 X_NUC_63.L_CORE X_NUC_155.L_CORE 0.001908
K_8370 X_NUC_63.L_CORE X_NUC_156.L_CORE 0.005419
K_8371 X_NUC_63.L_CORE X_NUC_157.L_CORE 0.001694
K_8372 X_NUC_63.L_CORE X_NUC_158.L_CORE 0.002795
K_8373 X_NUC_63.L_CORE X_NUC_159.L_CORE 0.002563
K_8374 X_NUC_63.L_CORE X_NUC_160.L_CORE 0.001771
K_8375 X_NUC_63.L_CORE X_NUC_161.L_CORE 0.003756
K_8376 X_NUC_63.L_CORE X_NUC_162.L_CORE 0.001939
K_8377 X_NUC_63.L_CORE X_NUC_163.L_CORE 0.002174
K_8378 X_NUC_63.L_CORE X_NUC_164.L_CORE 0.002675
K_8379 X_NUC_63.L_CORE X_NUC_165.L_CORE 0.002014
K_8380 X_NUC_64.L_CORE X_NUC_65.L_CORE 0.001849
K_8381 X_NUC_64.L_CORE X_NUC_66.L_CORE 0.001844
K_8382 X_NUC_64.L_CORE X_NUC_67.L_CORE 0.001854
K_8383 X_NUC_64.L_CORE X_NUC_68.L_CORE 0.001838
K_8384 X_NUC_64.L_CORE X_NUC_69.L_CORE 0.002548
K_8385 X_NUC_64.L_CORE X_NUC_70.L_CORE 0.002518
K_8386 X_NUC_64.L_CORE X_NUC_71.L_CORE 0.002532
K_8387 X_NUC_64.L_CORE X_NUC_72.L_CORE 0.002530
K_8388 X_NUC_64.L_CORE X_NUC_73.L_CORE 0.003833
K_8389 X_NUC_64.L_CORE X_NUC_74.L_CORE 0.003864
K_8390 X_NUC_64.L_CORE X_NUC_75.L_CORE 0.003870
K_8391 X_NUC_64.L_CORE X_NUC_76.L_CORE 0.003808
K_8392 X_NUC_64.L_CORE X_NUC_77.L_CORE 0.001733
K_8393 X_NUC_64.L_CORE X_NUC_78.L_CORE 0.001724
K_8394 X_NUC_64.L_CORE X_NUC_79.L_CORE 0.001733
K_8395 X_NUC_64.L_CORE X_NUC_80.L_CORE 0.001722
K_8396 X_NUC_64.L_CORE X_NUC_81.L_CORE 0.005536
K_8397 X_NUC_64.L_CORE X_NUC_82.L_CORE 0.005416
K_8398 X_NUC_64.L_CORE X_NUC_83.L_CORE 0.005407
K_8399 X_NUC_64.L_CORE X_NUC_84.L_CORE 0.005448
K_8400 X_NUC_64.L_CORE X_NUC_85.L_CORE 0.002168
K_8401 X_NUC_64.L_CORE X_NUC_86.L_CORE 0.002167
K_8402 X_NUC_64.L_CORE X_NUC_87.L_CORE 0.002175
K_8403 X_NUC_64.L_CORE X_NUC_88.L_CORE 0.002153
K_8404 X_NUC_64.L_CORE X_NUC_89.L_CORE 0.002027
K_8405 X_NUC_64.L_CORE X_NUC_90.L_CORE 0.002009
K_8406 X_NUC_64.L_CORE X_NUC_91.L_CORE 0.002018
K_8407 X_NUC_64.L_CORE X_NUC_92.L_CORE 0.002011
K_8408 X_NUC_64.L_CORE X_NUC_93.L_CORE 0.005875
K_8409 X_NUC_64.L_CORE X_NUC_94.L_CORE 0.005920
K_8410 X_NUC_64.L_CORE X_NUC_95.L_CORE 0.005844
K_8411 X_NUC_64.L_CORE X_NUC_96.L_CORE 0.005762
K_8412 X_NUC_64.L_CORE X_NUC_97.L_CORE 0.001800
K_8413 X_NUC_64.L_CORE X_NUC_98.L_CORE 0.001793
K_8414 X_NUC_64.L_CORE X_NUC_99.L_CORE 0.001800
K_8415 X_NUC_64.L_CORE X_NUC_100.L_CORE 0.001787
K_8416 X_NUC_64.L_CORE X_NUC_101.L_CORE 0.002974
K_8417 X_NUC_64.L_CORE X_NUC_102.L_CORE 0.002938
K_8418 X_NUC_64.L_CORE X_NUC_103.L_CORE 0.002942
K_8419 X_NUC_64.L_CORE X_NUC_104.L_CORE 0.002940
K_8420 X_NUC_64.L_CORE X_NUC_105.L_CORE 0.002735
K_8421 X_NUC_64.L_CORE X_NUC_106.L_CORE 0.002739
K_8422 X_NUC_64.L_CORE X_NUC_107.L_CORE 0.002739
K_8423 X_NUC_64.L_CORE X_NUC_108.L_CORE 0.002709
K_8424 X_NUC_64.L_CORE X_NUC_109.L_CORE 0.001882
K_8425 X_NUC_64.L_CORE X_NUC_110.L_CORE 0.001870
K_8426 X_NUC_64.L_CORE X_NUC_111.L_CORE 0.001876
K_8427 X_NUC_64.L_CORE X_NUC_112.L_CORE 0.001866
K_8428 X_NUC_64.L_CORE X_NUC_113.L_CORE 0.004026
K_8429 X_NUC_64.L_CORE X_NUC_114.L_CORE 0.003997
K_8430 X_NUC_64.L_CORE X_NUC_115.L_CORE 0.003969
K_8431 X_NUC_64.L_CORE X_NUC_116.L_CORE 0.003955
K_8432 X_NUC_64.L_CORE X_NUC_117.L_CORE 0.002064
K_8433 X_NUC_64.L_CORE X_NUC_118.L_CORE 0.002059
K_8434 X_NUC_64.L_CORE X_NUC_119.L_CORE 0.002063
K_8435 X_NUC_64.L_CORE X_NUC_120.L_CORE 0.002046
K_8436 X_NUC_64.L_CORE X_NUC_121.L_CORE 0.002314
K_8437 X_NUC_64.L_CORE X_NUC_122.L_CORE 0.002295
K_8438 X_NUC_64.L_CORE X_NUC_123.L_CORE 0.002298
K_8439 X_NUC_64.L_CORE X_NUC_124.L_CORE 0.002289
K_8440 X_NUC_64.L_CORE X_NUC_125.L_CORE 0.002857
K_8441 X_NUC_64.L_CORE X_NUC_126.L_CORE 0.002850
K_8442 X_NUC_64.L_CORE X_NUC_127.L_CORE 0.002843
K_8443 X_NUC_64.L_CORE X_NUC_128.L_CORE 0.002821
K_8444 X_NUC_64.L_CORE X_NUC_129.L_CORE 0.002144
K_8445 X_NUC_64.L_CORE X_NUC_130.L_CORE 0.002133
K_8446 X_NUC_64.L_CORE X_NUC_131.L_CORE 0.002135
K_8447 X_NUC_64.L_CORE X_NUC_132.L_CORE 0.002122
K_8448 X_NUC_64.L_CORE X_NUC_133.L_CORE 0.002333
K_8449 X_NUC_64.L_CORE X_NUC_134.L_CORE 0.002114
K_8450 X_NUC_64.L_CORE X_NUC_135.L_CORE 0.003477
K_8451 X_NUC_64.L_CORE X_NUC_136.L_CORE 0.001892
K_8452 X_NUC_64.L_CORE X_NUC_137.L_CORE 0.002645
K_8453 X_NUC_64.L_CORE X_NUC_138.L_CORE 0.002868
K_8454 X_NUC_64.L_CORE X_NUC_139.L_CORE 0.001769
K_8455 X_NUC_64.L_CORE X_NUC_140.L_CORE 0.005291
K_8456 X_NUC_64.L_CORE X_NUC_141.L_CORE 0.001970
K_8457 X_NUC_64.L_CORE X_NUC_142.L_CORE 0.002092
K_8458 X_NUC_64.L_CORE X_NUC_143.L_CORE 0.005192
K_8459 X_NUC_64.L_CORE X_NUC_144.L_CORE 0.001666
K_8460 X_NUC_64.L_CORE X_NUC_145.L_CORE 0.003625
K_8461 X_NUC_64.L_CORE X_NUC_146.L_CORE 0.002431
K_8462 X_NUC_64.L_CORE X_NUC_147.L_CORE 0.001756
K_8463 X_NUC_64.L_CORE X_NUC_148.L_CORE 0.030604
K_8464 X_NUC_64.L_CORE X_NUC_149.L_CORE 0.001753
K_8465 X_NUC_64.L_CORE X_NUC_150.L_CORE 0.002401
K_8466 X_NUC_64.L_CORE X_NUC_151.L_CORE 0.003631
K_8467 X_NUC_64.L_CORE X_NUC_152.L_CORE 0.001642
K_8468 X_NUC_64.L_CORE X_NUC_153.L_CORE 0.005114
K_8469 X_NUC_64.L_CORE X_NUC_154.L_CORE 0.002056
K_8470 X_NUC_64.L_CORE X_NUC_155.L_CORE 0.001914
K_8471 X_NUC_64.L_CORE X_NUC_156.L_CORE 0.005477
K_8472 X_NUC_64.L_CORE X_NUC_157.L_CORE 0.001705
K_8473 X_NUC_64.L_CORE X_NUC_158.L_CORE 0.002794
K_8474 X_NUC_64.L_CORE X_NUC_159.L_CORE 0.002589
K_8475 X_NUC_64.L_CORE X_NUC_160.L_CORE 0.001779
K_8476 X_NUC_64.L_CORE X_NUC_161.L_CORE 0.003764
K_8477 X_NUC_64.L_CORE X_NUC_162.L_CORE 0.001954
K_8478 X_NUC_64.L_CORE X_NUC_163.L_CORE 0.002182
K_8479 X_NUC_64.L_CORE X_NUC_164.L_CORE 0.002694
K_8480 X_NUC_64.L_CORE X_NUC_165.L_CORE 0.002026
K_8481 X_NUC_65.L_CORE X_NUC_66.L_CORE 0.207973
K_8482 X_NUC_65.L_CORE X_NUC_67.L_CORE 0.207973
K_8483 X_NUC_65.L_CORE X_NUC_68.L_CORE 0.207973
K_8484 X_NUC_65.L_CORE X_NUC_69.L_CORE 0.001838
K_8485 X_NUC_65.L_CORE X_NUC_70.L_CORE 0.001831
K_8486 X_NUC_65.L_CORE X_NUC_71.L_CORE 0.001827
K_8487 X_NUC_65.L_CORE X_NUC_72.L_CORE 0.001841
K_8488 X_NUC_65.L_CORE X_NUC_73.L_CORE 0.002534
K_8489 X_NUC_65.L_CORE X_NUC_74.L_CORE 0.002555
K_8490 X_NUC_65.L_CORE X_NUC_75.L_CORE 0.002531
K_8491 X_NUC_65.L_CORE X_NUC_76.L_CORE 0.002554
K_8492 X_NUC_65.L_CORE X_NUC_77.L_CORE 0.003821
K_8493 X_NUC_65.L_CORE X_NUC_78.L_CORE 0.003758
K_8494 X_NUC_65.L_CORE X_NUC_79.L_CORE 0.003767
K_8495 X_NUC_65.L_CORE X_NUC_80.L_CORE 0.003792
K_8496 X_NUC_65.L_CORE X_NUC_81.L_CORE 0.001732
K_8497 X_NUC_65.L_CORE X_NUC_82.L_CORE 0.001732
K_8498 X_NUC_65.L_CORE X_NUC_83.L_CORE 0.001724
K_8499 X_NUC_65.L_CORE X_NUC_84.L_CORE 0.001738
K_8500 X_NUC_65.L_CORE X_NUC_85.L_CORE 0.005471
K_8501 X_NUC_65.L_CORE X_NUC_86.L_CORE 0.005586
K_8502 X_NUC_65.L_CORE X_NUC_87.L_CORE 0.005450
K_8503 X_NUC_65.L_CORE X_NUC_88.L_CORE 0.005505
K_8504 X_NUC_65.L_CORE X_NUC_89.L_CORE 0.002173
K_8505 X_NUC_65.L_CORE X_NUC_90.L_CORE 0.002159
K_8506 X_NUC_65.L_CORE X_NUC_91.L_CORE 0.002154
K_8507 X_NUC_65.L_CORE X_NUC_92.L_CORE 0.002171
K_8508 X_NUC_65.L_CORE X_NUC_93.L_CORE 0.002034
K_8509 X_NUC_65.L_CORE X_NUC_94.L_CORE 0.002042
K_8510 X_NUC_65.L_CORE X_NUC_95.L_CORE 0.002026
K_8511 X_NUC_65.L_CORE X_NUC_96.L_CORE 0.002043
K_8512 X_NUC_65.L_CORE X_NUC_97.L_CORE 0.005733
K_8513 X_NUC_65.L_CORE X_NUC_98.L_CORE 0.005649
K_8514 X_NUC_65.L_CORE X_NUC_99.L_CORE 0.005584
K_8515 X_NUC_65.L_CORE X_NUC_100.L_CORE 0.005622
K_8516 X_NUC_65.L_CORE X_NUC_101.L_CORE 0.001818
K_8517 X_NUC_65.L_CORE X_NUC_102.L_CORE 0.001814
K_8518 X_NUC_65.L_CORE X_NUC_103.L_CORE 0.001805
K_8519 X_NUC_65.L_CORE X_NUC_104.L_CORE 0.001820
K_8520 X_NUC_65.L_CORE X_NUC_105.L_CORE 0.002975
K_8521 X_NUC_65.L_CORE X_NUC_106.L_CORE 0.002999
K_8522 X_NUC_65.L_CORE X_NUC_107.L_CORE 0.002957
K_8523 X_NUC_65.L_CORE X_NUC_108.L_CORE 0.002984
K_8524 X_NUC_65.L_CORE X_NUC_109.L_CORE 0.002748
K_8525 X_NUC_65.L_CORE X_NUC_110.L_CORE 0.002725
K_8526 X_NUC_65.L_CORE X_NUC_111.L_CORE 0.002713
K_8527 X_NUC_65.L_CORE X_NUC_112.L_CORE 0.002733
K_8528 X_NUC_65.L_CORE X_NUC_113.L_CORE 0.001918
K_8529 X_NUC_65.L_CORE X_NUC_114.L_CORE 0.001920
K_8530 X_NUC_65.L_CORE X_NUC_115.L_CORE 0.001906
K_8531 X_NUC_65.L_CORE X_NUC_116.L_CORE 0.001922
K_8532 X_NUC_65.L_CORE X_NUC_117.L_CORE 0.003836
K_8533 X_NUC_65.L_CORE X_NUC_118.L_CORE 0.003843
K_8534 X_NUC_65.L_CORE X_NUC_119.L_CORE 0.003780
K_8535 X_NUC_65.L_CORE X_NUC_120.L_CORE 0.003812
K_8536 X_NUC_65.L_CORE X_NUC_121.L_CORE 0.002121
K_8537 X_NUC_65.L_CORE X_NUC_122.L_CORE 0.002113
K_8538 X_NUC_65.L_CORE X_NUC_123.L_CORE 0.002101
K_8539 X_NUC_65.L_CORE X_NUC_124.L_CORE 0.002117
K_8540 X_NUC_65.L_CORE X_NUC_125.L_CORE 0.002359
K_8541 X_NUC_65.L_CORE X_NUC_126.L_CORE 0.002365
K_8542 X_NUC_65.L_CORE X_NUC_127.L_CORE 0.002341
K_8543 X_NUC_65.L_CORE X_NUC_128.L_CORE 0.002360
K_8544 X_NUC_65.L_CORE X_NUC_129.L_CORE 0.002686
K_8545 X_NUC_65.L_CORE X_NUC_130.L_CORE 0.002679
K_8546 X_NUC_65.L_CORE X_NUC_131.L_CORE 0.002653
K_8547 X_NUC_65.L_CORE X_NUC_132.L_CORE 0.002675
K_8548 X_NUC_65.L_CORE X_NUC_133.L_CORE 0.002557
K_8549 X_NUC_65.L_CORE X_NUC_134.L_CORE 0.002241
K_8550 X_NUC_65.L_CORE X_NUC_135.L_CORE 0.002019
K_8551 X_NUC_65.L_CORE X_NUC_136.L_CORE 0.003642
K_8552 X_NUC_65.L_CORE X_NUC_137.L_CORE 0.001822
K_8553 X_NUC_65.L_CORE X_NUC_138.L_CORE 0.002621
K_8554 X_NUC_65.L_CORE X_NUC_139.L_CORE 0.002813
K_8555 X_NUC_65.L_CORE X_NUC_140.L_CORE 0.001729
K_8556 X_NUC_65.L_CORE X_NUC_141.L_CORE 0.005457
K_8557 X_NUC_65.L_CORE X_NUC_142.L_CORE 0.001928
K_8558 X_NUC_65.L_CORE X_NUC_143.L_CORE 0.002071
K_8559 X_NUC_65.L_CORE X_NUC_144.L_CORE 0.005108
K_8560 X_NUC_65.L_CORE X_NUC_145.L_CORE 0.001645
K_8561 X_NUC_65.L_CORE X_NUC_146.L_CORE 0.003645
K_8562 X_NUC_65.L_CORE X_NUC_147.L_CORE 0.002394
K_8563 X_NUC_65.L_CORE X_NUC_148.L_CORE 0.001749
K_8564 X_NUC_65.L_CORE X_NUC_149.L_CORE 0.032747
K_8565 X_NUC_65.L_CORE X_NUC_150.L_CORE 0.001743
K_8566 X_NUC_65.L_CORE X_NUC_151.L_CORE 0.002413
K_8567 X_NUC_65.L_CORE X_NUC_152.L_CORE 0.003579
K_8568 X_NUC_65.L_CORE X_NUC_153.L_CORE 0.001645
K_8569 X_NUC_65.L_CORE X_NUC_154.L_CORE 0.005171
K_8570 X_NUC_65.L_CORE X_NUC_155.L_CORE 0.002055
K_8571 X_NUC_65.L_CORE X_NUC_156.L_CORE 0.001934
K_8572 X_NUC_65.L_CORE X_NUC_157.L_CORE 0.005302
K_8573 X_NUC_65.L_CORE X_NUC_158.L_CORE 0.001724
K_8574 X_NUC_65.L_CORE X_NUC_159.L_CORE 0.002824
K_8575 X_NUC_65.L_CORE X_NUC_160.L_CORE 0.002589
K_8576 X_NUC_65.L_CORE X_NUC_161.L_CORE 0.001821
K_8577 X_NUC_65.L_CORE X_NUC_162.L_CORE 0.003610
K_8578 X_NUC_65.L_CORE X_NUC_163.L_CORE 0.002006
K_8579 X_NUC_65.L_CORE X_NUC_164.L_CORE 0.002237
K_8580 X_NUC_65.L_CORE X_NUC_165.L_CORE 0.002536
K_8581 X_NUC_66.L_CORE X_NUC_67.L_CORE 0.207973
K_8582 X_NUC_66.L_CORE X_NUC_68.L_CORE 0.207973
K_8583 X_NUC_66.L_CORE X_NUC_69.L_CORE 0.001845
K_8584 X_NUC_66.L_CORE X_NUC_70.L_CORE 0.001838
K_8585 X_NUC_66.L_CORE X_NUC_71.L_CORE 0.001834
K_8586 X_NUC_66.L_CORE X_NUC_72.L_CORE 0.001849
K_8587 X_NUC_66.L_CORE X_NUC_73.L_CORE 0.002514
K_8588 X_NUC_66.L_CORE X_NUC_74.L_CORE 0.002534
K_8589 X_NUC_66.L_CORE X_NUC_75.L_CORE 0.002511
K_8590 X_NUC_66.L_CORE X_NUC_76.L_CORE 0.002533
K_8591 X_NUC_66.L_CORE X_NUC_77.L_CORE 0.003886
K_8592 X_NUC_66.L_CORE X_NUC_78.L_CORE 0.003821
K_8593 X_NUC_66.L_CORE X_NUC_79.L_CORE 0.003829
K_8594 X_NUC_66.L_CORE X_NUC_80.L_CORE 0.003856
K_8595 X_NUC_66.L_CORE X_NUC_81.L_CORE 0.001732
K_8596 X_NUC_66.L_CORE X_NUC_82.L_CORE 0.001732
K_8597 X_NUC_66.L_CORE X_NUC_83.L_CORE 0.001724
K_8598 X_NUC_66.L_CORE X_NUC_84.L_CORE 0.001738
K_8599 X_NUC_66.L_CORE X_NUC_85.L_CORE 0.005360
K_8600 X_NUC_66.L_CORE X_NUC_86.L_CORE 0.005471
K_8601 X_NUC_66.L_CORE X_NUC_87.L_CORE 0.005341
K_8602 X_NUC_66.L_CORE X_NUC_88.L_CORE 0.005393
K_8603 X_NUC_66.L_CORE X_NUC_89.L_CORE 0.002188
K_8604 X_NUC_66.L_CORE X_NUC_90.L_CORE 0.002173
K_8605 X_NUC_66.L_CORE X_NUC_91.L_CORE 0.002168
K_8606 X_NUC_66.L_CORE X_NUC_92.L_CORE 0.002185
K_8607 X_NUC_66.L_CORE X_NUC_93.L_CORE 0.002026
K_8608 X_NUC_66.L_CORE X_NUC_94.L_CORE 0.002034
K_8609 X_NUC_66.L_CORE X_NUC_95.L_CORE 0.002018
K_8610 X_NUC_66.L_CORE X_NUC_96.L_CORE 0.002035
K_8611 X_NUC_66.L_CORE X_NUC_97.L_CORE 0.005815
K_8612 X_NUC_66.L_CORE X_NUC_98.L_CORE 0.005733
K_8613 X_NUC_66.L_CORE X_NUC_99.L_CORE 0.005662
K_8614 X_NUC_66.L_CORE X_NUC_100.L_CORE 0.005702
K_8615 X_NUC_66.L_CORE X_NUC_101.L_CORE 0.001822
K_8616 X_NUC_66.L_CORE X_NUC_102.L_CORE 0.001818
K_8617 X_NUC_66.L_CORE X_NUC_103.L_CORE 0.001809
K_8618 X_NUC_66.L_CORE X_NUC_104.L_CORE 0.001824
K_8619 X_NUC_66.L_CORE X_NUC_105.L_CORE 0.002950
K_8620 X_NUC_66.L_CORE X_NUC_106.L_CORE 0.002975
K_8621 X_NUC_66.L_CORE X_NUC_107.L_CORE 0.002934
K_8622 X_NUC_66.L_CORE X_NUC_108.L_CORE 0.002960
K_8623 X_NUC_66.L_CORE X_NUC_109.L_CORE 0.002770
K_8624 X_NUC_66.L_CORE X_NUC_110.L_CORE 0.002748
K_8625 X_NUC_66.L_CORE X_NUC_111.L_CORE 0.002735
K_8626 X_NUC_66.L_CORE X_NUC_112.L_CORE 0.002755
K_8627 X_NUC_66.L_CORE X_NUC_113.L_CORE 0.001916
K_8628 X_NUC_66.L_CORE X_NUC_114.L_CORE 0.001918
K_8629 X_NUC_66.L_CORE X_NUC_115.L_CORE 0.001904
K_8630 X_NUC_66.L_CORE X_NUC_116.L_CORE 0.001920
K_8631 X_NUC_66.L_CORE X_NUC_117.L_CORE 0.003828
K_8632 X_NUC_66.L_CORE X_NUC_118.L_CORE 0.003836
K_8633 X_NUC_66.L_CORE X_NUC_119.L_CORE 0.003773
K_8634 X_NUC_66.L_CORE X_NUC_120.L_CORE 0.003804
K_8635 X_NUC_66.L_CORE X_NUC_121.L_CORE 0.002128
K_8636 X_NUC_66.L_CORE X_NUC_122.L_CORE 0.002121
K_8637 X_NUC_66.L_CORE X_NUC_123.L_CORE 0.002108
K_8638 X_NUC_66.L_CORE X_NUC_124.L_CORE 0.002124
K_8639 X_NUC_66.L_CORE X_NUC_125.L_CORE 0.002353
K_8640 X_NUC_66.L_CORE X_NUC_126.L_CORE 0.002359
K_8641 X_NUC_66.L_CORE X_NUC_127.L_CORE 0.002335
K_8642 X_NUC_66.L_CORE X_NUC_128.L_CORE 0.002355
K_8643 X_NUC_66.L_CORE X_NUC_129.L_CORE 0.002692
K_8644 X_NUC_66.L_CORE X_NUC_130.L_CORE 0.002686
K_8645 X_NUC_66.L_CORE X_NUC_131.L_CORE 0.002659
K_8646 X_NUC_66.L_CORE X_NUC_132.L_CORE 0.002681
K_8647 X_NUC_66.L_CORE X_NUC_133.L_CORE 0.002555
K_8648 X_NUC_66.L_CORE X_NUC_134.L_CORE 0.002249
K_8649 X_NUC_66.L_CORE X_NUC_135.L_CORE 0.002015
K_8650 X_NUC_66.L_CORE X_NUC_136.L_CORE 0.003654
K_8651 X_NUC_66.L_CORE X_NUC_137.L_CORE 0.001827
K_8652 X_NUC_66.L_CORE X_NUC_138.L_CORE 0.002603
K_8653 X_NUC_66.L_CORE X_NUC_139.L_CORE 0.002840
K_8654 X_NUC_66.L_CORE X_NUC_140.L_CORE 0.001728
K_8655 X_NUC_66.L_CORE X_NUC_141.L_CORE 0.005385
K_8656 X_NUC_66.L_CORE X_NUC_142.L_CORE 0.001939
K_8657 X_NUC_66.L_CORE X_NUC_143.L_CORE 0.002060
K_8658 X_NUC_66.L_CORE X_NUC_144.L_CORE 0.005219
K_8659 X_NUC_66.L_CORE X_NUC_145.L_CORE 0.001647
K_8660 X_NUC_66.L_CORE X_NUC_146.L_CORE 0.003590
K_8661 X_NUC_66.L_CORE X_NUC_147.L_CORE 0.002417
K_8662 X_NUC_66.L_CORE X_NUC_148.L_CORE 0.001744
K_8663 X_NUC_66.L_CORE X_NUC_149.L_CORE 0.032316
K_8664 X_NUC_66.L_CORE X_NUC_150.L_CORE 0.001749
K_8665 X_NUC_66.L_CORE X_NUC_151.L_CORE 0.002394
K_8666 X_NUC_66.L_CORE X_NUC_152.L_CORE 0.003638
K_8667 X_NUC_66.L_CORE X_NUC_153.L_CORE 0.001645
K_8668 X_NUC_66.L_CORE X_NUC_154.L_CORE 0.005066
K_8669 X_NUC_66.L_CORE X_NUC_155.L_CORE 0.002068
K_8670 X_NUC_66.L_CORE X_NUC_156.L_CORE 0.001926
K_8671 X_NUC_66.L_CORE X_NUC_157.L_CORE 0.005374
K_8672 X_NUC_66.L_CORE X_NUC_158.L_CORE 0.001727
K_8673 X_NUC_66.L_CORE X_NUC_159.L_CORE 0.002800
K_8674 X_NUC_66.L_CORE X_NUC_160.L_CORE 0.002610
K_8675 X_NUC_66.L_CORE X_NUC_161.L_CORE 0.001819
K_8676 X_NUC_66.L_CORE X_NUC_162.L_CORE 0.003603
K_8677 X_NUC_66.L_CORE X_NUC_163.L_CORE 0.002013
K_8678 X_NUC_66.L_CORE X_NUC_164.L_CORE 0.002231
K_8679 X_NUC_66.L_CORE X_NUC_165.L_CORE 0.002541
K_8680 X_NUC_67.L_CORE X_NUC_68.L_CORE 0.207973
K_8681 X_NUC_67.L_CORE X_NUC_69.L_CORE 0.001849
K_8682 X_NUC_67.L_CORE X_NUC_70.L_CORE 0.001842
K_8683 X_NUC_67.L_CORE X_NUC_71.L_CORE 0.001838
K_8684 X_NUC_67.L_CORE X_NUC_72.L_CORE 0.001853
K_8685 X_NUC_67.L_CORE X_NUC_73.L_CORE 0.002537
K_8686 X_NUC_67.L_CORE X_NUC_74.L_CORE 0.002558
K_8687 X_NUC_67.L_CORE X_NUC_75.L_CORE 0.002534
K_8688 X_NUC_67.L_CORE X_NUC_76.L_CORE 0.002557
K_8689 X_NUC_67.L_CORE X_NUC_77.L_CORE 0.003877
K_8690 X_NUC_67.L_CORE X_NUC_78.L_CORE 0.003812
K_8691 X_NUC_67.L_CORE X_NUC_79.L_CORE 0.003821
K_8692 X_NUC_67.L_CORE X_NUC_80.L_CORE 0.003847
K_8693 X_NUC_67.L_CORE X_NUC_81.L_CORE 0.001740
K_8694 X_NUC_67.L_CORE X_NUC_82.L_CORE 0.001740
K_8695 X_NUC_67.L_CORE X_NUC_83.L_CORE 0.001732
K_8696 X_NUC_67.L_CORE X_NUC_84.L_CORE 0.001746
K_8697 X_NUC_67.L_CORE X_NUC_85.L_CORE 0.005490
K_8698 X_NUC_67.L_CORE X_NUC_86.L_CORE 0.005608
K_8699 X_NUC_67.L_CORE X_NUC_87.L_CORE 0.005471
K_8700 X_NUC_67.L_CORE X_NUC_88.L_CORE 0.005525
K_8701 X_NUC_67.L_CORE X_NUC_89.L_CORE 0.002193
K_8702 X_NUC_67.L_CORE X_NUC_90.L_CORE 0.002178
K_8703 X_NUC_67.L_CORE X_NUC_91.L_CORE 0.002173
K_8704 X_NUC_67.L_CORE X_NUC_92.L_CORE 0.002190
K_8705 X_NUC_67.L_CORE X_NUC_93.L_CORE 0.002042
K_8706 X_NUC_67.L_CORE X_NUC_94.L_CORE 0.002051
K_8707 X_NUC_67.L_CORE X_NUC_95.L_CORE 0.002034
K_8708 X_NUC_67.L_CORE X_NUC_96.L_CORE 0.002052
K_8709 X_NUC_67.L_CORE X_NUC_97.L_CORE 0.005889
K_8710 X_NUC_67.L_CORE X_NUC_98.L_CORE 0.005801
K_8711 X_NUC_67.L_CORE X_NUC_99.L_CORE 0.005733
K_8712 X_NUC_67.L_CORE X_NUC_100.L_CORE 0.005771
K_8713 X_NUC_67.L_CORE X_NUC_101.L_CORE 0.001831
K_8714 X_NUC_67.L_CORE X_NUC_102.L_CORE 0.001827
K_8715 X_NUC_67.L_CORE X_NUC_103.L_CORE 0.001818
K_8716 X_NUC_67.L_CORE X_NUC_104.L_CORE 0.001833
K_8717 X_NUC_67.L_CORE X_NUC_105.L_CORE 0.002991
K_8718 X_NUC_67.L_CORE X_NUC_106.L_CORE 0.003017
K_8719 X_NUC_67.L_CORE X_NUC_107.L_CORE 0.002975
K_8720 X_NUC_67.L_CORE X_NUC_108.L_CORE 0.003001
K_8721 X_NUC_67.L_CORE X_NUC_109.L_CORE 0.002783
K_8722 X_NUC_67.L_CORE X_NUC_110.L_CORE 0.002760
K_8723 X_NUC_67.L_CORE X_NUC_111.L_CORE 0.002748
K_8724 X_NUC_67.L_CORE X_NUC_112.L_CORE 0.002768
K_8725 X_NUC_67.L_CORE X_NUC_113.L_CORE 0.001930
K_8726 X_NUC_67.L_CORE X_NUC_114.L_CORE 0.001933
K_8727 X_NUC_67.L_CORE X_NUC_115.L_CORE 0.001918
K_8728 X_NUC_67.L_CORE X_NUC_116.L_CORE 0.001934
K_8729 X_NUC_67.L_CORE X_NUC_117.L_CORE 0.003893
K_8730 X_NUC_67.L_CORE X_NUC_118.L_CORE 0.003901
K_8731 X_NUC_67.L_CORE X_NUC_119.L_CORE 0.003836
K_8732 X_NUC_67.L_CORE X_NUC_120.L_CORE 0.003868
K_8733 X_NUC_67.L_CORE X_NUC_121.L_CORE 0.002141
K_8734 X_NUC_67.L_CORE X_NUC_122.L_CORE 0.002133
K_8735 X_NUC_67.L_CORE X_NUC_123.L_CORE 0.002121
K_8736 X_NUC_67.L_CORE X_NUC_124.L_CORE 0.002138
K_8737 X_NUC_67.L_CORE X_NUC_125.L_CORE 0.002378
K_8738 X_NUC_67.L_CORE X_NUC_126.L_CORE 0.002385
K_8739 X_NUC_67.L_CORE X_NUC_127.L_CORE 0.002359
K_8740 X_NUC_67.L_CORE X_NUC_128.L_CORE 0.002380
K_8741 X_NUC_67.L_CORE X_NUC_129.L_CORE 0.002719
K_8742 X_NUC_67.L_CORE X_NUC_130.L_CORE 0.002712
K_8743 X_NUC_67.L_CORE X_NUC_131.L_CORE 0.002686
K_8744 X_NUC_67.L_CORE X_NUC_132.L_CORE 0.002707
K_8745 X_NUC_67.L_CORE X_NUC_133.L_CORE 0.002548
K_8746 X_NUC_67.L_CORE X_NUC_134.L_CORE 0.002242
K_8747 X_NUC_67.L_CORE X_NUC_135.L_CORE 0.002018
K_8748 X_NUC_67.L_CORE X_NUC_136.L_CORE 0.003617
K_8749 X_NUC_67.L_CORE X_NUC_137.L_CORE 0.001827
K_8750 X_NUC_67.L_CORE X_NUC_138.L_CORE 0.002609
K_8751 X_NUC_67.L_CORE X_NUC_139.L_CORE 0.002821
K_8752 X_NUC_67.L_CORE X_NUC_140.L_CORE 0.001732
K_8753 X_NUC_67.L_CORE X_NUC_141.L_CORE 0.005351
K_8754 X_NUC_67.L_CORE X_NUC_142.L_CORE 0.001937
K_8755 X_NUC_67.L_CORE X_NUC_143.L_CORE 0.002070
K_8756 X_NUC_67.L_CORE X_NUC_144.L_CORE 0.005124
K_8757 X_NUC_67.L_CORE X_NUC_145.L_CORE 0.001651
K_8758 X_NUC_67.L_CORE X_NUC_146.L_CORE 0.003622
K_8759 X_NUC_67.L_CORE X_NUC_147.L_CORE 0.002411
K_8760 X_NUC_67.L_CORE X_NUC_148.L_CORE 0.001753
K_8761 X_NUC_67.L_CORE X_NUC_149.L_CORE 0.030266
K_8762 X_NUC_67.L_CORE X_NUC_150.L_CORE 0.001753
K_8763 X_NUC_67.L_CORE X_NUC_151.L_CORE 0.002415
K_8764 X_NUC_67.L_CORE X_NUC_152.L_CORE 0.003626
K_8765 X_NUC_67.L_CORE X_NUC_153.L_CORE 0.001653
K_8766 X_NUC_67.L_CORE X_NUC_154.L_CORE 0.005178
K_8767 X_NUC_67.L_CORE X_NUC_155.L_CORE 0.002073
K_8768 X_NUC_67.L_CORE X_NUC_156.L_CORE 0.001941
K_8769 X_NUC_67.L_CORE X_NUC_157.L_CORE 0.005428
K_8770 X_NUC_67.L_CORE X_NUC_158.L_CORE 0.001735
K_8771 X_NUC_67.L_CORE X_NUC_159.L_CORE 0.002838
K_8772 X_NUC_67.L_CORE X_NUC_160.L_CORE 0.002621
K_8773 X_NUC_67.L_CORE X_NUC_161.L_CORE 0.001832
K_8774 X_NUC_67.L_CORE X_NUC_162.L_CORE 0.003660
K_8775 X_NUC_67.L_CORE X_NUC_163.L_CORE 0.002025
K_8776 X_NUC_67.L_CORE X_NUC_164.L_CORE 0.002254
K_8777 X_NUC_67.L_CORE X_NUC_165.L_CORE 0.002565
K_8778 X_NUC_68.L_CORE X_NUC_69.L_CORE 0.001835
K_8779 X_NUC_68.L_CORE X_NUC_70.L_CORE 0.001828
K_8780 X_NUC_68.L_CORE X_NUC_71.L_CORE 0.001824
K_8781 X_NUC_68.L_CORE X_NUC_72.L_CORE 0.001838
K_8782 X_NUC_68.L_CORE X_NUC_73.L_CORE 0.002515
K_8783 X_NUC_68.L_CORE X_NUC_74.L_CORE 0.002535
K_8784 X_NUC_68.L_CORE X_NUC_75.L_CORE 0.002512
K_8785 X_NUC_68.L_CORE X_NUC_76.L_CORE 0.002534
K_8786 X_NUC_68.L_CORE X_NUC_77.L_CORE 0.003850
K_8787 X_NUC_68.L_CORE X_NUC_78.L_CORE 0.003786
K_8788 X_NUC_68.L_CORE X_NUC_79.L_CORE 0.003795
K_8789 X_NUC_68.L_CORE X_NUC_80.L_CORE 0.003821
K_8790 X_NUC_68.L_CORE X_NUC_81.L_CORE 0.001726
K_8791 X_NUC_68.L_CORE X_NUC_82.L_CORE 0.001726
K_8792 X_NUC_68.L_CORE X_NUC_83.L_CORE 0.001718
K_8793 X_NUC_68.L_CORE X_NUC_84.L_CORE 0.001732
K_8794 X_NUC_68.L_CORE X_NUC_85.L_CORE 0.005435
K_8795 X_NUC_68.L_CORE X_NUC_86.L_CORE 0.005550
K_8796 X_NUC_68.L_CORE X_NUC_87.L_CORE 0.005416
K_8797 X_NUC_68.L_CORE X_NUC_88.L_CORE 0.005471
K_8798 X_NUC_68.L_CORE X_NUC_89.L_CORE 0.002176
K_8799 X_NUC_68.L_CORE X_NUC_90.L_CORE 0.002161
K_8800 X_NUC_68.L_CORE X_NUC_91.L_CORE 0.002157
K_8801 X_NUC_68.L_CORE X_NUC_92.L_CORE 0.002173
K_8802 X_NUC_68.L_CORE X_NUC_93.L_CORE 0.002025
K_8803 X_NUC_68.L_CORE X_NUC_94.L_CORE 0.002033
K_8804 X_NUC_68.L_CORE X_NUC_95.L_CORE 0.002017
K_8805 X_NUC_68.L_CORE X_NUC_96.L_CORE 0.002034
K_8806 X_NUC_68.L_CORE X_NUC_97.L_CORE 0.005846
K_8807 X_NUC_68.L_CORE X_NUC_98.L_CORE 0.005760
K_8808 X_NUC_68.L_CORE X_NUC_99.L_CORE 0.005691
K_8809 X_NUC_68.L_CORE X_NUC_100.L_CORE 0.005733
K_8810 X_NUC_68.L_CORE X_NUC_101.L_CORE 0.001816
K_8811 X_NUC_68.L_CORE X_NUC_102.L_CORE 0.001812
K_8812 X_NUC_68.L_CORE X_NUC_103.L_CORE 0.001803
K_8813 X_NUC_68.L_CORE X_NUC_104.L_CORE 0.001818
K_8814 X_NUC_68.L_CORE X_NUC_105.L_CORE 0.002965
K_8815 X_NUC_68.L_CORE X_NUC_106.L_CORE 0.002989
K_8816 X_NUC_68.L_CORE X_NUC_107.L_CORE 0.002948
K_8817 X_NUC_68.L_CORE X_NUC_108.L_CORE 0.002975
K_8818 X_NUC_68.L_CORE X_NUC_109.L_CORE 0.002762
K_8819 X_NUC_68.L_CORE X_NUC_110.L_CORE 0.002739
K_8820 X_NUC_68.L_CORE X_NUC_111.L_CORE 0.002727
K_8821 X_NUC_68.L_CORE X_NUC_112.L_CORE 0.002748
K_8822 X_NUC_68.L_CORE X_NUC_113.L_CORE 0.001914
K_8823 X_NUC_68.L_CORE X_NUC_114.L_CORE 0.001916
K_8824 X_NUC_68.L_CORE X_NUC_115.L_CORE 0.001902
K_8825 X_NUC_68.L_CORE X_NUC_116.L_CORE 0.001918
K_8826 X_NUC_68.L_CORE X_NUC_117.L_CORE 0.003860
K_8827 X_NUC_68.L_CORE X_NUC_118.L_CORE 0.003868
K_8828 X_NUC_68.L_CORE X_NUC_119.L_CORE 0.003804
K_8829 X_NUC_68.L_CORE X_NUC_120.L_CORE 0.003836
K_8830 X_NUC_68.L_CORE X_NUC_121.L_CORE 0.002124
K_8831 X_NUC_68.L_CORE X_NUC_122.L_CORE 0.002116
K_8832 X_NUC_68.L_CORE X_NUC_123.L_CORE 0.002104
K_8833 X_NUC_68.L_CORE X_NUC_124.L_CORE 0.002121
K_8834 X_NUC_68.L_CORE X_NUC_125.L_CORE 0.002358
K_8835 X_NUC_68.L_CORE X_NUC_126.L_CORE 0.002364
K_8836 X_NUC_68.L_CORE X_NUC_127.L_CORE 0.002340
K_8837 X_NUC_68.L_CORE X_NUC_128.L_CORE 0.002359
K_8838 X_NUC_68.L_CORE X_NUC_129.L_CORE 0.002696
K_8839 X_NUC_68.L_CORE X_NUC_130.L_CORE 0.002690
K_8840 X_NUC_68.L_CORE X_NUC_131.L_CORE 0.002664
K_8841 X_NUC_68.L_CORE X_NUC_132.L_CORE 0.002686
K_8842 X_NUC_68.L_CORE X_NUC_133.L_CORE 0.002529
K_8843 X_NUC_68.L_CORE X_NUC_134.L_CORE 0.002226
K_8844 X_NUC_68.L_CORE X_NUC_135.L_CORE 0.002002
K_8845 X_NUC_68.L_CORE X_NUC_136.L_CORE 0.003596
K_8846 X_NUC_68.L_CORE X_NUC_137.L_CORE 0.001813
K_8847 X_NUC_68.L_CORE X_NUC_138.L_CORE 0.002589
K_8848 X_NUC_68.L_CORE X_NUC_139.L_CORE 0.002803
K_8849 X_NUC_68.L_CORE X_NUC_140.L_CORE 0.001719
K_8850 X_NUC_68.L_CORE X_NUC_141.L_CORE 0.005325
K_8851 X_NUC_68.L_CORE X_NUC_142.L_CORE 0.001923
K_8852 X_NUC_68.L_CORE X_NUC_143.L_CORE 0.002053
K_8853 X_NUC_68.L_CORE X_NUC_144.L_CORE 0.005112
K_8854 X_NUC_68.L_CORE X_NUC_145.L_CORE 0.001639
K_8855 X_NUC_68.L_CORE X_NUC_146.L_CORE 0.003595
K_8856 X_NUC_68.L_CORE X_NUC_147.L_CORE 0.002396
K_8857 X_NUC_68.L_CORE X_NUC_148.L_CORE 0.001739
K_8858 X_NUC_68.L_CORE X_NUC_149.L_CORE 0.035390
K_8859 X_NUC_68.L_CORE X_NUC_150.L_CORE 0.001740
K_8860 X_NUC_68.L_CORE X_NUC_151.L_CORE 0.002396
K_8861 X_NUC_68.L_CORE X_NUC_152.L_CORE 0.003609
K_8862 X_NUC_68.L_CORE X_NUC_153.L_CORE 0.001640
K_8863 X_NUC_68.L_CORE X_NUC_154.L_CORE 0.005147
K_8864 X_NUC_68.L_CORE X_NUC_155.L_CORE 0.002058
K_8865 X_NUC_68.L_CORE X_NUC_156.L_CORE 0.001926
K_8866 X_NUC_68.L_CORE X_NUC_157.L_CORE 0.005414
K_8867 X_NUC_68.L_CORE X_NUC_158.L_CORE 0.001722
K_8868 X_NUC_68.L_CORE X_NUC_159.L_CORE 0.002816
K_8869 X_NUC_68.L_CORE X_NUC_160.L_CORE 0.002604
K_8870 X_NUC_68.L_CORE X_NUC_161.L_CORE 0.001817
K_8871 X_NUC_68.L_CORE X_NUC_162.L_CORE 0.003636
K_8872 X_NUC_68.L_CORE X_NUC_163.L_CORE 0.002010
K_8873 X_NUC_68.L_CORE X_NUC_164.L_CORE 0.002236
K_8874 X_NUC_68.L_CORE X_NUC_165.L_CORE 0.002547
K_8875 X_NUC_69.L_CORE X_NUC_70.L_CORE 0.207973
K_8876 X_NUC_69.L_CORE X_NUC_71.L_CORE 0.207973
K_8877 X_NUC_69.L_CORE X_NUC_72.L_CORE 0.207973
K_8878 X_NUC_69.L_CORE X_NUC_73.L_CORE 0.001845
K_8879 X_NUC_69.L_CORE X_NUC_74.L_CORE 0.001860
K_8880 X_NUC_69.L_CORE X_NUC_75.L_CORE 0.001855
K_8881 X_NUC_69.L_CORE X_NUC_76.L_CORE 0.001849
K_8882 X_NUC_69.L_CORE X_NUC_77.L_CORE 0.002548
K_8883 X_NUC_69.L_CORE X_NUC_78.L_CORE 0.002548
K_8884 X_NUC_69.L_CORE X_NUC_79.L_CORE 0.002562
K_8885 X_NUC_69.L_CORE X_NUC_80.L_CORE 0.002531
K_8886 X_NUC_69.L_CORE X_NUC_81.L_CORE 0.003848
K_8887 X_NUC_69.L_CORE X_NUC_82.L_CORE 0.003915
K_8888 X_NUC_69.L_CORE X_NUC_83.L_CORE 0.003858
K_8889 X_NUC_69.L_CORE X_NUC_84.L_CORE 0.003882
K_8890 X_NUC_69.L_CORE X_NUC_85.L_CORE 0.001749
K_8891 X_NUC_69.L_CORE X_NUC_86.L_CORE 0.001758
K_8892 X_NUC_69.L_CORE X_NUC_87.L_CORE 0.001758
K_8893 X_NUC_69.L_CORE X_NUC_88.L_CORE 0.001747
K_8894 X_NUC_69.L_CORE X_NUC_89.L_CORE 0.005507
K_8895 X_NUC_69.L_CORE X_NUC_90.L_CORE 0.005463
K_8896 X_NUC_69.L_CORE X_NUC_91.L_CORE 0.005493
K_8897 X_NUC_69.L_CORE X_NUC_92.L_CORE 0.005378
K_8898 X_NUC_69.L_CORE X_NUC_93.L_CORE 0.002203
K_8899 X_NUC_69.L_CORE X_NUC_94.L_CORE 0.002225
K_8900 X_NUC_69.L_CORE X_NUC_95.L_CORE 0.002211
K_8901 X_NUC_69.L_CORE X_NUC_96.L_CORE 0.002208
K_8902 X_NUC_69.L_CORE X_NUC_97.L_CORE 0.002067
K_8903 X_NUC_69.L_CORE X_NUC_98.L_CORE 0.002073
K_8904 X_NUC_69.L_CORE X_NUC_99.L_CORE 0.002076
K_8905 X_NUC_69.L_CORE X_NUC_100.L_CORE 0.002057
K_8906 X_NUC_69.L_CORE X_NUC_101.L_CORE 0.005691
K_8907 X_NUC_69.L_CORE X_NUC_102.L_CORE 0.005781
K_8908 X_NUC_69.L_CORE X_NUC_103.L_CORE 0.005637
K_8909 X_NUC_69.L_CORE X_NUC_104.L_CORE 0.005654
K_8910 X_NUC_69.L_CORE X_NUC_105.L_CORE 0.001859
K_8911 X_NUC_69.L_CORE X_NUC_106.L_CORE 0.001872
K_8912 X_NUC_69.L_CORE X_NUC_107.L_CORE 0.001866
K_8913 X_NUC_69.L_CORE X_NUC_108.L_CORE 0.001858
K_8914 X_NUC_69.L_CORE X_NUC_109.L_CORE 0.003017
K_8915 X_NUC_69.L_CORE X_NUC_110.L_CORE 0.003019
K_8916 X_NUC_69.L_CORE X_NUC_111.L_CORE 0.003020
K_8917 X_NUC_69.L_CORE X_NUC_112.L_CORE 0.002983
K_8918 X_NUC_69.L_CORE X_NUC_113.L_CORE 0.002795
K_8919 X_NUC_69.L_CORE X_NUC_114.L_CORE 0.002827
K_8920 X_NUC_69.L_CORE X_NUC_115.L_CORE 0.002797
K_8921 X_NUC_69.L_CORE X_NUC_116.L_CORE 0.002795
K_8922 X_NUC_69.L_CORE X_NUC_117.L_CORE 0.001988
K_8923 X_NUC_69.L_CORE X_NUC_118.L_CORE 0.001998
K_8924 X_NUC_69.L_CORE X_NUC_119.L_CORE 0.001994
K_8925 X_NUC_69.L_CORE X_NUC_120.L_CORE 0.001980
K_8926 X_NUC_69.L_CORE X_NUC_121.L_CORE 0.003682
K_8927 X_NUC_69.L_CORE X_NUC_122.L_CORE 0.003701
K_8928 X_NUC_69.L_CORE X_NUC_123.L_CORE 0.003666
K_8929 X_NUC_69.L_CORE X_NUC_124.L_CORE 0.003638
K_8930 X_NUC_69.L_CORE X_NUC_125.L_CORE 0.002226
K_8931 X_NUC_69.L_CORE X_NUC_126.L_CORE 0.002243
K_8932 X_NUC_69.L_CORE X_NUC_127.L_CORE 0.002230
K_8933 X_NUC_69.L_CORE X_NUC_128.L_CORE 0.002221
K_8934 X_NUC_69.L_CORE X_NUC_129.L_CORE 0.002456
K_8935 X_NUC_69.L_CORE X_NUC_130.L_CORE 0.002468
K_8936 X_NUC_69.L_CORE X_NUC_131.L_CORE 0.002457
K_8937 X_NUC_69.L_CORE X_NUC_132.L_CORE 0.002439
K_8938 X_NUC_69.L_CORE X_NUC_133.L_CORE 0.002025
K_8939 X_NUC_69.L_CORE X_NUC_134.L_CORE 0.002688
K_8940 X_NUC_69.L_CORE X_NUC_135.L_CORE 0.002187
K_8941 X_NUC_69.L_CORE X_NUC_136.L_CORE 0.001950
K_8942 X_NUC_69.L_CORE X_NUC_137.L_CORE 0.003772
K_8943 X_NUC_69.L_CORE X_NUC_138.L_CORE 0.001781
K_8944 X_NUC_69.L_CORE X_NUC_139.L_CORE 0.002575
K_8945 X_NUC_69.L_CORE X_NUC_140.L_CORE 0.002810
K_8946 X_NUC_69.L_CORE X_NUC_141.L_CORE 0.001703
K_8947 X_NUC_69.L_CORE X_NUC_142.L_CORE 0.005426
K_8948 X_NUC_69.L_CORE X_NUC_143.L_CORE 0.001920
K_8949 X_NUC_69.L_CORE X_NUC_144.L_CORE 0.002047
K_8950 X_NUC_69.L_CORE X_NUC_145.L_CORE 0.005185
K_8951 X_NUC_69.L_CORE X_NUC_146.L_CORE 0.001642
K_8952 X_NUC_69.L_CORE X_NUC_147.L_CORE 0.003594
K_8953 X_NUC_69.L_CORE X_NUC_148.L_CORE 0.002415
K_8954 X_NUC_69.L_CORE X_NUC_149.L_CORE 0.001749
K_8955 X_NUC_69.L_CORE X_NUC_150.L_CORE 0.030724
K_8956 X_NUC_69.L_CORE X_NUC_151.L_CORE 0.001759
K_8957 X_NUC_69.L_CORE X_NUC_152.L_CORE 0.002416
K_8958 X_NUC_69.L_CORE X_NUC_153.L_CORE 0.003661
K_8959 X_NUC_69.L_CORE X_NUC_154.L_CORE 0.001665
K_8960 X_NUC_69.L_CORE X_NUC_155.L_CORE 0.005123
K_8961 X_NUC_69.L_CORE X_NUC_156.L_CORE 0.002100
K_8962 X_NUC_69.L_CORE X_NUC_157.L_CORE 0.001964
K_8963 X_NUC_69.L_CORE X_NUC_158.L_CORE 0.005333
K_8964 X_NUC_69.L_CORE X_NUC_159.L_CORE 0.001770
K_8965 X_NUC_69.L_CORE X_NUC_160.L_CORE 0.002851
K_8966 X_NUC_69.L_CORE X_NUC_161.L_CORE 0.002657
K_8967 X_NUC_69.L_CORE X_NUC_162.L_CORE 0.001890
K_8968 X_NUC_69.L_CORE X_NUC_163.L_CORE 0.003471
K_8969 X_NUC_69.L_CORE X_NUC_164.L_CORE 0.002116
K_8970 X_NUC_69.L_CORE X_NUC_165.L_CORE 0.002329
K_8971 X_NUC_70.L_CORE X_NUC_71.L_CORE 0.207973
K_8972 X_NUC_70.L_CORE X_NUC_72.L_CORE 0.207973
K_8973 X_NUC_70.L_CORE X_NUC_73.L_CORE 0.001830
K_8974 X_NUC_70.L_CORE X_NUC_74.L_CORE 0.001845
K_8975 X_NUC_70.L_CORE X_NUC_75.L_CORE 0.001840
K_8976 X_NUC_70.L_CORE X_NUC_76.L_CORE 0.001834
K_8977 X_NUC_70.L_CORE X_NUC_77.L_CORE 0.002548
K_8978 X_NUC_70.L_CORE X_NUC_78.L_CORE 0.002548
K_8979 X_NUC_70.L_CORE X_NUC_79.L_CORE 0.002562
K_8980 X_NUC_70.L_CORE X_NUC_80.L_CORE 0.002531
K_8981 X_NUC_70.L_CORE X_NUC_81.L_CORE 0.003783
K_8982 X_NUC_70.L_CORE X_NUC_82.L_CORE 0.003848
K_8983 X_NUC_70.L_CORE X_NUC_83.L_CORE 0.003794
K_8984 X_NUC_70.L_CORE X_NUC_84.L_CORE 0.003816
K_8985 X_NUC_70.L_CORE X_NUC_85.L_CORE 0.001739
K_8986 X_NUC_70.L_CORE X_NUC_86.L_CORE 0.001749
K_8987 X_NUC_70.L_CORE X_NUC_87.L_CORE 0.001748
K_8988 X_NUC_70.L_CORE X_NUC_88.L_CORE 0.001737
K_8989 X_NUC_70.L_CORE X_NUC_89.L_CORE 0.005548
K_8990 X_NUC_70.L_CORE X_NUC_90.L_CORE 0.005507
K_8991 X_NUC_70.L_CORE X_NUC_91.L_CORE 0.005536
K_8992 X_NUC_70.L_CORE X_NUC_92.L_CORE 0.005418
K_8993 X_NUC_70.L_CORE X_NUC_93.L_CORE 0.002180
K_8994 X_NUC_70.L_CORE X_NUC_94.L_CORE 0.002203
K_8995 X_NUC_70.L_CORE X_NUC_95.L_CORE 0.002189
K_8996 X_NUC_70.L_CORE X_NUC_96.L_CORE 0.002186
K_8997 X_NUC_70.L_CORE X_NUC_97.L_CORE 0.002061
K_8998 X_NUC_70.L_CORE X_NUC_98.L_CORE 0.002067
K_8999 X_NUC_70.L_CORE X_NUC_99.L_CORE 0.002069
K_9000 X_NUC_70.L_CORE X_NUC_100.L_CORE 0.002051
K_9001 X_NUC_70.L_CORE X_NUC_101.L_CORE 0.005600
K_9002 X_NUC_70.L_CORE X_NUC_102.L_CORE 0.005691
K_9003 X_NUC_70.L_CORE X_NUC_103.L_CORE 0.005551
K_9004 X_NUC_70.L_CORE X_NUC_104.L_CORE 0.005568
K_9005 X_NUC_70.L_CORE X_NUC_105.L_CORE 0.001846
K_9006 X_NUC_70.L_CORE X_NUC_106.L_CORE 0.001859
K_9007 X_NUC_70.L_CORE X_NUC_107.L_CORE 0.001853
K_9008 X_NUC_70.L_CORE X_NUC_108.L_CORE 0.001845
K_9009 X_NUC_70.L_CORE X_NUC_109.L_CORE 0.003015
K_9010 X_NUC_70.L_CORE X_NUC_110.L_CORE 0.003017
K_9011 X_NUC_70.L_CORE X_NUC_111.L_CORE 0.003018
K_9012 X_NUC_70.L_CORE X_NUC_112.L_CORE 0.002982
K_9013 X_NUC_70.L_CORE X_NUC_113.L_CORE 0.002764
K_9014 X_NUC_70.L_CORE X_NUC_114.L_CORE 0.002795
K_9015 X_NUC_70.L_CORE X_NUC_115.L_CORE 0.002766
K_9016 X_NUC_70.L_CORE X_NUC_116.L_CORE 0.002764
K_9017 X_NUC_70.L_CORE X_NUC_117.L_CORE 0.001978
K_9018 X_NUC_70.L_CORE X_NUC_118.L_CORE 0.001988
K_9019 X_NUC_70.L_CORE X_NUC_119.L_CORE 0.001984
K_9020 X_NUC_70.L_CORE X_NUC_120.L_CORE 0.001970
K_9021 X_NUC_70.L_CORE X_NUC_121.L_CORE 0.003662
K_9022 X_NUC_70.L_CORE X_NUC_122.L_CORE 0.003682
K_9023 X_NUC_70.L_CORE X_NUC_123.L_CORE 0.003647
K_9024 X_NUC_70.L_CORE X_NUC_124.L_CORE 0.003620
K_9025 X_NUC_70.L_CORE X_NUC_125.L_CORE 0.002208
K_9026 X_NUC_70.L_CORE X_NUC_126.L_CORE 0.002226
K_9027 X_NUC_70.L_CORE X_NUC_127.L_CORE 0.002212
K_9028 X_NUC_70.L_CORE X_NUC_128.L_CORE 0.002203
K_9029 X_NUC_70.L_CORE X_NUC_129.L_CORE 0.002443
K_9030 X_NUC_70.L_CORE X_NUC_130.L_CORE 0.002456
K_9031 X_NUC_70.L_CORE X_NUC_131.L_CORE 0.002445
K_9032 X_NUC_70.L_CORE X_NUC_132.L_CORE 0.002427
K_9033 X_NUC_70.L_CORE X_NUC_133.L_CORE 0.002014
K_9034 X_NUC_70.L_CORE X_NUC_134.L_CORE 0.002681
K_9035 X_NUC_70.L_CORE X_NUC_135.L_CORE 0.002170
K_9036 X_NUC_70.L_CORE X_NUC_136.L_CORE 0.001943
K_9037 X_NUC_70.L_CORE X_NUC_137.L_CORE 0.003749
K_9038 X_NUC_70.L_CORE X_NUC_138.L_CORE 0.001769
K_9039 X_NUC_70.L_CORE X_NUC_139.L_CORE 0.002576
K_9040 X_NUC_70.L_CORE X_NUC_140.L_CORE 0.002779
K_9041 X_NUC_70.L_CORE X_NUC_141.L_CORE 0.001695
K_9042 X_NUC_70.L_CORE X_NUC_142.L_CORE 0.005469
K_9043 X_NUC_70.L_CORE X_NUC_143.L_CORE 0.001903
K_9044 X_NUC_70.L_CORE X_NUC_144.L_CORE 0.002044
K_9045 X_NUC_70.L_CORE X_NUC_145.L_CORE 0.005097
K_9046 X_NUC_70.L_CORE X_NUC_146.L_CORE 0.001632
K_9047 X_NUC_70.L_CORE X_NUC_147.L_CORE 0.003616
K_9048 X_NUC_70.L_CORE X_NUC_148.L_CORE 0.002387
K_9049 X_NUC_70.L_CORE X_NUC_149.L_CORE 0.001743
K_9050 X_NUC_70.L_CORE X_NUC_150.L_CORE 0.034436
K_9051 X_NUC_70.L_CORE X_NUC_151.L_CORE 0.001746
K_9052 X_NUC_70.L_CORE X_NUC_152.L_CORE 0.002417
K_9053 X_NUC_70.L_CORE X_NUC_153.L_CORE 0.003605
K_9054 X_NUC_70.L_CORE X_NUC_154.L_CORE 0.001656
K_9055 X_NUC_70.L_CORE X_NUC_155.L_CORE 0.005176
K_9056 X_NUC_70.L_CORE X_NUC_156.L_CORE 0.002079
K_9057 X_NUC_70.L_CORE X_NUC_157.L_CORE 0.001958
K_9058 X_NUC_70.L_CORE X_NUC_158.L_CORE 0.005268
K_9059 X_NUC_70.L_CORE X_NUC_159.L_CORE 0.001758
K_9060 X_NUC_70.L_CORE X_NUC_160.L_CORE 0.002852
K_9061 X_NUC_70.L_CORE X_NUC_161.L_CORE 0.002630
K_9062 X_NUC_70.L_CORE X_NUC_162.L_CORE 0.001881
K_9063 X_NUC_70.L_CORE X_NUC_163.L_CORE 0.003458
K_9064 X_NUC_70.L_CORE X_NUC_164.L_CORE 0.002101
K_9065 X_NUC_70.L_CORE X_NUC_165.L_CORE 0.002319
K_9066 X_NUC_71.L_CORE X_NUC_72.L_CORE 0.207973
K_9067 X_NUC_71.L_CORE X_NUC_73.L_CORE 0.001835
K_9068 X_NUC_71.L_CORE X_NUC_74.L_CORE 0.001850
K_9069 X_NUC_71.L_CORE X_NUC_75.L_CORE 0.001845
K_9070 X_NUC_71.L_CORE X_NUC_76.L_CORE 0.001839
K_9071 X_NUC_71.L_CORE X_NUC_77.L_CORE 0.002535
K_9072 X_NUC_71.L_CORE X_NUC_78.L_CORE 0.002535
K_9073 X_NUC_71.L_CORE X_NUC_79.L_CORE 0.002548
K_9074 X_NUC_71.L_CORE X_NUC_80.L_CORE 0.002518
K_9075 X_NUC_71.L_CORE X_NUC_81.L_CORE 0.003836
K_9076 X_NUC_71.L_CORE X_NUC_82.L_CORE 0.003903
K_9077 X_NUC_71.L_CORE X_NUC_83.L_CORE 0.003848
K_9078 X_NUC_71.L_CORE X_NUC_84.L_CORE 0.003871
K_9079 X_NUC_71.L_CORE X_NUC_85.L_CORE 0.001740
K_9080 X_NUC_71.L_CORE X_NUC_86.L_CORE 0.001749
K_9081 X_NUC_71.L_CORE X_NUC_87.L_CORE 0.001749
K_9082 X_NUC_71.L_CORE X_NUC_88.L_CORE 0.001738
K_9083 X_NUC_71.L_CORE X_NUC_89.L_CORE 0.005517
K_9084 X_NUC_71.L_CORE X_NUC_90.L_CORE 0.005474
K_9085 X_NUC_71.L_CORE X_NUC_91.L_CORE 0.005507
K_9086 X_NUC_71.L_CORE X_NUC_92.L_CORE 0.005389
K_9087 X_NUC_71.L_CORE X_NUC_93.L_CORE 0.002194
K_9088 X_NUC_71.L_CORE X_NUC_94.L_CORE 0.002216
K_9089 X_NUC_71.L_CORE X_NUC_95.L_CORE 0.002203
K_9090 X_NUC_71.L_CORE X_NUC_96.L_CORE 0.002200
K_9091 X_NUC_71.L_CORE X_NUC_97.L_CORE 0.002058
K_9092 X_NUC_71.L_CORE X_NUC_98.L_CORE 0.002064
K_9093 X_NUC_71.L_CORE X_NUC_99.L_CORE 0.002067
K_9094 X_NUC_71.L_CORE X_NUC_100.L_CORE 0.002048
K_9095 X_NUC_71.L_CORE X_NUC_101.L_CORE 0.005742
K_9096 X_NUC_71.L_CORE X_NUC_102.L_CORE 0.005837
K_9097 X_NUC_71.L_CORE X_NUC_103.L_CORE 0.005691
K_9098 X_NUC_71.L_CORE X_NUC_104.L_CORE 0.005707
K_9099 X_NUC_71.L_CORE X_NUC_105.L_CORE 0.001851
K_9100 X_NUC_71.L_CORE X_NUC_106.L_CORE 0.001865
K_9101 X_NUC_71.L_CORE X_NUC_107.L_CORE 0.001859
K_9102 X_NUC_71.L_CORE X_NUC_108.L_CORE 0.001850
K_9103 X_NUC_71.L_CORE X_NUC_109.L_CORE 0.003014
K_9104 X_NUC_71.L_CORE X_NUC_110.L_CORE 0.003016
K_9105 X_NUC_71.L_CORE X_NUC_111.L_CORE 0.003017
K_9106 X_NUC_71.L_CORE X_NUC_112.L_CORE 0.002981
K_9107 X_NUC_71.L_CORE X_NUC_113.L_CORE 0.002792
K_9108 X_NUC_71.L_CORE X_NUC_114.L_CORE 0.002824
K_9109 X_NUC_71.L_CORE X_NUC_115.L_CORE 0.002795
K_9110 X_NUC_71.L_CORE X_NUC_116.L_CORE 0.002793
K_9111 X_NUC_71.L_CORE X_NUC_117.L_CORE 0.001982
K_9112 X_NUC_71.L_CORE X_NUC_118.L_CORE 0.001992
K_9113 X_NUC_71.L_CORE X_NUC_119.L_CORE 0.001988
K_9114 X_NUC_71.L_CORE X_NUC_120.L_CORE 0.001974
K_9115 X_NUC_71.L_CORE X_NUC_121.L_CORE 0.003696
K_9116 X_NUC_71.L_CORE X_NUC_122.L_CORE 0.003716
K_9117 X_NUC_71.L_CORE X_NUC_123.L_CORE 0.003682
K_9118 X_NUC_71.L_CORE X_NUC_124.L_CORE 0.003653
K_9119 X_NUC_71.L_CORE X_NUC_125.L_CORE 0.002221
K_9120 X_NUC_71.L_CORE X_NUC_126.L_CORE 0.002239
K_9121 X_NUC_71.L_CORE X_NUC_127.L_CORE 0.002226
K_9122 X_NUC_71.L_CORE X_NUC_128.L_CORE 0.002216
K_9123 X_NUC_71.L_CORE X_NUC_129.L_CORE 0.002454
K_9124 X_NUC_71.L_CORE X_NUC_130.L_CORE 0.002466
K_9125 X_NUC_71.L_CORE X_NUC_131.L_CORE 0.002456
K_9126 X_NUC_71.L_CORE X_NUC_132.L_CORE 0.002438
K_9127 X_NUC_71.L_CORE X_NUC_133.L_CORE 0.002006
K_9128 X_NUC_71.L_CORE X_NUC_134.L_CORE 0.002656
K_9129 X_NUC_71.L_CORE X_NUC_135.L_CORE 0.002166
K_9130 X_NUC_71.L_CORE X_NUC_136.L_CORE 0.001933
K_9131 X_NUC_71.L_CORE X_NUC_137.L_CORE 0.003714
K_9132 X_NUC_71.L_CORE X_NUC_138.L_CORE 0.001767
K_9133 X_NUC_71.L_CORE X_NUC_139.L_CORE 0.002550
K_9134 X_NUC_71.L_CORE X_NUC_140.L_CORE 0.002783
K_9135 X_NUC_71.L_CORE X_NUC_141.L_CORE 0.001691
K_9136 X_NUC_71.L_CORE X_NUC_142.L_CORE 0.005333
K_9137 X_NUC_71.L_CORE X_NUC_143.L_CORE 0.001907
K_9138 X_NUC_71.L_CORE X_NUC_144.L_CORE 0.002033
K_9139 X_NUC_71.L_CORE X_NUC_145.L_CORE 0.005131
K_9140 X_NUC_71.L_CORE X_NUC_146.L_CORE 0.001632
K_9141 X_NUC_71.L_CORE X_NUC_147.L_CORE 0.003568
K_9142 X_NUC_71.L_CORE X_NUC_148.L_CORE 0.002401
K_9143 X_NUC_71.L_CORE X_NUC_149.L_CORE 0.001739
K_9144 X_NUC_71.L_CORE X_NUC_150.L_CORE 0.034519
K_9145 X_NUC_71.L_CORE X_NUC_151.L_CORE 0.001750
K_9146 X_NUC_71.L_CORE X_NUC_152.L_CORE 0.002405
K_9147 X_NUC_71.L_CORE X_NUC_153.L_CORE 0.003656
K_9148 X_NUC_71.L_CORE X_NUC_154.L_CORE 0.001657
K_9149 X_NUC_71.L_CORE X_NUC_155.L_CORE 0.005148
K_9150 X_NUC_71.L_CORE X_NUC_156.L_CORE 0.002092
K_9151 X_NUC_71.L_CORE X_NUC_157.L_CORE 0.001956
K_9152 X_NUC_71.L_CORE X_NUC_158.L_CORE 0.005398
K_9153 X_NUC_71.L_CORE X_NUC_159.L_CORE 0.001764
K_9154 X_NUC_71.L_CORE X_NUC_160.L_CORE 0.002851
K_9155 X_NUC_71.L_CORE X_NUC_161.L_CORE 0.002657
K_9156 X_NUC_71.L_CORE X_NUC_162.L_CORE 0.001885
K_9157 X_NUC_71.L_CORE X_NUC_163.L_CORE 0.003490
K_9158 X_NUC_71.L_CORE X_NUC_164.L_CORE 0.002114
K_9159 X_NUC_71.L_CORE X_NUC_165.L_CORE 0.002329
K_9160 X_NUC_72.L_CORE X_NUC_73.L_CORE 0.001841
K_9161 X_NUC_72.L_CORE X_NUC_74.L_CORE 0.001856
K_9162 X_NUC_72.L_CORE X_NUC_75.L_CORE 0.001851
K_9163 X_NUC_72.L_CORE X_NUC_76.L_CORE 0.001845
K_9164 X_NUC_72.L_CORE X_NUC_77.L_CORE 0.002566
K_9165 X_NUC_72.L_CORE X_NUC_78.L_CORE 0.002566
K_9166 X_NUC_72.L_CORE X_NUC_79.L_CORE 0.002580
K_9167 X_NUC_72.L_CORE X_NUC_80.L_CORE 0.002548
K_9168 X_NUC_72.L_CORE X_NUC_81.L_CORE 0.003814
K_9169 X_NUC_72.L_CORE X_NUC_82.L_CORE 0.003879
K_9170 X_NUC_72.L_CORE X_NUC_83.L_CORE 0.003824
K_9171 X_NUC_72.L_CORE X_NUC_84.L_CORE 0.003848
K_9172 X_NUC_72.L_CORE X_NUC_85.L_CORE 0.001750
K_9173 X_NUC_72.L_CORE X_NUC_86.L_CORE 0.001760
K_9174 X_NUC_72.L_CORE X_NUC_87.L_CORE 0.001759
K_9175 X_NUC_72.L_CORE X_NUC_88.L_CORE 0.001749
K_9176 X_NUC_72.L_CORE X_NUC_89.L_CORE 0.005641
K_9177 X_NUC_72.L_CORE X_NUC_90.L_CORE 0.005596
K_9178 X_NUC_72.L_CORE X_NUC_91.L_CORE 0.005629
K_9179 X_NUC_72.L_CORE X_NUC_92.L_CORE 0.005507
K_9180 X_NUC_72.L_CORE X_NUC_93.L_CORE 0.002197
K_9181 X_NUC_72.L_CORE X_NUC_94.L_CORE 0.002219
K_9182 X_NUC_72.L_CORE X_NUC_95.L_CORE 0.002205
K_9183 X_NUC_72.L_CORE X_NUC_96.L_CORE 0.002203
K_9184 X_NUC_72.L_CORE X_NUC_97.L_CORE 0.002077
K_9185 X_NUC_72.L_CORE X_NUC_98.L_CORE 0.002083
K_9186 X_NUC_72.L_CORE X_NUC_99.L_CORE 0.002086
K_9187 X_NUC_72.L_CORE X_NUC_100.L_CORE 0.002067
K_9188 X_NUC_72.L_CORE X_NUC_101.L_CORE 0.005723
K_9189 X_NUC_72.L_CORE X_NUC_102.L_CORE 0.005818
K_9190 X_NUC_72.L_CORE X_NUC_103.L_CORE 0.005671
K_9191 X_NUC_72.L_CORE X_NUC_104.L_CORE 0.005691
K_9192 X_NUC_72.L_CORE X_NUC_105.L_CORE 0.001860
K_9193 X_NUC_72.L_CORE X_NUC_106.L_CORE 0.001874
K_9194 X_NUC_72.L_CORE X_NUC_107.L_CORE 0.001868
K_9195 X_NUC_72.L_CORE X_NUC_108.L_CORE 0.001859
K_9196 X_NUC_72.L_CORE X_NUC_109.L_CORE 0.003052
K_9197 X_NUC_72.L_CORE X_NUC_110.L_CORE 0.003053
K_9198 X_NUC_72.L_CORE X_NUC_111.L_CORE 0.003055
K_9199 X_NUC_72.L_CORE X_NUC_112.L_CORE 0.003017
K_9200 X_NUC_72.L_CORE X_NUC_113.L_CORE 0.002794
K_9201 X_NUC_72.L_CORE X_NUC_114.L_CORE 0.002826
K_9202 X_NUC_72.L_CORE X_NUC_115.L_CORE 0.002796
K_9203 X_NUC_72.L_CORE X_NUC_116.L_CORE 0.002795
K_9204 X_NUC_72.L_CORE X_NUC_117.L_CORE 0.001996
K_9205 X_NUC_72.L_CORE X_NUC_118.L_CORE 0.002006
K_9206 X_NUC_72.L_CORE X_NUC_119.L_CORE 0.002002
K_9207 X_NUC_72.L_CORE X_NUC_120.L_CORE 0.001988
K_9208 X_NUC_72.L_CORE X_NUC_121.L_CORE 0.003726
K_9209 X_NUC_72.L_CORE X_NUC_122.L_CORE 0.003746
K_9210 X_NUC_72.L_CORE X_NUC_123.L_CORE 0.003710
K_9211 X_NUC_72.L_CORE X_NUC_124.L_CORE 0.003682
K_9212 X_NUC_72.L_CORE X_NUC_125.L_CORE 0.002231
K_9213 X_NUC_72.L_CORE X_NUC_126.L_CORE 0.002249
K_9214 X_NUC_72.L_CORE X_NUC_127.L_CORE 0.002235
K_9215 X_NUC_72.L_CORE X_NUC_128.L_CORE 0.002226
K_9216 X_NUC_72.L_CORE X_NUC_129.L_CORE 0.002472
K_9217 X_NUC_72.L_CORE X_NUC_130.L_CORE 0.002485
K_9218 X_NUC_72.L_CORE X_NUC_131.L_CORE 0.002474
K_9219 X_NUC_72.L_CORE X_NUC_132.L_CORE 0.002456
K_9220 X_NUC_72.L_CORE X_NUC_133.L_CORE 0.002015
K_9221 X_NUC_72.L_CORE X_NUC_134.L_CORE 0.002673
K_9222 X_NUC_72.L_CORE X_NUC_135.L_CORE 0.002170
K_9223 X_NUC_72.L_CORE X_NUC_136.L_CORE 0.001947
K_9224 X_NUC_72.L_CORE X_NUC_137.L_CORE 0.003718
K_9225 X_NUC_72.L_CORE X_NUC_138.L_CORE 0.001774
K_9226 X_NUC_72.L_CORE X_NUC_139.L_CORE 0.002577
K_9227 X_NUC_72.L_CORE X_NUC_140.L_CORE 0.002777
K_9228 X_NUC_72.L_CORE X_NUC_141.L_CORE 0.001702
K_9229 X_NUC_72.L_CORE X_NUC_142.L_CORE 0.005396
K_9230 X_NUC_72.L_CORE X_NUC_143.L_CORE 0.001910
K_9231 X_NUC_72.L_CORE X_NUC_144.L_CORE 0.002052
K_9232 X_NUC_72.L_CORE X_NUC_145.L_CORE 0.005064
K_9233 X_NUC_72.L_CORE X_NUC_146.L_CORE 0.001640
K_9234 X_NUC_72.L_CORE X_NUC_147.L_CORE 0.003625
K_9235 X_NUC_72.L_CORE X_NUC_148.L_CORE 0.002397
K_9236 X_NUC_72.L_CORE X_NUC_149.L_CORE 0.001753
K_9237 X_NUC_72.L_CORE X_NUC_150.L_CORE 0.031036
K_9238 X_NUC_72.L_CORE X_NUC_151.L_CORE 0.001755
K_9239 X_NUC_72.L_CORE X_NUC_152.L_CORE 0.002433
K_9240 X_NUC_72.L_CORE X_NUC_153.L_CORE 0.003630
K_9241 X_NUC_72.L_CORE X_NUC_154.L_CORE 0.001667
K_9242 X_NUC_72.L_CORE X_NUC_155.L_CORE 0.005245
K_9243 X_NUC_72.L_CORE X_NUC_156.L_CORE 0.002094
K_9244 X_NUC_72.L_CORE X_NUC_157.L_CORE 0.001973
K_9245 X_NUC_72.L_CORE X_NUC_158.L_CORE 0.005366
K_9246 X_NUC_72.L_CORE X_NUC_159.L_CORE 0.001771
K_9247 X_NUC_72.L_CORE X_NUC_160.L_CORE 0.002884
K_9248 X_NUC_72.L_CORE X_NUC_161.L_CORE 0.002657
K_9249 X_NUC_72.L_CORE X_NUC_162.L_CORE 0.001897
K_9250 X_NUC_72.L_CORE X_NUC_163.L_CORE 0.003513
K_9251 X_NUC_72.L_CORE X_NUC_164.L_CORE 0.002121
K_9252 X_NUC_72.L_CORE X_NUC_165.L_CORE 0.002345
K_9253 X_NUC_73.L_CORE X_NUC_74.L_CORE 0.207973
K_9254 X_NUC_73.L_CORE X_NUC_75.L_CORE 0.207973
K_9255 X_NUC_73.L_CORE X_NUC_76.L_CORE 0.207973
K_9256 X_NUC_73.L_CORE X_NUC_77.L_CORE 0.001859
K_9257 X_NUC_73.L_CORE X_NUC_78.L_CORE 0.001843
K_9258 X_NUC_73.L_CORE X_NUC_79.L_CORE 0.001853
K_9259 X_NUC_73.L_CORE X_NUC_80.L_CORE 0.001848
K_9260 X_NUC_73.L_CORE X_NUC_81.L_CORE 0.002572
K_9261 X_NUC_73.L_CORE X_NUC_82.L_CORE 0.002551
K_9262 X_NUC_73.L_CORE X_NUC_83.L_CORE 0.002548
K_9263 X_NUC_73.L_CORE X_NUC_84.L_CORE 0.002571
K_9264 X_NUC_73.L_CORE X_NUC_85.L_CORE 0.003889
K_9265 X_NUC_73.L_CORE X_NUC_86.L_CORE 0.003855
K_9266 X_NUC_73.L_CORE X_NUC_87.L_CORE 0.003892
K_9267 X_NUC_73.L_CORE X_NUC_88.L_CORE 0.003831
K_9268 X_NUC_73.L_CORE X_NUC_89.L_CORE 0.001773
K_9269 X_NUC_73.L_CORE X_NUC_90.L_CORE 0.001758
K_9270 X_NUC_73.L_CORE X_NUC_91.L_CORE 0.001763
K_9271 X_NUC_73.L_CORE X_NUC_92.L_CORE 0.001765
K_9272 X_NUC_73.L_CORE X_NUC_93.L_CORE 0.005554
K_9273 X_NUC_73.L_CORE X_NUC_94.L_CORE 0.005498
K_9274 X_NUC_73.L_CORE X_NUC_95.L_CORE 0.005419
K_9275 X_NUC_73.L_CORE X_NUC_96.L_CORE 0.005532
K_9276 X_NUC_73.L_CORE X_NUC_97.L_CORE 0.002242
K_9277 X_NUC_73.L_CORE X_NUC_98.L_CORE 0.002223
K_9278 X_NUC_73.L_CORE X_NUC_99.L_CORE 0.002235
K_9279 X_NUC_73.L_CORE X_NUC_100.L_CORE 0.002222
K_9280 X_NUC_73.L_CORE X_NUC_101.L_CORE 0.002110
K_9281 X_NUC_73.L_CORE X_NUC_102.L_CORE 0.002092
K_9282 X_NUC_73.L_CORE X_NUC_103.L_CORE 0.002092
K_9283 X_NUC_73.L_CORE X_NUC_104.L_CORE 0.002102
K_9284 X_NUC_73.L_CORE X_NUC_105.L_CORE 0.005632
K_9285 X_NUC_73.L_CORE X_NUC_106.L_CORE 0.005569
K_9286 X_NUC_73.L_CORE X_NUC_107.L_CORE 0.005549
K_9287 X_NUC_73.L_CORE X_NUC_108.L_CORE 0.005485
K_9288 X_NUC_73.L_CORE X_NUC_109.L_CORE 0.001913
K_9289 X_NUC_73.L_CORE X_NUC_110.L_CORE 0.001896
K_9290 X_NUC_73.L_CORE X_NUC_111.L_CORE 0.001902
K_9291 X_NUC_73.L_CORE X_NUC_112.L_CORE 0.001899
K_9292 X_NUC_73.L_CORE X_NUC_113.L_CORE 0.003068
K_9293 X_NUC_73.L_CORE X_NUC_114.L_CORE 0.003040
K_9294 X_NUC_73.L_CORE X_NUC_115.L_CORE 0.003024
K_9295 X_NUC_73.L_CORE X_NUC_116.L_CORE 0.003049
K_9296 X_NUC_73.L_CORE X_NUC_117.L_CORE 0.002851
K_9297 X_NUC_73.L_CORE X_NUC_118.L_CORE 0.002825
K_9298 X_NUC_73.L_CORE X_NUC_119.L_CORE 0.002832
K_9299 X_NUC_73.L_CORE X_NUC_120.L_CORE 0.002814
K_9300 X_NUC_73.L_CORE X_NUC_121.L_CORE 0.002083
K_9301 X_NUC_73.L_CORE X_NUC_122.L_CORE 0.002065
K_9302 X_NUC_73.L_CORE X_NUC_123.L_CORE 0.002066
K_9303 X_NUC_73.L_CORE X_NUC_124.L_CORE 0.002069
K_9304 X_NUC_73.L_CORE X_NUC_125.L_CORE 0.003474
K_9305 X_NUC_73.L_CORE X_NUC_126.L_CORE 0.003440
K_9306 X_NUC_73.L_CORE X_NUC_127.L_CORE 0.003422
K_9307 X_NUC_73.L_CORE X_NUC_128.L_CORE 0.003427
K_9308 X_NUC_73.L_CORE X_NUC_129.L_CORE 0.002396
K_9309 X_NUC_73.L_CORE X_NUC_130.L_CORE 0.002374
K_9310 X_NUC_73.L_CORE X_NUC_131.L_CORE 0.002375
K_9311 X_NUC_73.L_CORE X_NUC_132.L_CORE 0.002371
K_9312 X_NUC_73.L_CORE X_NUC_133.L_CORE 0.002363
K_9313 X_NUC_73.L_CORE X_NUC_134.L_CORE 0.001861
K_9314 X_NUC_73.L_CORE X_NUC_135.L_CORE 0.002745
K_9315 X_NUC_73.L_CORE X_NUC_136.L_CORE 0.002119
K_9316 X_NUC_73.L_CORE X_NUC_137.L_CORE 0.001887
K_9317 X_NUC_73.L_CORE X_NUC_138.L_CORE 0.003840
K_9318 X_NUC_73.L_CORE X_NUC_139.L_CORE 0.001732
K_9319 X_NUC_73.L_CORE X_NUC_140.L_CORE 0.002539
K_9320 X_NUC_73.L_CORE X_NUC_141.L_CORE 0.002760
K_9321 X_NUC_73.L_CORE X_NUC_142.L_CORE 0.001672
K_9322 X_NUC_73.L_CORE X_NUC_143.L_CORE 0.005462
K_9323 X_NUC_73.L_CORE X_NUC_144.L_CORE 0.001890
K_9324 X_NUC_73.L_CORE X_NUC_145.L_CORE 0.002027
K_9325 X_NUC_73.L_CORE X_NUC_146.L_CORE 0.005122
K_9326 X_NUC_73.L_CORE X_NUC_147.L_CORE 0.001628
K_9327 X_NUC_73.L_CORE X_NUC_148.L_CORE 0.003594
K_9328 X_NUC_73.L_CORE X_NUC_149.L_CORE 0.002397
K_9329 X_NUC_73.L_CORE X_NUC_150.L_CORE 0.001746
K_9330 X_NUC_73.L_CORE X_NUC_151.L_CORE 0.035102
K_9331 X_NUC_73.L_CORE X_NUC_152.L_CORE 0.001759
K_9332 X_NUC_73.L_CORE X_NUC_153.L_CORE 0.002430
K_9333 X_NUC_73.L_CORE X_NUC_154.L_CORE 0.003659
K_9334 X_NUC_73.L_CORE X_NUC_155.L_CORE 0.001677
K_9335 X_NUC_73.L_CORE X_NUC_156.L_CORE 0.005177
K_9336 X_NUC_73.L_CORE X_NUC_157.L_CORE 0.002118
K_9337 X_NUC_73.L_CORE X_NUC_158.L_CORE 0.001994
K_9338 X_NUC_73.L_CORE X_NUC_159.L_CORE 0.005230
K_9339 X_NUC_73.L_CORE X_NUC_160.L_CORE 0.001808
K_9340 X_NUC_73.L_CORE X_NUC_161.L_CORE 0.002888
K_9341 X_NUC_73.L_CORE X_NUC_162.L_CORE 0.002685
K_9342 X_NUC_73.L_CORE X_NUC_163.L_CORE 0.001967
K_9343 X_NUC_73.L_CORE X_NUC_164.L_CORE 0.003260
K_9344 X_NUC_73.L_CORE X_NUC_165.L_CORE 0.002259
K_9345 X_NUC_74.L_CORE X_NUC_75.L_CORE 0.207973
K_9346 X_NUC_74.L_CORE X_NUC_76.L_CORE 0.207973
K_9347 X_NUC_74.L_CORE X_NUC_77.L_CORE 0.001874
K_9348 X_NUC_74.L_CORE X_NUC_78.L_CORE 0.001859
K_9349 X_NUC_74.L_CORE X_NUC_79.L_CORE 0.001869
K_9350 X_NUC_74.L_CORE X_NUC_80.L_CORE 0.001863
K_9351 X_NUC_74.L_CORE X_NUC_81.L_CORE 0.002594
K_9352 X_NUC_74.L_CORE X_NUC_82.L_CORE 0.002572
K_9353 X_NUC_74.L_CORE X_NUC_83.L_CORE 0.002569
K_9354 X_NUC_74.L_CORE X_NUC_84.L_CORE 0.002593
K_9355 X_NUC_74.L_CORE X_NUC_85.L_CORE 0.003923
K_9356 X_NUC_74.L_CORE X_NUC_86.L_CORE 0.003889
K_9357 X_NUC_74.L_CORE X_NUC_87.L_CORE 0.003927
K_9358 X_NUC_74.L_CORE X_NUC_88.L_CORE 0.003864
K_9359 X_NUC_74.L_CORE X_NUC_89.L_CORE 0.001788
K_9360 X_NUC_74.L_CORE X_NUC_90.L_CORE 0.001773
K_9361 X_NUC_74.L_CORE X_NUC_91.L_CORE 0.001778
K_9362 X_NUC_74.L_CORE X_NUC_92.L_CORE 0.001779
K_9363 X_NUC_74.L_CORE X_NUC_93.L_CORE 0.005607
K_9364 X_NUC_74.L_CORE X_NUC_94.L_CORE 0.005554
K_9365 X_NUC_74.L_CORE X_NUC_95.L_CORE 0.005471
K_9366 X_NUC_74.L_CORE X_NUC_96.L_CORE 0.005586
K_9367 X_NUC_74.L_CORE X_NUC_97.L_CORE 0.002262
K_9368 X_NUC_74.L_CORE X_NUC_98.L_CORE 0.002242
K_9369 X_NUC_74.L_CORE X_NUC_99.L_CORE 0.002254
K_9370 X_NUC_74.L_CORE X_NUC_100.L_CORE 0.002241
K_9371 X_NUC_74.L_CORE X_NUC_101.L_CORE 0.002128
K_9372 X_NUC_74.L_CORE X_NUC_102.L_CORE 0.002110
K_9373 X_NUC_74.L_CORE X_NUC_103.L_CORE 0.002110
K_9374 X_NUC_74.L_CORE X_NUC_104.L_CORE 0.002120
K_9375 X_NUC_74.L_CORE X_NUC_105.L_CORE 0.005693
K_9376 X_NUC_74.L_CORE X_NUC_106.L_CORE 0.005632
K_9377 X_NUC_74.L_CORE X_NUC_107.L_CORE 0.005609
K_9378 X_NUC_74.L_CORE X_NUC_108.L_CORE 0.005543
K_9379 X_NUC_74.L_CORE X_NUC_109.L_CORE 0.001929
K_9380 X_NUC_74.L_CORE X_NUC_110.L_CORE 0.001913
K_9381 X_NUC_74.L_CORE X_NUC_111.L_CORE 0.001919
K_9382 X_NUC_74.L_CORE X_NUC_112.L_CORE 0.001916
K_9383 X_NUC_74.L_CORE X_NUC_113.L_CORE 0.003097
K_9384 X_NUC_74.L_CORE X_NUC_114.L_CORE 0.003068
K_9385 X_NUC_74.L_CORE X_NUC_115.L_CORE 0.003052
K_9386 X_NUC_74.L_CORE X_NUC_116.L_CORE 0.003077
K_9387 X_NUC_74.L_CORE X_NUC_117.L_CORE 0.002877
K_9388 X_NUC_74.L_CORE X_NUC_118.L_CORE 0.002851
K_9389 X_NUC_74.L_CORE X_NUC_119.L_CORE 0.002858
K_9390 X_NUC_74.L_CORE X_NUC_120.L_CORE 0.002839
K_9391 X_NUC_74.L_CORE X_NUC_121.L_CORE 0.002102
K_9392 X_NUC_74.L_CORE X_NUC_122.L_CORE 0.002083
K_9393 X_NUC_74.L_CORE X_NUC_123.L_CORE 0.002084
K_9394 X_NUC_74.L_CORE X_NUC_124.L_CORE 0.002087
K_9395 X_NUC_74.L_CORE X_NUC_125.L_CORE 0.003509
K_9396 X_NUC_74.L_CORE X_NUC_126.L_CORE 0.003474
K_9397 X_NUC_74.L_CORE X_NUC_127.L_CORE 0.003456
K_9398 X_NUC_74.L_CORE X_NUC_128.L_CORE 0.003461
K_9399 X_NUC_74.L_CORE X_NUC_129.L_CORE 0.002418
K_9400 X_NUC_74.L_CORE X_NUC_130.L_CORE 0.002396
K_9401 X_NUC_74.L_CORE X_NUC_131.L_CORE 0.002397
K_9402 X_NUC_74.L_CORE X_NUC_132.L_CORE 0.002393
K_9403 X_NUC_74.L_CORE X_NUC_133.L_CORE 0.002379
K_9404 X_NUC_74.L_CORE X_NUC_134.L_CORE 0.001874
K_9405 X_NUC_74.L_CORE X_NUC_135.L_CORE 0.002761
K_9406 X_NUC_74.L_CORE X_NUC_136.L_CORE 0.002134
K_9407 X_NUC_74.L_CORE X_NUC_137.L_CORE 0.001901
K_9408 X_NUC_74.L_CORE X_NUC_138.L_CORE 0.003855
K_9409 X_NUC_74.L_CORE X_NUC_139.L_CORE 0.001745
K_9410 X_NUC_74.L_CORE X_NUC_140.L_CORE 0.002555
K_9411 X_NUC_74.L_CORE X_NUC_141.L_CORE 0.002778
K_9412 X_NUC_74.L_CORE X_NUC_142.L_CORE 0.001685
K_9413 X_NUC_74.L_CORE X_NUC_143.L_CORE 0.005468
K_9414 X_NUC_74.L_CORE X_NUC_144.L_CORE 0.001904
K_9415 X_NUC_74.L_CORE X_NUC_145.L_CORE 0.002042
K_9416 X_NUC_74.L_CORE X_NUC_146.L_CORE 0.005137
K_9417 X_NUC_74.L_CORE X_NUC_147.L_CORE 0.001640
K_9418 X_NUC_74.L_CORE X_NUC_148.L_CORE 0.003615
K_9419 X_NUC_74.L_CORE X_NUC_149.L_CORE 0.002414
K_9420 X_NUC_74.L_CORE X_NUC_150.L_CORE 0.001760
K_9421 X_NUC_74.L_CORE X_NUC_151.L_CORE 0.030101
K_9422 X_NUC_74.L_CORE X_NUC_152.L_CORE 0.001772
K_9423 X_NUC_74.L_CORE X_NUC_153.L_CORE 0.002448
K_9424 X_NUC_74.L_CORE X_NUC_154.L_CORE 0.003684
K_9425 X_NUC_74.L_CORE X_NUC_155.L_CORE 0.001690
K_9426 X_NUC_74.L_CORE X_NUC_156.L_CORE 0.005206
K_9427 X_NUC_74.L_CORE X_NUC_157.L_CORE 0.002135
K_9428 X_NUC_74.L_CORE X_NUC_158.L_CORE 0.002010
K_9429 X_NUC_74.L_CORE X_NUC_159.L_CORE 0.005264
K_9430 X_NUC_74.L_CORE X_NUC_160.L_CORE 0.001823
K_9431 X_NUC_74.L_CORE X_NUC_161.L_CORE 0.002910
K_9432 X_NUC_74.L_CORE X_NUC_162.L_CORE 0.002707
K_9433 X_NUC_74.L_CORE X_NUC_163.L_CORE 0.001983
K_9434 X_NUC_74.L_CORE X_NUC_164.L_CORE 0.003286
K_9435 X_NUC_74.L_CORE X_NUC_165.L_CORE 0.002278
K_9436 X_NUC_75.L_CORE X_NUC_76.L_CORE 0.207973
K_9437 X_NUC_75.L_CORE X_NUC_77.L_CORE 0.001864
K_9438 X_NUC_75.L_CORE X_NUC_78.L_CORE 0.001848
K_9439 X_NUC_75.L_CORE X_NUC_79.L_CORE 0.001859
K_9440 X_NUC_75.L_CORE X_NUC_80.L_CORE 0.001853
K_9441 X_NUC_75.L_CORE X_NUC_81.L_CORE 0.002597
K_9442 X_NUC_75.L_CORE X_NUC_82.L_CORE 0.002575
K_9443 X_NUC_75.L_CORE X_NUC_83.L_CORE 0.002572
K_9444 X_NUC_75.L_CORE X_NUC_84.L_CORE 0.002596
K_9445 X_NUC_75.L_CORE X_NUC_85.L_CORE 0.003885
K_9446 X_NUC_75.L_CORE X_NUC_86.L_CORE 0.003852
K_9447 X_NUC_75.L_CORE X_NUC_87.L_CORE 0.003889
K_9448 X_NUC_75.L_CORE X_NUC_88.L_CORE 0.003828
K_9449 X_NUC_75.L_CORE X_NUC_89.L_CORE 0.001782
K_9450 X_NUC_75.L_CORE X_NUC_90.L_CORE 0.001767
K_9451 X_NUC_75.L_CORE X_NUC_91.L_CORE 0.001773
K_9452 X_NUC_75.L_CORE X_NUC_92.L_CORE 0.001774
K_9453 X_NUC_75.L_CORE X_NUC_93.L_CORE 0.005694
K_9454 X_NUC_75.L_CORE X_NUC_94.L_CORE 0.005636
K_9455 X_NUC_75.L_CORE X_NUC_95.L_CORE 0.005554
K_9456 X_NUC_75.L_CORE X_NUC_96.L_CORE 0.005673
K_9457 X_NUC_75.L_CORE X_NUC_97.L_CORE 0.002249
K_9458 X_NUC_75.L_CORE X_NUC_98.L_CORE 0.002230
K_9459 X_NUC_75.L_CORE X_NUC_99.L_CORE 0.002242
K_9460 X_NUC_75.L_CORE X_NUC_100.L_CORE 0.002229
K_9461 X_NUC_75.L_CORE X_NUC_101.L_CORE 0.002128
K_9462 X_NUC_75.L_CORE X_NUC_102.L_CORE 0.002110
K_9463 X_NUC_75.L_CORE X_NUC_103.L_CORE 0.002110
K_9464 X_NUC_75.L_CORE X_NUC_104.L_CORE 0.002120
K_9465 X_NUC_75.L_CORE X_NUC_105.L_CORE 0.005715
K_9466 X_NUC_75.L_CORE X_NUC_106.L_CORE 0.005651
K_9467 X_NUC_75.L_CORE X_NUC_107.L_CORE 0.005632
K_9468 X_NUC_75.L_CORE X_NUC_108.L_CORE 0.005563
K_9469 X_NUC_75.L_CORE X_NUC_109.L_CORE 0.001923
K_9470 X_NUC_75.L_CORE X_NUC_110.L_CORE 0.001907
K_9471 X_NUC_75.L_CORE X_NUC_111.L_CORE 0.001913
K_9472 X_NUC_75.L_CORE X_NUC_112.L_CORE 0.001910
K_9473 X_NUC_75.L_CORE X_NUC_113.L_CORE 0.003113
K_9474 X_NUC_75.L_CORE X_NUC_114.L_CORE 0.003084
K_9475 X_NUC_75.L_CORE X_NUC_115.L_CORE 0.003068
K_9476 X_NUC_75.L_CORE X_NUC_116.L_CORE 0.003093
K_9477 X_NUC_75.L_CORE X_NUC_117.L_CORE 0.002870
K_9478 X_NUC_75.L_CORE X_NUC_118.L_CORE 0.002843
K_9479 X_NUC_75.L_CORE X_NUC_119.L_CORE 0.002851
K_9480 X_NUC_75.L_CORE X_NUC_120.L_CORE 0.002832
K_9481 X_NUC_75.L_CORE X_NUC_121.L_CORE 0.002101
K_9482 X_NUC_75.L_CORE X_NUC_122.L_CORE 0.002082
K_9483 X_NUC_75.L_CORE X_NUC_123.L_CORE 0.002083
K_9484 X_NUC_75.L_CORE X_NUC_124.L_CORE 0.002086
K_9485 X_NUC_75.L_CORE X_NUC_125.L_CORE 0.003528
K_9486 X_NUC_75.L_CORE X_NUC_126.L_CORE 0.003492
K_9487 X_NUC_75.L_CORE X_NUC_127.L_CORE 0.003474
K_9488 X_NUC_75.L_CORE X_NUC_128.L_CORE 0.003479
K_9489 X_NUC_75.L_CORE X_NUC_129.L_CORE 0.002416
K_9490 X_NUC_75.L_CORE X_NUC_130.L_CORE 0.002394
K_9491 X_NUC_75.L_CORE X_NUC_131.L_CORE 0.002396
K_9492 X_NUC_75.L_CORE X_NUC_132.L_CORE 0.002392
K_9493 X_NUC_75.L_CORE X_NUC_133.L_CORE 0.002354
K_9494 X_NUC_75.L_CORE X_NUC_134.L_CORE 0.001860
K_9495 X_NUC_75.L_CORE X_NUC_135.L_CORE 0.002736
K_9496 X_NUC_75.L_CORE X_NUC_136.L_CORE 0.002113
K_9497 X_NUC_75.L_CORE X_NUC_137.L_CORE 0.001891
K_9498 X_NUC_75.L_CORE X_NUC_138.L_CORE 0.003793
K_9499 X_NUC_75.L_CORE X_NUC_139.L_CORE 0.001732
K_9500 X_NUC_75.L_CORE X_NUC_140.L_CORE 0.002545
K_9501 X_NUC_75.L_CORE X_NUC_141.L_CORE 0.002743
K_9502 X_NUC_75.L_CORE X_NUC_142.L_CORE 0.001677
K_9503 X_NUC_75.L_CORE X_NUC_143.L_CORE 0.005421
K_9504 X_NUC_75.L_CORE X_NUC_144.L_CORE 0.001889
K_9505 X_NUC_75.L_CORE X_NUC_145.L_CORE 0.002038
K_9506 X_NUC_75.L_CORE X_NUC_146.L_CORE 0.005034
K_9507 X_NUC_75.L_CORE X_NUC_147.L_CORE 0.001632
K_9508 X_NUC_75.L_CORE X_NUC_148.L_CORE 0.003625
K_9509 X_NUC_75.L_CORE X_NUC_149.L_CORE 0.002393
K_9510 X_NUC_75.L_CORE X_NUC_150.L_CORE 0.001755
K_9511 X_NUC_75.L_CORE X_NUC_151.L_CORE 0.032742
K_9512 X_NUC_75.L_CORE X_NUC_152.L_CORE 0.001763
K_9513 X_NUC_75.L_CORE X_NUC_153.L_CORE 0.002452
K_9514 X_NUC_75.L_CORE X_NUC_154.L_CORE 0.003653
K_9515 X_NUC_75.L_CORE X_NUC_155.L_CORE 0.001686
K_9516 X_NUC_75.L_CORE X_NUC_156.L_CORE 0.005295
K_9517 X_NUC_75.L_CORE X_NUC_157.L_CORE 0.002124
K_9518 X_NUC_75.L_CORE X_NUC_158.L_CORE 0.002010
K_9519 X_NUC_75.L_CORE X_NUC_159.L_CORE 0.005296
K_9520 X_NUC_75.L_CORE X_NUC_160.L_CORE 0.001817
K_9521 X_NUC_75.L_CORE X_NUC_161.L_CORE 0.002928
K_9522 X_NUC_75.L_CORE X_NUC_162.L_CORE 0.002701
K_9523 X_NUC_75.L_CORE X_NUC_163.L_CORE 0.001983
K_9524 X_NUC_75.L_CORE X_NUC_164.L_CORE 0.003307
K_9525 X_NUC_75.L_CORE X_NUC_165.L_CORE 0.002277
K_9526 X_NUC_76.L_CORE X_NUC_77.L_CORE 0.001870
K_9527 X_NUC_76.L_CORE X_NUC_78.L_CORE 0.001854
K_9528 X_NUC_76.L_CORE X_NUC_79.L_CORE 0.001865
K_9529 X_NUC_76.L_CORE X_NUC_80.L_CORE 0.001859
K_9530 X_NUC_76.L_CORE X_NUC_81.L_CORE 0.002573
K_9531 X_NUC_76.L_CORE X_NUC_82.L_CORE 0.002552
K_9532 X_NUC_76.L_CORE X_NUC_83.L_CORE 0.002549
K_9533 X_NUC_76.L_CORE X_NUC_84.L_CORE 0.002572
K_9534 X_NUC_76.L_CORE X_NUC_85.L_CORE 0.003949
K_9535 X_NUC_76.L_CORE X_NUC_86.L_CORE 0.003914
K_9536 X_NUC_76.L_CORE X_NUC_87.L_CORE 0.003953
K_9537 X_NUC_76.L_CORE X_NUC_88.L_CORE 0.003889
K_9538 X_NUC_76.L_CORE X_NUC_89.L_CORE 0.001781
K_9539 X_NUC_76.L_CORE X_NUC_90.L_CORE 0.001766
K_9540 X_NUC_76.L_CORE X_NUC_91.L_CORE 0.001771
K_9541 X_NUC_76.L_CORE X_NUC_92.L_CORE 0.001773
K_9542 X_NUC_76.L_CORE X_NUC_93.L_CORE 0.005572
K_9543 X_NUC_76.L_CORE X_NUC_94.L_CORE 0.005518
K_9544 X_NUC_76.L_CORE X_NUC_95.L_CORE 0.005439
K_9545 X_NUC_76.L_CORE X_NUC_96.L_CORE 0.005554
K_9546 X_NUC_76.L_CORE X_NUC_97.L_CORE 0.002263
K_9547 X_NUC_76.L_CORE X_NUC_98.L_CORE 0.002243
K_9548 X_NUC_76.L_CORE X_NUC_99.L_CORE 0.002256
K_9549 X_NUC_76.L_CORE X_NUC_100.L_CORE 0.002242
K_9550 X_NUC_76.L_CORE X_NUC_101.L_CORE 0.002118
K_9551 X_NUC_76.L_CORE X_NUC_102.L_CORE 0.002100
K_9552 X_NUC_76.L_CORE X_NUC_103.L_CORE 0.002100
K_9553 X_NUC_76.L_CORE X_NUC_104.L_CORE 0.002110
K_9554 X_NUC_76.L_CORE X_NUC_105.L_CORE 0.005787
K_9555 X_NUC_76.L_CORE X_NUC_106.L_CORE 0.005721
K_9556 X_NUC_76.L_CORE X_NUC_107.L_CORE 0.005700
K_9557 X_NUC_76.L_CORE X_NUC_108.L_CORE 0.005632
K_9558 X_NUC_76.L_CORE X_NUC_109.L_CORE 0.001926
K_9559 X_NUC_76.L_CORE X_NUC_110.L_CORE 0.001910
K_9560 X_NUC_76.L_CORE X_NUC_111.L_CORE 0.001915
K_9561 X_NUC_76.L_CORE X_NUC_112.L_CORE 0.001913
K_9562 X_NUC_76.L_CORE X_NUC_113.L_CORE 0.003087
K_9563 X_NUC_76.L_CORE X_NUC_114.L_CORE 0.003058
K_9564 X_NUC_76.L_CORE X_NUC_115.L_CORE 0.003043
K_9565 X_NUC_76.L_CORE X_NUC_116.L_CORE 0.003068
K_9566 X_NUC_76.L_CORE X_NUC_117.L_CORE 0.002890
K_9567 X_NUC_76.L_CORE X_NUC_118.L_CORE 0.002863
K_9568 X_NUC_76.L_CORE X_NUC_119.L_CORE 0.002870
K_9569 X_NUC_76.L_CORE X_NUC_120.L_CORE 0.002851
K_9570 X_NUC_76.L_CORE X_NUC_121.L_CORE 0.002097
K_9571 X_NUC_76.L_CORE X_NUC_122.L_CORE 0.002079
K_9572 X_NUC_76.L_CORE X_NUC_123.L_CORE 0.002080
K_9573 X_NUC_76.L_CORE X_NUC_124.L_CORE 0.002083
K_9574 X_NUC_76.L_CORE X_NUC_125.L_CORE 0.003522
K_9575 X_NUC_76.L_CORE X_NUC_126.L_CORE 0.003487
K_9576 X_NUC_76.L_CORE X_NUC_127.L_CORE 0.003468
K_9577 X_NUC_76.L_CORE X_NUC_128.L_CORE 0.003474
K_9578 X_NUC_76.L_CORE X_NUC_129.L_CORE 0.002420
K_9579 X_NUC_76.L_CORE X_NUC_130.L_CORE 0.002398
K_9580 X_NUC_76.L_CORE X_NUC_131.L_CORE 0.002399
K_9581 X_NUC_76.L_CORE X_NUC_132.L_CORE 0.002396
K_9582 X_NUC_76.L_CORE X_NUC_133.L_CORE 0.002357
K_9583 X_NUC_76.L_CORE X_NUC_134.L_CORE 0.001860
K_9584 X_NUC_76.L_CORE X_NUC_135.L_CORE 0.002726
K_9585 X_NUC_76.L_CORE X_NUC_136.L_CORE 0.002122
K_9586 X_NUC_76.L_CORE X_NUC_137.L_CORE 0.001885
K_9587 X_NUC_76.L_CORE X_NUC_138.L_CORE 0.003806
K_9588 X_NUC_76.L_CORE X_NUC_139.L_CORE 0.001736
K_9589 X_NUC_76.L_CORE X_NUC_140.L_CORE 0.002525
K_9590 X_NUC_76.L_CORE X_NUC_141.L_CORE 0.002768
K_9591 X_NUC_76.L_CORE X_NUC_142.L_CORE 0.001675
K_9592 X_NUC_76.L_CORE X_NUC_143.L_CORE 0.005344
K_9593 X_NUC_76.L_CORE X_NUC_144.L_CORE 0.001898
K_9594 X_NUC_76.L_CORE X_NUC_145.L_CORE 0.002025
K_9595 X_NUC_76.L_CORE X_NUC_146.L_CORE 0.005141
K_9596 X_NUC_76.L_CORE X_NUC_147.L_CORE 0.001633
K_9597 X_NUC_76.L_CORE X_NUC_148.L_CORE 0.003568
K_9598 X_NUC_76.L_CORE X_NUC_149.L_CORE 0.002414
K_9599 X_NUC_76.L_CORE X_NUC_150.L_CORE 0.001750
K_9600 X_NUC_76.L_CORE X_NUC_151.L_CORE 0.032755
K_9601 X_NUC_76.L_CORE X_NUC_152.L_CORE 0.001769
K_9602 X_NUC_76.L_CORE X_NUC_153.L_CORE 0.002431
K_9603 X_NUC_76.L_CORE X_NUC_154.L_CORE 0.003712
K_9604 X_NUC_76.L_CORE X_NUC_155.L_CORE 0.001684
K_9605 X_NUC_76.L_CORE X_NUC_156.L_CORE 0.005187
K_9606 X_NUC_76.L_CORE X_NUC_157.L_CORE 0.002137
K_9607 X_NUC_76.L_CORE X_NUC_158.L_CORE 0.002001
K_9608 X_NUC_76.L_CORE X_NUC_159.L_CORE 0.005360
K_9609 X_NUC_76.L_CORE X_NUC_160.L_CORE 0.001820
K_9610 X_NUC_76.L_CORE X_NUC_161.L_CORE 0.002904
K_9611 X_NUC_76.L_CORE X_NUC_162.L_CORE 0.002720
K_9612 X_NUC_76.L_CORE X_NUC_163.L_CORE 0.001980
K_9613 X_NUC_76.L_CORE X_NUC_164.L_CORE 0.003302
K_9614 X_NUC_76.L_CORE X_NUC_165.L_CORE 0.002281
K_9615 X_NUC_77.L_CORE X_NUC_78.L_CORE 0.207973
K_9616 X_NUC_77.L_CORE X_NUC_79.L_CORE 0.207973
K_9617 X_NUC_77.L_CORE X_NUC_80.L_CORE 0.207973
K_9618 X_NUC_77.L_CORE X_NUC_81.L_CORE 0.001880
K_9619 X_NUC_77.L_CORE X_NUC_82.L_CORE 0.001888
K_9620 X_NUC_77.L_CORE X_NUC_83.L_CORE 0.001876
K_9621 X_NUC_77.L_CORE X_NUC_84.L_CORE 0.001891
K_9622 X_NUC_77.L_CORE X_NUC_85.L_CORE 0.002607
K_9623 X_NUC_77.L_CORE X_NUC_86.L_CORE 0.002640
K_9624 X_NUC_77.L_CORE X_NUC_87.L_CORE 0.002622
K_9625 X_NUC_77.L_CORE X_NUC_88.L_CORE 0.002620
K_9626 X_NUC_77.L_CORE X_NUC_89.L_CORE 0.003947
K_9627 X_NUC_77.L_CORE X_NUC_90.L_CORE 0.003930
K_9628 X_NUC_77.L_CORE X_NUC_91.L_CORE 0.003892
K_9629 X_NUC_77.L_CORE X_NUC_92.L_CORE 0.003962
K_9630 X_NUC_77.L_CORE X_NUC_93.L_CORE 0.001805
K_9631 X_NUC_77.L_CORE X_NUC_94.L_CORE 0.001818
K_9632 X_NUC_77.L_CORE X_NUC_95.L_CORE 0.001805
K_9633 X_NUC_77.L_CORE X_NUC_96.L_CORE 0.001815
K_9634 X_NUC_77.L_CORE X_NUC_97.L_CORE 0.005612
K_9635 X_NUC_77.L_CORE X_NUC_98.L_CORE 0.005738
K_9636 X_NUC_77.L_CORE X_NUC_99.L_CORE 0.005642
K_9637 X_NUC_77.L_CORE X_NUC_100.L_CORE 0.005596
K_9638 X_NUC_77.L_CORE X_NUC_101.L_CORE 0.002294
K_9639 X_NUC_77.L_CORE X_NUC_102.L_CORE 0.002299
K_9640 X_NUC_77.L_CORE X_NUC_103.L_CORE 0.002280
K_9641 X_NUC_77.L_CORE X_NUC_104.L_CORE 0.002304
K_9642 X_NUC_77.L_CORE X_NUC_105.L_CORE 0.002166
K_9643 X_NUC_77.L_CORE X_NUC_106.L_CORE 0.002187
K_9644 X_NUC_77.L_CORE X_NUC_107.L_CORE 0.002169
K_9645 X_NUC_77.L_CORE X_NUC_108.L_CORE 0.002175
K_9646 X_NUC_77.L_CORE X_NUC_109.L_CORE 0.005551
K_9647 X_NUC_77.L_CORE X_NUC_110.L_CORE 0.005558
K_9648 X_NUC_77.L_CORE X_NUC_111.L_CORE 0.005430
K_9649 X_NUC_77.L_CORE X_NUC_112.L_CORE 0.005517
K_9650 X_NUC_77.L_CORE X_NUC_113.L_CORE 0.001983
K_9651 X_NUC_77.L_CORE X_NUC_114.L_CORE 0.001994
K_9652 X_NUC_77.L_CORE X_NUC_115.L_CORE 0.001977
K_9653 X_NUC_77.L_CORE X_NUC_116.L_CORE 0.001991
K_9654 X_NUC_77.L_CORE X_NUC_117.L_CORE 0.003126
K_9655 X_NUC_77.L_CORE X_NUC_118.L_CORE 0.003166
K_9656 X_NUC_77.L_CORE X_NUC_119.L_CORE 0.003125
K_9657 X_NUC_77.L_CORE X_NUC_120.L_CORE 0.003129
K_9658 X_NUC_77.L_CORE X_NUC_121.L_CORE 0.002916
K_9659 X_NUC_77.L_CORE X_NUC_122.L_CORE 0.002925
K_9660 X_NUC_77.L_CORE X_NUC_123.L_CORE 0.002888
K_9661 X_NUC_77.L_CORE X_NUC_124.L_CORE 0.002920
K_9662 X_NUC_77.L_CORE X_NUC_125.L_CORE 0.002221
K_9663 X_NUC_77.L_CORE X_NUC_126.L_CORE 0.002238
K_9664 X_NUC_77.L_CORE X_NUC_127.L_CORE 0.002216
K_9665 X_NUC_77.L_CORE X_NUC_128.L_CORE 0.002227
K_9666 X_NUC_77.L_CORE X_NUC_129.L_CORE 0.003155
K_9667 X_NUC_77.L_CORE X_NUC_130.L_CORE 0.003181
K_9668 X_NUC_77.L_CORE X_NUC_131.L_CORE 0.003133
K_9669 X_NUC_77.L_CORE X_NUC_132.L_CORE 0.003154
K_9670 X_NUC_77.L_CORE X_NUC_133.L_CORE 0.002122
K_9671 X_NUC_77.L_CORE X_NUC_134.L_CORE 0.002468
K_9672 X_NUC_77.L_CORE X_NUC_135.L_CORE 0.001786
K_9673 X_NUC_77.L_CORE X_NUC_136.L_CORE 0.002805
K_9674 X_NUC_77.L_CORE X_NUC_137.L_CORE 0.002089
K_9675 X_NUC_77.L_CORE X_NUC_138.L_CORE 0.001862
K_9676 X_NUC_77.L_CORE X_NUC_139.L_CORE 0.003911
K_9677 X_NUC_77.L_CORE X_NUC_140.L_CORE 0.001715
K_9678 X_NUC_77.L_CORE X_NUC_141.L_CORE 0.002539
K_9679 X_NUC_77.L_CORE X_NUC_142.L_CORE 0.002748
K_9680 X_NUC_77.L_CORE X_NUC_143.L_CORE 0.001671
K_9681 X_NUC_77.L_CORE X_NUC_144.L_CORE 0.005502
K_9682 X_NUC_77.L_CORE X_NUC_145.L_CORE 0.001892
K_9683 X_NUC_77.L_CORE X_NUC_146.L_CORE 0.002041
K_9684 X_NUC_77.L_CORE X_NUC_147.L_CORE 0.005096
K_9685 X_NUC_77.L_CORE X_NUC_148.L_CORE 0.001641
K_9686 X_NUC_77.L_CORE X_NUC_149.L_CORE 0.003645
K_9687 X_NUC_77.L_CORE X_NUC_150.L_CORE 0.002418
K_9688 X_NUC_77.L_CORE X_NUC_151.L_CORE 0.001773
K_9689 X_NUC_77.L_CORE X_NUC_152.L_CORE 0.030558
K_9690 X_NUC_77.L_CORE X_NUC_153.L_CORE 0.001789
K_9691 X_NUC_77.L_CORE X_NUC_154.L_CORE 0.002487
K_9692 X_NUC_77.L_CORE X_NUC_155.L_CORE 0.003714
K_9693 X_NUC_77.L_CORE X_NUC_156.L_CORE 0.001720
K_9694 X_NUC_77.L_CORE X_NUC_157.L_CORE 0.005292
K_9695 X_NUC_77.L_CORE X_NUC_158.L_CORE 0.002177
K_9696 X_NUC_77.L_CORE X_NUC_159.L_CORE 0.002064
K_9697 X_NUC_77.L_CORE X_NUC_160.L_CORE 0.005171
K_9698 X_NUC_77.L_CORE X_NUC_161.L_CORE 0.001886
K_9699 X_NUC_77.L_CORE X_NUC_162.L_CORE 0.002970
K_9700 X_NUC_77.L_CORE X_NUC_163.L_CORE 0.002759
K_9701 X_NUC_77.L_CORE X_NUC_164.L_CORE 0.002112
K_9702 X_NUC_77.L_CORE X_NUC_165.L_CORE 0.002988
K_9703 X_NUC_78.L_CORE X_NUC_79.L_CORE 0.207973
K_9704 X_NUC_78.L_CORE X_NUC_80.L_CORE 0.207973
K_9705 X_NUC_78.L_CORE X_NUC_81.L_CORE 0.001872
K_9706 X_NUC_78.L_CORE X_NUC_82.L_CORE 0.001880
K_9707 X_NUC_78.L_CORE X_NUC_83.L_CORE 0.001868
K_9708 X_NUC_78.L_CORE X_NUC_84.L_CORE 0.001883
K_9709 X_NUC_78.L_CORE X_NUC_85.L_CORE 0.002575
K_9710 X_NUC_78.L_CORE X_NUC_86.L_CORE 0.002607
K_9711 X_NUC_78.L_CORE X_NUC_87.L_CORE 0.002590
K_9712 X_NUC_78.L_CORE X_NUC_88.L_CORE 0.002587
K_9713 X_NUC_78.L_CORE X_NUC_89.L_CORE 0.003962
K_9714 X_NUC_78.L_CORE X_NUC_90.L_CORE 0.003947
K_9715 X_NUC_78.L_CORE X_NUC_91.L_CORE 0.003908
K_9716 X_NUC_78.L_CORE X_NUC_92.L_CORE 0.003979
K_9717 X_NUC_78.L_CORE X_NUC_93.L_CORE 0.001793
K_9718 X_NUC_78.L_CORE X_NUC_94.L_CORE 0.001805
K_9719 X_NUC_78.L_CORE X_NUC_95.L_CORE 0.001793
K_9720 X_NUC_78.L_CORE X_NUC_96.L_CORE 0.001802
K_9721 X_NUC_78.L_CORE X_NUC_97.L_CORE 0.005491
K_9722 X_NUC_78.L_CORE X_NUC_98.L_CORE 0.005612
K_9723 X_NUC_78.L_CORE X_NUC_99.L_CORE 0.005520
K_9724 X_NUC_78.L_CORE X_NUC_100.L_CORE 0.005478
K_9725 X_NUC_78.L_CORE X_NUC_101.L_CORE 0.002288
K_9726 X_NUC_78.L_CORE X_NUC_102.L_CORE 0.002294
K_9727 X_NUC_78.L_CORE X_NUC_103.L_CORE 0.002275
K_9728 X_NUC_78.L_CORE X_NUC_104.L_CORE 0.002298
K_9729 X_NUC_78.L_CORE X_NUC_105.L_CORE 0.002145
K_9730 X_NUC_78.L_CORE X_NUC_106.L_CORE 0.002166
K_9731 X_NUC_78.L_CORE X_NUC_107.L_CORE 0.002148
K_9732 X_NUC_78.L_CORE X_NUC_108.L_CORE 0.002154
K_9733 X_NUC_78.L_CORE X_NUC_109.L_CORE 0.005540
K_9734 X_NUC_78.L_CORE X_NUC_110.L_CORE 0.005551
K_9735 X_NUC_78.L_CORE X_NUC_111.L_CORE 0.005422
K_9736 X_NUC_78.L_CORE X_NUC_112.L_CORE 0.005509
K_9737 X_NUC_78.L_CORE X_NUC_113.L_CORE 0.001972
K_9738 X_NUC_78.L_CORE X_NUC_114.L_CORE 0.001983
K_9739 X_NUC_78.L_CORE X_NUC_115.L_CORE 0.001966
K_9740 X_NUC_78.L_CORE X_NUC_116.L_CORE 0.001980
K_9741 X_NUC_78.L_CORE X_NUC_117.L_CORE 0.003088
K_9742 X_NUC_78.L_CORE X_NUC_118.L_CORE 0.003126
K_9743 X_NUC_78.L_CORE X_NUC_119.L_CORE 0.003087
K_9744 X_NUC_78.L_CORE X_NUC_120.L_CORE 0.003090
K_9745 X_NUC_78.L_CORE X_NUC_121.L_CORE 0.002906
K_9746 X_NUC_78.L_CORE X_NUC_122.L_CORE 0.002916
K_9747 X_NUC_78.L_CORE X_NUC_123.L_CORE 0.002879
K_9748 X_NUC_78.L_CORE X_NUC_124.L_CORE 0.002910
K_9749 X_NUC_78.L_CORE X_NUC_125.L_CORE 0.002204
K_9750 X_NUC_78.L_CORE X_NUC_126.L_CORE 0.002221
K_9751 X_NUC_78.L_CORE X_NUC_127.L_CORE 0.002199
K_9752 X_NUC_78.L_CORE X_NUC_128.L_CORE 0.002210
K_9753 X_NUC_78.L_CORE X_NUC_129.L_CORE 0.003130
K_9754 X_NUC_78.L_CORE X_NUC_130.L_CORE 0.003155
K_9755 X_NUC_78.L_CORE X_NUC_131.L_CORE 0.003108
K_9756 X_NUC_78.L_CORE X_NUC_132.L_CORE 0.003128
K_9757 X_NUC_78.L_CORE X_NUC_133.L_CORE 0.002110
K_9758 X_NUC_78.L_CORE X_NUC_134.L_CORE 0.002462
K_9759 X_NUC_78.L_CORE X_NUC_135.L_CORE 0.001777
K_9760 X_NUC_78.L_CORE X_NUC_136.L_CORE 0.002785
K_9761 X_NUC_78.L_CORE X_NUC_137.L_CORE 0.002085
K_9762 X_NUC_78.L_CORE X_NUC_138.L_CORE 0.001848
K_9763 X_NUC_78.L_CORE X_NUC_139.L_CORE 0.003914
K_9764 X_NUC_78.L_CORE X_NUC_140.L_CORE 0.001708
K_9765 X_NUC_78.L_CORE X_NUC_141.L_CORE 0.002513
K_9766 X_NUC_78.L_CORE X_NUC_142.L_CORE 0.002754
K_9767 X_NUC_78.L_CORE X_NUC_143.L_CORE 0.001660
K_9768 X_NUC_78.L_CORE X_NUC_144.L_CORE 0.005447
K_9769 X_NUC_78.L_CORE X_NUC_145.L_CORE 0.001888
K_9770 X_NUC_78.L_CORE X_NUC_146.L_CORE 0.002021
K_9771 X_NUC_78.L_CORE X_NUC_147.L_CORE 0.005163
K_9772 X_NUC_78.L_CORE X_NUC_148.L_CORE 0.001633
K_9773 X_NUC_78.L_CORE X_NUC_149.L_CORE 0.003590
K_9774 X_NUC_78.L_CORE X_NUC_150.L_CORE 0.002419
K_9775 X_NUC_78.L_CORE X_NUC_151.L_CORE 0.001759
K_9776 X_NUC_78.L_CORE X_NUC_152.L_CORE 0.034159
K_9777 X_NUC_78.L_CORE X_NUC_153.L_CORE 0.001782
K_9778 X_NUC_78.L_CORE X_NUC_154.L_CORE 0.002458
K_9779 X_NUC_78.L_CORE X_NUC_155.L_CORE 0.003735
K_9780 X_NUC_78.L_CORE X_NUC_156.L_CORE 0.001709
K_9781 X_NUC_78.L_CORE X_NUC_157.L_CORE 0.005196
K_9782 X_NUC_78.L_CORE X_NUC_158.L_CORE 0.002173
K_9783 X_NUC_78.L_CORE X_NUC_159.L_CORE 0.002045
K_9784 X_NUC_78.L_CORE X_NUC_160.L_CORE 0.005178
K_9785 X_NUC_78.L_CORE X_NUC_161.L_CORE 0.001876
K_9786 X_NUC_78.L_CORE X_NUC_162.L_CORE 0.002936
K_9787 X_NUC_78.L_CORE X_NUC_163.L_CORE 0.002753
K_9788 X_NUC_78.L_CORE X_NUC_164.L_CORE 0.002097
K_9789 X_NUC_78.L_CORE X_NUC_165.L_CORE 0.002967
K_9790 X_NUC_79.L_CORE X_NUC_80.L_CORE 0.207973
K_9791 X_NUC_79.L_CORE X_NUC_81.L_CORE 0.001884
K_9792 X_NUC_79.L_CORE X_NUC_82.L_CORE 0.001892
K_9793 X_NUC_79.L_CORE X_NUC_83.L_CORE 0.001880
K_9794 X_NUC_79.L_CORE X_NUC_84.L_CORE 0.001895
K_9795 X_NUC_79.L_CORE X_NUC_85.L_CORE 0.002592
K_9796 X_NUC_79.L_CORE X_NUC_86.L_CORE 0.002624
K_9797 X_NUC_79.L_CORE X_NUC_87.L_CORE 0.002607
K_9798 X_NUC_79.L_CORE X_NUC_88.L_CORE 0.002604
K_9799 X_NUC_79.L_CORE X_NUC_89.L_CORE 0.004002
K_9800 X_NUC_79.L_CORE X_NUC_90.L_CORE 0.003985
K_9801 X_NUC_79.L_CORE X_NUC_91.L_CORE 0.003947
K_9802 X_NUC_79.L_CORE X_NUC_92.L_CORE 0.004019
K_9803 X_NUC_79.L_CORE X_NUC_93.L_CORE 0.001805
K_9804 X_NUC_79.L_CORE X_NUC_94.L_CORE 0.001818
K_9805 X_NUC_79.L_CORE X_NUC_95.L_CORE 0.001805
K_9806 X_NUC_79.L_CORE X_NUC_96.L_CORE 0.001815
K_9807 X_NUC_79.L_CORE X_NUC_97.L_CORE 0.005580
K_9808 X_NUC_79.L_CORE X_NUC_98.L_CORE 0.005705
K_9809 X_NUC_79.L_CORE X_NUC_99.L_CORE 0.005612
K_9810 X_NUC_79.L_CORE X_NUC_100.L_CORE 0.005566
K_9811 X_NUC_79.L_CORE X_NUC_101.L_CORE 0.002307
K_9812 X_NUC_79.L_CORE X_NUC_102.L_CORE 0.002313
K_9813 X_NUC_79.L_CORE X_NUC_103.L_CORE 0.002294
K_9814 X_NUC_79.L_CORE X_NUC_104.L_CORE 0.002318
K_9815 X_NUC_79.L_CORE X_NUC_105.L_CORE 0.002162
K_9816 X_NUC_79.L_CORE X_NUC_106.L_CORE 0.002184
K_9817 X_NUC_79.L_CORE X_NUC_107.L_CORE 0.002166
K_9818 X_NUC_79.L_CORE X_NUC_108.L_CORE 0.002171
K_9819 X_NUC_79.L_CORE X_NUC_109.L_CORE 0.005677
K_9820 X_NUC_79.L_CORE X_NUC_110.L_CORE 0.005686
K_9821 X_NUC_79.L_CORE X_NUC_111.L_CORE 0.005551
K_9822 X_NUC_79.L_CORE X_NUC_112.L_CORE 0.005643
K_9823 X_NUC_79.L_CORE X_NUC_113.L_CORE 0.001989
K_9824 X_NUC_79.L_CORE X_NUC_114.L_CORE 0.002000
K_9825 X_NUC_79.L_CORE X_NUC_115.L_CORE 0.001983
K_9826 X_NUC_79.L_CORE X_NUC_116.L_CORE 0.001997
K_9827 X_NUC_79.L_CORE X_NUC_117.L_CORE 0.003126
K_9828 X_NUC_79.L_CORE X_NUC_118.L_CORE 0.003166
K_9829 X_NUC_79.L_CORE X_NUC_119.L_CORE 0.003126
K_9830 X_NUC_79.L_CORE X_NUC_120.L_CORE 0.003129
K_9831 X_NUC_79.L_CORE X_NUC_121.L_CORE 0.002944
K_9832 X_NUC_79.L_CORE X_NUC_122.L_CORE 0.002953
K_9833 X_NUC_79.L_CORE X_NUC_123.L_CORE 0.002916
K_9834 X_NUC_79.L_CORE X_NUC_124.L_CORE 0.002948
K_9835 X_NUC_79.L_CORE X_NUC_125.L_CORE 0.002226
K_9836 X_NUC_79.L_CORE X_NUC_126.L_CORE 0.002243
K_9837 X_NUC_79.L_CORE X_NUC_127.L_CORE 0.002221
K_9838 X_NUC_79.L_CORE X_NUC_128.L_CORE 0.002232
K_9839 X_NUC_79.L_CORE X_NUC_129.L_CORE 0.003177
K_9840 X_NUC_79.L_CORE X_NUC_130.L_CORE 0.003204
K_9841 X_NUC_79.L_CORE X_NUC_131.L_CORE 0.003155
K_9842 X_NUC_79.L_CORE X_NUC_132.L_CORE 0.003176
K_9843 X_NUC_79.L_CORE X_NUC_133.L_CORE 0.002107
K_9844 X_NUC_79.L_CORE X_NUC_134.L_CORE 0.002455
K_9845 X_NUC_79.L_CORE X_NUC_135.L_CORE 0.001779
K_9846 X_NUC_79.L_CORE X_NUC_136.L_CORE 0.002772
K_9847 X_NUC_79.L_CORE X_NUC_137.L_CORE 0.002086
K_9848 X_NUC_79.L_CORE X_NUC_138.L_CORE 0.001851
K_9849 X_NUC_79.L_CORE X_NUC_139.L_CORE 0.003872
K_9850 X_NUC_79.L_CORE X_NUC_140.L_CORE 0.001713
K_9851 X_NUC_79.L_CORE X_NUC_141.L_CORE 0.002512
K_9852 X_NUC_79.L_CORE X_NUC_142.L_CORE 0.002753
K_9853 X_NUC_79.L_CORE X_NUC_143.L_CORE 0.001666
K_9854 X_NUC_79.L_CORE X_NUC_144.L_CORE 0.005362
K_9855 X_NUC_79.L_CORE X_NUC_145.L_CORE 0.001895
K_9856 X_NUC_79.L_CORE X_NUC_146.L_CORE 0.002028
K_9857 X_NUC_79.L_CORE X_NUC_147.L_CORE 0.005131
K_9858 X_NUC_79.L_CORE X_NUC_148.L_CORE 0.001641
K_9859 X_NUC_79.L_CORE X_NUC_149.L_CORE 0.003594
K_9860 X_NUC_79.L_CORE X_NUC_150.L_CORE 0.002431
K_9861 X_NUC_79.L_CORE X_NUC_151.L_CORE 0.001768
K_9862 X_NUC_79.L_CORE X_NUC_152.L_CORE 0.031256
K_9863 X_NUC_79.L_CORE X_NUC_153.L_CORE 0.001793
K_9864 X_NUC_79.L_CORE X_NUC_154.L_CORE 0.002472
K_9865 X_NUC_79.L_CORE X_NUC_155.L_CORE 0.003767
K_9866 X_NUC_79.L_CORE X_NUC_156.L_CORE 0.001720
K_9867 X_NUC_79.L_CORE X_NUC_157.L_CORE 0.005267
K_9868 X_NUC_79.L_CORE X_NUC_158.L_CORE 0.002190
K_9869 X_NUC_79.L_CORE X_NUC_159.L_CORE 0.002061
K_9870 X_NUC_79.L_CORE X_NUC_160.L_CORE 0.005289
K_9871 X_NUC_79.L_CORE X_NUC_161.L_CORE 0.001892
K_9872 X_NUC_79.L_CORE X_NUC_162.L_CORE 0.002971
K_9873 X_NUC_79.L_CORE X_NUC_163.L_CORE 0.002786
K_9874 X_NUC_79.L_CORE X_NUC_164.L_CORE 0.002117
K_9875 X_NUC_79.L_CORE X_NUC_165.L_CORE 0.003010
K_9876 X_NUC_80.L_CORE X_NUC_81.L_CORE 0.001869
K_9877 X_NUC_80.L_CORE X_NUC_82.L_CORE 0.001877
K_9878 X_NUC_80.L_CORE X_NUC_83.L_CORE 0.001865
K_9879 X_NUC_80.L_CORE X_NUC_84.L_CORE 0.001880
K_9880 X_NUC_80.L_CORE X_NUC_85.L_CORE 0.002594
K_9881 X_NUC_80.L_CORE X_NUC_86.L_CORE 0.002627
K_9882 X_NUC_80.L_CORE X_NUC_87.L_CORE 0.002609
K_9883 X_NUC_80.L_CORE X_NUC_88.L_CORE 0.002607
K_9884 X_NUC_80.L_CORE X_NUC_89.L_CORE 0.003930
K_9885 X_NUC_80.L_CORE X_NUC_90.L_CORE 0.003914
K_9886 X_NUC_80.L_CORE X_NUC_91.L_CORE 0.003877
K_9887 X_NUC_80.L_CORE X_NUC_92.L_CORE 0.003947
K_9888 X_NUC_80.L_CORE X_NUC_93.L_CORE 0.001796
K_9889 X_NUC_80.L_CORE X_NUC_94.L_CORE 0.001808
K_9890 X_NUC_80.L_CORE X_NUC_95.L_CORE 0.001796
K_9891 X_NUC_80.L_CORE X_NUC_96.L_CORE 0.001805
K_9892 X_NUC_80.L_CORE X_NUC_97.L_CORE 0.005624
K_9893 X_NUC_80.L_CORE X_NUC_98.L_CORE 0.005753
K_9894 X_NUC_80.L_CORE X_NUC_99.L_CORE 0.005656
K_9895 X_NUC_80.L_CORE X_NUC_100.L_CORE 0.005612
K_9896 X_NUC_80.L_CORE X_NUC_101.L_CORE 0.002283
K_9897 X_NUC_80.L_CORE X_NUC_102.L_CORE 0.002289
K_9898 X_NUC_80.L_CORE X_NUC_103.L_CORE 0.002270
K_9899 X_NUC_80.L_CORE X_NUC_104.L_CORE 0.002294
K_9900 X_NUC_80.L_CORE X_NUC_105.L_CORE 0.002157
K_9901 X_NUC_80.L_CORE X_NUC_106.L_CORE 0.002178
K_9902 X_NUC_80.L_CORE X_NUC_107.L_CORE 0.002160
K_9903 X_NUC_80.L_CORE X_NUC_108.L_CORE 0.002166
K_9904 X_NUC_80.L_CORE X_NUC_109.L_CORE 0.005582
K_9905 X_NUC_80.L_CORE X_NUC_110.L_CORE 0.005591
K_9906 X_NUC_80.L_CORE X_NUC_111.L_CORE 0.005460
K_9907 X_NUC_80.L_CORE X_NUC_112.L_CORE 0.005551
K_9908 X_NUC_80.L_CORE X_NUC_113.L_CORE 0.001975
K_9909 X_NUC_80.L_CORE X_NUC_114.L_CORE 0.001986
K_9910 X_NUC_80.L_CORE X_NUC_115.L_CORE 0.001969
K_9911 X_NUC_80.L_CORE X_NUC_116.L_CORE 0.001983
K_9912 X_NUC_80.L_CORE X_NUC_117.L_CORE 0.003123
K_9913 X_NUC_80.L_CORE X_NUC_118.L_CORE 0.003163
K_9914 X_NUC_80.L_CORE X_NUC_119.L_CORE 0.003123
K_9915 X_NUC_80.L_CORE X_NUC_120.L_CORE 0.003126
K_9916 X_NUC_80.L_CORE X_NUC_121.L_CORE 0.002911
K_9917 X_NUC_80.L_CORE X_NUC_122.L_CORE 0.002920
K_9918 X_NUC_80.L_CORE X_NUC_123.L_CORE 0.002883
K_9919 X_NUC_80.L_CORE X_NUC_124.L_CORE 0.002916
K_9920 X_NUC_80.L_CORE X_NUC_125.L_CORE 0.002214
K_9921 X_NUC_80.L_CORE X_NUC_126.L_CORE 0.002232
K_9922 X_NUC_80.L_CORE X_NUC_127.L_CORE 0.002209
K_9923 X_NUC_80.L_CORE X_NUC_128.L_CORE 0.002221
K_9924 X_NUC_80.L_CORE X_NUC_129.L_CORE 0.003157
K_9925 X_NUC_80.L_CORE X_NUC_130.L_CORE 0.003183
K_9926 X_NUC_80.L_CORE X_NUC_131.L_CORE 0.003135
K_9927 X_NUC_80.L_CORE X_NUC_132.L_CORE 0.003155
K_9928 X_NUC_80.L_CORE X_NUC_133.L_CORE 0.002101
K_9929 X_NUC_80.L_CORE X_NUC_134.L_CORE 0.002441
K_9930 X_NUC_80.L_CORE X_NUC_135.L_CORE 0.001771
K_9931 X_NUC_80.L_CORE X_NUC_136.L_CORE 0.002772
K_9932 X_NUC_80.L_CORE X_NUC_137.L_CORE 0.002070
K_9933 X_NUC_80.L_CORE X_NUC_138.L_CORE 0.001847
K_9934 X_NUC_80.L_CORE X_NUC_139.L_CORE 0.003854
K_9935 X_NUC_80.L_CORE X_NUC_140.L_CORE 0.001702
K_9936 X_NUC_80.L_CORE X_NUC_141.L_CORE 0.002517
K_9937 X_NUC_80.L_CORE X_NUC_142.L_CORE 0.002723
K_9938 X_NUC_80.L_CORE X_NUC_143.L_CORE 0.001659
K_9939 X_NUC_80.L_CORE X_NUC_144.L_CORE 0.005422
K_9940 X_NUC_80.L_CORE X_NUC_145.L_CORE 0.001879
K_9941 X_NUC_80.L_CORE X_NUC_146.L_CORE 0.002027
K_9942 X_NUC_80.L_CORE X_NUC_147.L_CORE 0.005044
K_9943 X_NUC_80.L_CORE X_NUC_148.L_CORE 0.001631
K_9944 X_NUC_80.L_CORE X_NUC_149.L_CORE 0.003623
K_9945 X_NUC_80.L_CORE X_NUC_150.L_CORE 0.002403
K_9946 X_NUC_80.L_CORE X_NUC_151.L_CORE 0.001763
K_9947 X_NUC_80.L_CORE X_NUC_152.L_CORE 0.034739
K_9948 X_NUC_80.L_CORE X_NUC_153.L_CORE 0.001779
K_9949 X_NUC_80.L_CORE X_NUC_154.L_CORE 0.002476
K_9950 X_NUC_80.L_CORE X_NUC_155.L_CORE 0.003705
K_9951 X_NUC_80.L_CORE X_NUC_156.L_CORE 0.001712
K_9952 X_NUC_80.L_CORE X_NUC_157.L_CORE 0.005323
K_9953 X_NUC_80.L_CORE X_NUC_158.L_CORE 0.002169
K_9954 X_NUC_80.L_CORE X_NUC_159.L_CORE 0.002056
K_9955 X_NUC_80.L_CORE X_NUC_160.L_CORE 0.005217
K_9956 X_NUC_80.L_CORE X_NUC_161.L_CORE 0.001879
K_9957 X_NUC_80.L_CORE X_NUC_162.L_CORE 0.002971
K_9958 X_NUC_80.L_CORE X_NUC_163.L_CORE 0.002758
K_9959 X_NUC_80.L_CORE X_NUC_164.L_CORE 0.002107
K_9960 X_NUC_80.L_CORE X_NUC_165.L_CORE 0.002993
K_9961 X_NUC_81.L_CORE X_NUC_82.L_CORE 0.207973
K_9962 X_NUC_81.L_CORE X_NUC_83.L_CORE 0.207973
K_9963 X_NUC_81.L_CORE X_NUC_84.L_CORE 0.207973
K_9964 X_NUC_81.L_CORE X_NUC_85.L_CORE 0.001910
K_9965 X_NUC_81.L_CORE X_NUC_86.L_CORE 0.001914
K_9966 X_NUC_81.L_CORE X_NUC_87.L_CORE 0.001920
K_9967 X_NUC_81.L_CORE X_NUC_88.L_CORE 0.001903
K_9968 X_NUC_81.L_CORE X_NUC_89.L_CORE 0.002654
K_9969 X_NUC_81.L_CORE X_NUC_90.L_CORE 0.002628
K_9970 X_NUC_81.L_CORE X_NUC_91.L_CORE 0.002649
K_9971 X_NUC_81.L_CORE X_NUC_92.L_CORE 0.002628
K_9972 X_NUC_81.L_CORE X_NUC_93.L_CORE 0.004022
K_9973 X_NUC_81.L_CORE X_NUC_94.L_CORE 0.004084
K_9974 X_NUC_81.L_CORE X_NUC_95.L_CORE 0.004063
K_9975 X_NUC_81.L_CORE X_NUC_96.L_CORE 0.004018
K_9976 X_NUC_81.L_CORE X_NUC_97.L_CORE 0.001848
K_9977 X_NUC_81.L_CORE X_NUC_98.L_CORE 0.001845
K_9978 X_NUC_81.L_CORE X_NUC_99.L_CORE 0.001853
K_9979 X_NUC_81.L_CORE X_NUC_100.L_CORE 0.001837
K_9980 X_NUC_81.L_CORE X_NUC_101.L_CORE 0.005682
K_9981 X_NUC_81.L_CORE X_NUC_102.L_CORE 0.005562
K_9982 X_NUC_81.L_CORE X_NUC_103.L_CORE 0.005594
K_9983 X_NUC_81.L_CORE X_NUC_104.L_CORE 0.005541
K_9984 X_NUC_81.L_CORE X_NUC_105.L_CORE 0.002360
K_9985 X_NUC_81.L_CORE X_NUC_106.L_CORE 0.002372
K_9986 X_NUC_81.L_CORE X_NUC_107.L_CORE 0.002372
K_9987 X_NUC_81.L_CORE X_NUC_108.L_CORE 0.002349
K_9988 X_NUC_81.L_CORE X_NUC_109.L_CORE 0.002237
K_9989 X_NUC_81.L_CORE X_NUC_110.L_CORE 0.002225
K_9990 X_NUC_81.L_CORE X_NUC_111.L_CORE 0.002236
K_9991 X_NUC_81.L_CORE X_NUC_112.L_CORE 0.002217
K_9992 X_NUC_81.L_CORE X_NUC_113.L_CORE 0.005440
K_9993 X_NUC_81.L_CORE X_NUC_114.L_CORE 0.005485
K_9994 X_NUC_81.L_CORE X_NUC_115.L_CORE 0.005423
K_9995 X_NUC_81.L_CORE X_NUC_116.L_CORE 0.005347
K_9996 X_NUC_81.L_CORE X_NUC_117.L_CORE 0.002076
K_9997 X_NUC_81.L_CORE X_NUC_118.L_CORE 0.002077
K_9998 X_NUC_81.L_CORE X_NUC_119.L_CORE 0.002081
K_9999 X_NUC_81.L_CORE X_NUC_120.L_CORE 0.002062
K_10000 X_NUC_81.L_CORE X_NUC_121.L_CORE 0.003189
K_10001 X_NUC_81.L_CORE X_NUC_122.L_CORE 0.003164
K_10002 X_NUC_81.L_CORE X_NUC_123.L_CORE 0.003173
K_10003 X_NUC_81.L_CORE X_NUC_124.L_CORE 0.003142
K_10004 X_NUC_81.L_CORE X_NUC_125.L_CORE 0.002984
K_10005 X_NUC_81.L_CORE X_NUC_126.L_CORE 0.002996
K_10006 X_NUC_81.L_CORE X_NUC_127.L_CORE 0.002989
K_10007 X_NUC_81.L_CORE X_NUC_128.L_CORE 0.002956
K_10008 X_NUC_81.L_CORE X_NUC_129.L_CORE 0.002459
K_10009 X_NUC_81.L_CORE X_NUC_130.L_CORE 0.002454
K_10010 X_NUC_81.L_CORE X_NUC_131.L_CORE 0.002458
K_10011 X_NUC_81.L_CORE X_NUC_132.L_CORE 0.002434
K_10012 X_NUC_81.L_CORE X_NUC_133.L_CORE 0.001958
K_10013 X_NUC_81.L_CORE X_NUC_134.L_CORE 0.002068
K_10014 X_NUC_81.L_CORE X_NUC_135.L_CORE 0.002517
K_10015 X_NUC_81.L_CORE X_NUC_136.L_CORE 0.001723
K_10016 X_NUC_81.L_CORE X_NUC_137.L_CORE 0.002814
K_10017 X_NUC_81.L_CORE X_NUC_138.L_CORE 0.002062
K_10018 X_NUC_81.L_CORE X_NUC_139.L_CORE 0.001823
K_10019 X_NUC_81.L_CORE X_NUC_140.L_CORE 0.003968
K_10020 X_NUC_81.L_CORE X_NUC_141.L_CORE 0.001694
K_10021 X_NUC_81.L_CORE X_NUC_142.L_CORE 0.002501
K_10022 X_NUC_81.L_CORE X_NUC_143.L_CORE 0.002754
K_10023 X_NUC_81.L_CORE X_NUC_144.L_CORE 0.001657
K_10024 X_NUC_81.L_CORE X_NUC_145.L_CORE 0.005436
K_10025 X_NUC_81.L_CORE X_NUC_146.L_CORE 0.001894
K_10026 X_NUC_81.L_CORE X_NUC_147.L_CORE 0.002028
K_10027 X_NUC_81.L_CORE X_NUC_148.L_CORE 0.005196
K_10028 X_NUC_81.L_CORE X_NUC_149.L_CORE 0.001646
K_10029 X_NUC_81.L_CORE X_NUC_150.L_CORE 0.003612
K_10030 X_NUC_81.L_CORE X_NUC_151.L_CORE 0.002451
K_10031 X_NUC_81.L_CORE X_NUC_152.L_CORE 0.001783
K_10032 X_NUC_81.L_CORE X_NUC_153.L_CORE 0.032318
K_10033 X_NUC_81.L_CORE X_NUC_154.L_CORE 0.001816
K_10034 X_NUC_81.L_CORE X_NUC_155.L_CORE 0.002504
K_10035 X_NUC_81.L_CORE X_NUC_156.L_CORE 0.003823
K_10036 X_NUC_81.L_CORE X_NUC_157.L_CORE 0.001753
K_10037 X_NUC_81.L_CORE X_NUC_158.L_CORE 0.005253
K_10038 X_NUC_81.L_CORE X_NUC_159.L_CORE 0.002243
K_10039 X_NUC_81.L_CORE X_NUC_160.L_CORE 0.002116
K_10040 X_NUC_81.L_CORE X_NUC_161.L_CORE 0.005096
K_10041 X_NUC_81.L_CORE X_NUC_162.L_CORE 0.001969
K_10042 X_NUC_81.L_CORE X_NUC_163.L_CORE 0.003000
K_10043 X_NUC_81.L_CORE X_NUC_164.L_CORE 0.002825
K_10044 X_NUC_81.L_CORE X_NUC_165.L_CORE 0.002326
K_10045 X_NUC_82.L_CORE X_NUC_83.L_CORE 0.207973
K_10046 X_NUC_82.L_CORE X_NUC_84.L_CORE 0.207973
K_10047 X_NUC_82.L_CORE X_NUC_85.L_CORE 0.001905
K_10048 X_NUC_82.L_CORE X_NUC_86.L_CORE 0.001910
K_10049 X_NUC_82.L_CORE X_NUC_87.L_CORE 0.001915
K_10050 X_NUC_82.L_CORE X_NUC_88.L_CORE 0.001898
K_10051 X_NUC_82.L_CORE X_NUC_89.L_CORE 0.002680
K_10052 X_NUC_82.L_CORE X_NUC_90.L_CORE 0.002654
K_10053 X_NUC_82.L_CORE X_NUC_91.L_CORE 0.002675
K_10054 X_NUC_82.L_CORE X_NUC_92.L_CORE 0.002654
K_10055 X_NUC_82.L_CORE X_NUC_93.L_CORE 0.003961
K_10056 X_NUC_82.L_CORE X_NUC_94.L_CORE 0.004022
K_10057 X_NUC_82.L_CORE X_NUC_95.L_CORE 0.004000
K_10058 X_NUC_82.L_CORE X_NUC_96.L_CORE 0.003958
K_10059 X_NUC_82.L_CORE X_NUC_97.L_CORE 0.001850
K_10060 X_NUC_82.L_CORE X_NUC_98.L_CORE 0.001848
K_10061 X_NUC_82.L_CORE X_NUC_99.L_CORE 0.001856
K_10062 X_NUC_82.L_CORE X_NUC_100.L_CORE 0.001840
K_10063 X_NUC_82.L_CORE X_NUC_101.L_CORE 0.005805
K_10064 X_NUC_82.L_CORE X_NUC_102.L_CORE 0.005682
K_10065 X_NUC_82.L_CORE X_NUC_103.L_CORE 0.005714
K_10066 X_NUC_82.L_CORE X_NUC_104.L_CORE 0.005657
K_10067 X_NUC_82.L_CORE X_NUC_105.L_CORE 0.002347
K_10068 X_NUC_82.L_CORE X_NUC_106.L_CORE 0.002360
K_10069 X_NUC_82.L_CORE X_NUC_107.L_CORE 0.002360
K_10070 X_NUC_82.L_CORE X_NUC_108.L_CORE 0.002338
K_10071 X_NUC_82.L_CORE X_NUC_109.L_CORE 0.002250
K_10072 X_NUC_82.L_CORE X_NUC_110.L_CORE 0.002237
K_10073 X_NUC_82.L_CORE X_NUC_111.L_CORE 0.002249
K_10074 X_NUC_82.L_CORE X_NUC_112.L_CORE 0.002229
K_10075 X_NUC_82.L_CORE X_NUC_113.L_CORE 0.005392
K_10076 X_NUC_82.L_CORE X_NUC_114.L_CORE 0.005440
K_10077 X_NUC_82.L_CORE X_NUC_115.L_CORE 0.005377
K_10078 X_NUC_82.L_CORE X_NUC_116.L_CORE 0.005303
K_10079 X_NUC_82.L_CORE X_NUC_117.L_CORE 0.002074
K_10080 X_NUC_82.L_CORE X_NUC_118.L_CORE 0.002076
K_10081 X_NUC_82.L_CORE X_NUC_119.L_CORE 0.002080
K_10082 X_NUC_82.L_CORE X_NUC_120.L_CORE 0.002061
K_10083 X_NUC_82.L_CORE X_NUC_121.L_CORE 0.003214
K_10084 X_NUC_82.L_CORE X_NUC_122.L_CORE 0.003189
K_10085 X_NUC_82.L_CORE X_NUC_123.L_CORE 0.003198
K_10086 X_NUC_82.L_CORE X_NUC_124.L_CORE 0.003166
K_10087 X_NUC_82.L_CORE X_NUC_125.L_CORE 0.002972
K_10088 X_NUC_82.L_CORE X_NUC_126.L_CORE 0.002984
K_10089 X_NUC_82.L_CORE X_NUC_127.L_CORE 0.002977
K_10090 X_NUC_82.L_CORE X_NUC_128.L_CORE 0.002945
K_10091 X_NUC_82.L_CORE X_NUC_129.L_CORE 0.002464
K_10092 X_NUC_82.L_CORE X_NUC_130.L_CORE 0.002459
K_10093 X_NUC_82.L_CORE X_NUC_131.L_CORE 0.002463
K_10094 X_NUC_82.L_CORE X_NUC_132.L_CORE 0.002439
K_10095 X_NUC_82.L_CORE X_NUC_133.L_CORE 0.001957
K_10096 X_NUC_82.L_CORE X_NUC_134.L_CORE 0.002075
K_10097 X_NUC_82.L_CORE X_NUC_135.L_CORE 0.002509
K_10098 X_NUC_82.L_CORE X_NUC_136.L_CORE 0.001724
K_10099 X_NUC_82.L_CORE X_NUC_137.L_CORE 0.002830
K_10100 X_NUC_82.L_CORE X_NUC_138.L_CORE 0.002053
K_10101 X_NUC_82.L_CORE X_NUC_139.L_CORE 0.001830
K_10102 X_NUC_82.L_CORE X_NUC_140.L_CORE 0.003951
K_10103 X_NUC_82.L_CORE X_NUC_141.L_CORE 0.001692
K_10104 X_NUC_82.L_CORE X_NUC_142.L_CORE 0.002524
K_10105 X_NUC_82.L_CORE X_NUC_143.L_CORE 0.002728
K_10106 X_NUC_82.L_CORE X_NUC_144.L_CORE 0.001660
K_10107 X_NUC_82.L_CORE X_NUC_145.L_CORE 0.005519
K_10108 X_NUC_82.L_CORE X_NUC_146.L_CORE 0.001886
K_10109 X_NUC_82.L_CORE X_NUC_147.L_CORE 0.002042
K_10110 X_NUC_82.L_CORE X_NUC_148.L_CORE 0.005084
K_10111 X_NUC_82.L_CORE X_NUC_149.L_CORE 0.001646
K_10112 X_NUC_82.L_CORE X_NUC_150.L_CORE 0.003673
K_10113 X_NUC_82.L_CORE X_NUC_151.L_CORE 0.002431
K_10114 X_NUC_82.L_CORE X_NUC_152.L_CORE 0.001790
K_10115 X_NUC_82.L_CORE X_NUC_153.L_CORE 0.031894
K_10116 X_NUC_82.L_CORE X_NUC_154.L_CORE 0.001811
K_10117 X_NUC_82.L_CORE X_NUC_155.L_CORE 0.002528
K_10118 X_NUC_82.L_CORE X_NUC_156.L_CORE 0.003765
K_10119 X_NUC_82.L_CORE X_NUC_157.L_CORE 0.001756
K_10120 X_NUC_82.L_CORE X_NUC_158.L_CORE 0.005360
K_10121 X_NUC_82.L_CORE X_NUC_159.L_CORE 0.002231
K_10122 X_NUC_82.L_CORE X_NUC_160.L_CORE 0.002127
K_10123 X_NUC_82.L_CORE X_NUC_161.L_CORE 0.005053
K_10124 X_NUC_82.L_CORE X_NUC_162.L_CORE 0.001968
K_10125 X_NUC_82.L_CORE X_NUC_163.L_CORE 0.003023
K_10126 X_NUC_82.L_CORE X_NUC_164.L_CORE 0.002814
K_10127 X_NUC_82.L_CORE X_NUC_165.L_CORE 0.002330
K_10128 X_NUC_83.L_CORE X_NUC_84.L_CORE 0.207973
K_10129 X_NUC_83.L_CORE X_NUC_85.L_CORE 0.001899
K_10130 X_NUC_83.L_CORE X_NUC_86.L_CORE 0.001904
K_10131 X_NUC_83.L_CORE X_NUC_87.L_CORE 0.001910
K_10132 X_NUC_83.L_CORE X_NUC_88.L_CORE 0.001893
K_10133 X_NUC_83.L_CORE X_NUC_89.L_CORE 0.002658
K_10134 X_NUC_83.L_CORE X_NUC_90.L_CORE 0.002632
K_10135 X_NUC_83.L_CORE X_NUC_91.L_CORE 0.002654
K_10136 X_NUC_83.L_CORE X_NUC_92.L_CORE 0.002633
K_10137 X_NUC_83.L_CORE X_NUC_93.L_CORE 0.003980
K_10138 X_NUC_83.L_CORE X_NUC_94.L_CORE 0.004042
K_10139 X_NUC_83.L_CORE X_NUC_95.L_CORE 0.004022
K_10140 X_NUC_83.L_CORE X_NUC_96.L_CORE 0.003978
K_10141 X_NUC_83.L_CORE X_NUC_97.L_CORE 0.001843
K_10142 X_NUC_83.L_CORE X_NUC_98.L_CORE 0.001840
K_10143 X_NUC_83.L_CORE X_NUC_99.L_CORE 0.001848
K_10144 X_NUC_83.L_CORE X_NUC_100.L_CORE 0.001832
K_10145 X_NUC_83.L_CORE X_NUC_101.L_CORE 0.005769
K_10146 X_NUC_83.L_CORE X_NUC_102.L_CORE 0.005646
K_10147 X_NUC_83.L_CORE X_NUC_103.L_CORE 0.005682
K_10148 X_NUC_83.L_CORE X_NUC_104.L_CORE 0.005624
K_10149 X_NUC_83.L_CORE X_NUC_105.L_CORE 0.002347
K_10150 X_NUC_83.L_CORE X_NUC_106.L_CORE 0.002359
K_10151 X_NUC_83.L_CORE X_NUC_107.L_CORE 0.002360
K_10152 X_NUC_83.L_CORE X_NUC_108.L_CORE 0.002337
K_10153 X_NUC_83.L_CORE X_NUC_109.L_CORE 0.002238
K_10154 X_NUC_83.L_CORE X_NUC_110.L_CORE 0.002226
K_10155 X_NUC_83.L_CORE X_NUC_111.L_CORE 0.002237
K_10156 X_NUC_83.L_CORE X_NUC_112.L_CORE 0.002218
K_10157 X_NUC_83.L_CORE X_NUC_113.L_CORE 0.005453
K_10158 X_NUC_83.L_CORE X_NUC_114.L_CORE 0.005500
K_10159 X_NUC_83.L_CORE X_NUC_115.L_CORE 0.005440
K_10160 X_NUC_83.L_CORE X_NUC_116.L_CORE 0.005361
K_10161 X_NUC_83.L_CORE X_NUC_117.L_CORE 0.002070
K_10162 X_NUC_83.L_CORE X_NUC_118.L_CORE 0.002071
K_10163 X_NUC_83.L_CORE X_NUC_119.L_CORE 0.002076
K_10164 X_NUC_83.L_CORE X_NUC_120.L_CORE 0.002056
K_10165 X_NUC_83.L_CORE X_NUC_121.L_CORE 0.003205
K_10166 X_NUC_83.L_CORE X_NUC_122.L_CORE 0.003180
K_10167 X_NUC_83.L_CORE X_NUC_123.L_CORE 0.003189
K_10168 X_NUC_83.L_CORE X_NUC_124.L_CORE 0.003157
K_10169 X_NUC_83.L_CORE X_NUC_125.L_CORE 0.002979
K_10170 X_NUC_83.L_CORE X_NUC_126.L_CORE 0.002991
K_10171 X_NUC_83.L_CORE X_NUC_127.L_CORE 0.002984
K_10172 X_NUC_83.L_CORE X_NUC_128.L_CORE 0.002952
K_10173 X_NUC_83.L_CORE X_NUC_129.L_CORE 0.002460
K_10174 X_NUC_83.L_CORE X_NUC_130.L_CORE 0.002455
K_10175 X_NUC_83.L_CORE X_NUC_131.L_CORE 0.002459
K_10176 X_NUC_83.L_CORE X_NUC_132.L_CORE 0.002435
K_10177 X_NUC_83.L_CORE X_NUC_133.L_CORE 0.001942
K_10178 X_NUC_83.L_CORE X_NUC_134.L_CORE 0.002055
K_10179 X_NUC_83.L_CORE X_NUC_135.L_CORE 0.002488
K_10180 X_NUC_83.L_CORE X_NUC_136.L_CORE 0.001712
K_10181 X_NUC_83.L_CORE X_NUC_137.L_CORE 0.002794
K_10182 X_NUC_83.L_CORE X_NUC_138.L_CORE 0.002042
K_10183 X_NUC_83.L_CORE X_NUC_139.L_CORE 0.001815
K_10184 X_NUC_83.L_CORE X_NUC_140.L_CORE 0.003905
K_10185 X_NUC_83.L_CORE X_NUC_141.L_CORE 0.001683
K_10186 X_NUC_83.L_CORE X_NUC_142.L_CORE 0.002495
K_10187 X_NUC_83.L_CORE X_NUC_143.L_CORE 0.002719
K_10188 X_NUC_83.L_CORE X_NUC_144.L_CORE 0.001650
K_10189 X_NUC_83.L_CORE X_NUC_145.L_CORE 0.005403
K_10190 X_NUC_83.L_CORE X_NUC_146.L_CORE 0.001880
K_10191 X_NUC_83.L_CORE X_NUC_147.L_CORE 0.002025
K_10192 X_NUC_83.L_CORE X_NUC_148.L_CORE 0.005089
K_10193 X_NUC_83.L_CORE X_NUC_149.L_CORE 0.001639
K_10194 X_NUC_83.L_CORE X_NUC_150.L_CORE 0.003626
K_10195 X_NUC_83.L_CORE X_NUC_151.L_CORE 0.002430
K_10196 X_NUC_83.L_CORE X_NUC_152.L_CORE 0.001779
K_10197 X_NUC_83.L_CORE X_NUC_153.L_CORE 0.035860
K_10198 X_NUC_83.L_CORE X_NUC_154.L_CORE 0.001807
K_10199 X_NUC_83.L_CORE X_NUC_155.L_CORE 0.002510
K_10200 X_NUC_83.L_CORE X_NUC_156.L_CORE 0.003790
K_10201 X_NUC_83.L_CORE X_NUC_157.L_CORE 0.001749
K_10202 X_NUC_83.L_CORE X_NUC_158.L_CORE 0.005344
K_10203 X_NUC_83.L_CORE X_NUC_159.L_CORE 0.002232
K_10204 X_NUC_83.L_CORE X_NUC_160.L_CORE 0.002118
K_10205 X_NUC_83.L_CORE X_NUC_161.L_CORE 0.005122
K_10206 X_NUC_83.L_CORE X_NUC_162.L_CORE 0.001965
K_10207 X_NUC_83.L_CORE X_NUC_163.L_CORE 0.003017
K_10208 X_NUC_83.L_CORE X_NUC_164.L_CORE 0.002823
K_10209 X_NUC_83.L_CORE X_NUC_165.L_CORE 0.002328
K_10210 X_NUC_84.L_CORE X_NUC_85.L_CORE 0.001916
K_10211 X_NUC_84.L_CORE X_NUC_86.L_CORE 0.001921
K_10212 X_NUC_84.L_CORE X_NUC_87.L_CORE 0.001927
K_10213 X_NUC_84.L_CORE X_NUC_88.L_CORE 0.001910
K_10214 X_NUC_84.L_CORE X_NUC_89.L_CORE 0.002680
K_10215 X_NUC_84.L_CORE X_NUC_90.L_CORE 0.002653
K_10216 X_NUC_84.L_CORE X_NUC_91.L_CORE 0.002675
K_10217 X_NUC_84.L_CORE X_NUC_92.L_CORE 0.002654
K_10218 X_NUC_84.L_CORE X_NUC_93.L_CORE 0.004024
K_10219 X_NUC_84.L_CORE X_NUC_94.L_CORE 0.004087
K_10220 X_NUC_84.L_CORE X_NUC_95.L_CORE 0.004066
K_10221 X_NUC_84.L_CORE X_NUC_96.L_CORE 0.004022
K_10222 X_NUC_84.L_CORE X_NUC_97.L_CORE 0.001859
K_10223 X_NUC_84.L_CORE X_NUC_98.L_CORE 0.001856
K_10224 X_NUC_84.L_CORE X_NUC_99.L_CORE 0.001864
K_10225 X_NUC_84.L_CORE X_NUC_100.L_CORE 0.001848
K_10226 X_NUC_84.L_CORE X_NUC_101.L_CORE 0.005830
K_10227 X_NUC_84.L_CORE X_NUC_102.L_CORE 0.005703
K_10228 X_NUC_84.L_CORE X_NUC_103.L_CORE 0.005738
K_10229 X_NUC_84.L_CORE X_NUC_104.L_CORE 0.005682
K_10230 X_NUC_84.L_CORE X_NUC_105.L_CORE 0.002370
K_10231 X_NUC_84.L_CORE X_NUC_106.L_CORE 0.002382
K_10232 X_NUC_84.L_CORE X_NUC_107.L_CORE 0.002383
K_10233 X_NUC_84.L_CORE X_NUC_108.L_CORE 0.002360
K_10234 X_NUC_84.L_CORE X_NUC_109.L_CORE 0.002258
K_10235 X_NUC_84.L_CORE X_NUC_110.L_CORE 0.002246
K_10236 X_NUC_84.L_CORE X_NUC_111.L_CORE 0.002257
K_10237 X_NUC_84.L_CORE X_NUC_112.L_CORE 0.002237
K_10238 X_NUC_84.L_CORE X_NUC_113.L_CORE 0.005533
K_10239 X_NUC_84.L_CORE X_NUC_114.L_CORE 0.005583
K_10240 X_NUC_84.L_CORE X_NUC_115.L_CORE 0.005517
K_10241 X_NUC_84.L_CORE X_NUC_116.L_CORE 0.005440
K_10242 X_NUC_84.L_CORE X_NUC_117.L_CORE 0.002090
K_10243 X_NUC_84.L_CORE X_NUC_118.L_CORE 0.002091
K_10244 X_NUC_84.L_CORE X_NUC_119.L_CORE 0.002095
K_10245 X_NUC_84.L_CORE X_NUC_120.L_CORE 0.002076
K_10246 X_NUC_84.L_CORE X_NUC_121.L_CORE 0.003238
K_10247 X_NUC_84.L_CORE X_NUC_122.L_CORE 0.003212
K_10248 X_NUC_84.L_CORE X_NUC_123.L_CORE 0.003221
K_10249 X_NUC_84.L_CORE X_NUC_124.L_CORE 0.003189
K_10250 X_NUC_84.L_CORE X_NUC_125.L_CORE 0.003012
K_10251 X_NUC_84.L_CORE X_NUC_126.L_CORE 0.003025
K_10252 X_NUC_84.L_CORE X_NUC_127.L_CORE 0.003017
K_10253 X_NUC_84.L_CORE X_NUC_128.L_CORE 0.002984
K_10254 X_NUC_84.L_CORE X_NUC_129.L_CORE 0.002484
K_10255 X_NUC_84.L_CORE X_NUC_130.L_CORE 0.002480
K_10256 X_NUC_84.L_CORE X_NUC_131.L_CORE 0.002483
K_10257 X_NUC_84.L_CORE X_NUC_132.L_CORE 0.002459
K_10258 X_NUC_84.L_CORE X_NUC_133.L_CORE 0.001954
K_10259 X_NUC_84.L_CORE X_NUC_134.L_CORE 0.002066
K_10260 X_NUC_84.L_CORE X_NUC_135.L_CORE 0.002501
K_10261 X_NUC_84.L_CORE X_NUC_136.L_CORE 0.001724
K_10262 X_NUC_84.L_CORE X_NUC_137.L_CORE 0.002804
K_10263 X_NUC_84.L_CORE X_NUC_138.L_CORE 0.002056
K_10264 X_NUC_84.L_CORE X_NUC_139.L_CORE 0.001827
K_10265 X_NUC_84.L_CORE X_NUC_140.L_CORE 0.003912
K_10266 X_NUC_84.L_CORE X_NUC_141.L_CORE 0.001695
K_10267 X_NUC_84.L_CORE X_NUC_142.L_CORE 0.002507
K_10268 X_NUC_84.L_CORE X_NUC_143.L_CORE 0.002737
K_10269 X_NUC_84.L_CORE X_NUC_144.L_CORE 0.001662
K_10270 X_NUC_84.L_CORE X_NUC_145.L_CORE 0.005388
K_10271 X_NUC_84.L_CORE X_NUC_146.L_CORE 0.001894
K_10272 X_NUC_84.L_CORE X_NUC_147.L_CORE 0.002038
K_10273 X_NUC_84.L_CORE X_NUC_148.L_CORE 0.005107
K_10274 X_NUC_84.L_CORE X_NUC_149.L_CORE 0.001652
K_10275 X_NUC_84.L_CORE X_NUC_150.L_CORE 0.003641
K_10276 X_NUC_84.L_CORE X_NUC_151.L_CORE 0.002449
K_10277 X_NUC_84.L_CORE X_NUC_152.L_CORE 0.001793
K_10278 X_NUC_84.L_CORE X_NUC_153.L_CORE 0.030686
K_10279 X_NUC_84.L_CORE X_NUC_154.L_CORE 0.001822
K_10280 X_NUC_84.L_CORE X_NUC_155.L_CORE 0.002527
K_10281 X_NUC_84.L_CORE X_NUC_156.L_CORE 0.003823
K_10282 X_NUC_84.L_CORE X_NUC_157.L_CORE 0.001763
K_10283 X_NUC_84.L_CORE X_NUC_158.L_CORE 0.005375
K_10284 X_NUC_84.L_CORE X_NUC_159.L_CORE 0.002252
K_10285 X_NUC_84.L_CORE X_NUC_160.L_CORE 0.002135
K_10286 X_NUC_84.L_CORE X_NUC_161.L_CORE 0.005176
K_10287 X_NUC_84.L_CORE X_NUC_162.L_CORE 0.001982
K_10288 X_NUC_84.L_CORE X_NUC_163.L_CORE 0.003044
K_10289 X_NUC_84.L_CORE X_NUC_164.L_CORE 0.002851
K_10290 X_NUC_84.L_CORE X_NUC_165.L_CORE 0.002349
K_10291 X_NUC_85.L_CORE X_NUC_86.L_CORE 0.207973
K_10292 X_NUC_85.L_CORE X_NUC_87.L_CORE 0.207973
K_10293 X_NUC_85.L_CORE X_NUC_88.L_CORE 0.207973
K_10294 X_NUC_85.L_CORE X_NUC_89.L_CORE 0.001949
K_10295 X_NUC_85.L_CORE X_NUC_90.L_CORE 0.001933
K_10296 X_NUC_85.L_CORE X_NUC_91.L_CORE 0.001936
K_10297 X_NUC_85.L_CORE X_NUC_92.L_CORE 0.001945
K_10298 X_NUC_85.L_CORE X_NUC_93.L_CORE 0.002714
K_10299 X_NUC_85.L_CORE X_NUC_94.L_CORE 0.002720
K_10300 X_NUC_85.L_CORE X_NUC_95.L_CORE 0.002697
K_10301 X_NUC_85.L_CORE X_NUC_96.L_CORE 0.002732
K_10302 X_NUC_85.L_CORE X_NUC_97.L_CORE 0.004117
K_10303 X_NUC_85.L_CORE X_NUC_98.L_CORE 0.004040
K_10304 X_NUC_85.L_CORE X_NUC_99.L_CORE 0.004070
K_10305 X_NUC_85.L_CORE X_NUC_100.L_CORE 0.004061
K_10306 X_NUC_85.L_CORE X_NUC_101.L_CORE 0.001902
K_10307 X_NUC_85.L_CORE X_NUC_102.L_CORE 0.001893
K_10308 X_NUC_85.L_CORE X_NUC_103.L_CORE 0.001889
K_10309 X_NUC_85.L_CORE X_NUC_104.L_CORE 0.001903
K_10310 X_NUC_85.L_CORE X_NUC_105.L_CORE 0.005760
K_10311 X_NUC_85.L_CORE X_NUC_106.L_CORE 0.005804
K_10312 X_NUC_85.L_CORE X_NUC_107.L_CORE 0.005661
K_10313 X_NUC_85.L_CORE X_NUC_108.L_CORE 0.005788
K_10314 X_NUC_85.L_CORE X_NUC_109.L_CORE 0.002443
K_10315 X_NUC_85.L_CORE X_NUC_110.L_CORE 0.002418
K_10316 X_NUC_85.L_CORE X_NUC_111.L_CORE 0.002420
K_10317 X_NUC_85.L_CORE X_NUC_112.L_CORE 0.002430
K_10318 X_NUC_85.L_CORE X_NUC_113.L_CORE 0.002329
K_10319 X_NUC_85.L_CORE X_NUC_114.L_CORE 0.002324
K_10320 X_NUC_85.L_CORE X_NUC_115.L_CORE 0.002309
K_10321 X_NUC_85.L_CORE X_NUC_116.L_CORE 0.002333
K_10322 X_NUC_85.L_CORE X_NUC_117.L_CORE 0.005285
K_10323 X_NUC_85.L_CORE X_NUC_118.L_CORE 0.005203
K_10324 X_NUC_85.L_CORE X_NUC_119.L_CORE 0.005158
K_10325 X_NUC_85.L_CORE X_NUC_120.L_CORE 0.005191
K_10326 X_NUC_85.L_CORE X_NUC_121.L_CORE 0.002202
K_10327 X_NUC_85.L_CORE X_NUC_122.L_CORE 0.002187
K_10328 X_NUC_85.L_CORE X_NUC_123.L_CORE 0.002181
K_10329 X_NUC_85.L_CORE X_NUC_124.L_CORE 0.002197
K_10330 X_NUC_85.L_CORE X_NUC_125.L_CORE 0.003247
K_10331 X_NUC_85.L_CORE X_NUC_126.L_CORE 0.003239
K_10332 X_NUC_85.L_CORE X_NUC_127.L_CORE 0.003203
K_10333 X_NUC_85.L_CORE X_NUC_128.L_CORE 0.003242
K_10334 X_NUC_85.L_CORE X_NUC_129.L_CORE 0.003036
K_10335 X_NUC_85.L_CORE X_NUC_130.L_CORE 0.003007
K_10336 X_NUC_85.L_CORE X_NUC_131.L_CORE 0.002993
K_10337 X_NUC_85.L_CORE X_NUC_132.L_CORE 0.003014
K_10338 X_NUC_85.L_CORE X_NUC_133.L_CORE 0.002234
K_10339 X_NUC_85.L_CORE X_NUC_134.L_CORE 0.001859
K_10340 X_NUC_85.L_CORE X_NUC_135.L_CORE 0.002037
K_10341 X_NUC_85.L_CORE X_NUC_136.L_CORE 0.002534
K_10342 X_NUC_85.L_CORE X_NUC_137.L_CORE 0.001680
K_10343 X_NUC_85.L_CORE X_NUC_138.L_CORE 0.002843
K_10344 X_NUC_85.L_CORE X_NUC_139.L_CORE 0.002028
K_10345 X_NUC_85.L_CORE X_NUC_140.L_CORE 0.001806
K_10346 X_NUC_85.L_CORE X_NUC_141.L_CORE 0.003982
K_10347 X_NUC_85.L_CORE X_NUC_142.L_CORE 0.001677
K_10348 X_NUC_85.L_CORE X_NUC_143.L_CORE 0.002510
K_10349 X_NUC_85.L_CORE X_NUC_144.L_CORE 0.002722
K_10350 X_NUC_85.L_CORE X_NUC_145.L_CORE 0.001656
K_10351 X_NUC_85.L_CORE X_NUC_146.L_CORE 0.005512
K_10352 X_NUC_85.L_CORE X_NUC_147.L_CORE 0.001889
K_10353 X_NUC_85.L_CORE X_NUC_148.L_CORE 0.002046
K_10354 X_NUC_85.L_CORE X_NUC_149.L_CORE 0.005115
K_10355 X_NUC_85.L_CORE X_NUC_150.L_CORE 0.001657
K_10356 X_NUC_85.L_CORE X_NUC_151.L_CORE 0.003699
K_10357 X_NUC_85.L_CORE X_NUC_152.L_CORE 0.002459
K_10358 X_NUC_85.L_CORE X_NUC_153.L_CORE 0.001812
K_10359 X_NUC_85.L_CORE X_NUC_154.L_CORE 0.033492
K_10360 X_NUC_85.L_CORE X_NUC_155.L_CORE 0.001844
K_10361 X_NUC_85.L_CORE X_NUC_156.L_CORE 0.002576
K_10362 X_NUC_85.L_CORE X_NUC_157.L_CORE 0.003849
K_10363 X_NUC_85.L_CORE X_NUC_158.L_CORE 0.001802
K_10364 X_NUC_85.L_CORE X_NUC_159.L_CORE 0.005403
K_10365 X_NUC_85.L_CORE X_NUC_160.L_CORE 0.002304
K_10366 X_NUC_85.L_CORE X_NUC_161.L_CORE 0.002206
K_10367 X_NUC_85.L_CORE X_NUC_162.L_CORE 0.004903
K_10368 X_NUC_85.L_CORE X_NUC_163.L_CORE 0.002081
K_10369 X_NUC_85.L_CORE X_NUC_164.L_CORE 0.003063
K_10370 X_NUC_85.L_CORE X_NUC_165.L_CORE 0.002856
K_10371 X_NUC_86.L_CORE X_NUC_87.L_CORE 0.207973
K_10372 X_NUC_86.L_CORE X_NUC_88.L_CORE 0.207973
K_10373 X_NUC_86.L_CORE X_NUC_89.L_CORE 0.001964
K_10374 X_NUC_86.L_CORE X_NUC_90.L_CORE 0.001949
K_10375 X_NUC_86.L_CORE X_NUC_91.L_CORE 0.001951
K_10376 X_NUC_86.L_CORE X_NUC_92.L_CORE 0.001961
K_10377 X_NUC_86.L_CORE X_NUC_93.L_CORE 0.002709
K_10378 X_NUC_86.L_CORE X_NUC_94.L_CORE 0.002714
K_10379 X_NUC_86.L_CORE X_NUC_95.L_CORE 0.002692
K_10380 X_NUC_86.L_CORE X_NUC_96.L_CORE 0.002727
K_10381 X_NUC_86.L_CORE X_NUC_97.L_CORE 0.004198
K_10382 X_NUC_86.L_CORE X_NUC_98.L_CORE 0.004117
K_10383 X_NUC_86.L_CORE X_NUC_99.L_CORE 0.004148
K_10384 X_NUC_86.L_CORE X_NUC_100.L_CORE 0.004140
K_10385 X_NUC_86.L_CORE X_NUC_101.L_CORE 0.001911
K_10386 X_NUC_86.L_CORE X_NUC_102.L_CORE 0.001902
K_10387 X_NUC_86.L_CORE X_NUC_103.L_CORE 0.001898
K_10388 X_NUC_86.L_CORE X_NUC_104.L_CORE 0.001912
K_10389 X_NUC_86.L_CORE X_NUC_105.L_CORE 0.005713
K_10390 X_NUC_86.L_CORE X_NUC_106.L_CORE 0.005760
K_10391 X_NUC_86.L_CORE X_NUC_107.L_CORE 0.005619
K_10392 X_NUC_86.L_CORE X_NUC_108.L_CORE 0.005743
K_10393 X_NUC_86.L_CORE X_NUC_109.L_CORE 0.002470
K_10394 X_NUC_86.L_CORE X_NUC_110.L_CORE 0.002443
K_10395 X_NUC_86.L_CORE X_NUC_111.L_CORE 0.002446
K_10396 X_NUC_86.L_CORE X_NUC_112.L_CORE 0.002456
K_10397 X_NUC_86.L_CORE X_NUC_113.L_CORE 0.002334
K_10398 X_NUC_86.L_CORE X_NUC_114.L_CORE 0.002329
K_10399 X_NUC_86.L_CORE X_NUC_115.L_CORE 0.002314
K_10400 X_NUC_86.L_CORE X_NUC_116.L_CORE 0.002339
K_10401 X_NUC_86.L_CORE X_NUC_117.L_CORE 0.005367
K_10402 X_NUC_86.L_CORE X_NUC_118.L_CORE 0.005285
K_10403 X_NUC_86.L_CORE X_NUC_119.L_CORE 0.005236
K_10404 X_NUC_86.L_CORE X_NUC_120.L_CORE 0.005271
K_10405 X_NUC_86.L_CORE X_NUC_121.L_CORE 0.002218
K_10406 X_NUC_86.L_CORE X_NUC_122.L_CORE 0.002202
K_10407 X_NUC_86.L_CORE X_NUC_123.L_CORE 0.002197
K_10408 X_NUC_86.L_CORE X_NUC_124.L_CORE 0.002212
K_10409 X_NUC_86.L_CORE X_NUC_125.L_CORE 0.003255
K_10410 X_NUC_86.L_CORE X_NUC_126.L_CORE 0.003247
K_10411 X_NUC_86.L_CORE X_NUC_127.L_CORE 0.003211
K_10412 X_NUC_86.L_CORE X_NUC_128.L_CORE 0.003251
K_10413 X_NUC_86.L_CORE X_NUC_129.L_CORE 0.003064
K_10414 X_NUC_86.L_CORE X_NUC_130.L_CORE 0.003036
K_10415 X_NUC_86.L_CORE X_NUC_131.L_CORE 0.003020
K_10416 X_NUC_86.L_CORE X_NUC_132.L_CORE 0.003042
K_10417 X_NUC_86.L_CORE X_NUC_133.L_CORE 0.002240
K_10418 X_NUC_86.L_CORE X_NUC_134.L_CORE 0.001869
K_10419 X_NUC_86.L_CORE X_NUC_135.L_CORE 0.002038
K_10420 X_NUC_86.L_CORE X_NUC_136.L_CORE 0.002550
K_10421 X_NUC_86.L_CORE X_NUC_137.L_CORE 0.001687
K_10422 X_NUC_86.L_CORE X_NUC_138.L_CORE 0.002836
K_10423 X_NUC_86.L_CORE X_NUC_139.L_CORE 0.002044
K_10424 X_NUC_86.L_CORE X_NUC_140.L_CORE 0.001809
K_10425 X_NUC_86.L_CORE X_NUC_141.L_CORE 0.003997
K_10426 X_NUC_86.L_CORE X_NUC_142.L_CORE 0.001687
K_10427 X_NUC_86.L_CORE X_NUC_143.L_CORE 0.002501
K_10428 X_NUC_86.L_CORE X_NUC_144.L_CORE 0.002753
K_10429 X_NUC_86.L_CORE X_NUC_145.L_CORE 0.001661
K_10430 X_NUC_86.L_CORE X_NUC_146.L_CORE 0.005435
K_10431 X_NUC_86.L_CORE X_NUC_147.L_CORE 0.001905
K_10432 X_NUC_86.L_CORE X_NUC_148.L_CORE 0.002045
K_10433 X_NUC_86.L_CORE X_NUC_149.L_CORE 0.005208
K_10434 X_NUC_86.L_CORE X_NUC_150.L_CORE 0.001666
K_10435 X_NUC_86.L_CORE X_NUC_151.L_CORE 0.003663
K_10436 X_NUC_86.L_CORE X_NUC_152.L_CORE 0.002489
K_10437 X_NUC_86.L_CORE X_NUC_153.L_CORE 0.001816
K_10438 X_NUC_86.L_CORE X_NUC_154.L_CORE 0.030692
K_10439 X_NUC_86.L_CORE X_NUC_155.L_CORE 0.001858
K_10440 X_NUC_86.L_CORE X_NUC_156.L_CORE 0.002570
K_10441 X_NUC_86.L_CORE X_NUC_157.L_CORE 0.003917
K_10442 X_NUC_86.L_CORE X_NUC_158.L_CORE 0.001810
K_10443 X_NUC_86.L_CORE X_NUC_159.L_CORE 0.005349
K_10444 X_NUC_86.L_CORE X_NUC_160.L_CORE 0.002328
K_10445 X_NUC_86.L_CORE X_NUC_161.L_CORE 0.002210
K_10446 X_NUC_86.L_CORE X_NUC_162.L_CORE 0.004967
K_10447 X_NUC_86.L_CORE X_NUC_163.L_CORE 0.002095
K_10448 X_NUC_86.L_CORE X_NUC_164.L_CORE 0.003068
K_10449 X_NUC_86.L_CORE X_NUC_165.L_CORE 0.002880
K_10450 X_NUC_87.L_CORE X_NUC_88.L_CORE 0.207973
K_10451 X_NUC_87.L_CORE X_NUC_89.L_CORE 0.001962
K_10452 X_NUC_87.L_CORE X_NUC_90.L_CORE 0.001946
K_10453 X_NUC_87.L_CORE X_NUC_91.L_CORE 0.001949
K_10454 X_NUC_87.L_CORE X_NUC_92.L_CORE 0.001958
K_10455 X_NUC_87.L_CORE X_NUC_93.L_CORE 0.002732
K_10456 X_NUC_87.L_CORE X_NUC_94.L_CORE 0.002737
K_10457 X_NUC_87.L_CORE X_NUC_95.L_CORE 0.002714
K_10458 X_NUC_87.L_CORE X_NUC_96.L_CORE 0.002750
K_10459 X_NUC_87.L_CORE X_NUC_97.L_CORE 0.004165
K_10460 X_NUC_87.L_CORE X_NUC_98.L_CORE 0.004086
K_10461 X_NUC_87.L_CORE X_NUC_99.L_CORE 0.004117
K_10462 X_NUC_87.L_CORE X_NUC_100.L_CORE 0.004108
K_10463 X_NUC_87.L_CORE X_NUC_101.L_CORE 0.001916
K_10464 X_NUC_87.L_CORE X_NUC_102.L_CORE 0.001906
K_10465 X_NUC_87.L_CORE X_NUC_103.L_CORE 0.001902
K_10466 X_NUC_87.L_CORE X_NUC_104.L_CORE 0.001917
K_10467 X_NUC_87.L_CORE X_NUC_105.L_CORE 0.005860
K_10468 X_NUC_87.L_CORE X_NUC_106.L_CORE 0.005909
K_10469 X_NUC_87.L_CORE X_NUC_107.L_CORE 0.005760
K_10470 X_NUC_87.L_CORE X_NUC_108.L_CORE 0.005892
K_10471 X_NUC_87.L_CORE X_NUC_109.L_CORE 0.002467
K_10472 X_NUC_87.L_CORE X_NUC_110.L_CORE 0.002440
K_10473 X_NUC_87.L_CORE X_NUC_111.L_CORE 0.002443
K_10474 X_NUC_87.L_CORE X_NUC_112.L_CORE 0.002453
K_10475 X_NUC_87.L_CORE X_NUC_113.L_CORE 0.002349
K_10476 X_NUC_87.L_CORE X_NUC_114.L_CORE 0.002344
K_10477 X_NUC_87.L_CORE X_NUC_115.L_CORE 0.002329
K_10478 X_NUC_87.L_CORE X_NUC_116.L_CORE 0.002354
K_10479 X_NUC_87.L_CORE X_NUC_117.L_CORE 0.005418
K_10480 X_NUC_87.L_CORE X_NUC_118.L_CORE 0.005332
K_10481 X_NUC_87.L_CORE X_NUC_119.L_CORE 0.005285
K_10482 X_NUC_87.L_CORE X_NUC_120.L_CORE 0.005319
K_10483 X_NUC_87.L_CORE X_NUC_121.L_CORE 0.002224
K_10484 X_NUC_87.L_CORE X_NUC_122.L_CORE 0.002208
K_10485 X_NUC_87.L_CORE X_NUC_123.L_CORE 0.002202
K_10486 X_NUC_87.L_CORE X_NUC_124.L_CORE 0.002218
K_10487 X_NUC_87.L_CORE X_NUC_125.L_CORE 0.003293
K_10488 X_NUC_87.L_CORE X_NUC_126.L_CORE 0.003284
K_10489 X_NUC_87.L_CORE X_NUC_127.L_CORE 0.003247
K_10490 X_NUC_87.L_CORE X_NUC_128.L_CORE 0.003288
K_10491 X_NUC_87.L_CORE X_NUC_129.L_CORE 0.003080
K_10492 X_NUC_87.L_CORE X_NUC_130.L_CORE 0.003051
K_10493 X_NUC_87.L_CORE X_NUC_131.L_CORE 0.003036
K_10494 X_NUC_87.L_CORE X_NUC_132.L_CORE 0.003057
K_10495 X_NUC_87.L_CORE X_NUC_133.L_CORE 0.002226
K_10496 X_NUC_87.L_CORE X_NUC_134.L_CORE 0.001859
K_10497 X_NUC_87.L_CORE X_NUC_135.L_CORE 0.002034
K_10498 X_NUC_87.L_CORE X_NUC_136.L_CORE 0.002524
K_10499 X_NUC_87.L_CORE X_NUC_137.L_CORE 0.001683
K_10500 X_NUC_87.L_CORE X_NUC_138.L_CORE 0.002825
K_10501 X_NUC_87.L_CORE X_NUC_139.L_CORE 0.002030
K_10502 X_NUC_87.L_CORE X_NUC_140.L_CORE 0.001809
K_10503 X_NUC_87.L_CORE X_NUC_141.L_CORE 0.003933
K_10504 X_NUC_87.L_CORE X_NUC_142.L_CORE 0.001682
K_10505 X_NUC_87.L_CORE X_NUC_143.L_CORE 0.002507
K_10506 X_NUC_87.L_CORE X_NUC_144.L_CORE 0.002722
K_10507 X_NUC_87.L_CORE X_NUC_145.L_CORE 0.001662
K_10508 X_NUC_87.L_CORE X_NUC_146.L_CORE 0.005412
K_10509 X_NUC_87.L_CORE X_NUC_147.L_CORE 0.001897
K_10510 X_NUC_87.L_CORE X_NUC_148.L_CORE 0.002053
K_10511 X_NUC_87.L_CORE X_NUC_149.L_CORE 0.005088
K_10512 X_NUC_87.L_CORE X_NUC_150.L_CORE 0.001666
K_10513 X_NUC_87.L_CORE X_NUC_151.L_CORE 0.003699
K_10514 X_NUC_87.L_CORE X_NUC_152.L_CORE 0.002473
K_10515 X_NUC_87.L_CORE X_NUC_153.L_CORE 0.001822
K_10516 X_NUC_87.L_CORE X_NUC_154.L_CORE 0.031235
K_10517 X_NUC_87.L_CORE X_NUC_155.L_CORE 0.001856
K_10518 X_NUC_87.L_CORE X_NUC_156.L_CORE 0.002591
K_10519 X_NUC_87.L_CORE X_NUC_157.L_CORE 0.003889
K_10520 X_NUC_87.L_CORE X_NUC_158.L_CORE 0.001814
K_10521 X_NUC_87.L_CORE X_NUC_159.L_CORE 0.005485
K_10522 X_NUC_87.L_CORE X_NUC_160.L_CORE 0.002325
K_10523 X_NUC_87.L_CORE X_NUC_161.L_CORE 0.002225
K_10524 X_NUC_87.L_CORE X_NUC_162.L_CORE 0.005014
K_10525 X_NUC_87.L_CORE X_NUC_163.L_CORE 0.002101
K_10526 X_NUC_87.L_CORE X_NUC_164.L_CORE 0.003103
K_10527 X_NUC_87.L_CORE X_NUC_165.L_CORE 0.002895
K_10528 X_NUC_88.L_CORE X_NUC_89.L_CORE 0.001952
K_10529 X_NUC_88.L_CORE X_NUC_90.L_CORE 0.001937
K_10530 X_NUC_88.L_CORE X_NUC_91.L_CORE 0.001939
K_10531 X_NUC_88.L_CORE X_NUC_92.L_CORE 0.001949
K_10532 X_NUC_88.L_CORE X_NUC_93.L_CORE 0.002697
K_10533 X_NUC_88.L_CORE X_NUC_94.L_CORE 0.002702
K_10534 X_NUC_88.L_CORE X_NUC_95.L_CORE 0.002680
K_10535 X_NUC_88.L_CORE X_NUC_96.L_CORE 0.002714
K_10536 X_NUC_88.L_CORE X_NUC_97.L_CORE 0.004174
K_10537 X_NUC_88.L_CORE X_NUC_98.L_CORE 0.004094
K_10538 X_NUC_88.L_CORE X_NUC_99.L_CORE 0.004125
K_10539 X_NUC_88.L_CORE X_NUC_100.L_CORE 0.004117
K_10540 X_NUC_88.L_CORE X_NUC_101.L_CORE 0.001901
K_10541 X_NUC_88.L_CORE X_NUC_102.L_CORE 0.001892
K_10542 X_NUC_88.L_CORE X_NUC_103.L_CORE 0.001888
K_10543 X_NUC_88.L_CORE X_NUC_104.L_CORE 0.001902
K_10544 X_NUC_88.L_CORE X_NUC_105.L_CORE 0.005728
K_10545 X_NUC_88.L_CORE X_NUC_106.L_CORE 0.005773
K_10546 X_NUC_88.L_CORE X_NUC_107.L_CORE 0.005633
K_10547 X_NUC_88.L_CORE X_NUC_108.L_CORE 0.005760
K_10548 X_NUC_88.L_CORE X_NUC_109.L_CORE 0.002457
K_10549 X_NUC_88.L_CORE X_NUC_110.L_CORE 0.002431
K_10550 X_NUC_88.L_CORE X_NUC_111.L_CORE 0.002434
K_10551 X_NUC_88.L_CORE X_NUC_112.L_CORE 0.002443
K_10552 X_NUC_88.L_CORE X_NUC_113.L_CORE 0.002325
K_10553 X_NUC_88.L_CORE X_NUC_114.L_CORE 0.002320
K_10554 X_NUC_88.L_CORE X_NUC_115.L_CORE 0.002305
K_10555 X_NUC_88.L_CORE X_NUC_116.L_CORE 0.002329
K_10556 X_NUC_88.L_CORE X_NUC_117.L_CORE 0.005380
K_10557 X_NUC_88.L_CORE X_NUC_118.L_CORE 0.005296
K_10558 X_NUC_88.L_CORE X_NUC_119.L_CORE 0.005249
K_10559 X_NUC_88.L_CORE X_NUC_120.L_CORE 0.005285
K_10560 X_NUC_88.L_CORE X_NUC_121.L_CORE 0.002208
K_10561 X_NUC_88.L_CORE X_NUC_122.L_CORE 0.002193
K_10562 X_NUC_88.L_CORE X_NUC_123.L_CORE 0.002187
K_10563 X_NUC_88.L_CORE X_NUC_124.L_CORE 0.002202
K_10564 X_NUC_88.L_CORE X_NUC_125.L_CORE 0.003251
K_10565 X_NUC_88.L_CORE X_NUC_126.L_CORE 0.003243
K_10566 X_NUC_88.L_CORE X_NUC_127.L_CORE 0.003207
K_10567 X_NUC_88.L_CORE X_NUC_128.L_CORE 0.003247
K_10568 X_NUC_88.L_CORE X_NUC_129.L_CORE 0.003057
K_10569 X_NUC_88.L_CORE X_NUC_130.L_CORE 0.003029
K_10570 X_NUC_88.L_CORE X_NUC_131.L_CORE 0.003014
K_10571 X_NUC_88.L_CORE X_NUC_132.L_CORE 0.003036
K_10572 X_NUC_88.L_CORE X_NUC_133.L_CORE 0.002218
K_10573 X_NUC_88.L_CORE X_NUC_134.L_CORE 0.001852
K_10574 X_NUC_88.L_CORE X_NUC_135.L_CORE 0.002020
K_10575 X_NUC_88.L_CORE X_NUC_136.L_CORE 0.002522
K_10576 X_NUC_88.L_CORE X_NUC_137.L_CORE 0.001674
K_10577 X_NUC_88.L_CORE X_NUC_138.L_CORE 0.002807
K_10578 X_NUC_88.L_CORE X_NUC_139.L_CORE 0.002026
K_10579 X_NUC_88.L_CORE X_NUC_140.L_CORE 0.001796
K_10580 X_NUC_88.L_CORE X_NUC_141.L_CORE 0.003943
K_10581 X_NUC_88.L_CORE X_NUC_142.L_CORE 0.001675
K_10582 X_NUC_88.L_CORE X_NUC_143.L_CORE 0.002482
K_10583 X_NUC_88.L_CORE X_NUC_144.L_CORE 0.002727
K_10584 X_NUC_88.L_CORE X_NUC_145.L_CORE 0.001650
K_10585 X_NUC_88.L_CORE X_NUC_146.L_CORE 0.005374
K_10586 X_NUC_88.L_CORE X_NUC_147.L_CORE 0.001891
K_10587 X_NUC_88.L_CORE X_NUC_148.L_CORE 0.002033
K_10588 X_NUC_88.L_CORE X_NUC_149.L_CORE 0.005152
K_10589 X_NUC_88.L_CORE X_NUC_150.L_CORE 0.001656
K_10590 X_NUC_88.L_CORE X_NUC_151.L_CORE 0.003646
K_10591 X_NUC_88.L_CORE X_NUC_152.L_CORE 0.002472
K_10592 X_NUC_88.L_CORE X_NUC_153.L_CORE 0.001806
K_10593 X_NUC_88.L_CORE X_NUC_154.L_CORE 0.035311
K_10594 X_NUC_88.L_CORE X_NUC_155.L_CORE 0.001847
K_10595 X_NUC_88.L_CORE X_NUC_156.L_CORE 0.002560
K_10596 X_NUC_88.L_CORE X_NUC_157.L_CORE 0.003903
K_10597 X_NUC_88.L_CORE X_NUC_158.L_CORE 0.001801
K_10598 X_NUC_88.L_CORE X_NUC_159.L_CORE 0.005383
K_10599 X_NUC_88.L_CORE X_NUC_160.L_CORE 0.002318
K_10600 X_NUC_88.L_CORE X_NUC_161.L_CORE 0.002203
K_10601 X_NUC_88.L_CORE X_NUC_162.L_CORE 0.004995
K_10602 X_NUC_88.L_CORE X_NUC_163.L_CORE 0.002087
K_10603 X_NUC_88.L_CORE X_NUC_164.L_CORE 0.003068
K_10604 X_NUC_88.L_CORE X_NUC_165.L_CORE 0.002877
K_10605 X_NUC_89.L_CORE X_NUC_90.L_CORE 0.207973
K_10606 X_NUC_89.L_CORE X_NUC_91.L_CORE 0.207973
K_10607 X_NUC_89.L_CORE X_NUC_92.L_CORE 0.207973
K_10608 X_NUC_89.L_CORE X_NUC_93.L_CORE 0.001999
K_10609 X_NUC_89.L_CORE X_NUC_94.L_CORE 0.002018
K_10610 X_NUC_89.L_CORE X_NUC_95.L_CORE 0.002006
K_10611 X_NUC_89.L_CORE X_NUC_96.L_CORE 0.002010
K_10612 X_NUC_89.L_CORE X_NUC_97.L_CORE 0.002792
K_10613 X_NUC_89.L_CORE X_NUC_98.L_CORE 0.002813
K_10614 X_NUC_89.L_CORE X_NUC_99.L_CORE 0.002815
K_10615 X_NUC_89.L_CORE X_NUC_100.L_CORE 0.002784
K_10616 X_NUC_89.L_CORE X_NUC_101.L_CORE 0.004238
K_10617 X_NUC_89.L_CORE X_NUC_102.L_CORE 0.004295
K_10618 X_NUC_89.L_CORE X_NUC_103.L_CORE 0.004221
K_10619 X_NUC_89.L_CORE X_NUC_104.L_CORE 0.004283
K_10620 X_NUC_89.L_CORE X_NUC_105.L_CORE 0.001971
K_10621 X_NUC_89.L_CORE X_NUC_106.L_CORE 0.001989
K_10622 X_NUC_89.L_CORE X_NUC_107.L_CORE 0.001981
K_10623 X_NUC_89.L_CORE X_NUC_108.L_CORE 0.001976
K_10624 X_NUC_89.L_CORE X_NUC_109.L_CORE 0.005844
K_10625 X_NUC_89.L_CORE X_NUC_110.L_CORE 0.005906
K_10626 X_NUC_89.L_CORE X_NUC_111.L_CORE 0.005876
K_10627 X_NUC_89.L_CORE X_NUC_112.L_CORE 0.005753
K_10628 X_NUC_89.L_CORE X_NUC_113.L_CORE 0.002551
K_10629 X_NUC_89.L_CORE X_NUC_114.L_CORE 0.002579
K_10630 X_NUC_89.L_CORE X_NUC_115.L_CORE 0.002553
K_10631 X_NUC_89.L_CORE X_NUC_116.L_CORE 0.002564
K_10632 X_NUC_89.L_CORE X_NUC_117.L_CORE 0.002449
K_10633 X_NUC_89.L_CORE X_NUC_118.L_CORE 0.002472
K_10634 X_NUC_89.L_CORE X_NUC_119.L_CORE 0.002462
K_10635 X_NUC_89.L_CORE X_NUC_120.L_CORE 0.002446
K_10636 X_NUC_89.L_CORE X_NUC_121.L_CORE 0.005068
K_10637 X_NUC_89.L_CORE X_NUC_122.L_CORE 0.005152
K_10638 X_NUC_89.L_CORE X_NUC_123.L_CORE 0.005036
K_10639 X_NUC_89.L_CORE X_NUC_124.L_CORE 0.005055
K_10640 X_NUC_89.L_CORE X_NUC_125.L_CORE 0.002388
K_10641 X_NUC_89.L_CORE X_NUC_126.L_CORE 0.002414
K_10642 X_NUC_89.L_CORE X_NUC_127.L_CORE 0.002394
K_10643 X_NUC_89.L_CORE X_NUC_128.L_CORE 0.002393
K_10644 X_NUC_89.L_CORE X_NUC_129.L_CORE 0.003263
K_10645 X_NUC_89.L_CORE X_NUC_130.L_CORE 0.003301
K_10646 X_NUC_89.L_CORE X_NUC_131.L_CORE 0.003269
K_10647 X_NUC_89.L_CORE X_NUC_132.L_CORE 0.003252
K_10648 X_NUC_89.L_CORE X_NUC_133.L_CORE 0.001864
K_10649 X_NUC_89.L_CORE X_NUC_134.L_CORE 0.002376
K_10650 X_NUC_89.L_CORE X_NUC_135.L_CORE 0.001815
K_10651 X_NUC_89.L_CORE X_NUC_136.L_CORE 0.002017
K_10652 X_NUC_89.L_CORE X_NUC_137.L_CORE 0.002566
K_10653 X_NUC_89.L_CORE X_NUC_138.L_CORE 0.001662
K_10654 X_NUC_89.L_CORE X_NUC_139.L_CORE 0.002853
K_10655 X_NUC_89.L_CORE X_NUC_140.L_CORE 0.002029
K_10656 X_NUC_89.L_CORE X_NUC_141.L_CORE 0.001802
K_10657 X_NUC_89.L_CORE X_NUC_142.L_CORE 0.004004
K_10658 X_NUC_89.L_CORE X_NUC_143.L_CORE 0.001685
K_10659 X_NUC_89.L_CORE X_NUC_144.L_CORE 0.002510
K_10660 X_NUC_89.L_CORE X_NUC_145.L_CORE 0.002750
K_10661 X_NUC_89.L_CORE X_NUC_146.L_CORE 0.001671
K_10662 X_NUC_89.L_CORE X_NUC_147.L_CORE 0.005444
K_10663 X_NUC_89.L_CORE X_NUC_148.L_CORE 0.001919
K_10664 X_NUC_89.L_CORE X_NUC_149.L_CORE 0.002071
K_10665 X_NUC_89.L_CORE X_NUC_150.L_CORE 0.005203
K_10666 X_NUC_89.L_CORE X_NUC_151.L_CORE 0.001692
K_10667 X_NUC_89.L_CORE X_NUC_152.L_CORE 0.003738
K_10668 X_NUC_89.L_CORE X_NUC_153.L_CORE 0.002529
K_10669 X_NUC_89.L_CORE X_NUC_154.L_CORE 0.001858
K_10670 X_NUC_89.L_CORE X_NUC_155.L_CORE 0.029910
K_10671 X_NUC_89.L_CORE X_NUC_156.L_CORE 0.001907
K_10672 X_NUC_89.L_CORE X_NUC_157.L_CORE 0.002654
K_10673 X_NUC_89.L_CORE X_NUC_158.L_CORE 0.004016
K_10674 X_NUC_89.L_CORE X_NUC_159.L_CORE 0.001879
K_10675 X_NUC_89.L_CORE X_NUC_160.L_CORE 0.005468
K_10676 X_NUC_89.L_CORE X_NUC_161.L_CORE 0.002429
K_10677 X_NUC_89.L_CORE X_NUC_162.L_CORE 0.002331
K_10678 X_NUC_89.L_CORE X_NUC_163.L_CORE 0.004770
K_10679 X_NUC_89.L_CORE X_NUC_164.L_CORE 0.002274
K_10680 X_NUC_89.L_CORE X_NUC_165.L_CORE 0.003096
K_10681 X_NUC_90.L_CORE X_NUC_91.L_CORE 0.207973
K_10682 X_NUC_90.L_CORE X_NUC_92.L_CORE 0.207973
K_10683 X_NUC_90.L_CORE X_NUC_93.L_CORE 0.001980
K_10684 X_NUC_90.L_CORE X_NUC_94.L_CORE 0.001999
K_10685 X_NUC_90.L_CORE X_NUC_95.L_CORE 0.001987
K_10686 X_NUC_90.L_CORE X_NUC_96.L_CORE 0.001991
K_10687 X_NUC_90.L_CORE X_NUC_97.L_CORE 0.002771
K_10688 X_NUC_90.L_CORE X_NUC_98.L_CORE 0.002792
K_10689 X_NUC_90.L_CORE X_NUC_99.L_CORE 0.002794
K_10690 X_NUC_90.L_CORE X_NUC_100.L_CORE 0.002764
K_10691 X_NUC_90.L_CORE X_NUC_101.L_CORE 0.004181
K_10692 X_NUC_90.L_CORE X_NUC_102.L_CORE 0.004238
K_10693 X_NUC_90.L_CORE X_NUC_103.L_CORE 0.004166
K_10694 X_NUC_90.L_CORE X_NUC_104.L_CORE 0.004226
K_10695 X_NUC_90.L_CORE X_NUC_105.L_CORE 0.001954
K_10696 X_NUC_90.L_CORE X_NUC_106.L_CORE 0.001971
K_10697 X_NUC_90.L_CORE X_NUC_107.L_CORE 0.001963
K_10698 X_NUC_90.L_CORE X_NUC_108.L_CORE 0.001958
K_10699 X_NUC_90.L_CORE X_NUC_109.L_CORE 0.005779
K_10700 X_NUC_90.L_CORE X_NUC_110.L_CORE 0.005844
K_10701 X_NUC_90.L_CORE X_NUC_111.L_CORE 0.005813
K_10702 X_NUC_90.L_CORE X_NUC_112.L_CORE 0.005693
K_10703 X_NUC_90.L_CORE X_NUC_113.L_CORE 0.002523
K_10704 X_NUC_90.L_CORE X_NUC_114.L_CORE 0.002551
K_10705 X_NUC_90.L_CORE X_NUC_115.L_CORE 0.002525
K_10706 X_NUC_90.L_CORE X_NUC_116.L_CORE 0.002536
K_10707 X_NUC_90.L_CORE X_NUC_117.L_CORE 0.002426
K_10708 X_NUC_90.L_CORE X_NUC_118.L_CORE 0.002449
K_10709 X_NUC_90.L_CORE X_NUC_119.L_CORE 0.002439
K_10710 X_NUC_90.L_CORE X_NUC_120.L_CORE 0.002424
K_10711 X_NUC_90.L_CORE X_NUC_121.L_CORE 0.004984
K_10712 X_NUC_90.L_CORE X_NUC_122.L_CORE 0.005068
K_10713 X_NUC_90.L_CORE X_NUC_123.L_CORE 0.004956
K_10714 X_NUC_90.L_CORE X_NUC_124.L_CORE 0.004974
K_10715 X_NUC_90.L_CORE X_NUC_125.L_CORE 0.002363
K_10716 X_NUC_90.L_CORE X_NUC_126.L_CORE 0.002388
K_10717 X_NUC_90.L_CORE X_NUC_127.L_CORE 0.002369
K_10718 X_NUC_90.L_CORE X_NUC_128.L_CORE 0.002368
K_10719 X_NUC_90.L_CORE X_NUC_129.L_CORE 0.003225
K_10720 X_NUC_90.L_CORE X_NUC_130.L_CORE 0.003263
K_10721 X_NUC_90.L_CORE X_NUC_131.L_CORE 0.003232
K_10722 X_NUC_90.L_CORE X_NUC_132.L_CORE 0.003215
K_10723 X_NUC_90.L_CORE X_NUC_133.L_CORE 0.001854
K_10724 X_NUC_90.L_CORE X_NUC_134.L_CORE 0.002367
K_10725 X_NUC_90.L_CORE X_NUC_135.L_CORE 0.001803
K_10726 X_NUC_90.L_CORE X_NUC_136.L_CORE 0.002007
K_10727 X_NUC_90.L_CORE X_NUC_137.L_CORE 0.002554
K_10728 X_NUC_90.L_CORE X_NUC_138.L_CORE 0.001651
K_10729 X_NUC_90.L_CORE X_NUC_139.L_CORE 0.002848
K_10730 X_NUC_90.L_CORE X_NUC_140.L_CORE 0.002015
K_10731 X_NUC_90.L_CORE X_NUC_141.L_CORE 0.001791
K_10732 X_NUC_90.L_CORE X_NUC_142.L_CORE 0.004005
K_10733 X_NUC_90.L_CORE X_NUC_143.L_CORE 0.001672
K_10734 X_NUC_90.L_CORE X_NUC_144.L_CORE 0.002501
K_10735 X_NUC_90.L_CORE X_NUC_145.L_CORE 0.002731
K_10736 X_NUC_90.L_CORE X_NUC_146.L_CORE 0.001659
K_10737 X_NUC_90.L_CORE X_NUC_147.L_CORE 0.005481
K_10738 X_NUC_90.L_CORE X_NUC_148.L_CORE 0.001903
K_10739 X_NUC_90.L_CORE X_NUC_149.L_CORE 0.002059
K_10740 X_NUC_90.L_CORE X_NUC_150.L_CORE 0.005183
K_10741 X_NUC_90.L_CORE X_NUC_151.L_CORE 0.001678
K_10742 X_NUC_90.L_CORE X_NUC_152.L_CORE 0.003730
K_10743 X_NUC_90.L_CORE X_NUC_153.L_CORE 0.002507
K_10744 X_NUC_90.L_CORE X_NUC_154.L_CORE 0.001844
K_10745 X_NUC_90.L_CORE X_NUC_155.L_CORE 0.034341
K_10746 X_NUC_90.L_CORE X_NUC_156.L_CORE 0.001890
K_10747 X_NUC_90.L_CORE X_NUC_157.L_CORE 0.002637
K_10748 X_NUC_90.L_CORE X_NUC_158.L_CORE 0.003972
K_10749 X_NUC_90.L_CORE X_NUC_159.L_CORE 0.001863
K_10750 X_NUC_90.L_CORE X_NUC_160.L_CORE 0.005433
K_10751 X_NUC_90.L_CORE X_NUC_161.L_CORE 0.002405
K_10752 X_NUC_90.L_CORE X_NUC_162.L_CORE 0.002311
K_10753 X_NUC_90.L_CORE X_NUC_163.L_CORE 0.004708
K_10754 X_NUC_90.L_CORE X_NUC_164.L_CORE 0.002252
K_10755 X_NUC_90.L_CORE X_NUC_165.L_CORE 0.003064
K_10756 X_NUC_91.L_CORE X_NUC_92.L_CORE 0.207973
K_10757 X_NUC_91.L_CORE X_NUC_93.L_CORE 0.001992
K_10758 X_NUC_91.L_CORE X_NUC_94.L_CORE 0.002011
K_10759 X_NUC_91.L_CORE X_NUC_95.L_CORE 0.001999
K_10760 X_NUC_91.L_CORE X_NUC_96.L_CORE 0.002003
K_10761 X_NUC_91.L_CORE X_NUC_97.L_CORE 0.002769
K_10762 X_NUC_91.L_CORE X_NUC_98.L_CORE 0.002789
K_10763 X_NUC_91.L_CORE X_NUC_99.L_CORE 0.002792
K_10764 X_NUC_91.L_CORE X_NUC_100.L_CORE 0.002761
K_10765 X_NUC_91.L_CORE X_NUC_101.L_CORE 0.004253
K_10766 X_NUC_91.L_CORE X_NUC_102.L_CORE 0.004312
K_10767 X_NUC_91.L_CORE X_NUC_103.L_CORE 0.004238
K_10768 X_NUC_91.L_CORE X_NUC_104.L_CORE 0.004300
K_10769 X_NUC_91.L_CORE X_NUC_105.L_CORE 0.001962
K_10770 X_NUC_91.L_CORE X_NUC_106.L_CORE 0.001980
K_10771 X_NUC_91.L_CORE X_NUC_107.L_CORE 0.001971
K_10772 X_NUC_91.L_CORE X_NUC_108.L_CORE 0.001967
K_10773 X_NUC_91.L_CORE X_NUC_109.L_CORE 0.005808
K_10774 X_NUC_91.L_CORE X_NUC_110.L_CORE 0.005871
K_10775 X_NUC_91.L_CORE X_NUC_111.L_CORE 0.005844
K_10776 X_NUC_91.L_CORE X_NUC_112.L_CORE 0.005720
K_10777 X_NUC_91.L_CORE X_NUC_113.L_CORE 0.002548
K_10778 X_NUC_91.L_CORE X_NUC_114.L_CORE 0.002576
K_10779 X_NUC_91.L_CORE X_NUC_115.L_CORE 0.002551
K_10780 X_NUC_91.L_CORE X_NUC_116.L_CORE 0.002561
K_10781 X_NUC_91.L_CORE X_NUC_117.L_CORE 0.002436
K_10782 X_NUC_91.L_CORE X_NUC_118.L_CORE 0.002459
K_10783 X_NUC_91.L_CORE X_NUC_119.L_CORE 0.002449
K_10784 X_NUC_91.L_CORE X_NUC_120.L_CORE 0.002433
K_10785 X_NUC_91.L_CORE X_NUC_121.L_CORE 0.005096
K_10786 X_NUC_91.L_CORE X_NUC_122.L_CORE 0.005184
K_10787 X_NUC_91.L_CORE X_NUC_123.L_CORE 0.005068
K_10788 X_NUC_91.L_CORE X_NUC_124.L_CORE 0.005085
K_10789 X_NUC_91.L_CORE X_NUC_125.L_CORE 0.002382
K_10790 X_NUC_91.L_CORE X_NUC_126.L_CORE 0.002408
K_10791 X_NUC_91.L_CORE X_NUC_127.L_CORE 0.002388
K_10792 X_NUC_91.L_CORE X_NUC_128.L_CORE 0.002387
K_10793 X_NUC_91.L_CORE X_NUC_129.L_CORE 0.003256
K_10794 X_NUC_91.L_CORE X_NUC_130.L_CORE 0.003294
K_10795 X_NUC_91.L_CORE X_NUC_131.L_CORE 0.003263
K_10796 X_NUC_91.L_CORE X_NUC_132.L_CORE 0.003245
K_10797 X_NUC_91.L_CORE X_NUC_133.L_CORE 0.001848
K_10798 X_NUC_91.L_CORE X_NUC_134.L_CORE 0.002352
K_10799 X_NUC_91.L_CORE X_NUC_135.L_CORE 0.001802
K_10800 X_NUC_91.L_CORE X_NUC_136.L_CORE 0.001997
K_10801 X_NUC_91.L_CORE X_NUC_137.L_CORE 0.002546
K_10802 X_NUC_91.L_CORE X_NUC_138.L_CORE 0.001650
K_10803 X_NUC_91.L_CORE X_NUC_139.L_CORE 0.002817
K_10804 X_NUC_91.L_CORE X_NUC_140.L_CORE 0.002018
K_10805 X_NUC_91.L_CORE X_NUC_141.L_CORE 0.001787
K_10806 X_NUC_91.L_CORE X_NUC_142.L_CORE 0.003962
K_10807 X_NUC_91.L_CORE X_NUC_143.L_CORE 0.001676
K_10808 X_NUC_91.L_CORE X_NUC_144.L_CORE 0.002483
K_10809 X_NUC_91.L_CORE X_NUC_145.L_CORE 0.002740
K_10810 X_NUC_91.L_CORE X_NUC_146.L_CORE 0.001660
K_10811 X_NUC_91.L_CORE X_NUC_147.L_CORE 0.005346
K_10812 X_NUC_91.L_CORE X_NUC_148.L_CORE 0.001912
K_10813 X_NUC_91.L_CORE X_NUC_149.L_CORE 0.002054
K_10814 X_NUC_91.L_CORE X_NUC_150.L_CORE 0.005209
K_10815 X_NUC_91.L_CORE X_NUC_151.L_CORE 0.001683
K_10816 X_NUC_91.L_CORE X_NUC_152.L_CORE 0.003694
K_10817 X_NUC_91.L_CORE X_NUC_153.L_CORE 0.002527
K_10818 X_NUC_91.L_CORE X_NUC_154.L_CORE 0.001846
K_10819 X_NUC_91.L_CORE X_NUC_155.L_CORE 0.033653
K_10820 X_NUC_91.L_CORE X_NUC_156.L_CORE 0.001901
K_10821 X_NUC_91.L_CORE X_NUC_157.L_CORE 0.002635
K_10822 X_NUC_91.L_CORE X_NUC_158.L_CORE 0.004039
K_10823 X_NUC_91.L_CORE X_NUC_159.L_CORE 0.001871
K_10824 X_NUC_91.L_CORE X_NUC_160.L_CORE 0.005456
K_10825 X_NUC_91.L_CORE X_NUC_161.L_CORE 0.002428
K_10826 X_NUC_91.L_CORE X_NUC_162.L_CORE 0.002320
K_10827 X_NUC_91.L_CORE X_NUC_163.L_CORE 0.004811
K_10828 X_NUC_91.L_CORE X_NUC_164.L_CORE 0.002270
K_10829 X_NUC_91.L_CORE X_NUC_165.L_CORE 0.003093
K_10830 X_NUC_92.L_CORE X_NUC_93.L_CORE 0.001988
K_10831 X_NUC_92.L_CORE X_NUC_94.L_CORE 0.002007
K_10832 X_NUC_92.L_CORE X_NUC_95.L_CORE 0.001995
K_10833 X_NUC_92.L_CORE X_NUC_96.L_CORE 0.001999
K_10834 X_NUC_92.L_CORE X_NUC_97.L_CORE 0.002799
K_10835 X_NUC_92.L_CORE X_NUC_98.L_CORE 0.002821
K_10836 X_NUC_92.L_CORE X_NUC_99.L_CORE 0.002823
K_10837 X_NUC_92.L_CORE X_NUC_100.L_CORE 0.002792
K_10838 X_NUC_92.L_CORE X_NUC_101.L_CORE 0.004192
K_10839 X_NUC_92.L_CORE X_NUC_102.L_CORE 0.004248
K_10840 X_NUC_92.L_CORE X_NUC_103.L_CORE 0.004176
K_10841 X_NUC_92.L_CORE X_NUC_104.L_CORE 0.004238
K_10842 X_NUC_92.L_CORE X_NUC_105.L_CORE 0.001967
K_10843 X_NUC_92.L_CORE X_NUC_106.L_CORE 0.001985
K_10844 X_NUC_92.L_CORE X_NUC_107.L_CORE 0.001976
K_10845 X_NUC_92.L_CORE X_NUC_108.L_CORE 0.001971
K_10846 X_NUC_92.L_CORE X_NUC_109.L_CORE 0.005935
K_10847 X_NUC_92.L_CORE X_NUC_110.L_CORE 0.006003
K_10848 X_NUC_92.L_CORE X_NUC_111.L_CORE 0.005971
K_10849 X_NUC_92.L_CORE X_NUC_112.L_CORE 0.005844
K_10850 X_NUC_92.L_CORE X_NUC_113.L_CORE 0.002537
K_10851 X_NUC_92.L_CORE X_NUC_114.L_CORE 0.002565
K_10852 X_NUC_92.L_CORE X_NUC_115.L_CORE 0.002540
K_10853 X_NUC_92.L_CORE X_NUC_116.L_CORE 0.002551
K_10854 X_NUC_92.L_CORE X_NUC_117.L_CORE 0.002451
K_10855 X_NUC_92.L_CORE X_NUC_118.L_CORE 0.002475
K_10856 X_NUC_92.L_CORE X_NUC_119.L_CORE 0.002465
K_10857 X_NUC_92.L_CORE X_NUC_120.L_CORE 0.002449
K_10858 X_NUC_92.L_CORE X_NUC_121.L_CORE 0.005078
K_10859 X_NUC_92.L_CORE X_NUC_122.L_CORE 0.005164
K_10860 X_NUC_92.L_CORE X_NUC_123.L_CORE 0.005048
K_10861 X_NUC_92.L_CORE X_NUC_124.L_CORE 0.005068
K_10862 X_NUC_92.L_CORE X_NUC_125.L_CORE 0.002384
K_10863 X_NUC_92.L_CORE X_NUC_126.L_CORE 0.002409
K_10864 X_NUC_92.L_CORE X_NUC_127.L_CORE 0.002390
K_10865 X_NUC_92.L_CORE X_NUC_128.L_CORE 0.002388
K_10866 X_NUC_92.L_CORE X_NUC_129.L_CORE 0.003273
K_10867 X_NUC_92.L_CORE X_NUC_130.L_CORE 0.003312
K_10868 X_NUC_92.L_CORE X_NUC_131.L_CORE 0.003280
K_10869 X_NUC_92.L_CORE X_NUC_132.L_CORE 0.003263
K_10870 X_NUC_92.L_CORE X_NUC_133.L_CORE 0.001851
K_10871 X_NUC_92.L_CORE X_NUC_134.L_CORE 0.002355
K_10872 X_NUC_92.L_CORE X_NUC_135.L_CORE 0.001800
K_10873 X_NUC_92.L_CORE X_NUC_136.L_CORE 0.002007
K_10874 X_NUC_92.L_CORE X_NUC_137.L_CORE 0.002535
K_10875 X_NUC_92.L_CORE X_NUC_138.L_CORE 0.001652
K_10876 X_NUC_92.L_CORE X_NUC_139.L_CORE 0.002837
K_10877 X_NUC_92.L_CORE X_NUC_140.L_CORE 0.002010
K_10878 X_NUC_92.L_CORE X_NUC_141.L_CORE 0.001795
K_10879 X_NUC_92.L_CORE X_NUC_142.L_CORE 0.003943
K_10880 X_NUC_92.L_CORE X_NUC_143.L_CORE 0.001674
K_10881 X_NUC_92.L_CORE X_NUC_144.L_CORE 0.002506
K_10882 X_NUC_92.L_CORE X_NUC_145.L_CORE 0.002715
K_10883 X_NUC_92.L_CORE X_NUC_146.L_CORE 0.001665
K_10884 X_NUC_92.L_CORE X_NUC_147.L_CORE 0.005423
K_10885 X_NUC_92.L_CORE X_NUC_148.L_CORE 0.001905
K_10886 X_NUC_92.L_CORE X_NUC_149.L_CORE 0.002070
K_10887 X_NUC_92.L_CORE X_NUC_150.L_CORE 0.005097
K_10888 X_NUC_92.L_CORE X_NUC_151.L_CORE 0.001684
K_10889 X_NUC_92.L_CORE X_NUC_152.L_CORE 0.003759
K_10890 X_NUC_92.L_CORE X_NUC_153.L_CORE 0.002506
K_10891 X_NUC_92.L_CORE X_NUC_154.L_CORE 0.001855
K_10892 X_NUC_92.L_CORE X_NUC_155.L_CORE 0.032767
K_10893 X_NUC_92.L_CORE X_NUC_156.L_CORE 0.001897
K_10894 X_NUC_92.L_CORE X_NUC_157.L_CORE 0.002663
K_10895 X_NUC_92.L_CORE X_NUC_158.L_CORE 0.003979
K_10896 X_NUC_92.L_CORE X_NUC_159.L_CORE 0.001876
K_10897 X_NUC_92.L_CORE X_NUC_160.L_CORE 0.005568
K_10898 X_NUC_92.L_CORE X_NUC_161.L_CORE 0.002418
K_10899 X_NUC_92.L_CORE X_NUC_162.L_CORE 0.002334
K_10900 X_NUC_92.L_CORE X_NUC_163.L_CORE 0.004790
K_10901 X_NUC_92.L_CORE X_NUC_164.L_CORE 0.002271
K_10902 X_NUC_92.L_CORE X_NUC_165.L_CORE 0.003109
K_10903 X_NUC_93.L_CORE X_NUC_94.L_CORE 0.207973
K_10904 X_NUC_93.L_CORE X_NUC_95.L_CORE 0.207973
K_10905 X_NUC_93.L_CORE X_NUC_96.L_CORE 0.207973
K_10906 X_NUC_93.L_CORE X_NUC_97.L_CORE 0.002063
K_10907 X_NUC_93.L_CORE X_NUC_98.L_CORE 0.002051
K_10908 X_NUC_93.L_CORE X_NUC_99.L_CORE 0.002064
K_10909 X_NUC_93.L_CORE X_NUC_100.L_CORE 0.002048
K_10910 X_NUC_93.L_CORE X_NUC_101.L_CORE 0.002890
K_10911 X_NUC_93.L_CORE X_NUC_102.L_CORE 0.002852
K_10912 X_NUC_93.L_CORE X_NUC_103.L_CORE 0.002863
K_10913 X_NUC_93.L_CORE X_NUC_104.L_CORE 0.002872
K_10914 X_NUC_93.L_CORE X_NUC_105.L_CORE 0.004388
K_10915 X_NUC_93.L_CORE X_NUC_106.L_CORE 0.004385
K_10916 X_NUC_93.L_CORE X_NUC_107.L_CORE 0.004416
K_10917 X_NUC_93.L_CORE X_NUC_108.L_CORE 0.004327
K_10918 X_NUC_93.L_CORE X_NUC_109.L_CORE 0.002060
K_10919 X_NUC_93.L_CORE X_NUC_110.L_CORE 0.002042
K_10920 X_NUC_93.L_CORE X_NUC_111.L_CORE 0.002054
K_10921 X_NUC_93.L_CORE X_NUC_112.L_CORE 0.002045
K_10922 X_NUC_93.L_CORE X_NUC_113.L_CORE 0.005925
K_10923 X_NUC_93.L_CORE X_NUC_114.L_CORE 0.005790
K_10924 X_NUC_93.L_CORE X_NUC_115.L_CORE 0.005777
K_10925 X_NUC_93.L_CORE X_NUC_116.L_CORE 0.005815
K_10926 X_NUC_93.L_CORE X_NUC_117.L_CORE 0.002690
K_10927 X_NUC_93.L_CORE X_NUC_118.L_CORE 0.002674
K_10928 X_NUC_93.L_CORE X_NUC_119.L_CORE 0.002689
K_10929 X_NUC_93.L_CORE X_NUC_120.L_CORE 0.002661
K_10930 X_NUC_93.L_CORE X_NUC_121.L_CORE 0.002610
K_10931 X_NUC_93.L_CORE X_NUC_122.L_CORE 0.002580
K_10932 X_NUC_93.L_CORE X_NUC_123.L_CORE 0.002590
K_10933 X_NUC_93.L_CORE X_NUC_124.L_CORE 0.002585
K_10934 X_NUC_93.L_CORE X_NUC_125.L_CORE 0.004750
K_10935 X_NUC_93.L_CORE X_NUC_126.L_CORE 0.004696
K_10936 X_NUC_93.L_CORE X_NUC_127.L_CORE 0.004701
K_10937 X_NUC_93.L_CORE X_NUC_128.L_CORE 0.004644
K_10938 X_NUC_93.L_CORE X_NUC_129.L_CORE 0.002719
K_10939 X_NUC_93.L_CORE X_NUC_130.L_CORE 0.002694
K_10940 X_NUC_93.L_CORE X_NUC_131.L_CORE 0.002705
K_10941 X_NUC_93.L_CORE X_NUC_132.L_CORE 0.002686
K_10942 X_NUC_93.L_CORE X_NUC_133.L_CORE 0.001973
K_10943 X_NUC_93.L_CORE X_NUC_134.L_CORE 0.001766
K_10944 X_NUC_93.L_CORE X_NUC_135.L_CORE 0.002449
K_10945 X_NUC_93.L_CORE X_NUC_136.L_CORE 0.001769
K_10946 X_NUC_93.L_CORE X_NUC_137.L_CORE 0.001987
K_10947 X_NUC_93.L_CORE X_NUC_138.L_CORE 0.002571
K_10948 X_NUC_93.L_CORE X_NUC_139.L_CORE 0.001634
K_10949 X_NUC_93.L_CORE X_NUC_140.L_CORE 0.002848
K_10950 X_NUC_93.L_CORE X_NUC_141.L_CORE 0.002013
K_10951 X_NUC_93.L_CORE X_NUC_142.L_CORE 0.001786
K_10952 X_NUC_93.L_CORE X_NUC_143.L_CORE 0.004014
K_10953 X_NUC_93.L_CORE X_NUC_144.L_CORE 0.001678
K_10954 X_NUC_93.L_CORE X_NUC_145.L_CORE 0.002501
K_10955 X_NUC_93.L_CORE X_NUC_146.L_CORE 0.002753
K_10956 X_NUC_93.L_CORE X_NUC_147.L_CORE 0.001672
K_10957 X_NUC_93.L_CORE X_NUC_148.L_CORE 0.005434
K_10958 X_NUC_93.L_CORE X_NUC_149.L_CORE 0.001930
K_10959 X_NUC_93.L_CORE X_NUC_150.L_CORE 0.002083
K_10960 X_NUC_93.L_CORE X_NUC_151.L_CORE 0.005270
K_10961 X_NUC_93.L_CORE X_NUC_152.L_CORE 0.001710
K_10962 X_NUC_93.L_CORE X_NUC_153.L_CORE 0.003779
K_10963 X_NUC_93.L_CORE X_NUC_154.L_CORE 0.002574
K_10964 X_NUC_93.L_CORE X_NUC_155.L_CORE 0.001890
K_10965 X_NUC_93.L_CORE X_NUC_156.L_CORE 0.033776
K_10966 X_NUC_93.L_CORE X_NUC_157.L_CORE 0.001953
K_10967 X_NUC_93.L_CORE X_NUC_158.L_CORE 0.002721
K_10968 X_NUC_93.L_CORE X_NUC_159.L_CORE 0.004135
K_10969 X_NUC_93.L_CORE X_NUC_160.L_CORE 0.001947
K_10970 X_NUC_93.L_CORE X_NUC_161.L_CORE 0.005471
K_10971 X_NUC_93.L_CORE X_NUC_162.L_CORE 0.002541
K_10972 X_NUC_93.L_CORE X_NUC_163.L_CORE 0.002459
K_10973 X_NUC_93.L_CORE X_NUC_164.L_CORE 0.004431
K_10974 X_NUC_93.L_CORE X_NUC_165.L_CORE 0.002563
K_10975 X_NUC_94.L_CORE X_NUC_95.L_CORE 0.207973
K_10976 X_NUC_94.L_CORE X_NUC_96.L_CORE 0.207973
K_10977 X_NUC_94.L_CORE X_NUC_97.L_CORE 0.002075
K_10978 X_NUC_94.L_CORE X_NUC_98.L_CORE 0.002063
K_10979 X_NUC_94.L_CORE X_NUC_99.L_CORE 0.002077
K_10980 X_NUC_94.L_CORE X_NUC_100.L_CORE 0.002060
K_10981 X_NUC_94.L_CORE X_NUC_101.L_CORE 0.002929
K_10982 X_NUC_94.L_CORE X_NUC_102.L_CORE 0.002890
K_10983 X_NUC_94.L_CORE X_NUC_103.L_CORE 0.002902
K_10984 X_NUC_94.L_CORE X_NUC_104.L_CORE 0.002911
K_10985 X_NUC_94.L_CORE X_NUC_105.L_CORE 0.004389
K_10986 X_NUC_94.L_CORE X_NUC_106.L_CORE 0.004388
K_10987 X_NUC_94.L_CORE X_NUC_107.L_CORE 0.004418
K_10988 X_NUC_94.L_CORE X_NUC_108.L_CORE 0.004329
K_10989 X_NUC_94.L_CORE X_NUC_109.L_CORE 0.002078
K_10990 X_NUC_94.L_CORE X_NUC_110.L_CORE 0.002060
K_10991 X_NUC_94.L_CORE X_NUC_111.L_CORE 0.002072
K_10992 X_NUC_94.L_CORE X_NUC_112.L_CORE 0.002062
K_10993 X_NUC_94.L_CORE X_NUC_113.L_CORE 0.006066
K_10994 X_NUC_94.L_CORE X_NUC_114.L_CORE 0.005925
K_10995 X_NUC_94.L_CORE X_NUC_115.L_CORE 0.005910
K_10996 X_NUC_94.L_CORE X_NUC_116.L_CORE 0.005950
K_10997 X_NUC_94.L_CORE X_NUC_117.L_CORE 0.002706
K_10998 X_NUC_94.L_CORE X_NUC_118.L_CORE 0.002690
K_10999 X_NUC_94.L_CORE X_NUC_119.L_CORE 0.002706
K_11000 X_NUC_94.L_CORE X_NUC_120.L_CORE 0.002676
K_11001 X_NUC_94.L_CORE X_NUC_121.L_CORE 0.002641
K_11002 X_NUC_94.L_CORE X_NUC_122.L_CORE 0.002610
K_11003 X_NUC_94.L_CORE X_NUC_123.L_CORE 0.002620
K_11004 X_NUC_94.L_CORE X_NUC_124.L_CORE 0.002615
K_11005 X_NUC_94.L_CORE X_NUC_125.L_CORE 0.004803
K_11006 X_NUC_94.L_CORE X_NUC_126.L_CORE 0.004750
K_11007 X_NUC_94.L_CORE X_NUC_127.L_CORE 0.004754
K_11008 X_NUC_94.L_CORE X_NUC_128.L_CORE 0.004695
K_11009 X_NUC_94.L_CORE X_NUC_129.L_CORE 0.002745
K_11010 X_NUC_94.L_CORE X_NUC_130.L_CORE 0.002719
K_11011 X_NUC_94.L_CORE X_NUC_131.L_CORE 0.002731
K_11012 X_NUC_94.L_CORE X_NUC_132.L_CORE 0.002711
K_11013 X_NUC_94.L_CORE X_NUC_133.L_CORE 0.001979
K_11014 X_NUC_94.L_CORE X_NUC_134.L_CORE 0.001776
K_11015 X_NUC_94.L_CORE X_NUC_135.L_CORE 0.002455
K_11016 X_NUC_94.L_CORE X_NUC_136.L_CORE 0.001776
K_11017 X_NUC_94.L_CORE X_NUC_137.L_CORE 0.002000
K_11018 X_NUC_94.L_CORE X_NUC_138.L_CORE 0.002570
K_11019 X_NUC_94.L_CORE X_NUC_139.L_CORE 0.001644
K_11020 X_NUC_94.L_CORE X_NUC_140.L_CORE 0.002864
K_11021 X_NUC_94.L_CORE X_NUC_141.L_CORE 0.002017
K_11022 X_NUC_94.L_CORE X_NUC_142.L_CORE 0.001800
K_11023 X_NUC_94.L_CORE X_NUC_143.L_CORE 0.003995
K_11024 X_NUC_94.L_CORE X_NUC_144.L_CORE 0.001686
K_11025 X_NUC_94.L_CORE X_NUC_145.L_CORE 0.002524
K_11026 X_NUC_94.L_CORE X_NUC_146.L_CORE 0.002749
K_11027 X_NUC_94.L_CORE X_NUC_147.L_CORE 0.001685
K_11028 X_NUC_94.L_CORE X_NUC_148.L_CORE 0.005455
K_11029 X_NUC_94.L_CORE X_NUC_149.L_CORE 0.001937
K_11030 X_NUC_94.L_CORE X_NUC_150.L_CORE 0.002103
K_11031 X_NUC_94.L_CORE X_NUC_151.L_CORE 0.005203
K_11032 X_NUC_94.L_CORE X_NUC_152.L_CORE 0.001721
K_11033 X_NUC_94.L_CORE X_NUC_153.L_CORE 0.003830
K_11034 X_NUC_94.L_CORE X_NUC_154.L_CORE 0.002577
K_11035 X_NUC_94.L_CORE X_NUC_155.L_CORE 0.001907
K_11036 X_NUC_94.L_CORE X_NUC_156.L_CORE 0.030127
K_11037 X_NUC_94.L_CORE X_NUC_157.L_CORE 0.001964
K_11038 X_NUC_94.L_CORE X_NUC_158.L_CORE 0.002755
K_11039 X_NUC_94.L_CORE X_NUC_159.L_CORE 0.004129
K_11040 X_NUC_94.L_CORE X_NUC_160.L_CORE 0.001963
K_11041 X_NUC_94.L_CORE X_NUC_161.L_CORE 0.005576
K_11042 X_NUC_94.L_CORE X_NUC_162.L_CORE 0.002554
K_11043 X_NUC_94.L_CORE X_NUC_163.L_CORE 0.002486
K_11044 X_NUC_94.L_CORE X_NUC_164.L_CORE 0.004470
K_11045 X_NUC_94.L_CORE X_NUC_165.L_CORE 0.002585
K_11046 X_NUC_95.L_CORE X_NUC_96.L_CORE 0.207973
K_11047 X_NUC_95.L_CORE X_NUC_97.L_CORE 0.002061
K_11048 X_NUC_95.L_CORE X_NUC_98.L_CORE 0.002049
K_11049 X_NUC_95.L_CORE X_NUC_99.L_CORE 0.002063
K_11050 X_NUC_95.L_CORE X_NUC_100.L_CORE 0.002047
K_11051 X_NUC_95.L_CORE X_NUC_101.L_CORE 0.002917
K_11052 X_NUC_95.L_CORE X_NUC_102.L_CORE 0.002878
K_11053 X_NUC_95.L_CORE X_NUC_103.L_CORE 0.002890
K_11054 X_NUC_95.L_CORE X_NUC_104.L_CORE 0.002899
K_11055 X_NUC_95.L_CORE X_NUC_105.L_CORE 0.004359
K_11056 X_NUC_95.L_CORE X_NUC_106.L_CORE 0.004356
K_11057 X_NUC_95.L_CORE X_NUC_107.L_CORE 0.004388
K_11058 X_NUC_95.L_CORE X_NUC_108.L_CORE 0.004300
K_11059 X_NUC_95.L_CORE X_NUC_109.L_CORE 0.002066
K_11060 X_NUC_95.L_CORE X_NUC_110.L_CORE 0.002049
K_11061 X_NUC_95.L_CORE X_NUC_111.L_CORE 0.002060
K_11062 X_NUC_95.L_CORE X_NUC_112.L_CORE 0.002051
K_11063 X_NUC_95.L_CORE X_NUC_113.L_CORE 0.006081
K_11064 X_NUC_95.L_CORE X_NUC_114.L_CORE 0.005937
K_11065 X_NUC_95.L_CORE X_NUC_115.L_CORE 0.005925
K_11066 X_NUC_95.L_CORE X_NUC_116.L_CORE 0.005963
K_11067 X_NUC_95.L_CORE X_NUC_117.L_CORE 0.002690
K_11068 X_NUC_95.L_CORE X_NUC_118.L_CORE 0.002674
K_11069 X_NUC_95.L_CORE X_NUC_119.L_CORE 0.002690
K_11070 X_NUC_95.L_CORE X_NUC_120.L_CORE 0.002661
K_11071 X_NUC_95.L_CORE X_NUC_121.L_CORE 0.002630
K_11072 X_NUC_95.L_CORE X_NUC_122.L_CORE 0.002599
K_11073 X_NUC_95.L_CORE X_NUC_123.L_CORE 0.002610
K_11074 X_NUC_95.L_CORE X_NUC_124.L_CORE 0.002604
K_11075 X_NUC_95.L_CORE X_NUC_125.L_CORE 0.004798
K_11076 X_NUC_95.L_CORE X_NUC_126.L_CORE 0.004744
K_11077 X_NUC_95.L_CORE X_NUC_127.L_CORE 0.004750
K_11078 X_NUC_95.L_CORE X_NUC_128.L_CORE 0.004690
K_11079 X_NUC_95.L_CORE X_NUC_129.L_CORE 0.002733
K_11080 X_NUC_95.L_CORE X_NUC_130.L_CORE 0.002708
K_11081 X_NUC_95.L_CORE X_NUC_131.L_CORE 0.002719
K_11082 X_NUC_95.L_CORE X_NUC_132.L_CORE 0.002700
K_11083 X_NUC_95.L_CORE X_NUC_133.L_CORE 0.001961
K_11084 X_NUC_95.L_CORE X_NUC_134.L_CORE 0.001761
K_11085 X_NUC_95.L_CORE X_NUC_135.L_CORE 0.002431
K_11086 X_NUC_95.L_CORE X_NUC_136.L_CORE 0.001761
K_11087 X_NUC_95.L_CORE X_NUC_137.L_CORE 0.001985
K_11088 X_NUC_95.L_CORE X_NUC_138.L_CORE 0.002544
K_11089 X_NUC_95.L_CORE X_NUC_139.L_CORE 0.001631
K_11090 X_NUC_95.L_CORE X_NUC_140.L_CORE 0.002839
K_11091 X_NUC_95.L_CORE X_NUC_141.L_CORE 0.002000
K_11092 X_NUC_95.L_CORE X_NUC_142.L_CORE 0.001787
K_11093 X_NUC_95.L_CORE X_NUC_143.L_CORE 0.003947
K_11094 X_NUC_95.L_CORE X_NUC_144.L_CORE 0.001674
K_11095 X_NUC_95.L_CORE X_NUC_145.L_CORE 0.002507
K_11096 X_NUC_95.L_CORE X_NUC_146.L_CORE 0.002723
K_11097 X_NUC_95.L_CORE X_NUC_147.L_CORE 0.001674
K_11098 X_NUC_95.L_CORE X_NUC_148.L_CORE 0.005410
K_11099 X_NUC_95.L_CORE X_NUC_149.L_CORE 0.001922
K_11100 X_NUC_95.L_CORE X_NUC_150.L_CORE 0.002091
K_11101 X_NUC_95.L_CORE X_NUC_151.L_CORE 0.005148
K_11102 X_NUC_95.L_CORE X_NUC_152.L_CORE 0.001710
K_11103 X_NUC_95.L_CORE X_NUC_153.L_CORE 0.003818
K_11104 X_NUC_95.L_CORE X_NUC_154.L_CORE 0.002558
K_11105 X_NUC_95.L_CORE X_NUC_155.L_CORE 0.001897
K_11106 X_NUC_95.L_CORE X_NUC_156.L_CORE 0.034718
K_11107 X_NUC_95.L_CORE X_NUC_157.L_CORE 0.001952
K_11108 X_NUC_95.L_CORE X_NUC_158.L_CORE 0.002746
K_11109 X_NUC_95.L_CORE X_NUC_159.L_CORE 0.004110
K_11110 X_NUC_95.L_CORE X_NUC_160.L_CORE 0.001954
K_11111 X_NUC_95.L_CORE X_NUC_161.L_CORE 0.005612
K_11112 X_NUC_95.L_CORE X_NUC_162.L_CORE 0.002542
K_11113 X_NUC_95.L_CORE X_NUC_163.L_CORE 0.002478
K_11114 X_NUC_95.L_CORE X_NUC_164.L_CORE 0.004477
K_11115 X_NUC_95.L_CORE X_NUC_165.L_CORE 0.002576
K_11116 X_NUC_96.L_CORE X_NUC_97.L_CORE 0.002078
K_11117 X_NUC_96.L_CORE X_NUC_98.L_CORE 0.002065
K_11118 X_NUC_96.L_CORE X_NUC_99.L_CORE 0.002079
K_11119 X_NUC_96.L_CORE X_NUC_100.L_CORE 0.002063
K_11120 X_NUC_96.L_CORE X_NUC_101.L_CORE 0.002908
K_11121 X_NUC_96.L_CORE X_NUC_102.L_CORE 0.002869
K_11122 X_NUC_96.L_CORE X_NUC_103.L_CORE 0.002881
K_11123 X_NUC_96.L_CORE X_NUC_104.L_CORE 0.002890
K_11124 X_NUC_96.L_CORE X_NUC_105.L_CORE 0.004450
K_11125 X_NUC_96.L_CORE X_NUC_106.L_CORE 0.004447
K_11126 X_NUC_96.L_CORE X_NUC_107.L_CORE 0.004480
K_11127 X_NUC_96.L_CORE X_NUC_108.L_CORE 0.004388
K_11128 X_NUC_96.L_CORE X_NUC_109.L_CORE 0.002076
K_11129 X_NUC_96.L_CORE X_NUC_110.L_CORE 0.002058
K_11130 X_NUC_96.L_CORE X_NUC_111.L_CORE 0.002070
K_11131 X_NUC_96.L_CORE X_NUC_112.L_CORE 0.002060
K_11132 X_NUC_96.L_CORE X_NUC_113.L_CORE 0.006038
K_11133 X_NUC_96.L_CORE X_NUC_114.L_CORE 0.005897
K_11134 X_NUC_96.L_CORE X_NUC_115.L_CORE 0.005884
K_11135 X_NUC_96.L_CORE X_NUC_116.L_CORE 0.005925
K_11136 X_NUC_96.L_CORE X_NUC_117.L_CORE 0.002720
K_11137 X_NUC_96.L_CORE X_NUC_118.L_CORE 0.002704
K_11138 X_NUC_96.L_CORE X_NUC_119.L_CORE 0.002720
K_11139 X_NUC_96.L_CORE X_NUC_120.L_CORE 0.002690
K_11140 X_NUC_96.L_CORE X_NUC_121.L_CORE 0.002636
K_11141 X_NUC_96.L_CORE X_NUC_122.L_CORE 0.002605
K_11142 X_NUC_96.L_CORE X_NUC_123.L_CORE 0.002615
K_11143 X_NUC_96.L_CORE X_NUC_124.L_CORE 0.002610
K_11144 X_NUC_96.L_CORE X_NUC_125.L_CORE 0.004861
K_11145 X_NUC_96.L_CORE X_NUC_126.L_CORE 0.004804
K_11146 X_NUC_96.L_CORE X_NUC_127.L_CORE 0.004809
K_11147 X_NUC_96.L_CORE X_NUC_128.L_CORE 0.004750
K_11148 X_NUC_96.L_CORE X_NUC_129.L_CORE 0.002753
K_11149 X_NUC_96.L_CORE X_NUC_130.L_CORE 0.002727
K_11150 X_NUC_96.L_CORE X_NUC_131.L_CORE 0.002739
K_11151 X_NUC_96.L_CORE X_NUC_132.L_CORE 0.002719
K_11152 X_NUC_96.L_CORE X_NUC_133.L_CORE 0.001968
K_11153 X_NUC_96.L_CORE X_NUC_134.L_CORE 0.001765
K_11154 X_NUC_96.L_CORE X_NUC_135.L_CORE 0.002434
K_11155 X_NUC_96.L_CORE X_NUC_136.L_CORE 0.001770
K_11156 X_NUC_96.L_CORE X_NUC_137.L_CORE 0.001983
K_11157 X_NUC_96.L_CORE X_NUC_138.L_CORE 0.002559
K_11158 X_NUC_96.L_CORE X_NUC_139.L_CORE 0.001637
K_11159 X_NUC_96.L_CORE X_NUC_140.L_CORE 0.002827
K_11160 X_NUC_96.L_CORE X_NUC_141.L_CORE 0.002015
K_11161 X_NUC_96.L_CORE X_NUC_142.L_CORE 0.001788
K_11162 X_NUC_96.L_CORE X_NUC_143.L_CORE 0.003959
K_11163 X_NUC_96.L_CORE X_NUC_144.L_CORE 0.001683
K_11164 X_NUC_96.L_CORE X_NUC_145.L_CORE 0.002495
K_11165 X_NUC_96.L_CORE X_NUC_146.L_CORE 0.002754
K_11166 X_NUC_96.L_CORE X_NUC_147.L_CORE 0.001678
K_11167 X_NUC_96.L_CORE X_NUC_148.L_CORE 0.005326
K_11168 X_NUC_96.L_CORE X_NUC_149.L_CORE 0.001938
K_11169 X_NUC_96.L_CORE X_NUC_150.L_CORE 0.002088
K_11170 X_NUC_96.L_CORE X_NUC_151.L_CORE 0.005244
K_11171 X_NUC_96.L_CORE X_NUC_152.L_CORE 0.001719
K_11172 X_NUC_96.L_CORE X_NUC_153.L_CORE 0.003774
K_11173 X_NUC_96.L_CORE X_NUC_154.L_CORE 0.002590
K_11174 X_NUC_96.L_CORE X_NUC_155.L_CORE 0.001900
K_11175 X_NUC_96.L_CORE X_NUC_156.L_CORE 0.032073
K_11176 X_NUC_96.L_CORE X_NUC_157.L_CORE 0.001967
K_11177 X_NUC_96.L_CORE X_NUC_158.L_CORE 0.002737
K_11178 X_NUC_96.L_CORE X_NUC_159.L_CORE 0.004189
K_11179 X_NUC_96.L_CORE X_NUC_160.L_CORE 0.001962
K_11180 X_NUC_96.L_CORE X_NUC_161.L_CORE 0.005563
K_11181 X_NUC_96.L_CORE X_NUC_162.L_CORE 0.002568
K_11182 X_NUC_96.L_CORE X_NUC_163.L_CORE 0.002482
K_11183 X_NUC_96.L_CORE X_NUC_164.L_CORE 0.004527
K_11184 X_NUC_96.L_CORE X_NUC_165.L_CORE 0.002593
K_11185 X_NUC_97.L_CORE X_NUC_98.L_CORE 0.207973
K_11186 X_NUC_97.L_CORE X_NUC_99.L_CORE 0.207973
K_11187 X_NUC_97.L_CORE X_NUC_100.L_CORE 0.207973
K_11188 X_NUC_97.L_CORE X_NUC_101.L_CORE 0.002144
K_11189 X_NUC_97.L_CORE X_NUC_102.L_CORE 0.002142
K_11190 X_NUC_97.L_CORE X_NUC_103.L_CORE 0.002131
K_11191 X_NUC_97.L_CORE X_NUC_104.L_CORE 0.002153
K_11192 X_NUC_97.L_CORE X_NUC_105.L_CORE 0.003015
K_11193 X_NUC_97.L_CORE X_NUC_106.L_CORE 0.003053
K_11194 X_NUC_97.L_CORE X_NUC_107.L_CORE 0.003019
K_11195 X_NUC_97.L_CORE X_NUC_108.L_CORE 0.003041
K_11196 X_NUC_97.L_CORE X_NUC_109.L_CORE 0.004576
K_11197 X_NUC_97.L_CORE X_NUC_110.L_CORE 0.004514
K_11198 X_NUC_97.L_CORE X_NUC_111.L_CORE 0.004491
K_11199 X_NUC_97.L_CORE X_NUC_112.L_CORE 0.004564
K_11200 X_NUC_97.L_CORE X_NUC_113.L_CORE 0.002176
K_11201 X_NUC_97.L_CORE X_NUC_114.L_CORE 0.002184
K_11202 X_NUC_97.L_CORE X_NUC_115.L_CORE 0.002167
K_11203 X_NUC_97.L_CORE X_NUC_116.L_CORE 0.002188
K_11204 X_NUC_97.L_CORE X_NUC_117.L_CORE 0.005988
K_11205 X_NUC_97.L_CORE X_NUC_118.L_CORE 0.006114
K_11206 X_NUC_97.L_CORE X_NUC_119.L_CORE 0.005945
K_11207 X_NUC_97.L_CORE X_NUC_120.L_CORE 0.006022
K_11208 X_NUC_97.L_CORE X_NUC_121.L_CORE 0.002877
K_11209 X_NUC_97.L_CORE X_NUC_122.L_CORE 0.002869
K_11210 X_NUC_97.L_CORE X_NUC_123.L_CORE 0.002846
K_11211 X_NUC_97.L_CORE X_NUC_124.L_CORE 0.002883
K_11212 X_NUC_97.L_CORE X_NUC_125.L_CORE 0.002840
K_11213 X_NUC_97.L_CORE X_NUC_126.L_CORE 0.002860
K_11214 X_NUC_97.L_CORE X_NUC_127.L_CORE 0.002825
K_11215 X_NUC_97.L_CORE X_NUC_128.L_CORE 0.002855
K_11216 X_NUC_97.L_CORE X_NUC_129.L_CORE 0.004221
K_11217 X_NUC_97.L_CORE X_NUC_130.L_CORE 0.004230
K_11218 X_NUC_97.L_CORE X_NUC_131.L_CORE 0.004156
K_11219 X_NUC_97.L_CORE X_NUC_132.L_CORE 0.004223
K_11220 X_NUC_97.L_CORE X_NUC_133.L_CORE 0.001977
K_11221 X_NUC_97.L_CORE X_NUC_134.L_CORE 0.001976
K_11222 X_NUC_97.L_CORE X_NUC_135.L_CORE 0.001725
K_11223 X_NUC_97.L_CORE X_NUC_136.L_CORE 0.002506
K_11224 X_NUC_97.L_CORE X_NUC_137.L_CORE 0.001748
K_11225 X_NUC_97.L_CORE X_NUC_138.L_CORE 0.001987
K_11226 X_NUC_97.L_CORE X_NUC_139.L_CORE 0.002570
K_11227 X_NUC_97.L_CORE X_NUC_140.L_CORE 0.001632
K_11228 X_NUC_97.L_CORE X_NUC_141.L_CORE 0.002869
K_11229 X_NUC_97.L_CORE X_NUC_142.L_CORE 0.002011
K_11230 X_NUC_97.L_CORE X_NUC_143.L_CORE 0.001801
K_11231 X_NUC_97.L_CORE X_NUC_144.L_CORE 0.003978
K_11232 X_NUC_97.L_CORE X_NUC_145.L_CORE 0.001693
K_11233 X_NUC_97.L_CORE X_NUC_146.L_CORE 0.002539
K_11234 X_NUC_97.L_CORE X_NUC_147.L_CORE 0.002756
K_11235 X_NUC_97.L_CORE X_NUC_148.L_CORE 0.001702
K_11236 X_NUC_97.L_CORE X_NUC_149.L_CORE 0.005453
K_11237 X_NUC_97.L_CORE X_NUC_150.L_CORE 0.001961
K_11238 X_NUC_97.L_CORE X_NUC_151.L_CORE 0.002139
K_11239 X_NUC_97.L_CORE X_NUC_152.L_CORE 0.005231
K_11240 X_NUC_97.L_CORE X_NUC_153.L_CORE 0.001757
K_11241 X_NUC_97.L_CORE X_NUC_154.L_CORE 0.003930
K_11242 X_NUC_97.L_CORE X_NUC_155.L_CORE 0.002638
K_11243 X_NUC_97.L_CORE X_NUC_156.L_CORE 0.001965
K_11244 X_NUC_97.L_CORE X_NUC_157.L_CORE 0.031171
K_11245 X_NUC_97.L_CORE X_NUC_158.L_CORE 0.002034
K_11246 X_NUC_97.L_CORE X_NUC_159.L_CORE 0.002872
K_11247 X_NUC_97.L_CORE X_NUC_160.L_CORE 0.004275
K_11248 X_NUC_97.L_CORE X_NUC_161.L_CORE 0.002068
K_11249 X_NUC_97.L_CORE X_NUC_162.L_CORE 0.005632
K_11250 X_NUC_97.L_CORE X_NUC_163.L_CORE 0.002719
K_11251 X_NUC_97.L_CORE X_NUC_164.L_CORE 0.002697
K_11252 X_NUC_97.L_CORE X_NUC_165.L_CORE 0.003971
K_11253 X_NUC_98.L_CORE X_NUC_99.L_CORE 0.207973
K_11254 X_NUC_98.L_CORE X_NUC_100.L_CORE 0.207973
K_11255 X_NUC_98.L_CORE X_NUC_101.L_CORE 0.002146
K_11256 X_NUC_98.L_CORE X_NUC_102.L_CORE 0.002144
K_11257 X_NUC_98.L_CORE X_NUC_103.L_CORE 0.002133
K_11258 X_NUC_98.L_CORE X_NUC_104.L_CORE 0.002155
K_11259 X_NUC_98.L_CORE X_NUC_105.L_CORE 0.002978
K_11260 X_NUC_98.L_CORE X_NUC_106.L_CORE 0.003015
K_11261 X_NUC_98.L_CORE X_NUC_107.L_CORE 0.002982
K_11262 X_NUC_98.L_CORE X_NUC_108.L_CORE 0.003003
K_11263 X_NUC_98.L_CORE X_NUC_109.L_CORE 0.004638
K_11264 X_NUC_98.L_CORE X_NUC_110.L_CORE 0.004576
K_11265 X_NUC_98.L_CORE X_NUC_111.L_CORE 0.004551
K_11266 X_NUC_98.L_CORE X_NUC_112.L_CORE 0.004627
K_11267 X_NUC_98.L_CORE X_NUC_113.L_CORE 0.002169
K_11268 X_NUC_98.L_CORE X_NUC_114.L_CORE 0.002176
K_11269 X_NUC_98.L_CORE X_NUC_115.L_CORE 0.002159
K_11270 X_NUC_98.L_CORE X_NUC_116.L_CORE 0.002180
K_11271 X_NUC_98.L_CORE X_NUC_117.L_CORE 0.005866
K_11272 X_NUC_98.L_CORE X_NUC_118.L_CORE 0.005988
K_11273 X_NUC_98.L_CORE X_NUC_119.L_CORE 0.005827
K_11274 X_NUC_98.L_CORE X_NUC_120.L_CORE 0.005900
K_11275 X_NUC_98.L_CORE X_NUC_121.L_CORE 0.002884
K_11276 X_NUC_98.L_CORE X_NUC_122.L_CORE 0.002877
K_11277 X_NUC_98.L_CORE X_NUC_123.L_CORE 0.002853
K_11278 X_NUC_98.L_CORE X_NUC_124.L_CORE 0.002890
K_11279 X_NUC_98.L_CORE X_NUC_125.L_CORE 0.002820
K_11280 X_NUC_98.L_CORE X_NUC_126.L_CORE 0.002840
K_11281 X_NUC_98.L_CORE X_NUC_127.L_CORE 0.002806
K_11282 X_NUC_98.L_CORE X_NUC_128.L_CORE 0.002835
K_11283 X_NUC_98.L_CORE X_NUC_129.L_CORE 0.004211
K_11284 X_NUC_98.L_CORE X_NUC_130.L_CORE 0.004221
K_11285 X_NUC_98.L_CORE X_NUC_131.L_CORE 0.004148
K_11286 X_NUC_98.L_CORE X_NUC_132.L_CORE 0.004214
K_11287 X_NUC_98.L_CORE X_NUC_133.L_CORE 0.001973
K_11288 X_NUC_98.L_CORE X_NUC_134.L_CORE 0.001978
K_11289 X_NUC_98.L_CORE X_NUC_135.L_CORE 0.001720
K_11290 X_NUC_98.L_CORE X_NUC_136.L_CORE 0.002503
K_11291 X_NUC_98.L_CORE X_NUC_137.L_CORE 0.001750
K_11292 X_NUC_98.L_CORE X_NUC_138.L_CORE 0.001976
K_11293 X_NUC_98.L_CORE X_NUC_139.L_CORE 0.002583
K_11294 X_NUC_98.L_CORE X_NUC_140.L_CORE 0.001629
K_11295 X_NUC_98.L_CORE X_NUC_141.L_CORE 0.002848
K_11296 X_NUC_98.L_CORE X_NUC_142.L_CORE 0.002019
K_11297 X_NUC_98.L_CORE X_NUC_143.L_CORE 0.001791
K_11298 X_NUC_98.L_CORE X_NUC_144.L_CORE 0.004001
K_11299 X_NUC_98.L_CORE X_NUC_145.L_CORE 0.001693
K_11300 X_NUC_98.L_CORE X_NUC_146.L_CORE 0.002513
K_11301 X_NUC_98.L_CORE X_NUC_147.L_CORE 0.002781
K_11302 X_NUC_98.L_CORE X_NUC_148.L_CORE 0.001696
K_11303 X_NUC_98.L_CORE X_NUC_149.L_CORE 0.005381
K_11304 X_NUC_98.L_CORE X_NUC_150.L_CORE 0.001967
K_11305 X_NUC_98.L_CORE X_NUC_151.L_CORE 0.002121
K_11306 X_NUC_98.L_CORE X_NUC_152.L_CORE 0.005350
K_11307 X_NUC_98.L_CORE X_NUC_153.L_CORE 0.001755
K_11308 X_NUC_98.L_CORE X_NUC_154.L_CORE 0.003858
K_11309 X_NUC_98.L_CORE X_NUC_155.L_CORE 0.002658
K_11310 X_NUC_98.L_CORE X_NUC_156.L_CORE 0.001953
K_11311 X_NUC_98.L_CORE X_NUC_157.L_CORE 0.032245
K_11312 X_NUC_98.L_CORE X_NUC_158.L_CORE 0.002036
K_11313 X_NUC_98.L_CORE X_NUC_159.L_CORE 0.002838
K_11314 X_NUC_98.L_CORE X_NUC_160.L_CORE 0.004335
K_11315 X_NUC_98.L_CORE X_NUC_161.L_CORE 0.002061
K_11316 X_NUC_98.L_CORE X_NUC_162.L_CORE 0.005527
K_11317 X_NUC_98.L_CORE X_NUC_163.L_CORE 0.002727
K_11318 X_NUC_98.L_CORE X_NUC_164.L_CORE 0.002678
K_11319 X_NUC_98.L_CORE X_NUC_165.L_CORE 0.003964
K_11320 X_NUC_99.L_CORE X_NUC_100.L_CORE 0.207973
K_11321 X_NUC_99.L_CORE X_NUC_101.L_CORE 0.002157
K_11322 X_NUC_99.L_CORE X_NUC_102.L_CORE 0.002154
K_11323 X_NUC_99.L_CORE X_NUC_103.L_CORE 0.002144
K_11324 X_NUC_99.L_CORE X_NUC_104.L_CORE 0.002166
K_11325 X_NUC_99.L_CORE X_NUC_105.L_CORE 0.003010
K_11326 X_NUC_99.L_CORE X_NUC_106.L_CORE 0.003048
K_11327 X_NUC_99.L_CORE X_NUC_107.L_CORE 0.003015
K_11328 X_NUC_99.L_CORE X_NUC_108.L_CORE 0.003037
K_11329 X_NUC_99.L_CORE X_NUC_109.L_CORE 0.004663
K_11330 X_NUC_99.L_CORE X_NUC_110.L_CORE 0.004599
K_11331 X_NUC_99.L_CORE X_NUC_111.L_CORE 0.004576
K_11332 X_NUC_99.L_CORE X_NUC_112.L_CORE 0.004652
K_11333 X_NUC_99.L_CORE X_NUC_113.L_CORE 0.002185
K_11334 X_NUC_99.L_CORE X_NUC_114.L_CORE 0.002193
K_11335 X_NUC_99.L_CORE X_NUC_115.L_CORE 0.002176
K_11336 X_NUC_99.L_CORE X_NUC_116.L_CORE 0.002198
K_11337 X_NUC_99.L_CORE X_NUC_117.L_CORE 0.006027
K_11338 X_NUC_99.L_CORE X_NUC_118.L_CORE 0.006158
K_11339 X_NUC_99.L_CORE X_NUC_119.L_CORE 0.005988
K_11340 X_NUC_99.L_CORE X_NUC_120.L_CORE 0.006065
K_11341 X_NUC_99.L_CORE X_NUC_121.L_CORE 0.002908
K_11342 X_NUC_99.L_CORE X_NUC_122.L_CORE 0.002900
K_11343 X_NUC_99.L_CORE X_NUC_123.L_CORE 0.002877
K_11344 X_NUC_99.L_CORE X_NUC_124.L_CORE 0.002914
K_11345 X_NUC_99.L_CORE X_NUC_125.L_CORE 0.002854
K_11346 X_NUC_99.L_CORE X_NUC_126.L_CORE 0.002875
K_11347 X_NUC_99.L_CORE X_NUC_127.L_CORE 0.002840
K_11348 X_NUC_99.L_CORE X_NUC_128.L_CORE 0.002870
K_11349 X_NUC_99.L_CORE X_NUC_129.L_CORE 0.004288
K_11350 X_NUC_99.L_CORE X_NUC_130.L_CORE 0.004297
K_11351 X_NUC_99.L_CORE X_NUC_131.L_CORE 0.004221
K_11352 X_NUC_99.L_CORE X_NUC_132.L_CORE 0.004290
K_11353 X_NUC_99.L_CORE X_NUC_133.L_CORE 0.001967
K_11354 X_NUC_99.L_CORE X_NUC_134.L_CORE 0.001971
K_11355 X_NUC_99.L_CORE X_NUC_135.L_CORE 0.001720
K_11356 X_NUC_99.L_CORE X_NUC_136.L_CORE 0.002486
K_11357 X_NUC_99.L_CORE X_NUC_137.L_CORE 0.001748
K_11358 X_NUC_99.L_CORE X_NUC_138.L_CORE 0.001976
K_11359 X_NUC_99.L_CORE X_NUC_139.L_CORE 0.002562
K_11360 X_NUC_99.L_CORE X_NUC_140.L_CORE 0.001631
K_11361 X_NUC_99.L_CORE X_NUC_141.L_CORE 0.002834
K_11362 X_NUC_99.L_CORE X_NUC_142.L_CORE 0.002014
K_11363 X_NUC_99.L_CORE X_NUC_143.L_CORE 0.001796
K_11364 X_NUC_99.L_CORE X_NUC_144.L_CORE 0.003935
K_11365 X_NUC_99.L_CORE X_NUC_145.L_CORE 0.001696
K_11366 X_NUC_99.L_CORE X_NUC_146.L_CORE 0.002518
K_11367 X_NUC_99.L_CORE X_NUC_147.L_CORE 0.002765
K_11368 X_NUC_99.L_CORE X_NUC_148.L_CORE 0.001703
K_11369 X_NUC_99.L_CORE X_NUC_149.L_CORE 0.005315
K_11370 X_NUC_99.L_CORE X_NUC_150.L_CORE 0.001970
K_11371 X_NUC_99.L_CORE X_NUC_151.L_CORE 0.002133
K_11372 X_NUC_99.L_CORE X_NUC_152.L_CORE 0.005260
K_11373 X_NUC_99.L_CORE X_NUC_153.L_CORE 0.001762
K_11374 X_NUC_99.L_CORE X_NUC_154.L_CORE 0.003885
K_11375 X_NUC_99.L_CORE X_NUC_155.L_CORE 0.002660
K_11376 X_NUC_99.L_CORE X_NUC_156.L_CORE 0.001966
K_11377 X_NUC_99.L_CORE X_NUC_157.L_CORE 0.031330
K_11378 X_NUC_99.L_CORE X_NUC_158.L_CORE 0.002046
K_11379 X_NUC_99.L_CORE X_NUC_159.L_CORE 0.002868
K_11380 X_NUC_99.L_CORE X_NUC_160.L_CORE 0.004355
K_11381 X_NUC_99.L_CORE X_NUC_161.L_CORE 0.002077
K_11382 X_NUC_99.L_CORE X_NUC_162.L_CORE 0.005671
K_11383 X_NUC_99.L_CORE X_NUC_163.L_CORE 0.002748
K_11384 X_NUC_99.L_CORE X_NUC_164.L_CORE 0.002711
K_11385 X_NUC_99.L_CORE X_NUC_165.L_CORE 0.004033
K_11386 X_NUC_100.L_CORE X_NUC_101.L_CORE 0.002135
K_11387 X_NUC_100.L_CORE X_NUC_102.L_CORE 0.002132
K_11388 X_NUC_100.L_CORE X_NUC_103.L_CORE 0.002122
K_11389 X_NUC_100.L_CORE X_NUC_104.L_CORE 0.002144
K_11390 X_NUC_100.L_CORE X_NUC_105.L_CORE 0.002988
K_11391 X_NUC_100.L_CORE X_NUC_106.L_CORE 0.003026
K_11392 X_NUC_100.L_CORE X_NUC_107.L_CORE 0.002993
K_11393 X_NUC_100.L_CORE X_NUC_108.L_CORE 0.003015
K_11394 X_NUC_100.L_CORE X_NUC_109.L_CORE 0.004585
K_11395 X_NUC_100.L_CORE X_NUC_110.L_CORE 0.004524
K_11396 X_NUC_100.L_CORE X_NUC_111.L_CORE 0.004501
K_11397 X_NUC_100.L_CORE X_NUC_112.L_CORE 0.004576
K_11398 X_NUC_100.L_CORE X_NUC_113.L_CORE 0.002164
K_11399 X_NUC_100.L_CORE X_NUC_114.L_CORE 0.002172
K_11400 X_NUC_100.L_CORE X_NUC_115.L_CORE 0.002155
K_11401 X_NUC_100.L_CORE X_NUC_116.L_CORE 0.002176
K_11402 X_NUC_100.L_CORE X_NUC_117.L_CORE 0.005950
K_11403 X_NUC_100.L_CORE X_NUC_118.L_CORE 0.006076
K_11404 X_NUC_100.L_CORE X_NUC_119.L_CORE 0.005910
K_11405 X_NUC_100.L_CORE X_NUC_120.L_CORE 0.005988
K_11406 X_NUC_100.L_CORE X_NUC_121.L_CORE 0.002870
K_11407 X_NUC_100.L_CORE X_NUC_122.L_CORE 0.002863
K_11408 X_NUC_100.L_CORE X_NUC_123.L_CORE 0.002840
K_11409 X_NUC_100.L_CORE X_NUC_124.L_CORE 0.002877
K_11410 X_NUC_100.L_CORE X_NUC_125.L_CORE 0.002824
K_11411 X_NUC_100.L_CORE X_NUC_126.L_CORE 0.002845
K_11412 X_NUC_100.L_CORE X_NUC_127.L_CORE 0.002810
K_11413 X_NUC_100.L_CORE X_NUC_128.L_CORE 0.002840
K_11414 X_NUC_100.L_CORE X_NUC_129.L_CORE 0.004218
K_11415 X_NUC_100.L_CORE X_NUC_130.L_CORE 0.004227
K_11416 X_NUC_100.L_CORE X_NUC_131.L_CORE 0.004154
K_11417 X_NUC_100.L_CORE X_NUC_132.L_CORE 0.004221
K_11418 X_NUC_100.L_CORE X_NUC_133.L_CORE 0.001960
K_11419 X_NUC_100.L_CORE X_NUC_134.L_CORE 0.001961
K_11420 X_NUC_100.L_CORE X_NUC_135.L_CORE 0.001711
K_11421 X_NUC_100.L_CORE X_NUC_136.L_CORE 0.002482
K_11422 X_NUC_100.L_CORE X_NUC_137.L_CORE 0.001737
K_11423 X_NUC_100.L_CORE X_NUC_138.L_CORE 0.001969
K_11424 X_NUC_100.L_CORE X_NUC_139.L_CORE 0.002552
K_11425 X_NUC_100.L_CORE X_NUC_140.L_CORE 0.001621
K_11426 X_NUC_100.L_CORE X_NUC_141.L_CORE 0.002835
K_11427 X_NUC_100.L_CORE X_NUC_142.L_CORE 0.002000
K_11428 X_NUC_100.L_CORE X_NUC_143.L_CORE 0.001786
K_11429 X_NUC_100.L_CORE X_NUC_144.L_CORE 0.003942
K_11430 X_NUC_100.L_CORE X_NUC_145.L_CORE 0.001683
K_11431 X_NUC_100.L_CORE X_NUC_146.L_CORE 0.002512
K_11432 X_NUC_100.L_CORE X_NUC_147.L_CORE 0.002746
K_11433 X_NUC_100.L_CORE X_NUC_148.L_CORE 0.001691
K_11434 X_NUC_100.L_CORE X_NUC_149.L_CORE 0.005370
K_11435 X_NUC_100.L_CORE X_NUC_150.L_CORE 0.001953
K_11436 X_NUC_100.L_CORE X_NUC_151.L_CORE 0.002121
K_11437 X_NUC_100.L_CORE X_NUC_152.L_CORE 0.005237
K_11438 X_NUC_100.L_CORE X_NUC_153.L_CORE 0.001748
K_11439 X_NUC_100.L_CORE X_NUC_154.L_CORE 0.003885
K_11440 X_NUC_100.L_CORE X_NUC_155.L_CORE 0.002633
K_11441 X_NUC_100.L_CORE X_NUC_156.L_CORE 0.001952
K_11442 X_NUC_100.L_CORE X_NUC_157.L_CORE 0.036028
K_11443 X_NUC_100.L_CORE X_NUC_158.L_CORE 0.002026
K_11444 X_NUC_100.L_CORE X_NUC_159.L_CORE 0.002850
K_11445 X_NUC_100.L_CORE X_NUC_160.L_CORE 0.004295
K_11446 X_NUC_100.L_CORE X_NUC_161.L_CORE 0.002058
K_11447 X_NUC_100.L_CORE X_NUC_162.L_CORE 0.005622
K_11448 X_NUC_100.L_CORE X_NUC_163.L_CORE 0.002716
K_11449 X_NUC_100.L_CORE X_NUC_164.L_CORE 0.002685
K_11450 X_NUC_100.L_CORE X_NUC_165.L_CORE 0.003977
K_11451 X_NUC_101.L_CORE X_NUC_102.L_CORE 0.207973
K_11452 X_NUC_101.L_CORE X_NUC_103.L_CORE 0.207973
K_11453 X_NUC_101.L_CORE X_NUC_104.L_CORE 0.207973
K_11454 X_NUC_101.L_CORE X_NUC_105.L_CORE 0.002248
K_11455 X_NUC_101.L_CORE X_NUC_106.L_CORE 0.002266
K_11456 X_NUC_101.L_CORE X_NUC_107.L_CORE 0.002264
K_11457 X_NUC_101.L_CORE X_NUC_108.L_CORE 0.002248
K_11458 X_NUC_101.L_CORE X_NUC_109.L_CORE 0.003175
K_11459 X_NUC_101.L_CORE X_NUC_110.L_CORE 0.003161
K_11460 X_NUC_101.L_CORE X_NUC_111.L_CORE 0.003187
K_11461 X_NUC_101.L_CORE X_NUC_112.L_CORE 0.003142
K_11462 X_NUC_101.L_CORE X_NUC_113.L_CORE 0.004812
K_11463 X_NUC_101.L_CORE X_NUC_114.L_CORE 0.004920
K_11464 X_NUC_101.L_CORE X_NUC_115.L_CORE 0.004854
K_11465 X_NUC_101.L_CORE X_NUC_116.L_CORE 0.004834
K_11466 X_NUC_101.L_CORE X_NUC_117.L_CORE 0.002332
K_11467 X_NUC_101.L_CORE X_NUC_118.L_CORE 0.002342
K_11468 X_NUC_101.L_CORE X_NUC_119.L_CORE 0.002346
K_11469 X_NUC_101.L_CORE X_NUC_120.L_CORE 0.002322
K_11470 X_NUC_101.L_CORE X_NUC_121.L_CORE 0.006000
K_11471 X_NUC_101.L_CORE X_NUC_122.L_CORE 0.005975
K_11472 X_NUC_101.L_CORE X_NUC_123.L_CORE 0.005994
K_11473 X_NUC_101.L_CORE X_NUC_124.L_CORE 0.005854
K_11474 X_NUC_101.L_CORE X_NUC_125.L_CORE 0.003140
K_11475 X_NUC_101.L_CORE X_NUC_126.L_CORE 0.003175
K_11476 X_NUC_101.L_CORE X_NUC_127.L_CORE 0.003160
K_11477 X_NUC_101.L_CORE X_NUC_128.L_CORE 0.003132
K_11478 X_NUC_101.L_CORE X_NUC_129.L_CORE 0.003221
K_11479 X_NUC_101.L_CORE X_NUC_130.L_CORE 0.003232
K_11480 X_NUC_101.L_CORE X_NUC_131.L_CORE 0.003234
K_11481 X_NUC_101.L_CORE X_NUC_132.L_CORE 0.003190
K_11482 X_NUC_101.L_CORE X_NUC_133.L_CORE 0.001759
K_11483 X_NUC_101.L_CORE X_NUC_134.L_CORE 0.002006
K_11484 X_NUC_101.L_CORE X_NUC_135.L_CORE 0.001978
K_11485 X_NUC_101.L_CORE X_NUC_136.L_CORE 0.001695
K_11486 X_NUC_101.L_CORE X_NUC_137.L_CORE 0.002537
K_11487 X_NUC_101.L_CORE X_NUC_138.L_CORE 0.001740
K_11488 X_NUC_101.L_CORE X_NUC_139.L_CORE 0.001974
K_11489 X_NUC_101.L_CORE X_NUC_140.L_CORE 0.002586
K_11490 X_NUC_101.L_CORE X_NUC_141.L_CORE 0.001633
K_11491 X_NUC_101.L_CORE X_NUC_142.L_CORE 0.002847
K_11492 X_NUC_101.L_CORE X_NUC_143.L_CORE 0.002030
K_11493 X_NUC_101.L_CORE X_NUC_144.L_CORE 0.001807
K_11494 X_NUC_101.L_CORE X_NUC_145.L_CORE 0.003963
K_11495 X_NUC_101.L_CORE X_NUC_146.L_CORE 0.001716
K_11496 X_NUC_101.L_CORE X_NUC_147.L_CORE 0.002539
K_11497 X_NUC_101.L_CORE X_NUC_148.L_CORE 0.002810
K_11498 X_NUC_101.L_CORE X_NUC_149.L_CORE 0.001730
K_11499 X_NUC_101.L_CORE X_NUC_150.L_CORE 0.005331
K_11500 X_NUC_101.L_CORE X_NUC_151.L_CORE 0.002014
K_11501 X_NUC_101.L_CORE X_NUC_152.L_CORE 0.002176
K_11502 X_NUC_101.L_CORE X_NUC_153.L_CORE 0.005406
K_11503 X_NUC_101.L_CORE X_NUC_154.L_CORE 0.001812
K_11504 X_NUC_101.L_CORE X_NUC_155.L_CORE 0.003978
K_11505 X_NUC_101.L_CORE X_NUC_156.L_CORE 0.002758
K_11506 X_NUC_101.L_CORE X_NUC_157.L_CORE 0.002037
K_11507 X_NUC_101.L_CORE X_NUC_158.L_CORE 0.030739
K_11508 X_NUC_101.L_CORE X_NUC_159.L_CORE 0.002141
K_11509 X_NUC_101.L_CORE X_NUC_160.L_CORE 0.002998
K_11510 X_NUC_101.L_CORE X_NUC_161.L_CORE 0.004568
K_11511 X_NUC_101.L_CORE X_NUC_162.L_CORE 0.002216
K_11512 X_NUC_101.L_CORE X_NUC_163.L_CORE 0.005573
K_11513 X_NUC_101.L_CORE X_NUC_164.L_CORE 0.002985
K_11514 X_NUC_101.L_CORE X_NUC_165.L_CORE 0.003048
K_11515 X_NUC_102.L_CORE X_NUC_103.L_CORE 0.207973
K_11516 X_NUC_102.L_CORE X_NUC_104.L_CORE 0.207973
K_11517 X_NUC_102.L_CORE X_NUC_105.L_CORE 0.002230
K_11518 X_NUC_102.L_CORE X_NUC_106.L_CORE 0.002248
K_11519 X_NUC_102.L_CORE X_NUC_107.L_CORE 0.002246
K_11520 X_NUC_102.L_CORE X_NUC_108.L_CORE 0.002230
K_11521 X_NUC_102.L_CORE X_NUC_109.L_CORE 0.003189
K_11522 X_NUC_102.L_CORE X_NUC_110.L_CORE 0.003175
K_11523 X_NUC_102.L_CORE X_NUC_111.L_CORE 0.003201
K_11524 X_NUC_102.L_CORE X_NUC_112.L_CORE 0.003155
K_11525 X_NUC_102.L_CORE X_NUC_113.L_CORE 0.004708
K_11526 X_NUC_102.L_CORE X_NUC_114.L_CORE 0.004812
K_11527 X_NUC_102.L_CORE X_NUC_115.L_CORE 0.004749
K_11528 X_NUC_102.L_CORE X_NUC_116.L_CORE 0.004730
K_11529 X_NUC_102.L_CORE X_NUC_117.L_CORE 0.002322
K_11530 X_NUC_102.L_CORE X_NUC_118.L_CORE 0.002332
K_11531 X_NUC_102.L_CORE X_NUC_119.L_CORE 0.002336
K_11532 X_NUC_102.L_CORE X_NUC_120.L_CORE 0.002312
K_11533 X_NUC_102.L_CORE X_NUC_121.L_CORE 0.006019
K_11534 X_NUC_102.L_CORE X_NUC_122.L_CORE 0.006000
K_11535 X_NUC_102.L_CORE X_NUC_123.L_CORE 0.006016
K_11536 X_NUC_102.L_CORE X_NUC_124.L_CORE 0.005875
K_11537 X_NUC_102.L_CORE X_NUC_125.L_CORE 0.003106
K_11538 X_NUC_102.L_CORE X_NUC_126.L_CORE 0.003140
K_11539 X_NUC_102.L_CORE X_NUC_127.L_CORE 0.003126
K_11540 X_NUC_102.L_CORE X_NUC_128.L_CORE 0.003098
K_11541 X_NUC_102.L_CORE X_NUC_129.L_CORE 0.003209
K_11542 X_NUC_102.L_CORE X_NUC_130.L_CORE 0.003221
K_11543 X_NUC_102.L_CORE X_NUC_131.L_CORE 0.003223
K_11544 X_NUC_102.L_CORE X_NUC_132.L_CORE 0.003179
K_11545 X_NUC_102.L_CORE X_NUC_133.L_CORE 0.001754
K_11546 X_NUC_102.L_CORE X_NUC_134.L_CORE 0.002007
K_11547 X_NUC_102.L_CORE X_NUC_135.L_CORE 0.001969
K_11548 X_NUC_102.L_CORE X_NUC_136.L_CORE 0.001693
K_11549 X_NUC_102.L_CORE X_NUC_137.L_CORE 0.002538
K_11550 X_NUC_102.L_CORE X_NUC_138.L_CORE 0.001731
K_11551 X_NUC_102.L_CORE X_NUC_139.L_CORE 0.001978
K_11552 X_NUC_102.L_CORE X_NUC_140.L_CORE 0.002570
K_11553 X_NUC_102.L_CORE X_NUC_141.L_CORE 0.001628
K_11554 X_NUC_102.L_CORE X_NUC_142.L_CORE 0.002865
K_11555 X_NUC_102.L_CORE X_NUC_143.L_CORE 0.002014
K_11556 X_NUC_102.L_CORE X_NUC_144.L_CORE 0.001808
K_11557 X_NUC_102.L_CORE X_NUC_145.L_CORE 0.003954
K_11558 X_NUC_102.L_CORE X_NUC_146.L_CORE 0.001706
K_11559 X_NUC_102.L_CORE X_NUC_147.L_CORE 0.002555
K_11560 X_NUC_102.L_CORE X_NUC_148.L_CORE 0.002778
K_11561 X_NUC_102.L_CORE X_NUC_149.L_CORE 0.001727
K_11562 X_NUC_102.L_CORE X_NUC_150.L_CORE 0.005424
K_11563 X_NUC_102.L_CORE X_NUC_151.L_CORE 0.001997
K_11564 X_NUC_102.L_CORE X_NUC_152.L_CORE 0.002182
K_11565 X_NUC_102.L_CORE X_NUC_153.L_CORE 0.005302
K_11566 X_NUC_102.L_CORE X_NUC_154.L_CORE 0.001803
K_11567 X_NUC_102.L_CORE X_NUC_155.L_CORE 0.004034
K_11568 X_NUC_102.L_CORE X_NUC_156.L_CORE 0.002723
K_11569 X_NUC_102.L_CORE X_NUC_157.L_CORE 0.002035
K_11570 X_NUC_102.L_CORE X_NUC_158.L_CORE 0.032526
K_11571 X_NUC_102.L_CORE X_NUC_159.L_CORE 0.002125
K_11572 X_NUC_102.L_CORE X_NUC_160.L_CORE 0.003013
K_11573 X_NUC_102.L_CORE X_NUC_161.L_CORE 0.004476
K_11574 X_NUC_102.L_CORE X_NUC_162.L_CORE 0.002207
K_11575 X_NUC_102.L_CORE X_NUC_163.L_CORE 0.005603
K_11576 X_NUC_102.L_CORE X_NUC_164.L_CORE 0.002954
K_11577 X_NUC_102.L_CORE X_NUC_165.L_CORE 0.003039
K_11578 X_NUC_103.L_CORE X_NUC_104.L_CORE 0.207973
K_11579 X_NUC_103.L_CORE X_NUC_105.L_CORE 0.002231
K_11580 X_NUC_103.L_CORE X_NUC_106.L_CORE 0.002249
K_11581 X_NUC_103.L_CORE X_NUC_107.L_CORE 0.002248
K_11582 X_NUC_103.L_CORE X_NUC_108.L_CORE 0.002231
K_11583 X_NUC_103.L_CORE X_NUC_109.L_CORE 0.003163
K_11584 X_NUC_103.L_CORE X_NUC_110.L_CORE 0.003149
K_11585 X_NUC_103.L_CORE X_NUC_111.L_CORE 0.003175
K_11586 X_NUC_103.L_CORE X_NUC_112.L_CORE 0.003130
K_11587 X_NUC_103.L_CORE X_NUC_113.L_CORE 0.004769
K_11588 X_NUC_103.L_CORE X_NUC_114.L_CORE 0.004875
K_11589 X_NUC_103.L_CORE X_NUC_115.L_CORE 0.004812
K_11590 X_NUC_103.L_CORE X_NUC_116.L_CORE 0.004791
K_11591 X_NUC_103.L_CORE X_NUC_117.L_CORE 0.002318
K_11592 X_NUC_103.L_CORE X_NUC_118.L_CORE 0.002328
K_11593 X_NUC_103.L_CORE X_NUC_119.L_CORE 0.002332
K_11594 X_NUC_103.L_CORE X_NUC_120.L_CORE 0.002308
K_11595 X_NUC_103.L_CORE X_NUC_121.L_CORE 0.006001
K_11596 X_NUC_103.L_CORE X_NUC_122.L_CORE 0.005979
K_11597 X_NUC_103.L_CORE X_NUC_123.L_CORE 0.006000
K_11598 X_NUC_103.L_CORE X_NUC_124.L_CORE 0.005857
K_11599 X_NUC_103.L_CORE X_NUC_125.L_CORE 0.003120
K_11600 X_NUC_103.L_CORE X_NUC_126.L_CORE 0.003154
K_11601 X_NUC_103.L_CORE X_NUC_127.L_CORE 0.003140
K_11602 X_NUC_103.L_CORE X_NUC_128.L_CORE 0.003112
K_11603 X_NUC_103.L_CORE X_NUC_129.L_CORE 0.003207
K_11604 X_NUC_103.L_CORE X_NUC_130.L_CORE 0.003218
K_11605 X_NUC_103.L_CORE X_NUC_131.L_CORE 0.003221
K_11606 X_NUC_103.L_CORE X_NUC_132.L_CORE 0.003177
K_11607 X_NUC_103.L_CORE X_NUC_133.L_CORE 0.001744
K_11608 X_NUC_103.L_CORE X_NUC_134.L_CORE 0.001990
K_11609 X_NUC_103.L_CORE X_NUC_135.L_CORE 0.001961
K_11610 X_NUC_103.L_CORE X_NUC_136.L_CORE 0.001682
K_11611 X_NUC_103.L_CORE X_NUC_137.L_CORE 0.002515
K_11612 X_NUC_103.L_CORE X_NUC_138.L_CORE 0.001726
K_11613 X_NUC_103.L_CORE X_NUC_139.L_CORE 0.001960
K_11614 X_NUC_103.L_CORE X_NUC_140.L_CORE 0.002561
K_11615 X_NUC_103.L_CORE X_NUC_141.L_CORE 0.001621
K_11616 X_NUC_103.L_CORE X_NUC_142.L_CORE 0.002827
K_11617 X_NUC_103.L_CORE X_NUC_143.L_CORE 0.002012
K_11618 X_NUC_103.L_CORE X_NUC_144.L_CORE 0.001795
K_11619 X_NUC_103.L_CORE X_NUC_145.L_CORE 0.003922
K_11620 X_NUC_103.L_CORE X_NUC_146.L_CORE 0.001703
K_11621 X_NUC_103.L_CORE X_NUC_147.L_CORE 0.002525
K_11622 X_NUC_103.L_CORE X_NUC_148.L_CORE 0.002782
K_11623 X_NUC_103.L_CORE X_NUC_149.L_CORE 0.001719
K_11624 X_NUC_103.L_CORE X_NUC_150.L_CORE 0.005305
K_11625 X_NUC_103.L_CORE X_NUC_151.L_CORE 0.001998
K_11626 X_NUC_103.L_CORE X_NUC_152.L_CORE 0.002165
K_11627 X_NUC_103.L_CORE X_NUC_153.L_CORE 0.005346
K_11628 X_NUC_103.L_CORE X_NUC_154.L_CORE 0.001800
K_11629 X_NUC_103.L_CORE X_NUC_155.L_CORE 0.003971
K_11630 X_NUC_103.L_CORE X_NUC_156.L_CORE 0.002736
K_11631 X_NUC_103.L_CORE X_NUC_157.L_CORE 0.002026
K_11632 X_NUC_103.L_CORE X_NUC_158.L_CORE 0.035836
K_11633 X_NUC_103.L_CORE X_NUC_159.L_CORE 0.002127
K_11634 X_NUC_103.L_CORE X_NUC_160.L_CORE 0.002990
K_11635 X_NUC_103.L_CORE X_NUC_161.L_CORE 0.004541
K_11636 X_NUC_103.L_CORE X_NUC_162.L_CORE 0.002205
K_11637 X_NUC_103.L_CORE X_NUC_163.L_CORE 0.005601
K_11638 X_NUC_103.L_CORE X_NUC_164.L_CORE 0.002969
K_11639 X_NUC_103.L_CORE X_NUC_165.L_CORE 0.003039
K_11640 X_NUC_104.L_CORE X_NUC_105.L_CORE 0.002247
K_11641 X_NUC_104.L_CORE X_NUC_106.L_CORE 0.002266
K_11642 X_NUC_104.L_CORE X_NUC_107.L_CORE 0.002264
K_11643 X_NUC_104.L_CORE X_NUC_108.L_CORE 0.002248
K_11644 X_NUC_104.L_CORE X_NUC_109.L_CORE 0.003209
K_11645 X_NUC_104.L_CORE X_NUC_110.L_CORE 0.003195
K_11646 X_NUC_104.L_CORE X_NUC_111.L_CORE 0.003222
K_11647 X_NUC_104.L_CORE X_NUC_112.L_CORE 0.003175
K_11648 X_NUC_104.L_CORE X_NUC_113.L_CORE 0.004788
K_11649 X_NUC_104.L_CORE X_NUC_114.L_CORE 0.004896
K_11650 X_NUC_104.L_CORE X_NUC_115.L_CORE 0.004830
K_11651 X_NUC_104.L_CORE X_NUC_116.L_CORE 0.004812
K_11652 X_NUC_104.L_CORE X_NUC_117.L_CORE 0.002342
K_11653 X_NUC_104.L_CORE X_NUC_118.L_CORE 0.002352
K_11654 X_NUC_104.L_CORE X_NUC_119.L_CORE 0.002356
K_11655 X_NUC_104.L_CORE X_NUC_120.L_CORE 0.002332
K_11656 X_NUC_104.L_CORE X_NUC_121.L_CORE 0.006151
K_11657 X_NUC_104.L_CORE X_NUC_122.L_CORE 0.006128
K_11658 X_NUC_104.L_CORE X_NUC_123.L_CORE 0.006148
K_11659 X_NUC_104.L_CORE X_NUC_124.L_CORE 0.006000
K_11660 X_NUC_104.L_CORE X_NUC_125.L_CORE 0.003148
K_11661 X_NUC_104.L_CORE X_NUC_126.L_CORE 0.003183
K_11662 X_NUC_104.L_CORE X_NUC_127.L_CORE 0.003169
K_11663 X_NUC_104.L_CORE X_NUC_128.L_CORE 0.003140
K_11664 X_NUC_104.L_CORE X_NUC_129.L_CORE 0.003251
K_11665 X_NUC_104.L_CORE X_NUC_130.L_CORE 0.003263
K_11666 X_NUC_104.L_CORE X_NUC_131.L_CORE 0.003265
K_11667 X_NUC_104.L_CORE X_NUC_132.L_CORE 0.003221
K_11668 X_NUC_104.L_CORE X_NUC_133.L_CORE 0.001751
K_11669 X_NUC_104.L_CORE X_NUC_134.L_CORE 0.001998
K_11670 X_NUC_104.L_CORE X_NUC_135.L_CORE 0.001965
K_11671 X_NUC_104.L_CORE X_NUC_136.L_CORE 0.001692
K_11672 X_NUC_104.L_CORE X_NUC_137.L_CORE 0.002517
K_11673 X_NUC_104.L_CORE X_NUC_138.L_CORE 0.001732
K_11674 X_NUC_104.L_CORE X_NUC_139.L_CORE 0.001973
K_11675 X_NUC_104.L_CORE X_NUC_140.L_CORE 0.002557
K_11676 X_NUC_104.L_CORE X_NUC_141.L_CORE 0.001631
K_11677 X_NUC_104.L_CORE X_NUC_142.L_CORE 0.002839
K_11678 X_NUC_104.L_CORE X_NUC_143.L_CORE 0.002016
K_11679 X_NUC_104.L_CORE X_NUC_144.L_CORE 0.001809
K_11680 X_NUC_104.L_CORE X_NUC_145.L_CORE 0.003897
K_11681 X_NUC_104.L_CORE X_NUC_146.L_CORE 0.001712
K_11682 X_NUC_104.L_CORE X_NUC_147.L_CORE 0.002546
K_11683 X_NUC_104.L_CORE X_NUC_148.L_CORE 0.002778
K_11684 X_NUC_104.L_CORE X_NUC_149.L_CORE 0.001732
K_11685 X_NUC_104.L_CORE X_NUC_150.L_CORE 0.005305
K_11686 X_NUC_104.L_CORE X_NUC_151.L_CORE 0.002006
K_11687 X_NUC_104.L_CORE X_NUC_152.L_CORE 0.002186
K_11688 X_NUC_104.L_CORE X_NUC_153.L_CORE 0.005278
K_11689 X_NUC_104.L_CORE X_NUC_154.L_CORE 0.001813
K_11690 X_NUC_104.L_CORE X_NUC_155.L_CORE 0.004022
K_11691 X_NUC_104.L_CORE X_NUC_156.L_CORE 0.002742
K_11692 X_NUC_104.L_CORE X_NUC_157.L_CORE 0.002046
K_11693 X_NUC_104.L_CORE X_NUC_158.L_CORE 0.031657
K_11694 X_NUC_104.L_CORE X_NUC_159.L_CORE 0.002142
K_11695 X_NUC_104.L_CORE X_NUC_160.L_CORE 0.003031
K_11696 X_NUC_104.L_CORE X_NUC_161.L_CORE 0.004549
K_11697 X_NUC_104.L_CORE X_NUC_162.L_CORE 0.002226
K_11698 X_NUC_104.L_CORE X_NUC_163.L_CORE 0.005715
K_11699 X_NUC_104.L_CORE X_NUC_164.L_CORE 0.002993
K_11700 X_NUC_104.L_CORE X_NUC_165.L_CORE 0.003078
K_11701 X_NUC_105.L_CORE X_NUC_106.L_CORE 0.207973
K_11702 X_NUC_105.L_CORE X_NUC_107.L_CORE 0.207973
K_11703 X_NUC_105.L_CORE X_NUC_108.L_CORE 0.207973
K_11704 X_NUC_105.L_CORE X_NUC_109.L_CORE 0.002383
K_11705 X_NUC_105.L_CORE X_NUC_110.L_CORE 0.002356
K_11706 X_NUC_105.L_CORE X_NUC_111.L_CORE 0.002368
K_11707 X_NUC_105.L_CORE X_NUC_112.L_CORE 0.002368
K_11708 X_NUC_105.L_CORE X_NUC_113.L_CORE 0.003386
K_11709 X_NUC_105.L_CORE X_NUC_114.L_CORE 0.003361
K_11710 X_NUC_105.L_CORE X_NUC_115.L_CORE 0.003345
K_11711 X_NUC_105.L_CORE X_NUC_116.L_CORE 0.003393
K_11712 X_NUC_105.L_CORE X_NUC_117.L_CORE 0.005112
K_11713 X_NUC_105.L_CORE X_NUC_118.L_CORE 0.005008
K_11714 X_NUC_105.L_CORE X_NUC_119.L_CORE 0.005063
K_11715 X_NUC_105.L_CORE X_NUC_120.L_CORE 0.005007
K_11716 X_NUC_105.L_CORE X_NUC_121.L_CORE 0.002552
K_11717 X_NUC_105.L_CORE X_NUC_122.L_CORE 0.002525
K_11718 X_NUC_105.L_CORE X_NUC_123.L_CORE 0.002528
K_11719 X_NUC_105.L_CORE X_NUC_124.L_CORE 0.002541
K_11720 X_NUC_105.L_CORE X_NUC_125.L_CORE 0.005883
K_11721 X_NUC_105.L_CORE X_NUC_126.L_CORE 0.005786
K_11722 X_NUC_105.L_CORE X_NUC_127.L_CORE 0.005726
K_11723 X_NUC_105.L_CORE X_NUC_128.L_CORE 0.005824
K_11724 X_NUC_105.L_CORE X_NUC_129.L_CORE 0.003560
K_11725 X_NUC_105.L_CORE X_NUC_130.L_CORE 0.003505
K_11726 X_NUC_105.L_CORE X_NUC_131.L_CORE 0.003514
K_11727 X_NUC_105.L_CORE X_NUC_132.L_CORE 0.003518
K_11728 X_NUC_105.L_CORE X_NUC_133.L_CORE 0.001939
K_11729 X_NUC_105.L_CORE X_NUC_134.L_CORE 0.001684
K_11730 X_NUC_105.L_CORE X_NUC_135.L_CORE 0.002018
K_11731 X_NUC_105.L_CORE X_NUC_136.L_CORE 0.001966
K_11732 X_NUC_105.L_CORE X_NUC_137.L_CORE 0.001674
K_11733 X_NUC_105.L_CORE X_NUC_138.L_CORE 0.002554
K_11734 X_NUC_105.L_CORE X_NUC_139.L_CORE 0.001726
K_11735 X_NUC_105.L_CORE X_NUC_140.L_CORE 0.001973
K_11736 X_NUC_105.L_CORE X_NUC_141.L_CORE 0.002572
K_11737 X_NUC_105.L_CORE X_NUC_142.L_CORE 0.001634
K_11738 X_NUC_105.L_CORE X_NUC_143.L_CORE 0.002854
K_11739 X_NUC_105.L_CORE X_NUC_144.L_CORE 0.002028
K_11740 X_NUC_105.L_CORE X_NUC_145.L_CORE 0.001822
K_11741 X_NUC_105.L_CORE X_NUC_146.L_CORE 0.003918
K_11742 X_NUC_105.L_CORE X_NUC_147.L_CORE 0.001731
K_11743 X_NUC_105.L_CORE X_NUC_148.L_CORE 0.002574
K_11744 X_NUC_105.L_CORE X_NUC_149.L_CORE 0.002816
K_11745 X_NUC_105.L_CORE X_NUC_150.L_CORE 0.001761
K_11746 X_NUC_105.L_CORE X_NUC_151.L_CORE 0.005360
K_11747 X_NUC_105.L_CORE X_NUC_152.L_CORE 0.002049
K_11748 X_NUC_105.L_CORE X_NUC_153.L_CORE 0.002236
K_11749 X_NUC_105.L_CORE X_NUC_154.L_CORE 0.005413
K_11750 X_NUC_105.L_CORE X_NUC_155.L_CORE 0.001865
K_11751 X_NUC_105.L_CORE X_NUC_156.L_CORE 0.004150
K_11752 X_NUC_105.L_CORE X_NUC_157.L_CORE 0.002842
K_11753 X_NUC_105.L_CORE X_NUC_158.L_CORE 0.002126
K_11754 X_NUC_105.L_CORE X_NUC_159.L_CORE 0.033366
K_11755 X_NUC_105.L_CORE X_NUC_160.L_CORE 0.002248
K_11756 X_NUC_105.L_CORE X_NUC_161.L_CORE 0.003193
K_11757 X_NUC_105.L_CORE X_NUC_162.L_CORE 0.004754
K_11758 X_NUC_105.L_CORE X_NUC_163.L_CORE 0.002407
K_11759 X_NUC_105.L_CORE X_NUC_164.L_CORE 0.005449
K_11760 X_NUC_105.L_CORE X_NUC_165.L_CORE 0.003336
K_11761 X_NUC_106.L_CORE X_NUC_107.L_CORE 0.207973
K_11762 X_NUC_106.L_CORE X_NUC_108.L_CORE 0.207973
K_11763 X_NUC_106.L_CORE X_NUC_109.L_CORE 0.002410
K_11764 X_NUC_106.L_CORE X_NUC_110.L_CORE 0.002383
K_11765 X_NUC_106.L_CORE X_NUC_111.L_CORE 0.002396
K_11766 X_NUC_106.L_CORE X_NUC_112.L_CORE 0.002395
K_11767 X_NUC_106.L_CORE X_NUC_113.L_CORE 0.003411
K_11768 X_NUC_106.L_CORE X_NUC_114.L_CORE 0.003386
K_11769 X_NUC_106.L_CORE X_NUC_115.L_CORE 0.003369
K_11770 X_NUC_106.L_CORE X_NUC_116.L_CORE 0.003418
K_11771 X_NUC_106.L_CORE X_NUC_117.L_CORE 0.005219
K_11772 X_NUC_106.L_CORE X_NUC_118.L_CORE 0.005112
K_11773 X_NUC_106.L_CORE X_NUC_119.L_CORE 0.005169
K_11774 X_NUC_106.L_CORE X_NUC_120.L_CORE 0.005110
K_11775 X_NUC_106.L_CORE X_NUC_121.L_CORE 0.002581
K_11776 X_NUC_106.L_CORE X_NUC_122.L_CORE 0.002552
K_11777 X_NUC_106.L_CORE X_NUC_123.L_CORE 0.002556
K_11778 X_NUC_106.L_CORE X_NUC_124.L_CORE 0.002569
K_11779 X_NUC_106.L_CORE X_NUC_125.L_CORE 0.005980
K_11780 X_NUC_106.L_CORE X_NUC_126.L_CORE 0.005883
K_11781 X_NUC_106.L_CORE X_NUC_127.L_CORE 0.005818
K_11782 X_NUC_106.L_CORE X_NUC_128.L_CORE 0.005921
K_11783 X_NUC_106.L_CORE X_NUC_129.L_CORE 0.003617
K_11784 X_NUC_106.L_CORE X_NUC_130.L_CORE 0.003560
K_11785 X_NUC_106.L_CORE X_NUC_131.L_CORE 0.003569
K_11786 X_NUC_106.L_CORE X_NUC_132.L_CORE 0.003574
K_11787 X_NUC_106.L_CORE X_NUC_133.L_CORE 0.001945
K_11788 X_NUC_106.L_CORE X_NUC_134.L_CORE 0.001692
K_11789 X_NUC_106.L_CORE X_NUC_135.L_CORE 0.002021
K_11790 X_NUC_106.L_CORE X_NUC_136.L_CORE 0.001975
K_11791 X_NUC_106.L_CORE X_NUC_137.L_CORE 0.001681
K_11792 X_NUC_106.L_CORE X_NUC_138.L_CORE 0.002552
K_11793 X_NUC_106.L_CORE X_NUC_139.L_CORE 0.001737
K_11794 X_NUC_106.L_CORE X_NUC_140.L_CORE 0.001978
K_11795 X_NUC_106.L_CORE X_NUC_141.L_CORE 0.002581
K_11796 X_NUC_106.L_CORE X_NUC_142.L_CORE 0.001644
K_11797 X_NUC_106.L_CORE X_NUC_143.L_CORE 0.002847
K_11798 X_NUC_106.L_CORE X_NUC_144.L_CORE 0.002043
K_11799 X_NUC_106.L_CORE X_NUC_145.L_CORE 0.001831
K_11800 X_NUC_106.L_CORE X_NUC_146.L_CORE 0.003904
K_11801 X_NUC_106.L_CORE X_NUC_147.L_CORE 0.001745
K_11802 X_NUC_106.L_CORE X_NUC_148.L_CORE 0.002576
K_11803 X_NUC_106.L_CORE X_NUC_149.L_CORE 0.002836
K_11804 X_NUC_106.L_CORE X_NUC_150.L_CORE 0.001774
K_11805 X_NUC_106.L_CORE X_NUC_151.L_CORE 0.005285
K_11806 X_NUC_106.L_CORE X_NUC_152.L_CORE 0.002068
K_11807 X_NUC_106.L_CORE X_NUC_153.L_CORE 0.002247
K_11808 X_NUC_106.L_CORE X_NUC_154.L_CORE 0.005438
K_11809 X_NUC_106.L_CORE X_NUC_155.L_CORE 0.001881
K_11810 X_NUC_106.L_CORE X_NUC_156.L_CORE 0.004141
K_11811 X_NUC_106.L_CORE X_NUC_157.L_CORE 0.002874
K_11812 X_NUC_106.L_CORE X_NUC_158.L_CORE 0.002142
K_11813 X_NUC_106.L_CORE X_NUC_159.L_CORE 0.029909
K_11814 X_NUC_106.L_CORE X_NUC_160.L_CORE 0.002273
K_11815 X_NUC_106.L_CORE X_NUC_161.L_CORE 0.003213
K_11816 X_NUC_106.L_CORE X_NUC_162.L_CORE 0.004838
K_11817 X_NUC_106.L_CORE X_NUC_163.L_CORE 0.002432
K_11818 X_NUC_106.L_CORE X_NUC_164.L_CORE 0.005518
K_11819 X_NUC_106.L_CORE X_NUC_165.L_CORE 0.003384
K_11820 X_NUC_107.L_CORE X_NUC_108.L_CORE 0.207973
K_11821 X_NUC_107.L_CORE X_NUC_109.L_CORE 0.002397
K_11822 X_NUC_107.L_CORE X_NUC_110.L_CORE 0.002370
K_11823 X_NUC_107.L_CORE X_NUC_111.L_CORE 0.002383
K_11824 X_NUC_107.L_CORE X_NUC_112.L_CORE 0.002382
K_11825 X_NUC_107.L_CORE X_NUC_113.L_CORE 0.003428
K_11826 X_NUC_107.L_CORE X_NUC_114.L_CORE 0.003403
K_11827 X_NUC_107.L_CORE X_NUC_115.L_CORE 0.003386
K_11828 X_NUC_107.L_CORE X_NUC_116.L_CORE 0.003436
K_11829 X_NUC_107.L_CORE X_NUC_117.L_CORE 0.005158
K_11830 X_NUC_107.L_CORE X_NUC_118.L_CORE 0.005053
K_11831 X_NUC_107.L_CORE X_NUC_119.L_CORE 0.005112
K_11832 X_NUC_107.L_CORE X_NUC_120.L_CORE 0.005053
K_11833 X_NUC_107.L_CORE X_NUC_121.L_CORE 0.002577
K_11834 X_NUC_107.L_CORE X_NUC_122.L_CORE 0.002548
K_11835 X_NUC_107.L_CORE X_NUC_123.L_CORE 0.002552
K_11836 X_NUC_107.L_CORE X_NUC_124.L_CORE 0.002565
K_11837 X_NUC_107.L_CORE X_NUC_125.L_CORE 0.006050
K_11838 X_NUC_107.L_CORE X_NUC_126.L_CORE 0.005947
K_11839 X_NUC_107.L_CORE X_NUC_127.L_CORE 0.005883
K_11840 X_NUC_107.L_CORE X_NUC_128.L_CORE 0.005988
K_11841 X_NUC_107.L_CORE X_NUC_129.L_CORE 0.003607
K_11842 X_NUC_107.L_CORE X_NUC_130.L_CORE 0.003550
K_11843 X_NUC_107.L_CORE X_NUC_131.L_CORE 0.003560
K_11844 X_NUC_107.L_CORE X_NUC_132.L_CORE 0.003564
K_11845 X_NUC_107.L_CORE X_NUC_133.L_CORE 0.001930
K_11846 X_NUC_107.L_CORE X_NUC_134.L_CORE 0.001681
K_11847 X_NUC_107.L_CORE X_NUC_135.L_CORE 0.002011
K_11848 X_NUC_107.L_CORE X_NUC_136.L_CORE 0.001957
K_11849 X_NUC_107.L_CORE X_NUC_137.L_CORE 0.001674
K_11850 X_NUC_107.L_CORE X_NUC_138.L_CORE 0.002532
K_11851 X_NUC_107.L_CORE X_NUC_139.L_CORE 0.001724
K_11852 X_NUC_107.L_CORE X_NUC_140.L_CORE 0.001973
K_11853 X_NUC_107.L_CORE X_NUC_141.L_CORE 0.002550
K_11854 X_NUC_107.L_CORE X_NUC_142.L_CORE 0.001636
K_11855 X_NUC_107.L_CORE X_NUC_143.L_CORE 0.002837
K_11856 X_NUC_107.L_CORE X_NUC_144.L_CORE 0.002024
K_11857 X_NUC_107.L_CORE X_NUC_145.L_CORE 0.001827
K_11858 X_NUC_107.L_CORE X_NUC_146.L_CORE 0.003852
K_11859 X_NUC_107.L_CORE X_NUC_147.L_CORE 0.001734
K_11860 X_NUC_107.L_CORE X_NUC_148.L_CORE 0.002577
K_11861 X_NUC_107.L_CORE X_NUC_149.L_CORE 0.002800
K_11862 X_NUC_107.L_CORE X_NUC_150.L_CORE 0.001768
K_11863 X_NUC_107.L_CORE X_NUC_151.L_CORE 0.005281
K_11864 X_NUC_107.L_CORE X_NUC_152.L_CORE 0.002052
K_11865 X_NUC_107.L_CORE X_NUC_153.L_CORE 0.002248
K_11866 X_NUC_107.L_CORE X_NUC_154.L_CORE 0.005322
K_11867 X_NUC_107.L_CORE X_NUC_155.L_CORE 0.001874
K_11868 X_NUC_107.L_CORE X_NUC_156.L_CORE 0.004177
K_11869 X_NUC_107.L_CORE X_NUC_157.L_CORE 0.002846
K_11870 X_NUC_107.L_CORE X_NUC_158.L_CORE 0.002141
K_11871 X_NUC_107.L_CORE X_NUC_159.L_CORE 0.032926
K_11872 X_NUC_107.L_CORE X_NUC_160.L_CORE 0.002262
K_11873 X_NUC_107.L_CORE X_NUC_161.L_CORE 0.003232
K_11874 X_NUC_107.L_CORE X_NUC_162.L_CORE 0.004795
K_11875 X_NUC_107.L_CORE X_NUC_163.L_CORE 0.002430
K_11876 X_NUC_107.L_CORE X_NUC_164.L_CORE 0.005595
K_11877 X_NUC_107.L_CORE X_NUC_165.L_CORE 0.003379
K_11878 X_NUC_108.L_CORE X_NUC_109.L_CORE 0.002397
K_11879 X_NUC_108.L_CORE X_NUC_110.L_CORE 0.002370
K_11880 X_NUC_108.L_CORE X_NUC_111.L_CORE 0.002383
K_11881 X_NUC_108.L_CORE X_NUC_112.L_CORE 0.002383
K_11882 X_NUC_108.L_CORE X_NUC_113.L_CORE 0.003378
K_11883 X_NUC_108.L_CORE X_NUC_114.L_CORE 0.003354
K_11884 X_NUC_108.L_CORE X_NUC_115.L_CORE 0.003338
K_11885 X_NUC_108.L_CORE X_NUC_116.L_CORE 0.003386
K_11886 X_NUC_108.L_CORE X_NUC_117.L_CORE 0.005220
K_11887 X_NUC_108.L_CORE X_NUC_118.L_CORE 0.005111
K_11888 X_NUC_108.L_CORE X_NUC_119.L_CORE 0.005170
K_11889 X_NUC_108.L_CORE X_NUC_120.L_CORE 0.005112
K_11890 X_NUC_108.L_CORE X_NUC_121.L_CORE 0.002564
K_11891 X_NUC_108.L_CORE X_NUC_122.L_CORE 0.002536
K_11892 X_NUC_108.L_CORE X_NUC_123.L_CORE 0.002540
K_11893 X_NUC_108.L_CORE X_NUC_124.L_CORE 0.002552
K_11894 X_NUC_108.L_CORE X_NUC_125.L_CORE 0.005940
K_11895 X_NUC_108.L_CORE X_NUC_126.L_CORE 0.005842
K_11896 X_NUC_108.L_CORE X_NUC_127.L_CORE 0.005780
K_11897 X_NUC_108.L_CORE X_NUC_128.L_CORE 0.005883
K_11898 X_NUC_108.L_CORE X_NUC_129.L_CORE 0.003602
K_11899 X_NUC_108.L_CORE X_NUC_130.L_CORE 0.003545
K_11900 X_NUC_108.L_CORE X_NUC_131.L_CORE 0.003555
K_11901 X_NUC_108.L_CORE X_NUC_132.L_CORE 0.003560
K_11902 X_NUC_108.L_CORE X_NUC_133.L_CORE 0.001930
K_11903 X_NUC_108.L_CORE X_NUC_134.L_CORE 0.001679
K_11904 X_NUC_108.L_CORE X_NUC_135.L_CORE 0.002003
K_11905 X_NUC_108.L_CORE X_NUC_136.L_CORE 0.001961
K_11906 X_NUC_108.L_CORE X_NUC_137.L_CORE 0.001668
K_11907 X_NUC_108.L_CORE X_NUC_138.L_CORE 0.002530
K_11908 X_NUC_108.L_CORE X_NUC_139.L_CORE 0.001725
K_11909 X_NUC_108.L_CORE X_NUC_140.L_CORE 0.001960
K_11910 X_NUC_108.L_CORE X_NUC_141.L_CORE 0.002564
K_11911 X_NUC_108.L_CORE X_NUC_142.L_CORE 0.001632
K_11912 X_NUC_108.L_CORE X_NUC_143.L_CORE 0.002817
K_11913 X_NUC_108.L_CORE X_NUC_144.L_CORE 0.002032
K_11914 X_NUC_108.L_CORE X_NUC_145.L_CORE 0.001816
K_11915 X_NUC_108.L_CORE X_NUC_146.L_CORE 0.003877
K_11916 X_NUC_108.L_CORE X_NUC_147.L_CORE 0.001734
K_11917 X_NUC_108.L_CORE X_NUC_148.L_CORE 0.002550
K_11918 X_NUC_108.L_CORE X_NUC_149.L_CORE 0.002826
K_11919 X_NUC_108.L_CORE X_NUC_150.L_CORE 0.001761
K_11920 X_NUC_108.L_CORE X_NUC_151.L_CORE 0.005225
K_11921 X_NUC_108.L_CORE X_NUC_152.L_CORE 0.002057
K_11922 X_NUC_108.L_CORE X_NUC_153.L_CORE 0.002227
K_11923 X_NUC_108.L_CORE X_NUC_154.L_CORE 0.005446
K_11924 X_NUC_108.L_CORE X_NUC_155.L_CORE 0.001870
K_11925 X_NUC_108.L_CORE X_NUC_156.L_CORE 0.004096
K_11926 X_NUC_108.L_CORE X_NUC_157.L_CORE 0.002867
K_11927 X_NUC_108.L_CORE X_NUC_158.L_CORE 0.002126
K_11928 X_NUC_108.L_CORE X_NUC_159.L_CORE 0.034471
K_11929 X_NUC_108.L_CORE X_NUC_160.L_CORE 0.002262
K_11930 X_NUC_108.L_CORE X_NUC_161.L_CORE 0.003187
K_11931 X_NUC_108.L_CORE X_NUC_162.L_CORE 0.004854
K_11932 X_NUC_108.L_CORE X_NUC_163.L_CORE 0.002418
K_11933 X_NUC_108.L_CORE X_NUC_164.L_CORE 0.005506
K_11934 X_NUC_108.L_CORE X_NUC_165.L_CORE 0.003376
K_11935 X_NUC_109.L_CORE X_NUC_110.L_CORE 0.207973
K_11936 X_NUC_109.L_CORE X_NUC_111.L_CORE 0.207973
K_11937 X_NUC_109.L_CORE X_NUC_112.L_CORE 0.207973
K_11938 X_NUC_109.L_CORE X_NUC_113.L_CORE 0.002564
K_11939 X_NUC_109.L_CORE X_NUC_114.L_CORE 0.002587
K_11940 X_NUC_109.L_CORE X_NUC_115.L_CORE 0.002563
K_11941 X_NUC_109.L_CORE X_NUC_116.L_CORE 0.002585
K_11942 X_NUC_109.L_CORE X_NUC_117.L_CORE 0.003674
K_11943 X_NUC_109.L_CORE X_NUC_118.L_CORE 0.003735
K_11944 X_NUC_109.L_CORE X_NUC_119.L_CORE 0.003708
K_11945 X_NUC_109.L_CORE X_NUC_120.L_CORE 0.003687
K_11946 X_NUC_109.L_CORE X_NUC_121.L_CORE 0.005494
K_11947 X_NUC_109.L_CORE X_NUC_122.L_CORE 0.005547
K_11948 X_NUC_109.L_CORE X_NUC_123.L_CORE 0.005426
K_11949 X_NUC_109.L_CORE X_NUC_124.L_CORE 0.005554
K_11950 X_NUC_109.L_CORE X_NUC_125.L_CORE 0.002895
K_11951 X_NUC_109.L_CORE X_NUC_126.L_CORE 0.002933
K_11952 X_NUC_109.L_CORE X_NUC_127.L_CORE 0.002901
K_11953 X_NUC_109.L_CORE X_NUC_128.L_CORE 0.002914
K_11954 X_NUC_109.L_CORE X_NUC_129.L_CORE 0.005417
K_11955 X_NUC_109.L_CORE X_NUC_130.L_CORE 0.005542
K_11956 X_NUC_109.L_CORE X_NUC_131.L_CORE 0.005419
K_11957 X_NUC_109.L_CORE X_NUC_132.L_CORE 0.005438
K_11958 X_NUC_109.L_CORE X_NUC_133.L_CORE 0.001764
K_11959 X_NUC_109.L_CORE X_NUC_134.L_CORE 0.002006
K_11960 X_NUC_109.L_CORE X_NUC_135.L_CORE 0.001659
K_11961 X_NUC_109.L_CORE X_NUC_136.L_CORE 0.002029
K_11962 X_NUC_109.L_CORE X_NUC_137.L_CORE 0.001970
K_11963 X_NUC_109.L_CORE X_NUC_138.L_CORE 0.001677
K_11964 X_NUC_109.L_CORE X_NUC_139.L_CORE 0.002552
K_11965 X_NUC_109.L_CORE X_NUC_140.L_CORE 0.001739
K_11966 X_NUC_109.L_CORE X_NUC_141.L_CORE 0.001988
K_11967 X_NUC_109.L_CORE X_NUC_142.L_CORE 0.002568
K_11968 X_NUC_109.L_CORE X_NUC_143.L_CORE 0.001661
K_11969 X_NUC_109.L_CORE X_NUC_144.L_CORE 0.002842
K_11970 X_NUC_109.L_CORE X_NUC_145.L_CORE 0.002060
K_11971 X_NUC_109.L_CORE X_NUC_146.L_CORE 0.001862
K_11972 X_NUC_109.L_CORE X_NUC_147.L_CORE 0.003830
K_11973 X_NUC_109.L_CORE X_NUC_148.L_CORE 0.001780
K_11974 X_NUC_109.L_CORE X_NUC_149.L_CORE 0.002621
K_11975 X_NUC_109.L_CORE X_NUC_150.L_CORE 0.002864
K_11976 X_NUC_109.L_CORE X_NUC_151.L_CORE 0.001826
K_11977 X_NUC_109.L_CORE X_NUC_152.L_CORE 0.005235
K_11978 X_NUC_109.L_CORE X_NUC_153.L_CORE 0.002131
K_11979 X_NUC_109.L_CORE X_NUC_154.L_CORE 0.002333
K_11980 X_NUC_109.L_CORE X_NUC_155.L_CORE 0.005465
K_11981 X_NUC_109.L_CORE X_NUC_156.L_CORE 0.001965
K_11982 X_NUC_109.L_CORE X_NUC_157.L_CORE 0.004345
K_11983 X_NUC_109.L_CORE X_NUC_158.L_CORE 0.003014
K_11984 X_NUC_109.L_CORE X_NUC_159.L_CORE 0.002274
K_11985 X_NUC_109.L_CORE X_NUC_160.L_CORE 0.029936
K_11986 X_NUC_109.L_CORE X_NUC_161.L_CORE 0.002442
K_11987 X_NUC_109.L_CORE X_NUC_162.L_CORE 0.003497
K_11988 X_NUC_109.L_CORE X_NUC_163.L_CORE 0.005160
K_11989 X_NUC_109.L_CORE X_NUC_164.L_CORE 0.002758
K_11990 X_NUC_109.L_CORE X_NUC_165.L_CORE 0.005113
K_11991 X_NUC_110.L_CORE X_NUC_111.L_CORE 0.207973
K_11992 X_NUC_110.L_CORE X_NUC_112.L_CORE 0.207973
K_11993 X_NUC_110.L_CORE X_NUC_113.L_CORE 0.002541
K_11994 X_NUC_110.L_CORE X_NUC_114.L_CORE 0.002564
K_11995 X_NUC_110.L_CORE X_NUC_115.L_CORE 0.002541
K_11996 X_NUC_110.L_CORE X_NUC_116.L_CORE 0.002562
K_11997 X_NUC_110.L_CORE X_NUC_117.L_CORE 0.003614
K_11998 X_NUC_110.L_CORE X_NUC_118.L_CORE 0.003674
K_11999 X_NUC_110.L_CORE X_NUC_119.L_CORE 0.003648
K_12000 X_NUC_110.L_CORE X_NUC_120.L_CORE 0.003627
K_12001 X_NUC_110.L_CORE X_NUC_121.L_CORE 0.005438
K_12002 X_NUC_110.L_CORE X_NUC_122.L_CORE 0.005494
K_12003 X_NUC_110.L_CORE X_NUC_123.L_CORE 0.005375
K_12004 X_NUC_110.L_CORE X_NUC_124.L_CORE 0.005499
K_12005 X_NUC_110.L_CORE X_NUC_125.L_CORE 0.002858
K_12006 X_NUC_110.L_CORE X_NUC_126.L_CORE 0.002895
K_12007 X_NUC_110.L_CORE X_NUC_127.L_CORE 0.002865
K_12008 X_NUC_110.L_CORE X_NUC_128.L_CORE 0.002877
K_12009 X_NUC_110.L_CORE X_NUC_129.L_CORE 0.005297
K_12010 X_NUC_110.L_CORE X_NUC_130.L_CORE 0.005417
K_12011 X_NUC_110.L_CORE X_NUC_131.L_CORE 0.005301
K_12012 X_NUC_110.L_CORE X_NUC_132.L_CORE 0.005318
K_12013 X_NUC_110.L_CORE X_NUC_133.L_CORE 0.001757
K_12014 X_NUC_110.L_CORE X_NUC_134.L_CORE 0.002004
K_12015 X_NUC_110.L_CORE X_NUC_135.L_CORE 0.001651
K_12016 X_NUC_110.L_CORE X_NUC_136.L_CORE 0.002022
K_12017 X_NUC_110.L_CORE X_NUC_137.L_CORE 0.001967
K_12018 X_NUC_110.L_CORE X_NUC_138.L_CORE 0.001668
K_12019 X_NUC_110.L_CORE X_NUC_139.L_CORE 0.002554
K_12020 X_NUC_110.L_CORE X_NUC_140.L_CORE 0.001732
K_12021 X_NUC_110.L_CORE X_NUC_141.L_CORE 0.001976
K_12022 X_NUC_110.L_CORE X_NUC_142.L_CORE 0.002573
K_12023 X_NUC_110.L_CORE X_NUC_143.L_CORE 0.001651
K_12024 X_NUC_110.L_CORE X_NUC_144.L_CORE 0.002836
K_12025 X_NUC_110.L_CORE X_NUC_145.L_CORE 0.002054
K_12026 X_NUC_110.L_CORE X_NUC_146.L_CORE 0.001848
K_12027 X_NUC_110.L_CORE X_NUC_147.L_CORE 0.003861
K_12028 X_NUC_110.L_CORE X_NUC_148.L_CORE 0.001770
K_12029 X_NUC_110.L_CORE X_NUC_149.L_CORE 0.002602
K_12030 X_NUC_110.L_CORE X_NUC_150.L_CORE 0.002868
K_12031 X_NUC_110.L_CORE X_NUC_151.L_CORE 0.001811
K_12032 X_NUC_110.L_CORE X_NUC_152.L_CORE 0.005258
K_12033 X_NUC_110.L_CORE X_NUC_153.L_CORE 0.002121
K_12034 X_NUC_110.L_CORE X_NUC_154.L_CORE 0.002309
K_12035 X_NUC_110.L_CORE X_NUC_155.L_CORE 0.005540
K_12036 X_NUC_110.L_CORE X_NUC_156.L_CORE 0.001949
K_12037 X_NUC_110.L_CORE X_NUC_157.L_CORE 0.004296
K_12038 X_NUC_110.L_CORE X_NUC_158.L_CORE 0.003004
K_12039 X_NUC_110.L_CORE X_NUC_159.L_CORE 0.002249
K_12040 X_NUC_110.L_CORE X_NUC_160.L_CORE 0.033097
K_12041 X_NUC_110.L_CORE X_NUC_161.L_CORE 0.002421
K_12042 X_NUC_110.L_CORE X_NUC_162.L_CORE 0.003445
K_12043 X_NUC_110.L_CORE X_NUC_163.L_CORE 0.005124
K_12044 X_NUC_110.L_CORE X_NUC_164.L_CORE 0.002725
K_12045 X_NUC_110.L_CORE X_NUC_165.L_CORE 0.005016
K_12046 X_NUC_111.L_CORE X_NUC_112.L_CORE 0.207973
K_12047 X_NUC_111.L_CORE X_NUC_113.L_CORE 0.002564
K_12048 X_NUC_111.L_CORE X_NUC_114.L_CORE 0.002587
K_12049 X_NUC_111.L_CORE X_NUC_115.L_CORE 0.002564
K_12050 X_NUC_111.L_CORE X_NUC_116.L_CORE 0.002585
K_12051 X_NUC_111.L_CORE X_NUC_117.L_CORE 0.003638
K_12052 X_NUC_111.L_CORE X_NUC_118.L_CORE 0.003699
K_12053 X_NUC_111.L_CORE X_NUC_119.L_CORE 0.003674
K_12054 X_NUC_111.L_CORE X_NUC_120.L_CORE 0.003652
K_12055 X_NUC_111.L_CORE X_NUC_121.L_CORE 0.005560
K_12056 X_NUC_111.L_CORE X_NUC_122.L_CORE 0.005617
K_12057 X_NUC_111.L_CORE X_NUC_123.L_CORE 0.005494
K_12058 X_NUC_111.L_CORE X_NUC_124.L_CORE 0.005624
K_12059 X_NUC_111.L_CORE X_NUC_125.L_CORE 0.002888
K_12060 X_NUC_111.L_CORE X_NUC_126.L_CORE 0.002926
K_12061 X_NUC_111.L_CORE X_NUC_127.L_CORE 0.002895
K_12062 X_NUC_111.L_CORE X_NUC_128.L_CORE 0.002908
K_12063 X_NUC_111.L_CORE X_NUC_129.L_CORE 0.005411
K_12064 X_NUC_111.L_CORE X_NUC_130.L_CORE 0.005537
K_12065 X_NUC_111.L_CORE X_NUC_131.L_CORE 0.005417
K_12066 X_NUC_111.L_CORE X_NUC_132.L_CORE 0.005434
K_12067 X_NUC_111.L_CORE X_NUC_133.L_CORE 0.001752
K_12068 X_NUC_111.L_CORE X_NUC_134.L_CORE 0.001994
K_12069 X_NUC_111.L_CORE X_NUC_135.L_CORE 0.001650
K_12070 X_NUC_111.L_CORE X_NUC_136.L_CORE 0.002011
K_12071 X_NUC_111.L_CORE X_NUC_137.L_CORE 0.001962
K_12072 X_NUC_111.L_CORE X_NUC_138.L_CORE 0.001666
K_12073 X_NUC_111.L_CORE X_NUC_139.L_CORE 0.002530
K_12074 X_NUC_111.L_CORE X_NUC_140.L_CORE 0.001733
K_12075 X_NUC_111.L_CORE X_NUC_141.L_CORE 0.001969
K_12076 X_NUC_111.L_CORE X_NUC_142.L_CORE 0.002559
K_12077 X_NUC_111.L_CORE X_NUC_143.L_CORE 0.001653
K_12078 X_NUC_111.L_CORE X_NUC_144.L_CORE 0.002806
K_12079 X_NUC_111.L_CORE X_NUC_145.L_CORE 0.002057
K_12080 X_NUC_111.L_CORE X_NUC_146.L_CORE 0.001848
K_12081 X_NUC_111.L_CORE X_NUC_147.L_CORE 0.003805
K_12082 X_NUC_111.L_CORE X_NUC_148.L_CORE 0.001775
K_12083 X_NUC_111.L_CORE X_NUC_149.L_CORE 0.002590
K_12084 X_NUC_111.L_CORE X_NUC_150.L_CORE 0.002869
K_12085 X_NUC_111.L_CORE X_NUC_151.L_CORE 0.001817
K_12086 X_NUC_111.L_CORE X_NUC_152.L_CORE 0.005137
K_12087 X_NUC_111.L_CORE X_NUC_153.L_CORE 0.002131
K_12088 X_NUC_111.L_CORE X_NUC_154.L_CORE 0.002312
K_12089 X_NUC_111.L_CORE X_NUC_155.L_CORE 0.005513
K_12090 X_NUC_111.L_CORE X_NUC_156.L_CORE 0.001960
K_12091 X_NUC_111.L_CORE X_NUC_157.L_CORE 0.004274
K_12092 X_NUC_111.L_CORE X_NUC_158.L_CORE 0.003028
K_12093 X_NUC_111.L_CORE X_NUC_159.L_CORE 0.002261
K_12094 X_NUC_111.L_CORE X_NUC_160.L_CORE 0.033018
K_12095 X_NUC_111.L_CORE X_NUC_161.L_CORE 0.002443
K_12096 X_NUC_111.L_CORE X_NUC_162.L_CORE 0.003468
K_12097 X_NUC_111.L_CORE X_NUC_163.L_CORE 0.005236
K_12098 X_NUC_111.L_CORE X_NUC_164.L_CORE 0.002754
K_12099 X_NUC_111.L_CORE X_NUC_165.L_CORE 0.005123
K_12100 X_NUC_112.L_CORE X_NUC_113.L_CORE 0.002542
K_12101 X_NUC_112.L_CORE X_NUC_114.L_CORE 0.002565
K_12102 X_NUC_112.L_CORE X_NUC_115.L_CORE 0.002542
K_12103 X_NUC_112.L_CORE X_NUC_116.L_CORE 0.002564
K_12104 X_NUC_112.L_CORE X_NUC_117.L_CORE 0.003659
K_12105 X_NUC_112.L_CORE X_NUC_118.L_CORE 0.003721
K_12106 X_NUC_112.L_CORE X_NUC_119.L_CORE 0.003694
K_12107 X_NUC_112.L_CORE X_NUC_120.L_CORE 0.003674
K_12108 X_NUC_112.L_CORE X_NUC_121.L_CORE 0.005432
K_12109 X_NUC_112.L_CORE X_NUC_122.L_CORE 0.005485
K_12110 X_NUC_112.L_CORE X_NUC_123.L_CORE 0.005368
K_12111 X_NUC_112.L_CORE X_NUC_124.L_CORE 0.005494
K_12112 X_NUC_112.L_CORE X_NUC_125.L_CORE 0.002876
K_12113 X_NUC_112.L_CORE X_NUC_126.L_CORE 0.002913
K_12114 X_NUC_112.L_CORE X_NUC_127.L_CORE 0.002882
K_12115 X_NUC_112.L_CORE X_NUC_128.L_CORE 0.002895
K_12116 X_NUC_112.L_CORE X_NUC_129.L_CORE 0.005392
K_12117 X_NUC_112.L_CORE X_NUC_130.L_CORE 0.005517
K_12118 X_NUC_112.L_CORE X_NUC_131.L_CORE 0.005397
K_12119 X_NUC_112.L_CORE X_NUC_132.L_CORE 0.005417
K_12120 X_NUC_112.L_CORE X_NUC_133.L_CORE 0.001751
K_12121 X_NUC_112.L_CORE X_NUC_134.L_CORE 0.001990
K_12122 X_NUC_112.L_CORE X_NUC_135.L_CORE 0.001646
K_12123 X_NUC_112.L_CORE X_NUC_136.L_CORE 0.002015
K_12124 X_NUC_112.L_CORE X_NUC_137.L_CORE 0.001953
K_12125 X_NUC_112.L_CORE X_NUC_138.L_CORE 0.001666
K_12126 X_NUC_112.L_CORE X_NUC_139.L_CORE 0.002533
K_12127 X_NUC_112.L_CORE X_NUC_140.L_CORE 0.001725
K_12128 X_NUC_112.L_CORE X_NUC_141.L_CORE 0.001976
K_12129 X_NUC_112.L_CORE X_NUC_142.L_CORE 0.002544
K_12130 X_NUC_112.L_CORE X_NUC_143.L_CORE 0.001649
K_12131 X_NUC_112.L_CORE X_NUC_144.L_CORE 0.002827
K_12132 X_NUC_112.L_CORE X_NUC_145.L_CORE 0.002041
K_12133 X_NUC_112.L_CORE X_NUC_146.L_CORE 0.001851
K_12134 X_NUC_112.L_CORE X_NUC_147.L_CORE 0.003797
K_12135 X_NUC_112.L_CORE X_NUC_148.L_CORE 0.001766
K_12136 X_NUC_112.L_CORE X_NUC_149.L_CORE 0.002610
K_12137 X_NUC_112.L_CORE X_NUC_150.L_CORE 0.002836
K_12138 X_NUC_112.L_CORE X_NUC_151.L_CORE 0.001814
K_12139 X_NUC_112.L_CORE X_NUC_152.L_CORE 0.005225
K_12140 X_NUC_112.L_CORE X_NUC_153.L_CORE 0.002113
K_12141 X_NUC_112.L_CORE X_NUC_154.L_CORE 0.002322
K_12142 X_NUC_112.L_CORE X_NUC_155.L_CORE 0.005407
K_12143 X_NUC_112.L_CORE X_NUC_156.L_CORE 0.001952
K_12144 X_NUC_112.L_CORE X_NUC_157.L_CORE 0.004347
K_12145 X_NUC_112.L_CORE X_NUC_158.L_CORE 0.002986
K_12146 X_NUC_112.L_CORE X_NUC_159.L_CORE 0.002262
K_12147 X_NUC_112.L_CORE X_NUC_160.L_CORE 0.034626
K_12148 X_NUC_112.L_CORE X_NUC_161.L_CORE 0.002423
K_12149 X_NUC_112.L_CORE X_NUC_162.L_CORE 0.003490
K_12150 X_NUC_112.L_CORE X_NUC_163.L_CORE 0.005124
K_12151 X_NUC_112.L_CORE X_NUC_164.L_CORE 0.002743
K_12152 X_NUC_112.L_CORE X_NUC_165.L_CORE 0.005111
K_12153 X_NUC_113.L_CORE X_NUC_114.L_CORE 0.207973
K_12154 X_NUC_113.L_CORE X_NUC_115.L_CORE 0.207973
K_12155 X_NUC_113.L_CORE X_NUC_116.L_CORE 0.207973
K_12156 X_NUC_113.L_CORE X_NUC_117.L_CORE 0.002818
K_12157 X_NUC_113.L_CORE X_NUC_118.L_CORE 0.002814
K_12158 X_NUC_113.L_CORE X_NUC_119.L_CORE 0.002834
K_12159 X_NUC_113.L_CORE X_NUC_120.L_CORE 0.002796
K_12160 X_NUC_113.L_CORE X_NUC_121.L_CORE 0.004087
K_12161 X_NUC_113.L_CORE X_NUC_122.L_CORE 0.004016
K_12162 X_NUC_113.L_CORE X_NUC_123.L_CORE 0.004059
K_12163 X_NUC_113.L_CORE X_NUC_124.L_CORE 0.004026
K_12164 X_NUC_113.L_CORE X_NUC_125.L_CORE 0.005964
K_12165 X_NUC_113.L_CORE X_NUC_126.L_CORE 0.005996
K_12166 X_NUC_113.L_CORE X_NUC_127.L_CORE 0.006021
K_12167 X_NUC_113.L_CORE X_NUC_128.L_CORE 0.005864
K_12168 X_NUC_113.L_CORE X_NUC_129.L_CORE 0.003571
K_12169 X_NUC_113.L_CORE X_NUC_130.L_CORE 0.003543
K_12170 X_NUC_113.L_CORE X_NUC_131.L_CORE 0.003572
K_12171 X_NUC_113.L_CORE X_NUC_132.L_CORE 0.003521
K_12172 X_NUC_113.L_CORE X_NUC_133.L_CORE 0.001738
K_12173 X_NUC_113.L_CORE X_NUC_134.L_CORE 0.001730
K_12174 X_NUC_113.L_CORE X_NUC_135.L_CORE 0.002035
K_12175 X_NUC_113.L_CORE X_NUC_136.L_CORE 0.001639
K_12176 X_NUC_113.L_CORE X_NUC_137.L_CORE 0.002023
K_12177 X_NUC_113.L_CORE X_NUC_138.L_CORE 0.001971
K_12178 X_NUC_113.L_CORE X_NUC_139.L_CORE 0.001674
K_12179 X_NUC_113.L_CORE X_NUC_140.L_CORE 0.002537
K_12180 X_NUC_113.L_CORE X_NUC_141.L_CORE 0.001749
K_12181 X_NUC_113.L_CORE X_NUC_142.L_CORE 0.001987
K_12182 X_NUC_113.L_CORE X_NUC_143.L_CORE 0.002568
K_12183 X_NUC_113.L_CORE X_NUC_144.L_CORE 0.001681
K_12184 X_NUC_113.L_CORE X_NUC_145.L_CORE 0.002812
K_12185 X_NUC_113.L_CORE X_NUC_146.L_CORE 0.002091
K_12186 X_NUC_113.L_CORE X_NUC_147.L_CORE 0.001887
K_12187 X_NUC_113.L_CORE X_NUC_148.L_CORE 0.003773
K_12188 X_NUC_113.L_CORE X_NUC_149.L_CORE 0.001824
K_12189 X_NUC_113.L_CORE X_NUC_150.L_CORE 0.002642
K_12190 X_NUC_113.L_CORE X_NUC_151.L_CORE 0.002929
K_12191 X_NUC_113.L_CORE X_NUC_152.L_CORE 0.001880
K_12192 X_NUC_113.L_CORE X_NUC_153.L_CORE 0.005123
K_12193 X_NUC_113.L_CORE X_NUC_154.L_CORE 0.002216
K_12194 X_NUC_113.L_CORE X_NUC_155.L_CORE 0.002409
K_12195 X_NUC_113.L_CORE X_NUC_156.L_CORE 0.005645
K_12196 X_NUC_113.L_CORE X_NUC_157.L_CORE 0.002064
K_12197 X_NUC_113.L_CORE X_NUC_158.L_CORE 0.004493
K_12198 X_NUC_113.L_CORE X_NUC_159.L_CORE 0.003219
K_12199 X_NUC_113.L_CORE X_NUC_160.L_CORE 0.002422
K_12200 X_NUC_113.L_CORE X_NUC_161.L_CORE 0.031982
K_12201 X_NUC_113.L_CORE X_NUC_162.L_CORE 0.002669
K_12202 X_NUC_113.L_CORE X_NUC_163.L_CORE 0.003823
K_12203 X_NUC_113.L_CORE X_NUC_164.L_CORE 0.005585
K_12204 X_NUC_113.L_CORE X_NUC_165.L_CORE 0.003361
K_12205 X_NUC_114.L_CORE X_NUC_115.L_CORE 0.207973
K_12206 X_NUC_114.L_CORE X_NUC_116.L_CORE 0.207973
K_12207 X_NUC_114.L_CORE X_NUC_117.L_CORE 0.002821
K_12208 X_NUC_114.L_CORE X_NUC_118.L_CORE 0.002818
K_12209 X_NUC_114.L_CORE X_NUC_119.L_CORE 0.002837
K_12210 X_NUC_114.L_CORE X_NUC_120.L_CORE 0.002799
K_12211 X_NUC_114.L_CORE X_NUC_121.L_CORE 0.004160
K_12212 X_NUC_114.L_CORE X_NUC_122.L_CORE 0.004087
K_12213 X_NUC_114.L_CORE X_NUC_123.L_CORE 0.004131
K_12214 X_NUC_114.L_CORE X_NUC_124.L_CORE 0.004097
K_12215 X_NUC_114.L_CORE X_NUC_125.L_CORE 0.005928
K_12216 X_NUC_114.L_CORE X_NUC_126.L_CORE 0.005964
K_12217 X_NUC_114.L_CORE X_NUC_127.L_CORE 0.005986
K_12218 X_NUC_114.L_CORE X_NUC_128.L_CORE 0.005832
K_12219 X_NUC_114.L_CORE X_NUC_129.L_CORE 0.003599
K_12220 X_NUC_114.L_CORE X_NUC_130.L_CORE 0.003571
K_12221 X_NUC_114.L_CORE X_NUC_131.L_CORE 0.003600
K_12222 X_NUC_114.L_CORE X_NUC_132.L_CORE 0.003548
K_12223 X_NUC_114.L_CORE X_NUC_133.L_CORE 0.001738
K_12224 X_NUC_114.L_CORE X_NUC_134.L_CORE 0.001736
K_12225 X_NUC_114.L_CORE X_NUC_135.L_CORE 0.002033
K_12226 X_NUC_114.L_CORE X_NUC_136.L_CORE 0.001642
K_12227 X_NUC_114.L_CORE X_NUC_137.L_CORE 0.002032
K_12228 X_NUC_114.L_CORE X_NUC_138.L_CORE 0.001966
K_12229 X_NUC_114.L_CORE X_NUC_139.L_CORE 0.001681
K_12230 X_NUC_114.L_CORE X_NUC_140.L_CORE 0.002537
K_12231 X_NUC_114.L_CORE X_NUC_141.L_CORE 0.001749
K_12232 X_NUC_114.L_CORE X_NUC_142.L_CORE 0.002000
K_12233 X_NUC_114.L_CORE X_NUC_143.L_CORE 0.002552
K_12234 X_NUC_114.L_CORE X_NUC_144.L_CORE 0.001686
K_12235 X_NUC_114.L_CORE X_NUC_145.L_CORE 0.002830
K_12236 X_NUC_114.L_CORE X_NUC_146.L_CORE 0.002083
K_12237 X_NUC_114.L_CORE X_NUC_147.L_CORE 0.001900
K_12238 X_NUC_114.L_CORE X_NUC_148.L_CORE 0.003744
K_12239 X_NUC_114.L_CORE X_NUC_149.L_CORE 0.001825
K_12240 X_NUC_114.L_CORE X_NUC_150.L_CORE 0.002671
K_12241 X_NUC_114.L_CORE X_NUC_151.L_CORE 0.002901
K_12242 X_NUC_114.L_CORE X_NUC_152.L_CORE 0.001890
K_12243 X_NUC_114.L_CORE X_NUC_153.L_CORE 0.005160
K_12244 X_NUC_114.L_CORE X_NUC_154.L_CORE 0.002210
K_12245 X_NUC_114.L_CORE X_NUC_155.L_CORE 0.002435
K_12246 X_NUC_114.L_CORE X_NUC_156.L_CORE 0.005511
K_12247 X_NUC_114.L_CORE X_NUC_157.L_CORE 0.002070
K_12248 X_NUC_114.L_CORE X_NUC_158.L_CORE 0.004587
K_12249 X_NUC_114.L_CORE X_NUC_159.L_CORE 0.003195
K_12250 X_NUC_114.L_CORE X_NUC_160.L_CORE 0.002443
K_12251 X_NUC_114.L_CORE X_NUC_161.L_CORE 0.030661
K_12252 X_NUC_114.L_CORE X_NUC_162.L_CORE 0.002672
K_12253 X_NUC_114.L_CORE X_NUC_163.L_CORE 0.003887
K_12254 X_NUC_114.L_CORE X_NUC_164.L_CORE 0.005547
K_12255 X_NUC_114.L_CORE X_NUC_165.L_CORE 0.003385
K_12256 X_NUC_115.L_CORE X_NUC_116.L_CORE 0.207973
K_12257 X_NUC_115.L_CORE X_NUC_117.L_CORE 0.002802
K_12258 X_NUC_115.L_CORE X_NUC_118.L_CORE 0.002798
K_12259 X_NUC_115.L_CORE X_NUC_119.L_CORE 0.002818
K_12260 X_NUC_115.L_CORE X_NUC_120.L_CORE 0.002780
K_12261 X_NUC_115.L_CORE X_NUC_121.L_CORE 0.004113
K_12262 X_NUC_115.L_CORE X_NUC_122.L_CORE 0.004042
K_12263 X_NUC_115.L_CORE X_NUC_123.L_CORE 0.004087
K_12264 X_NUC_115.L_CORE X_NUC_124.L_CORE 0.004052
K_12265 X_NUC_115.L_CORE X_NUC_125.L_CORE 0.005905
K_12266 X_NUC_115.L_CORE X_NUC_126.L_CORE 0.005938
K_12267 X_NUC_115.L_CORE X_NUC_127.L_CORE 0.005964
K_12268 X_NUC_115.L_CORE X_NUC_128.L_CORE 0.005810
K_12269 X_NUC_115.L_CORE X_NUC_129.L_CORE 0.003569
K_12270 X_NUC_115.L_CORE X_NUC_130.L_CORE 0.003542
K_12271 X_NUC_115.L_CORE X_NUC_131.L_CORE 0.003571
K_12272 X_NUC_115.L_CORE X_NUC_132.L_CORE 0.003519
K_12273 X_NUC_115.L_CORE X_NUC_133.L_CORE 0.001726
K_12274 X_NUC_115.L_CORE X_NUC_134.L_CORE 0.001722
K_12275 X_NUC_115.L_CORE X_NUC_135.L_CORE 0.002019
K_12276 X_NUC_115.L_CORE X_NUC_136.L_CORE 0.001630
K_12277 X_NUC_115.L_CORE X_NUC_137.L_CORE 0.002015
K_12278 X_NUC_115.L_CORE X_NUC_138.L_CORE 0.001953
K_12279 X_NUC_115.L_CORE X_NUC_139.L_CORE 0.001668
K_12280 X_NUC_115.L_CORE X_NUC_140.L_CORE 0.002519
K_12281 X_NUC_115.L_CORE X_NUC_141.L_CORE 0.001737
K_12282 X_NUC_115.L_CORE X_NUC_142.L_CORE 0.001983
K_12283 X_NUC_115.L_CORE X_NUC_143.L_CORE 0.002538
K_12284 X_NUC_115.L_CORE X_NUC_144.L_CORE 0.001673
K_12285 X_NUC_115.L_CORE X_NUC_145.L_CORE 0.002806
K_12286 X_NUC_115.L_CORE X_NUC_146.L_CORE 0.002071
K_12287 X_NUC_115.L_CORE X_NUC_147.L_CORE 0.001884
K_12288 X_NUC_115.L_CORE X_NUC_148.L_CORE 0.003726
K_12289 X_NUC_115.L_CORE X_NUC_149.L_CORE 0.001813
K_12290 X_NUC_115.L_CORE X_NUC_150.L_CORE 0.002646
K_12291 X_NUC_115.L_CORE X_NUC_151.L_CORE 0.002889
K_12292 X_NUC_115.L_CORE X_NUC_152.L_CORE 0.001875
K_12293 X_NUC_115.L_CORE X_NUC_153.L_CORE 0.005122
K_12294 X_NUC_115.L_CORE X_NUC_154.L_CORE 0.002198
K_12295 X_NUC_115.L_CORE X_NUC_155.L_CORE 0.002413
K_12296 X_NUC_115.L_CORE X_NUC_156.L_CORE 0.005523
K_12297 X_NUC_115.L_CORE X_NUC_157.L_CORE 0.002056
K_12298 X_NUC_115.L_CORE X_NUC_158.L_CORE 0.004541
K_12299 X_NUC_115.L_CORE X_NUC_159.L_CORE 0.003184
K_12300 X_NUC_115.L_CORE X_NUC_160.L_CORE 0.002423
K_12301 X_NUC_115.L_CORE X_NUC_161.L_CORE 0.035852
K_12302 X_NUC_115.L_CORE X_NUC_162.L_CORE 0.002656
K_12303 X_NUC_115.L_CORE X_NUC_163.L_CORE 0.003853
K_12304 X_NUC_115.L_CORE X_NUC_164.L_CORE 0.005550
K_12305 X_NUC_115.L_CORE X_NUC_165.L_CORE 0.003363
K_12306 X_NUC_116.L_CORE X_NUC_117.L_CORE 0.002840
K_12307 X_NUC_116.L_CORE X_NUC_118.L_CORE 0.002836
K_12308 X_NUC_116.L_CORE X_NUC_119.L_CORE 0.002856
K_12309 X_NUC_116.L_CORE X_NUC_120.L_CORE 0.002818
K_12310 X_NUC_116.L_CORE X_NUC_121.L_CORE 0.004149
K_12311 X_NUC_116.L_CORE X_NUC_122.L_CORE 0.004075
K_12312 X_NUC_116.L_CORE X_NUC_123.L_CORE 0.004120
K_12313 X_NUC_116.L_CORE X_NUC_124.L_CORE 0.004087
K_12314 X_NUC_116.L_CORE X_NUC_125.L_CORE 0.006065
K_12315 X_NUC_116.L_CORE X_NUC_126.L_CORE 0.006101
K_12316 X_NUC_116.L_CORE X_NUC_127.L_CORE 0.006127
K_12317 X_NUC_116.L_CORE X_NUC_128.L_CORE 0.005964
K_12318 X_NUC_116.L_CORE X_NUC_129.L_CORE 0.003623
K_12319 X_NUC_116.L_CORE X_NUC_130.L_CORE 0.003594
K_12320 X_NUC_116.L_CORE X_NUC_131.L_CORE 0.003624
K_12321 X_NUC_116.L_CORE X_NUC_132.L_CORE 0.003571
K_12322 X_NUC_116.L_CORE X_NUC_133.L_CORE 0.001732
K_12323 X_NUC_116.L_CORE X_NUC_134.L_CORE 0.001726
K_12324 X_NUC_116.L_CORE X_NUC_135.L_CORE 0.002021
K_12325 X_NUC_116.L_CORE X_NUC_136.L_CORE 0.001638
K_12326 X_NUC_116.L_CORE X_NUC_137.L_CORE 0.002015
K_12327 X_NUC_116.L_CORE X_NUC_138.L_CORE 0.001962
K_12328 X_NUC_116.L_CORE X_NUC_139.L_CORE 0.001674
K_12329 X_NUC_116.L_CORE X_NUC_140.L_CORE 0.002513
K_12330 X_NUC_116.L_CORE X_NUC_141.L_CORE 0.001748
K_12331 X_NUC_116.L_CORE X_NUC_142.L_CORE 0.001985
K_12332 X_NUC_116.L_CORE X_NUC_143.L_CORE 0.002544
K_12333 X_NUC_116.L_CORE X_NUC_144.L_CORE 0.001684
K_12334 X_NUC_116.L_CORE X_NUC_145.L_CORE 0.002793
K_12335 X_NUC_116.L_CORE X_NUC_146.L_CORE 0.002086
K_12336 X_NUC_116.L_CORE X_NUC_147.L_CORE 0.001892
K_12337 X_NUC_116.L_CORE X_NUC_148.L_CORE 0.003708
K_12338 X_NUC_116.L_CORE X_NUC_149.L_CORE 0.001827
K_12339 X_NUC_116.L_CORE X_NUC_150.L_CORE 0.002642
K_12340 X_NUC_116.L_CORE X_NUC_151.L_CORE 0.002911
K_12341 X_NUC_116.L_CORE X_NUC_152.L_CORE 0.001888
K_12342 X_NUC_116.L_CORE X_NUC_153.L_CORE 0.005040
K_12343 X_NUC_116.L_CORE X_NUC_154.L_CORE 0.002220
K_12344 X_NUC_116.L_CORE X_NUC_155.L_CORE 0.002422
K_12345 X_NUC_116.L_CORE X_NUC_156.L_CORE 0.005543
K_12346 X_NUC_116.L_CORE X_NUC_157.L_CORE 0.002075
K_12347 X_NUC_116.L_CORE X_NUC_158.L_CORE 0.004515
K_12348 X_NUC_116.L_CORE X_NUC_159.L_CORE 0.003227
K_12349 X_NUC_116.L_CORE X_NUC_160.L_CORE 0.002442
K_12350 X_NUC_116.L_CORE X_NUC_161.L_CORE 0.032263
K_12351 X_NUC_116.L_CORE X_NUC_162.L_CORE 0.002690
K_12352 X_NUC_116.L_CORE X_NUC_163.L_CORE 0.003880
K_12353 X_NUC_116.L_CORE X_NUC_164.L_CORE 0.005680
K_12354 X_NUC_116.L_CORE X_NUC_165.L_CORE 0.003409
K_12355 X_NUC_117.L_CORE X_NUC_118.L_CORE 0.207973
K_12356 X_NUC_117.L_CORE X_NUC_119.L_CORE 0.207973
K_12357 X_NUC_117.L_CORE X_NUC_120.L_CORE 0.207973
K_12358 X_NUC_117.L_CORE X_NUC_121.L_CORE 0.003203
K_12359 X_NUC_117.L_CORE X_NUC_122.L_CORE 0.003173
K_12360 X_NUC_117.L_CORE X_NUC_123.L_CORE 0.003166
K_12361 X_NUC_117.L_CORE X_NUC_124.L_CORE 0.003205
K_12362 X_NUC_117.L_CORE X_NUC_125.L_CORE 0.004738
K_12363 X_NUC_117.L_CORE X_NUC_126.L_CORE 0.004770
K_12364 X_NUC_117.L_CORE X_NUC_127.L_CORE 0.004690
K_12365 X_NUC_117.L_CORE X_NUC_128.L_CORE 0.004792
K_12366 X_NUC_117.L_CORE X_NUC_129.L_CORE 0.006372
K_12367 X_NUC_117.L_CORE X_NUC_130.L_CORE 0.006255
K_12368 X_NUC_117.L_CORE X_NUC_131.L_CORE 0.006200
K_12369 X_NUC_117.L_CORE X_NUC_132.L_CORE 0.006334
K_12370 X_NUC_117.L_CORE X_NUC_133.L_CORE 0.001807
K_12371 X_NUC_117.L_CORE X_NUC_134.L_CORE 0.001716
K_12372 X_NUC_117.L_CORE X_NUC_135.L_CORE 0.001723
K_12373 X_NUC_117.L_CORE X_NUC_136.L_CORE 0.002041
K_12374 X_NUC_117.L_CORE X_NUC_137.L_CORE 0.001639
K_12375 X_NUC_117.L_CORE X_NUC_138.L_CORE 0.002029
K_12376 X_NUC_117.L_CORE X_NUC_139.L_CORE 0.001965
K_12377 X_NUC_117.L_CORE X_NUC_140.L_CORE 0.001694
K_12378 X_NUC_117.L_CORE X_NUC_141.L_CORE 0.002507
K_12379 X_NUC_117.L_CORE X_NUC_142.L_CORE 0.001768
K_12380 X_NUC_117.L_CORE X_NUC_143.L_CORE 0.002016
K_12381 X_NUC_117.L_CORE X_NUC_144.L_CORE 0.002534
K_12382 X_NUC_117.L_CORE X_NUC_145.L_CORE 0.001722
K_12383 X_NUC_117.L_CORE X_NUC_146.L_CORE 0.002805
K_12384 X_NUC_117.L_CORE X_NUC_147.L_CORE 0.002118
K_12385 X_NUC_117.L_CORE X_NUC_148.L_CORE 0.001949
K_12386 X_NUC_117.L_CORE X_NUC_149.L_CORE 0.003643
K_12387 X_NUC_117.L_CORE X_NUC_150.L_CORE 0.001886
K_12388 X_NUC_117.L_CORE X_NUC_151.L_CORE 0.002722
K_12389 X_NUC_117.L_CORE X_NUC_152.L_CORE 0.002952
K_12390 X_NUC_117.L_CORE X_NUC_153.L_CORE 0.001973
K_12391 X_NUC_117.L_CORE X_NUC_154.L_CORE 0.005037
K_12392 X_NUC_117.L_CORE X_NUC_155.L_CORE 0.002316
K_12393 X_NUC_117.L_CORE X_NUC_156.L_CORE 0.002562
K_12394 X_NUC_117.L_CORE X_NUC_157.L_CORE 0.005580
K_12395 X_NUC_117.L_CORE X_NUC_158.L_CORE 0.002210
K_12396 X_NUC_117.L_CORE X_NUC_159.L_CORE 0.004868
K_12397 X_NUC_117.L_CORE X_NUC_160.L_CORE 0.003449
K_12398 X_NUC_117.L_CORE X_NUC_161.L_CORE 0.002674
K_12399 X_NUC_117.L_CORE X_NUC_162.L_CORE 0.031621
K_12400 X_NUC_117.L_CORE X_NUC_163.L_CORE 0.003018
K_12401 X_NUC_117.L_CORE X_NUC_164.L_CORE 0.004472
K_12402 X_NUC_117.L_CORE X_NUC_165.L_CORE 0.005881
K_12403 X_NUC_118.L_CORE X_NUC_119.L_CORE 0.207973
K_12404 X_NUC_118.L_CORE X_NUC_120.L_CORE 0.207973
K_12405 X_NUC_118.L_CORE X_NUC_121.L_CORE 0.003232
K_12406 X_NUC_118.L_CORE X_NUC_122.L_CORE 0.003203
K_12407 X_NUC_118.L_CORE X_NUC_123.L_CORE 0.003195
K_12408 X_NUC_118.L_CORE X_NUC_124.L_CORE 0.003235
K_12409 X_NUC_118.L_CORE X_NUC_125.L_CORE 0.004703
K_12410 X_NUC_118.L_CORE X_NUC_126.L_CORE 0.004738
K_12411 X_NUC_118.L_CORE X_NUC_127.L_CORE 0.004658
K_12412 X_NUC_118.L_CORE X_NUC_128.L_CORE 0.004757
K_12413 X_NUC_118.L_CORE X_NUC_129.L_CORE 0.006490
K_12414 X_NUC_118.L_CORE X_NUC_130.L_CORE 0.006372
K_12415 X_NUC_118.L_CORE X_NUC_131.L_CORE 0.006311
K_12416 X_NUC_118.L_CORE X_NUC_132.L_CORE 0.006453
K_12417 X_NUC_118.L_CORE X_NUC_133.L_CORE 0.001807
K_12418 X_NUC_118.L_CORE X_NUC_134.L_CORE 0.001720
K_12419 X_NUC_118.L_CORE X_NUC_135.L_CORE 0.001721
K_12420 X_NUC_118.L_CORE X_NUC_136.L_CORE 0.002044
K_12421 X_NUC_118.L_CORE X_NUC_137.L_CORE 0.001643
K_12422 X_NUC_118.L_CORE X_NUC_138.L_CORE 0.002022
K_12423 X_NUC_118.L_CORE X_NUC_139.L_CORE 0.001976
K_12424 X_NUC_118.L_CORE X_NUC_140.L_CORE 0.001693
K_12425 X_NUC_118.L_CORE X_NUC_141.L_CORE 0.002502
K_12426 X_NUC_118.L_CORE X_NUC_142.L_CORE 0.001777
K_12427 X_NUC_118.L_CORE X_NUC_143.L_CORE 0.002007
K_12428 X_NUC_118.L_CORE X_NUC_144.L_CORE 0.002549
K_12429 X_NUC_118.L_CORE X_NUC_145.L_CORE 0.001725
K_12430 X_NUC_118.L_CORE X_NUC_146.L_CORE 0.002783
K_12431 X_NUC_118.L_CORE X_NUC_147.L_CORE 0.002135
K_12432 X_NUC_118.L_CORE X_NUC_148.L_CORE 0.001944
K_12433 X_NUC_118.L_CORE X_NUC_149.L_CORE 0.003649
K_12434 X_NUC_118.L_CORE X_NUC_150.L_CORE 0.001895
K_12435 X_NUC_118.L_CORE X_NUC_151.L_CORE 0.002697
K_12436 X_NUC_118.L_CORE X_NUC_152.L_CORE 0.002988
K_12437 X_NUC_118.L_CORE X_NUC_153.L_CORE 0.001974
K_12438 X_NUC_118.L_CORE X_NUC_154.L_CORE 0.004957
K_12439 X_NUC_118.L_CORE X_NUC_155.L_CORE 0.002337
K_12440 X_NUC_118.L_CORE X_NUC_156.L_CORE 0.002546
K_12441 X_NUC_118.L_CORE X_NUC_157.L_CORE 0.005690
K_12442 X_NUC_118.L_CORE X_NUC_158.L_CORE 0.002219
K_12443 X_NUC_118.L_CORE X_NUC_159.L_CORE 0.004767
K_12444 X_NUC_118.L_CORE X_NUC_160.L_CORE 0.003504
K_12445 X_NUC_118.L_CORE X_NUC_161.L_CORE 0.002670
K_12446 X_NUC_118.L_CORE X_NUC_162.L_CORE 0.030803
K_12447 X_NUC_118.L_CORE X_NUC_163.L_CORE 0.003045
K_12448 X_NUC_118.L_CORE X_NUC_164.L_CORE 0.004439
K_12449 X_NUC_118.L_CORE X_NUC_165.L_CORE 0.005980
K_12450 X_NUC_119.L_CORE X_NUC_120.L_CORE 0.207973
K_12451 X_NUC_119.L_CORE X_NUC_121.L_CORE 0.003239
K_12452 X_NUC_119.L_CORE X_NUC_122.L_CORE 0.003209
K_12453 X_NUC_119.L_CORE X_NUC_123.L_CORE 0.003203
K_12454 X_NUC_119.L_CORE X_NUC_124.L_CORE 0.003242
K_12455 X_NUC_119.L_CORE X_NUC_125.L_CORE 0.004784
K_12456 X_NUC_119.L_CORE X_NUC_126.L_CORE 0.004818
K_12457 X_NUC_119.L_CORE X_NUC_127.L_CORE 0.004738
K_12458 X_NUC_119.L_CORE X_NUC_128.L_CORE 0.004841
K_12459 X_NUC_119.L_CORE X_NUC_129.L_CORE 0.006552
K_12460 X_NUC_119.L_CORE X_NUC_130.L_CORE 0.006428
K_12461 X_NUC_119.L_CORE X_NUC_131.L_CORE 0.006372
K_12462 X_NUC_119.L_CORE X_NUC_132.L_CORE 0.006515
K_12463 X_NUC_119.L_CORE X_NUC_133.L_CORE 0.001798
K_12464 X_NUC_119.L_CORE X_NUC_134.L_CORE 0.001711
K_12465 X_NUC_119.L_CORE X_NUC_135.L_CORE 0.001717
K_12466 X_NUC_119.L_CORE X_NUC_136.L_CORE 0.002028
K_12467 X_NUC_119.L_CORE X_NUC_137.L_CORE 0.001637
K_12468 X_NUC_119.L_CORE X_NUC_138.L_CORE 0.002015
K_12469 X_NUC_119.L_CORE X_NUC_139.L_CORE 0.001960
K_12470 X_NUC_119.L_CORE X_NUC_140.L_CORE 0.001692
K_12471 X_NUC_119.L_CORE X_NUC_141.L_CORE 0.002481
K_12472 X_NUC_119.L_CORE X_NUC_142.L_CORE 0.001769
K_12473 X_NUC_119.L_CORE X_NUC_143.L_CORE 0.002008
K_12474 X_NUC_119.L_CORE X_NUC_144.L_CORE 0.002520
K_12475 X_NUC_119.L_CORE X_NUC_145.L_CORE 0.001724
K_12476 X_NUC_119.L_CORE X_NUC_146.L_CORE 0.002773
K_12477 X_NUC_119.L_CORE X_NUC_147.L_CORE 0.002120
K_12478 X_NUC_119.L_CORE X_NUC_148.L_CORE 0.001947
K_12479 X_NUC_119.L_CORE X_NUC_149.L_CORE 0.003592
K_12480 X_NUC_119.L_CORE X_NUC_150.L_CORE 0.001892
K_12481 X_NUC_119.L_CORE X_NUC_151.L_CORE 0.002705
K_12482 X_NUC_119.L_CORE X_NUC_152.L_CORE 0.002952
K_12483 X_NUC_119.L_CORE X_NUC_153.L_CORE 0.001978
K_12484 X_NUC_119.L_CORE X_NUC_154.L_CORE 0.004921
K_12485 X_NUC_119.L_CORE X_NUC_155.L_CORE 0.002328
K_12486 X_NUC_119.L_CORE X_NUC_156.L_CORE 0.002562
K_12487 X_NUC_119.L_CORE X_NUC_157.L_CORE 0.005548
K_12488 X_NUC_119.L_CORE X_NUC_158.L_CORE 0.002223
K_12489 X_NUC_119.L_CORE X_NUC_159.L_CORE 0.004826
K_12490 X_NUC_119.L_CORE X_NUC_160.L_CORE 0.003482
K_12491 X_NUC_119.L_CORE X_NUC_161.L_CORE 0.002689
K_12492 X_NUC_119.L_CORE X_NUC_162.L_CORE 0.032451
K_12493 X_NUC_119.L_CORE X_NUC_163.L_CORE 0.003053
K_12494 X_NUC_119.L_CORE X_NUC_164.L_CORE 0.004518
K_12495 X_NUC_119.L_CORE X_NUC_165.L_CORE 0.006046
K_12496 X_NUC_120.L_CORE X_NUC_121.L_CORE 0.003199
K_12497 X_NUC_120.L_CORE X_NUC_122.L_CORE 0.003170
K_12498 X_NUC_120.L_CORE X_NUC_123.L_CORE 0.003164
K_12499 X_NUC_120.L_CORE X_NUC_124.L_CORE 0.003203
K_12500 X_NUC_120.L_CORE X_NUC_125.L_CORE 0.004683
K_12501 X_NUC_120.L_CORE X_NUC_126.L_CORE 0.004716
K_12502 X_NUC_120.L_CORE X_NUC_127.L_CORE 0.004639
K_12503 X_NUC_120.L_CORE X_NUC_128.L_CORE 0.004738
K_12504 X_NUC_120.L_CORE X_NUC_129.L_CORE 0.006404
K_12505 X_NUC_120.L_CORE X_NUC_130.L_CORE 0.006288
K_12506 X_NUC_120.L_CORE X_NUC_131.L_CORE 0.006233
K_12507 X_NUC_120.L_CORE X_NUC_132.L_CORE 0.006372
K_12508 X_NUC_120.L_CORE X_NUC_133.L_CORE 0.001794
K_12509 X_NUC_120.L_CORE X_NUC_134.L_CORE 0.001707
K_12510 X_NUC_120.L_CORE X_NUC_135.L_CORE 0.001710
K_12511 X_NUC_120.L_CORE X_NUC_136.L_CORE 0.002029
K_12512 X_NUC_120.L_CORE X_NUC_137.L_CORE 0.001630
K_12513 X_NUC_120.L_CORE X_NUC_138.L_CORE 0.002011
K_12514 X_NUC_120.L_CORE X_NUC_139.L_CORE 0.001959
K_12515 X_NUC_120.L_CORE X_NUC_140.L_CORE 0.001682
K_12516 X_NUC_120.L_CORE X_NUC_141.L_CORE 0.002487
K_12517 X_NUC_120.L_CORE X_NUC_142.L_CORE 0.001762
K_12518 X_NUC_120.L_CORE X_NUC_143.L_CORE 0.001997
K_12519 X_NUC_120.L_CORE X_NUC_144.L_CORE 0.002527
K_12520 X_NUC_120.L_CORE X_NUC_145.L_CORE 0.001712
K_12521 X_NUC_120.L_CORE X_NUC_146.L_CORE 0.002773
K_12522 X_NUC_120.L_CORE X_NUC_147.L_CORE 0.002115
K_12523 X_NUC_120.L_CORE X_NUC_148.L_CORE 0.001932
K_12524 X_NUC_120.L_CORE X_NUC_149.L_CORE 0.003626
K_12525 X_NUC_120.L_CORE X_NUC_150.L_CORE 0.001879
K_12526 X_NUC_120.L_CORE X_NUC_151.L_CORE 0.002689
K_12527 X_NUC_120.L_CORE X_NUC_152.L_CORE 0.002957
K_12528 X_NUC_120.L_CORE X_NUC_153.L_CORE 0.001960
K_12529 X_NUC_120.L_CORE X_NUC_154.L_CORE 0.004963
K_12530 X_NUC_120.L_CORE X_NUC_155.L_CORE 0.002315
K_12531 X_NUC_120.L_CORE X_NUC_156.L_CORE 0.002536
K_12532 X_NUC_120.L_CORE X_NUC_157.L_CORE 0.005633
K_12533 X_NUC_120.L_CORE X_NUC_158.L_CORE 0.002202
K_12534 X_NUC_120.L_CORE X_NUC_159.L_CORE 0.004781
K_12535 X_NUC_120.L_CORE X_NUC_160.L_CORE 0.003466
K_12536 X_NUC_120.L_CORE X_NUC_161.L_CORE 0.002655
K_12537 X_NUC_120.L_CORE X_NUC_162.L_CORE 0.035886
K_12538 X_NUC_120.L_CORE X_NUC_163.L_CORE 0.003019
K_12539 X_NUC_120.L_CORE X_NUC_164.L_CORE 0.004432
K_12540 X_NUC_120.L_CORE X_NUC_165.L_CORE 0.005935
K_12541 X_NUC_121.L_CORE X_NUC_122.L_CORE 0.207973
K_12542 X_NUC_121.L_CORE X_NUC_123.L_CORE 0.207973
K_12543 X_NUC_121.L_CORE X_NUC_124.L_CORE 0.207973
K_12544 X_NUC_121.L_CORE X_NUC_125.L_CORE 0.003872
K_12545 X_NUC_121.L_CORE X_NUC_126.L_CORE 0.003944
K_12546 X_NUC_121.L_CORE X_NUC_127.L_CORE 0.003911
K_12547 X_NUC_121.L_CORE X_NUC_128.L_CORE 0.003896
K_12548 X_NUC_121.L_CORE X_NUC_129.L_CORE 0.005945
K_12549 X_NUC_121.L_CORE X_NUC_130.L_CORE 0.006038
K_12550 X_NUC_121.L_CORE X_NUC_131.L_CORE 0.006035
K_12551 X_NUC_121.L_CORE X_NUC_132.L_CORE 0.005896
K_12552 X_NUC_121.L_CORE X_NUC_133.L_CORE 0.001655
K_12553 X_NUC_121.L_CORE X_NUC_134.L_CORE 0.001838
K_12554 X_NUC_121.L_CORE X_NUC_135.L_CORE 0.001716
K_12555 X_NUC_121.L_CORE X_NUC_136.L_CORE 0.001723
K_12556 X_NUC_121.L_CORE X_NUC_137.L_CORE 0.002034
K_12557 X_NUC_121.L_CORE X_NUC_138.L_CORE 0.001659
K_12558 X_NUC_121.L_CORE X_NUC_139.L_CORE 0.002018
K_12559 X_NUC_121.L_CORE X_NUC_140.L_CORE 0.001978
K_12560 X_NUC_121.L_CORE X_NUC_141.L_CORE 0.001726
K_12561 X_NUC_121.L_CORE X_NUC_142.L_CORE 0.002447
K_12562 X_NUC_121.L_CORE X_NUC_143.L_CORE 0.001815
K_12563 X_NUC_121.L_CORE X_NUC_144.L_CORE 0.002037
K_12564 X_NUC_121.L_CORE X_NUC_145.L_CORE 0.002515
K_12565 X_NUC_121.L_CORE X_NUC_146.L_CORE 0.001786
K_12566 X_NUC_121.L_CORE X_NUC_147.L_CORE 0.002743
K_12567 X_NUC_121.L_CORE X_NUC_148.L_CORE 0.002186
K_12568 X_NUC_121.L_CORE X_NUC_149.L_CORE 0.002020
K_12569 X_NUC_121.L_CORE X_NUC_150.L_CORE 0.003489
K_12570 X_NUC_121.L_CORE X_NUC_151.L_CORE 0.001989
K_12571 X_NUC_121.L_CORE X_NUC_152.L_CORE 0.002765
K_12572 X_NUC_121.L_CORE X_NUC_153.L_CORE 0.003040
K_12573 X_NUC_121.L_CORE X_NUC_154.L_CORE 0.002101
K_12574 X_NUC_121.L_CORE X_NUC_155.L_CORE 0.004751
K_12575 X_NUC_121.L_CORE X_NUC_156.L_CORE 0.002493
K_12576 X_NUC_121.L_CORE X_NUC_157.L_CORE 0.002733
K_12577 X_NUC_121.L_CORE X_NUC_158.L_CORE 0.005648
K_12578 X_NUC_121.L_CORE X_NUC_159.L_CORE 0.002436
K_12579 X_NUC_121.L_CORE X_NUC_160.L_CORE 0.005139
K_12580 X_NUC_121.L_CORE X_NUC_161.L_CORE 0.003894
K_12581 X_NUC_121.L_CORE X_NUC_162.L_CORE 0.003046
K_12582 X_NUC_121.L_CORE X_NUC_163.L_CORE 0.030143
K_12583 X_NUC_121.L_CORE X_NUC_164.L_CORE 0.003688
K_12584 X_NUC_121.L_CORE X_NUC_165.L_CORE 0.005590
K_12585 X_NUC_122.L_CORE X_NUC_123.L_CORE 0.207973
K_12586 X_NUC_122.L_CORE X_NUC_124.L_CORE 0.207973
K_12587 X_NUC_122.L_CORE X_NUC_125.L_CORE 0.003803
K_12588 X_NUC_122.L_CORE X_NUC_126.L_CORE 0.003872
K_12589 X_NUC_122.L_CORE X_NUC_127.L_CORE 0.003840
K_12590 X_NUC_122.L_CORE X_NUC_128.L_CORE 0.003826
K_12591 X_NUC_122.L_CORE X_NUC_129.L_CORE 0.005852
K_12592 X_NUC_122.L_CORE X_NUC_130.L_CORE 0.005945
K_12593 X_NUC_122.L_CORE X_NUC_131.L_CORE 0.005940
K_12594 X_NUC_122.L_CORE X_NUC_132.L_CORE 0.005807
K_12595 X_NUC_122.L_CORE X_NUC_133.L_CORE 0.001651
K_12596 X_NUC_122.L_CORE X_NUC_134.L_CORE 0.001838
K_12597 X_NUC_122.L_CORE X_NUC_135.L_CORE 0.001709
K_12598 X_NUC_122.L_CORE X_NUC_136.L_CORE 0.001721
K_12599 X_NUC_122.L_CORE X_NUC_137.L_CORE 0.002034
K_12600 X_NUC_122.L_CORE X_NUC_138.L_CORE 0.001651
K_12601 X_NUC_122.L_CORE X_NUC_139.L_CORE 0.002021
K_12602 X_NUC_122.L_CORE X_NUC_140.L_CORE 0.001970
K_12603 X_NUC_122.L_CORE X_NUC_141.L_CORE 0.001720
K_12604 X_NUC_122.L_CORE X_NUC_142.L_CORE 0.002457
K_12605 X_NUC_122.L_CORE X_NUC_143.L_CORE 0.001803
K_12606 X_NUC_122.L_CORE X_NUC_144.L_CORE 0.002037
K_12607 X_NUC_122.L_CORE X_NUC_145.L_CORE 0.002511
K_12608 X_NUC_122.L_CORE X_NUC_146.L_CORE 0.001776
K_12609 X_NUC_122.L_CORE X_NUC_147.L_CORE 0.002761
K_12610 X_NUC_122.L_CORE X_NUC_148.L_CORE 0.002169
K_12611 X_NUC_122.L_CORE X_NUC_149.L_CORE 0.002014
K_12612 X_NUC_122.L_CORE X_NUC_150.L_CORE 0.003510
K_12613 X_NUC_122.L_CORE X_NUC_151.L_CORE 0.001972
K_12614 X_NUC_122.L_CORE X_NUC_152.L_CORE 0.002776
K_12615 X_NUC_122.L_CORE X_NUC_153.L_CORE 0.003018
K_12616 X_NUC_122.L_CORE X_NUC_154.L_CORE 0.002086
K_12617 X_NUC_122.L_CORE X_NUC_155.L_CORE 0.004837
K_12618 X_NUC_122.L_CORE X_NUC_156.L_CORE 0.002465
K_12619 X_NUC_122.L_CORE X_NUC_157.L_CORE 0.002727
K_12620 X_NUC_122.L_CORE X_NUC_158.L_CORE 0.005640
K_12621 X_NUC_122.L_CORE X_NUC_159.L_CORE 0.002410
K_12622 X_NUC_122.L_CORE X_NUC_160.L_CORE 0.005198
K_12623 X_NUC_122.L_CORE X_NUC_161.L_CORE 0.003831
K_12624 X_NUC_122.L_CORE X_NUC_162.L_CORE 0.003021
K_12625 X_NUC_122.L_CORE X_NUC_163.L_CORE 0.032174
K_12626 X_NUC_122.L_CORE X_NUC_164.L_CORE 0.003626
K_12627 X_NUC_122.L_CORE X_NUC_165.L_CORE 0.005518
K_12628 X_NUC_123.L_CORE X_NUC_124.L_CORE 0.207973
K_12629 X_NUC_123.L_CORE X_NUC_125.L_CORE 0.003833
K_12630 X_NUC_123.L_CORE X_NUC_126.L_CORE 0.003903
K_12631 X_NUC_123.L_CORE X_NUC_127.L_CORE 0.003872
K_12632 X_NUC_123.L_CORE X_NUC_128.L_CORE 0.003857
K_12633 X_NUC_123.L_CORE X_NUC_129.L_CORE 0.005855
K_12634 X_NUC_123.L_CORE X_NUC_130.L_CORE 0.005946
K_12635 X_NUC_123.L_CORE X_NUC_131.L_CORE 0.005945
K_12636 X_NUC_123.L_CORE X_NUC_132.L_CORE 0.005810
K_12637 X_NUC_123.L_CORE X_NUC_133.L_CORE 0.001643
K_12638 X_NUC_123.L_CORE X_NUC_134.L_CORE 0.001826
K_12639 X_NUC_123.L_CORE X_NUC_135.L_CORE 0.001704
K_12640 X_NUC_123.L_CORE X_NUC_136.L_CORE 0.001710
K_12641 X_NUC_123.L_CORE X_NUC_137.L_CORE 0.002022
K_12642 X_NUC_123.L_CORE X_NUC_138.L_CORE 0.001647
K_12643 X_NUC_123.L_CORE X_NUC_139.L_CORE 0.002003
K_12644 X_NUC_123.L_CORE X_NUC_140.L_CORE 0.001966
K_12645 X_NUC_123.L_CORE X_NUC_141.L_CORE 0.001712
K_12646 X_NUC_123.L_CORE X_NUC_142.L_CORE 0.002434
K_12647 X_NUC_123.L_CORE X_NUC_143.L_CORE 0.001802
K_12648 X_NUC_123.L_CORE X_NUC_144.L_CORE 0.002020
K_12649 X_NUC_123.L_CORE X_NUC_145.L_CORE 0.002504
K_12650 X_NUC_123.L_CORE X_NUC_146.L_CORE 0.001772
K_12651 X_NUC_123.L_CORE X_NUC_147.L_CORE 0.002725
K_12652 X_NUC_123.L_CORE X_NUC_148.L_CORE 0.002173
K_12653 X_NUC_123.L_CORE X_NUC_149.L_CORE 0.002002
K_12654 X_NUC_123.L_CORE X_NUC_150.L_CORE 0.003481
K_12655 X_NUC_123.L_CORE X_NUC_151.L_CORE 0.001974
K_12656 X_NUC_123.L_CORE X_NUC_152.L_CORE 0.002742
K_12657 X_NUC_123.L_CORE X_NUC_153.L_CORE 0.003029
K_12658 X_NUC_123.L_CORE X_NUC_154.L_CORE 0.002082
K_12659 X_NUC_123.L_CORE X_NUC_155.L_CORE 0.004739
K_12660 X_NUC_123.L_CORE X_NUC_156.L_CORE 0.002476
K_12661 X_NUC_123.L_CORE X_NUC_157.L_CORE 0.002707
K_12662 X_NUC_123.L_CORE X_NUC_158.L_CORE 0.005671
K_12663 X_NUC_123.L_CORE X_NUC_159.L_CORE 0.002415
K_12664 X_NUC_123.L_CORE X_NUC_160.L_CORE 0.005098
K_12665 X_NUC_123.L_CORE X_NUC_161.L_CORE 0.003876
K_12666 X_NUC_123.L_CORE X_NUC_162.L_CORE 0.003016
K_12667 X_NUC_123.L_CORE X_NUC_163.L_CORE 0.034974
K_12668 X_NUC_123.L_CORE X_NUC_164.L_CORE 0.003658
K_12669 X_NUC_123.L_CORE X_NUC_165.L_CORE 0.005533
K_12670 X_NUC_124.L_CORE X_NUC_125.L_CORE 0.003847
K_12671 X_NUC_124.L_CORE X_NUC_126.L_CORE 0.003918
K_12672 X_NUC_124.L_CORE X_NUC_127.L_CORE 0.003886
K_12673 X_NUC_124.L_CORE X_NUC_128.L_CORE 0.003872
K_12674 X_NUC_124.L_CORE X_NUC_129.L_CORE 0.005991
K_12675 X_NUC_124.L_CORE X_NUC_130.L_CORE 0.006089
K_12676 X_NUC_124.L_CORE X_NUC_131.L_CORE 0.006085
K_12677 X_NUC_124.L_CORE X_NUC_132.L_CORE 0.005945
K_12678 X_NUC_124.L_CORE X_NUC_133.L_CORE 0.001646
K_12679 X_NUC_124.L_CORE X_NUC_134.L_CORE 0.001828
K_12680 X_NUC_124.L_CORE X_NUC_135.L_CORE 0.001703
K_12681 X_NUC_124.L_CORE X_NUC_136.L_CORE 0.001717
K_12682 X_NUC_124.L_CORE X_NUC_137.L_CORE 0.002018
K_12683 X_NUC_124.L_CORE X_NUC_138.L_CORE 0.001649
K_12684 X_NUC_124.L_CORE X_NUC_139.L_CORE 0.002011
K_12685 X_NUC_124.L_CORE X_NUC_140.L_CORE 0.001959
K_12686 X_NUC_124.L_CORE X_NUC_141.L_CORE 0.001720
K_12687 X_NUC_124.L_CORE X_NUC_142.L_CORE 0.002432
K_12688 X_NUC_124.L_CORE X_NUC_143.L_CORE 0.001801
K_12689 X_NUC_124.L_CORE X_NUC_144.L_CORE 0.002034
K_12690 X_NUC_124.L_CORE X_NUC_145.L_CORE 0.002487
K_12691 X_NUC_124.L_CORE X_NUC_146.L_CORE 0.001778
K_12692 X_NUC_124.L_CORE X_NUC_147.L_CORE 0.002738
K_12693 X_NUC_124.L_CORE X_NUC_148.L_CORE 0.002164
K_12694 X_NUC_124.L_CORE X_NUC_149.L_CORE 0.002018
K_12695 X_NUC_124.L_CORE X_NUC_150.L_CORE 0.003453
K_12696 X_NUC_124.L_CORE X_NUC_151.L_CORE 0.001977
K_12697 X_NUC_124.L_CORE X_NUC_152.L_CORE 0.002772
K_12698 X_NUC_124.L_CORE X_NUC_153.L_CORE 0.002998
K_12699 X_NUC_124.L_CORE X_NUC_154.L_CORE 0.002096
K_12700 X_NUC_124.L_CORE X_NUC_155.L_CORE 0.004752
K_12701 X_NUC_124.L_CORE X_NUC_156.L_CORE 0.002470
K_12702 X_NUC_124.L_CORE X_NUC_157.L_CORE 0.002741
K_12703 X_NUC_124.L_CORE X_NUC_158.L_CORE 0.005533
K_12704 X_NUC_124.L_CORE X_NUC_159.L_CORE 0.002426
K_12705 X_NUC_124.L_CORE X_NUC_160.L_CORE 0.005209
K_12706 X_NUC_124.L_CORE X_NUC_161.L_CORE 0.003843
K_12707 X_NUC_124.L_CORE X_NUC_162.L_CORE 0.003052
K_12708 X_NUC_124.L_CORE X_NUC_163.L_CORE 0.033408
K_12709 X_NUC_124.L_CORE X_NUC_164.L_CORE 0.003670
K_12710 X_NUC_124.L_CORE X_NUC_165.L_CORE 0.005653
K_12711 X_NUC_125.L_CORE X_NUC_126.L_CORE 0.207973
K_12712 X_NUC_125.L_CORE X_NUC_127.L_CORE 0.207973
K_12713 X_NUC_125.L_CORE X_NUC_128.L_CORE 0.207973
K_12714 X_NUC_125.L_CORE X_NUC_129.L_CORE 0.005505
K_12715 X_NUC_125.L_CORE X_NUC_130.L_CORE 0.005380
K_12716 X_NUC_125.L_CORE X_NUC_131.L_CORE 0.005463
K_12717 X_NUC_125.L_CORE X_NUC_132.L_CORE 0.005399
K_12718 X_NUC_125.L_CORE X_NUC_133.L_CORE 0.001707
K_12719 X_NUC_125.L_CORE X_NUC_134.L_CORE 0.001631
K_12720 X_NUC_125.L_CORE X_NUC_135.L_CORE 0.001838
K_12721 X_NUC_125.L_CORE X_NUC_136.L_CORE 0.001716
K_12722 X_NUC_125.L_CORE X_NUC_137.L_CORE 0.001730
K_12723 X_NUC_125.L_CORE X_NUC_138.L_CORE 0.002007
K_12724 X_NUC_125.L_CORE X_NUC_139.L_CORE 0.001684
K_12725 X_NUC_125.L_CORE X_NUC_140.L_CORE 0.002005
K_12726 X_NUC_125.L_CORE X_NUC_141.L_CORE 0.001977
K_12727 X_NUC_125.L_CORE X_NUC_142.L_CORE 0.001766
K_12728 X_NUC_125.L_CORE X_NUC_143.L_CORE 0.002377
K_12729 X_NUC_125.L_CORE X_NUC_144.L_CORE 0.001860
K_12730 X_NUC_125.L_CORE X_NUC_145.L_CORE 0.002067
K_12731 X_NUC_125.L_CORE X_NUC_146.L_CORE 0.002470
K_12732 X_NUC_125.L_CORE X_NUC_147.L_CORE 0.001860
K_12733 X_NUC_125.L_CORE X_NUC_148.L_CORE 0.002687
K_12734 X_NUC_125.L_CORE X_NUC_149.L_CORE 0.002242
K_12735 X_NUC_125.L_CORE X_NUC_150.L_CORE 0.002109
K_12736 X_NUC_125.L_CORE X_NUC_151.L_CORE 0.003320
K_12737 X_NUC_125.L_CORE X_NUC_152.L_CORE 0.002104
K_12738 X_NUC_125.L_CORE X_NUC_153.L_CORE 0.002831
K_12739 X_NUC_125.L_CORE X_NUC_154.L_CORE 0.003089
K_12740 X_NUC_125.L_CORE X_NUC_155.L_CORE 0.002258
K_12741 X_NUC_125.L_CORE X_NUC_156.L_CORE 0.004524
K_12742 X_NUC_125.L_CORE X_NUC_157.L_CORE 0.002687
K_12743 X_NUC_125.L_CORE X_NUC_158.L_CORE 0.002964
K_12744 X_NUC_125.L_CORE X_NUC_159.L_CORE 0.005587
K_12745 X_NUC_125.L_CORE X_NUC_160.L_CORE 0.002730
K_12746 X_NUC_125.L_CORE X_NUC_161.L_CORE 0.005589
K_12747 X_NUC_125.L_CORE X_NUC_162.L_CORE 0.004454
K_12748 X_NUC_125.L_CORE X_NUC_163.L_CORE 0.003629
K_12749 X_NUC_125.L_CORE X_NUC_164.L_CORE 0.031948
K_12750 X_NUC_125.L_CORE X_NUC_165.L_CORE 0.005107
K_12751 X_NUC_126.L_CORE X_NUC_127.L_CORE 0.207973
K_12752 X_NUC_126.L_CORE X_NUC_128.L_CORE 0.207973
K_12753 X_NUC_126.L_CORE X_NUC_129.L_CORE 0.005636
K_12754 X_NUC_126.L_CORE X_NUC_130.L_CORE 0.005505
K_12755 X_NUC_126.L_CORE X_NUC_131.L_CORE 0.005593
K_12756 X_NUC_126.L_CORE X_NUC_132.L_CORE 0.005524
K_12757 X_NUC_126.L_CORE X_NUC_133.L_CORE 0.001708
K_12758 X_NUC_126.L_CORE X_NUC_134.L_CORE 0.001636
K_12759 X_NUC_126.L_CORE X_NUC_135.L_CORE 0.001838
K_12760 X_NUC_126.L_CORE X_NUC_136.L_CORE 0.001720
K_12761 X_NUC_126.L_CORE X_NUC_137.L_CORE 0.001736
K_12762 X_NUC_126.L_CORE X_NUC_138.L_CORE 0.002003
K_12763 X_NUC_126.L_CORE X_NUC_139.L_CORE 0.001692
K_12764 X_NUC_126.L_CORE X_NUC_140.L_CORE 0.002007
K_12765 X_NUC_126.L_CORE X_NUC_141.L_CORE 0.001977
K_12766 X_NUC_126.L_CORE X_NUC_142.L_CORE 0.001776
K_12767 X_NUC_126.L_CORE X_NUC_143.L_CORE 0.002366
K_12768 X_NUC_126.L_CORE X_NUC_144.L_CORE 0.001868
K_12769 X_NUC_126.L_CORE X_NUC_145.L_CORE 0.002075
K_12770 X_NUC_126.L_CORE X_NUC_146.L_CORE 0.002459
K_12771 X_NUC_126.L_CORE X_NUC_147.L_CORE 0.001874
K_12772 X_NUC_126.L_CORE X_NUC_148.L_CORE 0.002680
K_12773 X_NUC_126.L_CORE X_NUC_149.L_CORE 0.002247
K_12774 X_NUC_126.L_CORE X_NUC_150.L_CORE 0.002125
K_12775 X_NUC_126.L_CORE X_NUC_151.L_CORE 0.003285
K_12776 X_NUC_126.L_CORE X_NUC_152.L_CORE 0.002120
K_12777 X_NUC_126.L_CORE X_NUC_153.L_CORE 0.002840
K_12778 X_NUC_126.L_CORE X_NUC_154.L_CORE 0.003079
K_12779 X_NUC_126.L_CORE X_NUC_155.L_CORE 0.002281
K_12780 X_NUC_126.L_CORE X_NUC_156.L_CORE 0.004468
K_12781 X_NUC_126.L_CORE X_NUC_157.L_CORE 0.002705
K_12782 X_NUC_126.L_CORE X_NUC_158.L_CORE 0.002995
K_12783 X_NUC_126.L_CORE X_NUC_159.L_CORE 0.005487
K_12784 X_NUC_126.L_CORE X_NUC_160.L_CORE 0.002764
K_12785 X_NUC_126.L_CORE X_NUC_161.L_CORE 0.005610
K_12786 X_NUC_126.L_CORE X_NUC_162.L_CORE 0.004479
K_12787 X_NUC_126.L_CORE X_NUC_163.L_CORE 0.003691
K_12788 X_NUC_126.L_CORE X_NUC_164.L_CORE 0.030158
K_12789 X_NUC_126.L_CORE X_NUC_165.L_CORE 0.005215
K_12790 X_NUC_127.L_CORE X_NUC_128.L_CORE 0.207973
K_12791 X_NUC_127.L_CORE X_NUC_129.L_CORE 0.005544
K_12792 X_NUC_127.L_CORE X_NUC_130.L_CORE 0.005418
K_12793 X_NUC_127.L_CORE X_NUC_131.L_CORE 0.005505
K_12794 X_NUC_127.L_CORE X_NUC_132.L_CORE 0.005437
K_12795 X_NUC_127.L_CORE X_NUC_133.L_CORE 0.001697
K_12796 X_NUC_127.L_CORE X_NUC_134.L_CORE 0.001625
K_12797 X_NUC_127.L_CORE X_NUC_135.L_CORE 0.001828
K_12798 X_NUC_127.L_CORE X_NUC_136.L_CORE 0.001706
K_12799 X_NUC_127.L_CORE X_NUC_137.L_CORE 0.001726
K_12800 X_NUC_127.L_CORE X_NUC_138.L_CORE 0.001991
K_12801 X_NUC_127.L_CORE X_NUC_139.L_CORE 0.001679
K_12802 X_NUC_127.L_CORE X_NUC_140.L_CORE 0.001998
K_12803 X_NUC_127.L_CORE X_NUC_141.L_CORE 0.001961
K_12804 X_NUC_127.L_CORE X_NUC_142.L_CORE 0.001764
K_12805 X_NUC_127.L_CORE X_NUC_143.L_CORE 0.002357
K_12806 X_NUC_127.L_CORE X_NUC_144.L_CORE 0.001851
K_12807 X_NUC_127.L_CORE X_NUC_145.L_CORE 0.002066
K_12808 X_NUC_127.L_CORE X_NUC_146.L_CORE 0.002441
K_12809 X_NUC_127.L_CORE X_NUC_147.L_CORE 0.001859
K_12810 X_NUC_127.L_CORE X_NUC_148.L_CORE 0.002676
K_12811 X_NUC_127.L_CORE X_NUC_149.L_CORE 0.002225
K_12812 X_NUC_127.L_CORE X_NUC_150.L_CORE 0.002113
K_12813 X_NUC_127.L_CORE X_NUC_151.L_CORE 0.003273
K_12814 X_NUC_127.L_CORE X_NUC_152.L_CORE 0.002100
K_12815 X_NUC_127.L_CORE X_NUC_153.L_CORE 0.002837
K_12816 X_NUC_127.L_CORE X_NUC_154.L_CORE 0.003049
K_12817 X_NUC_127.L_CORE X_NUC_155.L_CORE 0.002265
K_12818 X_NUC_127.L_CORE X_NUC_156.L_CORE 0.004484
K_12819 X_NUC_127.L_CORE X_NUC_157.L_CORE 0.002675
K_12820 X_NUC_127.L_CORE X_NUC_158.L_CORE 0.002985
K_12821 X_NUC_127.L_CORE X_NUC_159.L_CORE 0.005451
K_12822 X_NUC_127.L_CORE X_NUC_160.L_CORE 0.002737
K_12823 X_NUC_127.L_CORE X_NUC_161.L_CORE 0.005655
K_12824 X_NUC_127.L_CORE X_NUC_162.L_CORE 0.004418
K_12825 X_NUC_127.L_CORE X_NUC_163.L_CORE 0.003668
K_12826 X_NUC_127.L_CORE X_NUC_164.L_CORE 0.034556
K_12827 X_NUC_127.L_CORE X_NUC_165.L_CORE 0.005152
K_12828 X_NUC_128.L_CORE X_NUC_129.L_CORE 0.005615
K_12829 X_NUC_128.L_CORE X_NUC_130.L_CORE 0.005483
K_12830 X_NUC_128.L_CORE X_NUC_131.L_CORE 0.005572
K_12831 X_NUC_128.L_CORE X_NUC_132.L_CORE 0.005505
K_12832 X_NUC_128.L_CORE X_NUC_133.L_CORE 0.001699
K_12833 X_NUC_128.L_CORE X_NUC_134.L_CORE 0.001626
K_12834 X_NUC_128.L_CORE X_NUC_135.L_CORE 0.001825
K_12835 X_NUC_128.L_CORE X_NUC_136.L_CORE 0.001712
K_12836 X_NUC_128.L_CORE X_NUC_137.L_CORE 0.001722
K_12837 X_NUC_128.L_CORE X_NUC_138.L_CORE 0.001993
K_12838 X_NUC_128.L_CORE X_NUC_139.L_CORE 0.001682
K_12839 X_NUC_128.L_CORE X_NUC_140.L_CORE 0.001990
K_12840 X_NUC_128.L_CORE X_NUC_141.L_CORE 0.001971
K_12841 X_NUC_128.L_CORE X_NUC_142.L_CORE 0.001762
K_12842 X_NUC_128.L_CORE X_NUC_143.L_CORE 0.002352
K_12843 X_NUC_128.L_CORE X_NUC_144.L_CORE 0.001860
K_12844 X_NUC_128.L_CORE X_NUC_145.L_CORE 0.002055
K_12845 X_NUC_128.L_CORE X_NUC_146.L_CORE 0.002455
K_12846 X_NUC_128.L_CORE X_NUC_147.L_CORE 0.001862
K_12847 X_NUC_128.L_CORE X_NUC_148.L_CORE 0.002655
K_12848 X_NUC_128.L_CORE X_NUC_149.L_CORE 0.002244
K_12849 X_NUC_128.L_CORE X_NUC_150.L_CORE 0.002105
K_12850 X_NUC_128.L_CORE X_NUC_151.L_CORE 0.003277
K_12851 X_NUC_128.L_CORE X_NUC_152.L_CORE 0.002111
K_12852 X_NUC_128.L_CORE X_NUC_153.L_CORE 0.002806
K_12853 X_NUC_128.L_CORE X_NUC_154.L_CORE 0.003086
K_12854 X_NUC_128.L_CORE X_NUC_155.L_CORE 0.002263
K_12855 X_NUC_128.L_CORE X_NUC_156.L_CORE 0.004429
K_12856 X_NUC_128.L_CORE X_NUC_157.L_CORE 0.002703
K_12857 X_NUC_128.L_CORE X_NUC_158.L_CORE 0.002958
K_12858 X_NUC_128.L_CORE X_NUC_159.L_CORE 0.005543
K_12859 X_NUC_128.L_CORE X_NUC_160.L_CORE 0.002749
K_12860 X_NUC_128.L_CORE X_NUC_161.L_CORE 0.005509
K_12861 X_NUC_128.L_CORE X_NUC_162.L_CORE 0.004510
K_12862 X_NUC_128.L_CORE X_NUC_163.L_CORE 0.003654
K_12863 X_NUC_128.L_CORE X_NUC_164.L_CORE 0.034031
K_12864 X_NUC_128.L_CORE X_NUC_165.L_CORE 0.005213
K_12865 X_NUC_129.L_CORE X_NUC_130.L_CORE 0.207973
K_12866 X_NUC_129.L_CORE X_NUC_131.L_CORE 0.207973
K_12867 X_NUC_129.L_CORE X_NUC_132.L_CORE 0.207973
K_12868 X_NUC_129.L_CORE X_NUC_133.L_CORE 0.001662
K_12869 X_NUC_129.L_CORE X_NUC_134.L_CORE 0.001706
K_12870 X_NUC_129.L_CORE X_NUC_135.L_CORE 0.001655
K_12871 X_NUC_129.L_CORE X_NUC_136.L_CORE 0.001807
K_12872 X_NUC_129.L_CORE X_NUC_137.L_CORE 0.001737
K_12873 X_NUC_129.L_CORE X_NUC_138.L_CORE 0.001764
K_12874 X_NUC_129.L_CORE X_NUC_139.L_CORE 0.001939
K_12875 X_NUC_129.L_CORE X_NUC_140.L_CORE 0.001758
K_12876 X_NUC_129.L_CORE X_NUC_141.L_CORE 0.001978
K_12877 X_NUC_129.L_CORE X_NUC_142.L_CORE 0.001971
K_12878 X_NUC_129.L_CORE X_NUC_143.L_CORE 0.001863
K_12879 X_NUC_129.L_CORE X_NUC_144.L_CORE 0.002234
K_12880 X_NUC_129.L_CORE X_NUC_145.L_CORE 0.001957
K_12881 X_NUC_129.L_CORE X_NUC_146.L_CORE 0.002123
K_12882 X_NUC_129.L_CORE X_NUC_147.L_CORE 0.002362
K_12883 X_NUC_129.L_CORE X_NUC_148.L_CORE 0.002024
K_12884 X_NUC_129.L_CORE X_NUC_149.L_CORE 0.002558
K_12885 X_NUC_129.L_CORE X_NUC_150.L_CORE 0.002330
K_12886 X_NUC_129.L_CORE X_NUC_151.L_CORE 0.002289
K_12887 X_NUC_129.L_CORE X_NUC_152.L_CORE 0.002987
K_12888 X_NUC_129.L_CORE X_NUC_153.L_CORE 0.002340
K_12889 X_NUC_129.L_CORE X_NUC_154.L_CORE 0.002898
K_12890 X_NUC_129.L_CORE X_NUC_155.L_CORE 0.003080
K_12891 X_NUC_129.L_CORE X_NUC_156.L_CORE 0.002595
K_12892 X_NUC_129.L_CORE X_NUC_157.L_CORE 0.003995
K_12893 X_NUC_129.L_CORE X_NUC_158.L_CORE 0.003050
K_12894 X_NUC_129.L_CORE X_NUC_159.L_CORE 0.003401
K_12895 X_NUC_129.L_CORE X_NUC_160.L_CORE 0.005048
K_12896 X_NUC_129.L_CORE X_NUC_161.L_CORE 0.003395
K_12897 X_NUC_129.L_CORE X_NUC_162.L_CORE 0.006022
K_12898 X_NUC_129.L_CORE X_NUC_163.L_CORE 0.005532
K_12899 X_NUC_129.L_CORE X_NUC_164.L_CORE 0.005227
K_12900 X_NUC_129.L_CORE X_NUC_165.L_CORE 0.030619
K_12901 X_NUC_130.L_CORE X_NUC_131.L_CORE 0.207973
K_12902 X_NUC_130.L_CORE X_NUC_132.L_CORE 0.207973
K_12903 X_NUC_130.L_CORE X_NUC_133.L_CORE 0.001660
K_12904 X_NUC_130.L_CORE X_NUC_134.L_CORE 0.001708
K_12905 X_NUC_130.L_CORE X_NUC_135.L_CORE 0.001651
K_12906 X_NUC_130.L_CORE X_NUC_136.L_CORE 0.001807
K_12907 X_NUC_130.L_CORE X_NUC_137.L_CORE 0.001739
K_12908 X_NUC_130.L_CORE X_NUC_138.L_CORE 0.001757
K_12909 X_NUC_130.L_CORE X_NUC_139.L_CORE 0.001945
K_12910 X_NUC_130.L_CORE X_NUC_140.L_CORE 0.001755
K_12911 X_NUC_130.L_CORE X_NUC_141.L_CORE 0.001972
K_12912 X_NUC_130.L_CORE X_NUC_142.L_CORE 0.001980
K_12913 X_NUC_130.L_CORE X_NUC_143.L_CORE 0.001853
K_12914 X_NUC_130.L_CORE X_NUC_144.L_CORE 0.002239
K_12915 X_NUC_130.L_CORE X_NUC_145.L_CORE 0.001958
K_12916 X_NUC_130.L_CORE X_NUC_146.L_CORE 0.002108
K_12917 X_NUC_130.L_CORE X_NUC_147.L_CORE 0.002379
K_12918 X_NUC_130.L_CORE X_NUC_148.L_CORE 0.002015
K_12919 X_NUC_130.L_CORE X_NUC_149.L_CORE 0.002552
K_12920 X_NUC_130.L_CORE X_NUC_150.L_CORE 0.002342
K_12921 X_NUC_130.L_CORE X_NUC_151.L_CORE 0.002268
K_12922 X_NUC_130.L_CORE X_NUC_152.L_CORE 0.003012
K_12923 X_NUC_130.L_CORE X_NUC_153.L_CORE 0.002336
K_12924 X_NUC_130.L_CORE X_NUC_154.L_CORE 0.002871
K_12925 X_NUC_130.L_CORE X_NUC_155.L_CORE 0.003117
K_12926 X_NUC_130.L_CORE X_NUC_156.L_CORE 0.002571
K_12927 X_NUC_130.L_CORE X_NUC_157.L_CORE 0.004005
K_12928 X_NUC_130.L_CORE X_NUC_158.L_CORE 0.003061
K_12929 X_NUC_130.L_CORE X_NUC_159.L_CORE 0.003349
K_12930 X_NUC_130.L_CORE X_NUC_160.L_CORE 0.005164
K_12931 X_NUC_130.L_CORE X_NUC_161.L_CORE 0.003370
K_12932 X_NUC_130.L_CORE X_NUC_162.L_CORE 0.005919
K_12933 X_NUC_130.L_CORE X_NUC_163.L_CORE 0.005620
K_12934 X_NUC_130.L_CORE X_NUC_164.L_CORE 0.005112
K_12935 X_NUC_130.L_CORE X_NUC_165.L_CORE 0.031232
K_12936 X_NUC_131.L_CORE X_NUC_132.L_CORE 0.207973
K_12937 X_NUC_131.L_CORE X_NUC_133.L_CORE 0.001652
K_12938 X_NUC_131.L_CORE X_NUC_134.L_CORE 0.001698
K_12939 X_NUC_131.L_CORE X_NUC_135.L_CORE 0.001646
K_12940 X_NUC_131.L_CORE X_NUC_136.L_CORE 0.001794
K_12941 X_NUC_131.L_CORE X_NUC_137.L_CORE 0.001732
K_12942 X_NUC_131.L_CORE X_NUC_138.L_CORE 0.001751
K_12943 X_NUC_131.L_CORE X_NUC_139.L_CORE 0.001929
K_12944 X_NUC_131.L_CORE X_NUC_140.L_CORE 0.001752
K_12945 X_NUC_131.L_CORE X_NUC_141.L_CORE 0.001960
K_12946 X_NUC_131.L_CORE X_NUC_142.L_CORE 0.001968
K_12947 X_NUC_131.L_CORE X_NUC_143.L_CORE 0.001852
K_12948 X_NUC_131.L_CORE X_NUC_144.L_CORE 0.002217
K_12949 X_NUC_131.L_CORE X_NUC_145.L_CORE 0.001955
K_12950 X_NUC_131.L_CORE X_NUC_146.L_CORE 0.002102
K_12951 X_NUC_131.L_CORE X_NUC_147.L_CORE 0.002356
K_12952 X_NUC_131.L_CORE X_NUC_148.L_CORE 0.002017
K_12953 X_NUC_131.L_CORE X_NUC_149.L_CORE 0.002529
K_12954 X_NUC_131.L_CORE X_NUC_150.L_CORE 0.002333
K_12955 X_NUC_131.L_CORE X_NUC_151.L_CORE 0.002270
K_12956 X_NUC_131.L_CORE X_NUC_152.L_CORE 0.002969
K_12957 X_NUC_131.L_CORE X_NUC_153.L_CORE 0.002340
K_12958 X_NUC_131.L_CORE X_NUC_154.L_CORE 0.002859
K_12959 X_NUC_131.L_CORE X_NUC_155.L_CORE 0.003090
K_12960 X_NUC_131.L_CORE X_NUC_156.L_CORE 0.002584
K_12961 X_NUC_131.L_CORE X_NUC_157.L_CORE 0.003940
K_12962 X_NUC_131.L_CORE X_NUC_158.L_CORE 0.003066
K_12963 X_NUC_131.L_CORE X_NUC_159.L_CORE 0.003360
K_12964 X_NUC_131.L_CORE X_NUC_160.L_CORE 0.005065
K_12965 X_NUC_131.L_CORE X_NUC_161.L_CORE 0.003400
K_12966 X_NUC_131.L_CORE X_NUC_162.L_CORE 0.005884
K_12967 X_NUC_131.L_CORE X_NUC_163.L_CORE 0.005631
K_12968 X_NUC_131.L_CORE X_NUC_164.L_CORE 0.005203
K_12969 X_NUC_131.L_CORE X_NUC_165.L_CORE 0.033835
K_12970 X_NUC_132.L_CORE X_NUC_133.L_CORE 0.001652
K_12971 X_NUC_132.L_CORE X_NUC_134.L_CORE 0.001697
K_12972 X_NUC_132.L_CORE X_NUC_135.L_CORE 0.001643
K_12973 X_NUC_132.L_CORE X_NUC_136.L_CORE 0.001798
K_12974 X_NUC_132.L_CORE X_NUC_137.L_CORE 0.001726
K_12975 X_NUC_132.L_CORE X_NUC_138.L_CORE 0.001751
K_12976 X_NUC_132.L_CORE X_NUC_139.L_CORE 0.001931
K_12977 X_NUC_132.L_CORE X_NUC_140.L_CORE 0.001744
K_12978 X_NUC_132.L_CORE X_NUC_141.L_CORE 0.001967
K_12979 X_NUC_132.L_CORE X_NUC_142.L_CORE 0.001962
K_12980 X_NUC_132.L_CORE X_NUC_143.L_CORE 0.001847
K_12981 X_NUC_132.L_CORE X_NUC_144.L_CORE 0.002228
K_12982 X_NUC_132.L_CORE X_NUC_145.L_CORE 0.001942
K_12983 X_NUC_132.L_CORE X_NUC_146.L_CORE 0.002107
K_12984 X_NUC_132.L_CORE X_NUC_147.L_CORE 0.002356
K_12985 X_NUC_132.L_CORE X_NUC_148.L_CORE 0.002005
K_12986 X_NUC_132.L_CORE X_NUC_149.L_CORE 0.002550
K_12987 X_NUC_132.L_CORE X_NUC_150.L_CORE 0.002316
K_12988 X_NUC_132.L_CORE X_NUC_151.L_CORE 0.002267
K_12989 X_NUC_132.L_CORE X_NUC_152.L_CORE 0.002989
K_12990 X_NUC_132.L_CORE X_NUC_153.L_CORE 0.002318
K_12991 X_NUC_132.L_CORE X_NUC_154.L_CORE 0.002880
K_12992 X_NUC_132.L_CORE X_NUC_155.L_CORE 0.003074
K_12993 X_NUC_132.L_CORE X_NUC_156.L_CORE 0.002566
K_12994 X_NUC_132.L_CORE X_NUC_157.L_CORE 0.004005
K_12995 X_NUC_132.L_CORE X_NUC_158.L_CORE 0.003025
K_12996 X_NUC_132.L_CORE X_NUC_159.L_CORE 0.003366
K_12997 X_NUC_132.L_CORE X_NUC_160.L_CORE 0.005085
K_12998 X_NUC_132.L_CORE X_NUC_161.L_CORE 0.003352
K_12999 X_NUC_132.L_CORE X_NUC_162.L_CORE 0.006017
K_13000 X_NUC_132.L_CORE X_NUC_163.L_CORE 0.005511
K_13001 X_NUC_132.L_CORE X_NUC_164.L_CORE 0.005145
K_13002 X_NUC_132.L_CORE X_NUC_165.L_CORE 0.035033
K_13003 X_NUC_133.L_CORE X_NUC_134.L_CORE 0.004983
K_13004 X_NUC_133.L_CORE X_NUC_135.L_CORE 0.005381
K_13005 X_NUC_133.L_CORE X_NUC_136.L_CORE 0.005768
K_13006 X_NUC_133.L_CORE X_NUC_137.L_CORE 0.003232
K_13007 X_NUC_133.L_CORE X_NUC_138.L_CORE 0.004903
K_13008 X_NUC_133.L_CORE X_NUC_139.L_CORE 0.003222
K_13009 X_NUC_133.L_CORE X_NUC_140.L_CORE 0.002915
K_13010 X_NUC_133.L_CORE X_NUC_141.L_CORE 0.003821
K_13011 X_NUC_133.L_CORE X_NUC_142.L_CORE 0.002461
K_13012 X_NUC_133.L_CORE X_NUC_143.L_CORE 0.002953
K_13013 X_NUC_133.L_CORE X_NUC_144.L_CORE 0.002748
K_13014 X_NUC_133.L_CORE X_NUC_145.L_CORE 0.002226
K_13015 X_NUC_133.L_CORE X_NUC_146.L_CORE 0.002856
K_13016 X_NUC_133.L_CORE X_NUC_147.L_CORE 0.002168
K_13017 X_NUC_133.L_CORE X_NUC_148.L_CORE 0.002223
K_13018 X_NUC_133.L_CORE X_NUC_149.L_CORE 0.002431
K_13019 X_NUC_133.L_CORE X_NUC_150.L_CORE 0.001921
K_13020 X_NUC_133.L_CORE X_NUC_151.L_CORE 0.002254
K_13021 X_NUC_133.L_CORE X_NUC_152.L_CORE 0.002012
K_13022 X_NUC_133.L_CORE X_NUC_153.L_CORE 0.001861
K_13023 X_NUC_133.L_CORE X_NUC_154.L_CORE 0.002126
K_13024 X_NUC_133.L_CORE X_NUC_155.L_CORE 0.001767
K_13025 X_NUC_133.L_CORE X_NUC_156.L_CORE 0.001878
K_13026 X_NUC_133.L_CORE X_NUC_157.L_CORE 0.001877
K_13027 X_NUC_133.L_CORE X_NUC_158.L_CORE 0.001669
K_13028 X_NUC_133.L_CORE X_NUC_159.L_CORE 0.001845
K_13029 X_NUC_133.L_CORE X_NUC_160.L_CORE 0.001673
K_13030 X_NUC_133.L_CORE X_NUC_161.L_CORE 0.001651
K_13031 X_NUC_133.L_CORE X_NUC_162.L_CORE 0.001717
K_13032 X_NUC_133.L_CORE X_NUC_163.L_CORE 0.001571
K_13033 X_NUC_133.L_CORE X_NUC_164.L_CORE 0.001622
K_13034 X_NUC_133.L_CORE X_NUC_165.L_CORE 0.001578
K_13035 X_NUC_134.L_CORE X_NUC_135.L_CORE 0.003505
K_13036 X_NUC_134.L_CORE X_NUC_136.L_CORE 0.004288
K_13037 X_NUC_134.L_CORE X_NUC_137.L_CORE 0.005399
K_13038 X_NUC_134.L_CORE X_NUC_138.L_CORE 0.002621
K_13039 X_NUC_134.L_CORE X_NUC_139.L_CORE 0.005325
K_13040 X_NUC_134.L_CORE X_NUC_140.L_CORE 0.002842
K_13041 X_NUC_134.L_CORE X_NUC_141.L_CORE 0.002571
K_13042 X_NUC_134.L_CORE X_NUC_142.L_CORE 0.004299
K_13043 X_NUC_134.L_CORE X_NUC_143.L_CORE 0.002162
K_13044 X_NUC_134.L_CORE X_NUC_144.L_CORE 0.002939
K_13045 X_NUC_134.L_CORE X_NUC_145.L_CORE 0.002701
K_13046 X_NUC_134.L_CORE X_NUC_146.L_CORE 0.002010
K_13047 X_NUC_134.L_CORE X_NUC_147.L_CORE 0.003145
K_13048 X_NUC_134.L_CORE X_NUC_148.L_CORE 0.002015
K_13049 X_NUC_134.L_CORE X_NUC_149.L_CORE 0.002136
K_13050 X_NUC_134.L_CORE X_NUC_150.L_CORE 0.002553
K_13051 X_NUC_134.L_CORE X_NUC_151.L_CORE 0.001776
K_13052 X_NUC_134.L_CORE X_NUC_152.L_CORE 0.002344
K_13053 X_NUC_134.L_CORE X_NUC_153.L_CORE 0.001969
K_13054 X_NUC_134.L_CORE X_NUC_154.L_CORE 0.001772
K_13055 X_NUC_134.L_CORE X_NUC_155.L_CORE 0.002254
K_13056 X_NUC_134.L_CORE X_NUC_156.L_CORE 0.001684
K_13057 X_NUC_134.L_CORE X_NUC_157.L_CORE 0.001879
K_13058 X_NUC_134.L_CORE X_NUC_158.L_CORE 0.001906
K_13059 X_NUC_134.L_CORE X_NUC_159.L_CORE 0.001604
K_13060 X_NUC_134.L_CORE X_NUC_160.L_CORE 0.001905
K_13061 X_NUC_134.L_CORE X_NUC_161.L_CORE 0.001647
K_13062 X_NUC_134.L_CORE X_NUC_162.L_CORE 0.001632
K_13063 X_NUC_134.L_CORE X_NUC_163.L_CORE 0.001746
K_13064 X_NUC_134.L_CORE X_NUC_164.L_CORE 0.001552
K_13065 X_NUC_134.L_CORE X_NUC_165.L_CORE 0.001622
K_13066 X_NUC_135.L_CORE X_NUC_136.L_CORE 0.002899
K_13067 X_NUC_135.L_CORE X_NUC_137.L_CORE 0.003699
K_13068 X_NUC_135.L_CORE X_NUC_138.L_CORE 0.004972
K_13069 X_NUC_135.L_CORE X_NUC_139.L_CORE 0.002310
K_13070 X_NUC_135.L_CORE X_NUC_140.L_CORE 0.005431
K_13071 X_NUC_135.L_CORE X_NUC_141.L_CORE 0.002604
K_13072 X_NUC_135.L_CORE X_NUC_142.L_CORE 0.002363
K_13073 X_NUC_135.L_CORE X_NUC_143.L_CORE 0.004587
K_13074 X_NUC_135.L_CORE X_NUC_144.L_CORE 0.001994
K_13075 X_NUC_135.L_CORE X_NUC_145.L_CORE 0.002887
K_13076 X_NUC_135.L_CORE X_NUC_146.L_CORE 0.002639
K_13077 X_NUC_135.L_CORE X_NUC_147.L_CORE 0.001885
K_13078 X_NUC_135.L_CORE X_NUC_148.L_CORE 0.003333
K_13079 X_NUC_135.L_CORE X_NUC_149.L_CORE 0.001919
K_13080 X_NUC_135.L_CORE X_NUC_150.L_CORE 0.002072
K_13081 X_NUC_135.L_CORE X_NUC_151.L_CORE 0.002618
K_13082 X_NUC_135.L_CORE X_NUC_152.L_CORE 0.001694
K_13083 X_NUC_135.L_CORE X_NUC_153.L_CORE 0.002389
K_13084 X_NUC_135.L_CORE X_NUC_154.L_CORE 0.001937
K_13085 X_NUC_135.L_CORE X_NUC_155.L_CORE 0.001720
K_13086 X_NUC_135.L_CORE X_NUC_156.L_CORE 0.002330
K_13087 X_NUC_135.L_CORE X_NUC_157.L_CORE 0.001638
K_13088 X_NUC_135.L_CORE X_NUC_158.L_CORE 0.001876
K_13089 X_NUC_135.L_CORE X_NUC_159.L_CORE 0.001919
K_13090 X_NUC_135.L_CORE X_NUC_160.L_CORE 0.001573
K_13091 X_NUC_135.L_CORE X_NUC_161.L_CORE 0.001932
K_13092 X_NUC_135.L_CORE X_NUC_162.L_CORE 0.001636
K_13093 X_NUC_135.L_CORE X_NUC_163.L_CORE 0.001627
K_13094 X_NUC_135.L_CORE X_NUC_164.L_CORE 0.001746
K_13095 X_NUC_135.L_CORE X_NUC_165.L_CORE 0.001571
K_13096 X_NUC_136.L_CORE X_NUC_137.L_CORE 0.002551
K_13097 X_NUC_136.L_CORE X_NUC_138.L_CORE 0.003325
K_13098 X_NUC_136.L_CORE X_NUC_139.L_CORE 0.004627
K_13099 X_NUC_136.L_CORE X_NUC_140.L_CORE 0.002111
K_13100 X_NUC_136.L_CORE X_NUC_141.L_CORE 0.005420
K_13101 X_NUC_136.L_CORE X_NUC_142.L_CORE 0.002435
K_13102 X_NUC_136.L_CORE X_NUC_143.L_CORE 0.002217
K_13103 X_NUC_136.L_CORE X_NUC_144.L_CORE 0.004784
K_13104 X_NUC_136.L_CORE X_NUC_145.L_CORE 0.001879
K_13105 X_NUC_136.L_CORE X_NUC_146.L_CORE 0.002830
K_13106 X_NUC_136.L_CORE X_NUC_147.L_CORE 0.002581
K_13107 X_NUC_136.L_CORE X_NUC_148.L_CORE 0.001799
K_13108 X_NUC_136.L_CORE X_NUC_149.L_CORE 0.003472
K_13109 X_NUC_136.L_CORE X_NUC_150.L_CORE 0.001852
K_13110 X_NUC_136.L_CORE X_NUC_151.L_CORE 0.002023
K_13111 X_NUC_136.L_CORE X_NUC_152.L_CORE 0.002658
K_13112 X_NUC_136.L_CORE X_NUC_153.L_CORE 0.001639
K_13113 X_NUC_136.L_CORE X_NUC_154.L_CORE 0.002417
K_13114 X_NUC_136.L_CORE X_NUC_155.L_CORE 0.001913
K_13115 X_NUC_136.L_CORE X_NUC_156.L_CORE 0.001685
K_13116 X_NUC_136.L_CORE X_NUC_157.L_CORE 0.002380
K_13117 X_NUC_136.L_CORE X_NUC_158.L_CORE 0.001610
K_13118 X_NUC_136.L_CORE X_NUC_159.L_CORE 0.001873
K_13119 X_NUC_136.L_CORE X_NUC_160.L_CORE 0.001925
K_13120 X_NUC_136.L_CORE X_NUC_161.L_CORE 0.001560
K_13121 X_NUC_136.L_CORE X_NUC_162.L_CORE 0.001940
K_13122 X_NUC_136.L_CORE X_NUC_163.L_CORE 0.001636
K_13123 X_NUC_136.L_CORE X_NUC_164.L_CORE 0.001632
K_13124 X_NUC_136.L_CORE X_NUC_165.L_CORE 0.001717
K_13125 X_NUC_137.L_CORE X_NUC_138.L_CORE 0.002321
K_13126 X_NUC_137.L_CORE X_NUC_139.L_CORE 0.003065
K_13127 X_NUC_137.L_CORE X_NUC_140.L_CORE 0.004356
K_13128 X_NUC_137.L_CORE X_NUC_141.L_CORE 0.001970
K_13129 X_NUC_137.L_CORE X_NUC_142.L_CORE 0.005363
K_13130 X_NUC_137.L_CORE X_NUC_143.L_CORE 0.002309
K_13131 X_NUC_137.L_CORE X_NUC_144.L_CORE 0.002108
K_13132 X_NUC_137.L_CORE X_NUC_145.L_CORE 0.004924
K_13133 X_NUC_137.L_CORE X_NUC_146.L_CORE 0.001795
K_13134 X_NUC_137.L_CORE X_NUC_147.L_CORE 0.002777
K_13135 X_NUC_137.L_CORE X_NUC_148.L_CORE 0.002530
K_13136 X_NUC_137.L_CORE X_NUC_149.L_CORE 0.001736
K_13137 X_NUC_137.L_CORE X_NUC_150.L_CORE 0.003580
K_13138 X_NUC_137.L_CORE X_NUC_151.L_CORE 0.001802
K_13139 X_NUC_137.L_CORE X_NUC_152.L_CORE 0.001985
K_13140 X_NUC_137.L_CORE X_NUC_153.L_CORE 0.002684
K_13141 X_NUC_137.L_CORE X_NUC_154.L_CORE 0.001601
K_13142 X_NUC_137.L_CORE X_NUC_155.L_CORE 0.002434
K_13143 X_NUC_137.L_CORE X_NUC_156.L_CORE 0.001896
K_13144 X_NUC_137.L_CORE X_NUC_157.L_CORE 0.001663
K_13145 X_NUC_137.L_CORE X_NUC_158.L_CORE 0.002411
K_13146 X_NUC_137.L_CORE X_NUC_159.L_CORE 0.001595
K_13147 X_NUC_137.L_CORE X_NUC_160.L_CORE 0.001871
K_13148 X_NUC_137.L_CORE X_NUC_161.L_CORE 0.001926
K_13149 X_NUC_137.L_CORE X_NUC_162.L_CORE 0.001560
K_13150 X_NUC_137.L_CORE X_NUC_163.L_CORE 0.001932
K_13151 X_NUC_137.L_CORE X_NUC_164.L_CORE 0.001647
K_13152 X_NUC_137.L_CORE X_NUC_165.L_CORE 0.001651
K_13153 X_NUC_138.L_CORE X_NUC_139.L_CORE 0.002157
K_13154 X_NUC_138.L_CORE X_NUC_140.L_CORE 0.002874
K_13155 X_NUC_138.L_CORE X_NUC_141.L_CORE 0.004142
K_13156 X_NUC_138.L_CORE X_NUC_142.L_CORE 0.001865
K_13157 X_NUC_138.L_CORE X_NUC_143.L_CORE 0.005290
K_13158 X_NUC_138.L_CORE X_NUC_144.L_CORE 0.002212
K_13159 X_NUC_138.L_CORE X_NUC_145.L_CORE 0.002025
K_13160 X_NUC_138.L_CORE X_NUC_146.L_CORE 0.005025
K_13161 X_NUC_138.L_CORE X_NUC_147.L_CORE 0.001731
K_13162 X_NUC_138.L_CORE X_NUC_148.L_CORE 0.002731
K_13163 X_NUC_138.L_CORE X_NUC_149.L_CORE 0.002487
K_13164 X_NUC_138.L_CORE X_NUC_150.L_CORE 0.001689
K_13165 X_NUC_138.L_CORE X_NUC_151.L_CORE 0.003663
K_13166 X_NUC_138.L_CORE X_NUC_152.L_CORE 0.001765
K_13167 X_NUC_138.L_CORE X_NUC_153.L_CORE 0.001957
K_13168 X_NUC_138.L_CORE X_NUC_154.L_CORE 0.002701
K_13169 X_NUC_138.L_CORE X_NUC_155.L_CORE 0.001575
K_13170 X_NUC_138.L_CORE X_NUC_156.L_CORE 0.002444
K_13171 X_NUC_138.L_CORE X_NUC_157.L_CORE 0.001884
K_13172 X_NUC_138.L_CORE X_NUC_158.L_CORE 0.001651
K_13173 X_NUC_138.L_CORE X_NUC_159.L_CORE 0.002426
K_13174 X_NUC_138.L_CORE X_NUC_160.L_CORE 0.001590
K_13175 X_NUC_138.L_CORE X_NUC_161.L_CORE 0.001871
K_13176 X_NUC_138.L_CORE X_NUC_162.L_CORE 0.001925
K_13177 X_NUC_138.L_CORE X_NUC_163.L_CORE 0.001573
K_13178 X_NUC_138.L_CORE X_NUC_164.L_CORE 0.001905
K_13179 X_NUC_138.L_CORE X_NUC_165.L_CORE 0.001673
K_13180 X_NUC_139.L_CORE X_NUC_140.L_CORE 0.002034
K_13181 X_NUC_139.L_CORE X_NUC_141.L_CORE 0.002729
K_13182 X_NUC_139.L_CORE X_NUC_142.L_CORE 0.003972
K_13183 X_NUC_139.L_CORE X_NUC_143.L_CORE 0.001784
K_13184 X_NUC_139.L_CORE X_NUC_144.L_CORE 0.005214
K_13185 X_NUC_139.L_CORE X_NUC_145.L_CORE 0.002136
K_13186 X_NUC_139.L_CORE X_NUC_146.L_CORE 0.001960
K_13187 X_NUC_139.L_CORE X_NUC_147.L_CORE 0.005098
K_13188 X_NUC_139.L_CORE X_NUC_148.L_CORE 0.001683
K_13189 X_NUC_139.L_CORE X_NUC_149.L_CORE 0.002692
K_13190 X_NUC_139.L_CORE X_NUC_150.L_CORE 0.002452
K_13191 X_NUC_139.L_CORE X_NUC_151.L_CORE 0.001654
K_13192 X_NUC_139.L_CORE X_NUC_152.L_CORE 0.003725
K_13193 X_NUC_139.L_CORE X_NUC_153.L_CORE 0.001738
K_13194 X_NUC_139.L_CORE X_NUC_154.L_CORE 0.001937
K_13195 X_NUC_139.L_CORE X_NUC_155.L_CORE 0.002711
K_13196 X_NUC_139.L_CORE X_NUC_156.L_CORE 0.001559
K_13197 X_NUC_139.L_CORE X_NUC_157.L_CORE 0.002450
K_13198 X_NUC_139.L_CORE X_NUC_158.L_CORE 0.001879
K_13199 X_NUC_139.L_CORE X_NUC_159.L_CORE 0.001646
K_13200 X_NUC_139.L_CORE X_NUC_160.L_CORE 0.002426
K_13201 X_NUC_139.L_CORE X_NUC_161.L_CORE 0.001595
K_13202 X_NUC_139.L_CORE X_NUC_162.L_CORE 0.001873
K_13203 X_NUC_139.L_CORE X_NUC_163.L_CORE 0.001919
K_13204 X_NUC_139.L_CORE X_NUC_164.L_CORE 0.001604
K_13205 X_NUC_139.L_CORE X_NUC_165.L_CORE 0.001845
K_13206 X_NUC_140.L_CORE X_NUC_141.L_CORE 0.001941
K_13207 X_NUC_140.L_CORE X_NUC_142.L_CORE 0.002616
K_13208 X_NUC_140.L_CORE X_NUC_143.L_CORE 0.003836
K_13209 X_NUC_140.L_CORE X_NUC_144.L_CORE 0.001722
K_13210 X_NUC_140.L_CORE X_NUC_145.L_CORE 0.005143
K_13211 X_NUC_140.L_CORE X_NUC_146.L_CORE 0.002076
K_13212 X_NUC_140.L_CORE X_NUC_147.L_CORE 0.001910
K_13213 X_NUC_140.L_CORE X_NUC_148.L_CORE 0.005151
K_13214 X_NUC_140.L_CORE X_NUC_149.L_CORE 0.001645
K_13215 X_NUC_140.L_CORE X_NUC_150.L_CORE 0.002661
K_13216 X_NUC_140.L_CORE X_NUC_151.L_CORE 0.002425
K_13217 X_NUC_140.L_CORE X_NUC_152.L_CORE 0.001628
K_13218 X_NUC_140.L_CORE X_NUC_153.L_CORE 0.003770
K_13219 X_NUC_140.L_CORE X_NUC_154.L_CORE 0.001720
K_13220 X_NUC_140.L_CORE X_NUC_155.L_CORE 0.001924
K_13221 X_NUC_140.L_CORE X_NUC_156.L_CORE 0.002717
K_13222 X_NUC_140.L_CORE X_NUC_157.L_CORE 0.001551
K_13223 X_NUC_140.L_CORE X_NUC_158.L_CORE 0.002451
K_13224 X_NUC_140.L_CORE X_NUC_159.L_CORE 0.001879
K_13225 X_NUC_140.L_CORE X_NUC_160.L_CORE 0.001651
K_13226 X_NUC_140.L_CORE X_NUC_161.L_CORE 0.002411
K_13227 X_NUC_140.L_CORE X_NUC_162.L_CORE 0.001610
K_13228 X_NUC_140.L_CORE X_NUC_163.L_CORE 0.001876
K_13229 X_NUC_140.L_CORE X_NUC_164.L_CORE 0.001906
K_13230 X_NUC_140.L_CORE X_NUC_165.L_CORE 0.001669
K_13231 X_NUC_141.L_CORE X_NUC_142.L_CORE 0.001867
K_13232 X_NUC_141.L_CORE X_NUC_143.L_CORE 0.002527
K_13233 X_NUC_141.L_CORE X_NUC_144.L_CORE 0.003727
K_13234 X_NUC_141.L_CORE X_NUC_145.L_CORE 0.001672
K_13235 X_NUC_141.L_CORE X_NUC_146.L_CORE 0.005080
K_13236 X_NUC_141.L_CORE X_NUC_147.L_CORE 0.002030
K_13237 X_NUC_141.L_CORE X_NUC_148.L_CORE 0.001871
K_13238 X_NUC_141.L_CORE X_NUC_149.L_CORE 0.005189
K_13239 X_NUC_141.L_CORE X_NUC_150.L_CORE 0.001618
K_13240 X_NUC_141.L_CORE X_NUC_151.L_CORE 0.002637
K_13241 X_NUC_141.L_CORE X_NUC_152.L_CORE 0.002405
K_13242 X_NUC_141.L_CORE X_NUC_153.L_CORE 0.001611
K_13243 X_NUC_141.L_CORE X_NUC_154.L_CORE 0.003799
K_13244 X_NUC_141.L_CORE X_NUC_155.L_CORE 0.001709
K_13245 X_NUC_141.L_CORE X_NUC_156.L_CORE 0.001917
K_13246 X_NUC_141.L_CORE X_NUC_157.L_CORE 0.002719
K_13247 X_NUC_141.L_CORE X_NUC_158.L_CORE 0.001551
K_13248 X_NUC_141.L_CORE X_NUC_159.L_CORE 0.002450
K_13249 X_NUC_141.L_CORE X_NUC_160.L_CORE 0.001884
K_13250 X_NUC_141.L_CORE X_NUC_161.L_CORE 0.001663
K_13251 X_NUC_141.L_CORE X_NUC_162.L_CORE 0.002380
K_13252 X_NUC_141.L_CORE X_NUC_163.L_CORE 0.001638
K_13253 X_NUC_141.L_CORE X_NUC_164.L_CORE 0.001879
K_13254 X_NUC_141.L_CORE X_NUC_165.L_CORE 0.001877
K_13255 X_NUC_142.L_CORE X_NUC_143.L_CORE 0.001809
K_13256 X_NUC_142.L_CORE X_NUC_144.L_CORE 0.002457
K_13257 X_NUC_142.L_CORE X_NUC_145.L_CORE 0.003640
K_13258 X_NUC_142.L_CORE X_NUC_146.L_CORE 0.001634
K_13259 X_NUC_142.L_CORE X_NUC_147.L_CORE 0.005027
K_13260 X_NUC_142.L_CORE X_NUC_148.L_CORE 0.001994
K_13261 X_NUC_142.L_CORE X_NUC_149.L_CORE 0.001841
K_13262 X_NUC_142.L_CORE X_NUC_150.L_CORE 0.005215
K_13263 X_NUC_142.L_CORE X_NUC_151.L_CORE 0.001598
K_13264 X_NUC_142.L_CORE X_NUC_152.L_CORE 0.002621
K_13265 X_NUC_142.L_CORE X_NUC_153.L_CORE 0.002392
K_13266 X_NUC_142.L_CORE X_NUC_154.L_CORE 0.001601
K_13267 X_NUC_142.L_CORE X_NUC_155.L_CORE 0.003814
K_13268 X_NUC_142.L_CORE X_NUC_156.L_CORE 0.001706
K_13269 X_NUC_142.L_CORE X_NUC_157.L_CORE 0.001917
K_13270 X_NUC_142.L_CORE X_NUC_158.L_CORE 0.002717
K_13271 X_NUC_142.L_CORE X_NUC_159.L_CORE 0.001559
K_13272 X_NUC_142.L_CORE X_NUC_160.L_CORE 0.002444
K_13273 X_NUC_142.L_CORE X_NUC_161.L_CORE 0.001896
K_13274 X_NUC_142.L_CORE X_NUC_162.L_CORE 0.001685
K_13275 X_NUC_142.L_CORE X_NUC_163.L_CORE 0.002330
K_13276 X_NUC_142.L_CORE X_NUC_164.L_CORE 0.001684
K_13277 X_NUC_142.L_CORE X_NUC_165.L_CORE 0.001878
K_13278 X_NUC_143.L_CORE X_NUC_144.L_CORE 0.001764
K_13279 X_NUC_143.L_CORE X_NUC_145.L_CORE 0.002402
K_13280 X_NUC_143.L_CORE X_NUC_146.L_CORE 0.003572
K_13281 X_NUC_143.L_CORE X_NUC_147.L_CORE 0.001605
K_13282 X_NUC_143.L_CORE X_NUC_148.L_CORE 0.004984
K_13283 X_NUC_143.L_CORE X_NUC_149.L_CORE 0.001967
K_13284 X_NUC_143.L_CORE X_NUC_150.L_CORE 0.001820
K_13285 X_NUC_143.L_CORE X_NUC_151.L_CORE 0.005232
K_13286 X_NUC_143.L_CORE X_NUC_152.L_CORE 0.001585
K_13287 X_NUC_143.L_CORE X_NUC_153.L_CORE 0.002611
K_13288 X_NUC_143.L_CORE X_NUC_154.L_CORE 0.002385
K_13289 X_NUC_143.L_CORE X_NUC_155.L_CORE 0.001597
K_13290 X_NUC_143.L_CORE X_NUC_156.L_CORE 0.003814
K_13291 X_NUC_143.L_CORE X_NUC_157.L_CORE 0.001709
K_13292 X_NUC_143.L_CORE X_NUC_158.L_CORE 0.001924
K_13293 X_NUC_143.L_CORE X_NUC_159.L_CORE 0.002711
K_13294 X_NUC_143.L_CORE X_NUC_160.L_CORE 0.001575
K_13295 X_NUC_143.L_CORE X_NUC_161.L_CORE 0.002434
K_13296 X_NUC_143.L_CORE X_NUC_162.L_CORE 0.001913
K_13297 X_NUC_143.L_CORE X_NUC_163.L_CORE 0.001720
K_13298 X_NUC_143.L_CORE X_NUC_164.L_CORE 0.002254
K_13299 X_NUC_143.L_CORE X_NUC_165.L_CORE 0.001767
K_13300 X_NUC_144.L_CORE X_NUC_145.L_CORE 0.001729
K_13301 X_NUC_144.L_CORE X_NUC_146.L_CORE 0.002360
K_13302 X_NUC_144.L_CORE X_NUC_147.L_CORE 0.003520
K_13303 X_NUC_144.L_CORE X_NUC_148.L_CORE 0.001583
K_13304 X_NUC_144.L_CORE X_NUC_149.L_CORE 0.004952
K_13305 X_NUC_144.L_CORE X_NUC_150.L_CORE 0.001949
K_13306 X_NUC_144.L_CORE X_NUC_151.L_CORE 0.001806
K_13307 X_NUC_144.L_CORE X_NUC_152.L_CORE 0.005242
K_13308 X_NUC_144.L_CORE X_NUC_153.L_CORE 0.001579
K_13309 X_NUC_144.L_CORE X_NUC_154.L_CORE 0.002607
K_13310 X_NUC_144.L_CORE X_NUC_155.L_CORE 0.002385
K_13311 X_NUC_144.L_CORE X_NUC_156.L_CORE 0.001601
K_13312 X_NUC_144.L_CORE X_NUC_157.L_CORE 0.003799
K_13313 X_NUC_144.L_CORE X_NUC_158.L_CORE 0.001720
K_13314 X_NUC_144.L_CORE X_NUC_159.L_CORE 0.001937
K_13315 X_NUC_144.L_CORE X_NUC_160.L_CORE 0.002701
K_13316 X_NUC_144.L_CORE X_NUC_161.L_CORE 0.001601
K_13317 X_NUC_144.L_CORE X_NUC_162.L_CORE 0.002417
K_13318 X_NUC_144.L_CORE X_NUC_163.L_CORE 0.001937
K_13319 X_NUC_144.L_CORE X_NUC_164.L_CORE 0.001772
K_13320 X_NUC_144.L_CORE X_NUC_165.L_CORE 0.002126
K_13321 X_NUC_145.L_CORE X_NUC_146.L_CORE 0.001702
K_13322 X_NUC_145.L_CORE X_NUC_147.L_CORE 0.002328
K_13323 X_NUC_145.L_CORE X_NUC_148.L_CORE 0.003483
K_13324 X_NUC_145.L_CORE X_NUC_149.L_CORE 0.001568
K_13325 X_NUC_145.L_CORE X_NUC_150.L_CORE 0.004931
K_13326 X_NUC_145.L_CORE X_NUC_151.L_CORE 0.001938
K_13327 X_NUC_145.L_CORE X_NUC_152.L_CORE 0.001800
K_13328 X_NUC_145.L_CORE X_NUC_153.L_CORE 0.005245
K_13329 X_NUC_145.L_CORE X_NUC_154.L_CORE 0.001579
K_13330 X_NUC_145.L_CORE X_NUC_155.L_CORE 0.002611
K_13331 X_NUC_145.L_CORE X_NUC_156.L_CORE 0.002392
K_13332 X_NUC_145.L_CORE X_NUC_157.L_CORE 0.001611
K_13333 X_NUC_145.L_CORE X_NUC_158.L_CORE 0.003770
K_13334 X_NUC_145.L_CORE X_NUC_159.L_CORE 0.001738
K_13335 X_NUC_145.L_CORE X_NUC_160.L_CORE 0.001957
K_13336 X_NUC_145.L_CORE X_NUC_161.L_CORE 0.002684
K_13337 X_NUC_145.L_CORE X_NUC_162.L_CORE 0.001639
K_13338 X_NUC_145.L_CORE X_NUC_163.L_CORE 0.002389
K_13339 X_NUC_145.L_CORE X_NUC_164.L_CORE 0.001969
K_13340 X_NUC_145.L_CORE X_NUC_165.L_CORE 0.001861
K_13341 X_NUC_146.L_CORE X_NUC_147.L_CORE 0.001682
K_13342 X_NUC_146.L_CORE X_NUC_148.L_CORE 0.002307
K_13343 X_NUC_146.L_CORE X_NUC_149.L_CORE 0.003459
K_13344 X_NUC_146.L_CORE X_NUC_150.L_CORE 0.001559
K_13345 X_NUC_146.L_CORE X_NUC_151.L_CORE 0.004921
K_13346 X_NUC_146.L_CORE X_NUC_152.L_CORE 0.001934
K_13347 X_NUC_146.L_CORE X_NUC_153.L_CORE 0.001800
K_13348 X_NUC_146.L_CORE X_NUC_154.L_CORE 0.005242
K_13349 X_NUC_146.L_CORE X_NUC_155.L_CORE 0.001585
K_13350 X_NUC_146.L_CORE X_NUC_156.L_CORE 0.002621
K_13351 X_NUC_146.L_CORE X_NUC_157.L_CORE 0.002405
K_13352 X_NUC_146.L_CORE X_NUC_158.L_CORE 0.001628
K_13353 X_NUC_146.L_CORE X_NUC_159.L_CORE 0.003725
K_13354 X_NUC_146.L_CORE X_NUC_160.L_CORE 0.001765
K_13355 X_NUC_146.L_CORE X_NUC_161.L_CORE 0.001985
K_13356 X_NUC_146.L_CORE X_NUC_162.L_CORE 0.002658
K_13357 X_NUC_146.L_CORE X_NUC_163.L_CORE 0.001694
K_13358 X_NUC_146.L_CORE X_NUC_164.L_CORE 0.002344
K_13359 X_NUC_146.L_CORE X_NUC_165.L_CORE 0.002012
K_13360 X_NUC_147.L_CORE X_NUC_148.L_CORE 0.001670
K_13361 X_NUC_147.L_CORE X_NUC_149.L_CORE 0.002294
K_13362 X_NUC_147.L_CORE X_NUC_150.L_CORE 0.003447
K_13363 X_NUC_147.L_CORE X_NUC_151.L_CORE 0.001556
K_13364 X_NUC_147.L_CORE X_NUC_152.L_CORE 0.004921
K_13365 X_NUC_147.L_CORE X_NUC_153.L_CORE 0.001938
K_13366 X_NUC_147.L_CORE X_NUC_154.L_CORE 0.001806
K_13367 X_NUC_147.L_CORE X_NUC_155.L_CORE 0.005232
K_13368 X_NUC_147.L_CORE X_NUC_156.L_CORE 0.001598
K_13369 X_NUC_147.L_CORE X_NUC_157.L_CORE 0.002637
K_13370 X_NUC_147.L_CORE X_NUC_158.L_CORE 0.002425
K_13371 X_NUC_147.L_CORE X_NUC_159.L_CORE 0.001654
K_13372 X_NUC_147.L_CORE X_NUC_160.L_CORE 0.003663
K_13373 X_NUC_147.L_CORE X_NUC_161.L_CORE 0.001802
K_13374 X_NUC_147.L_CORE X_NUC_162.L_CORE 0.002023
K_13375 X_NUC_147.L_CORE X_NUC_163.L_CORE 0.002618
K_13376 X_NUC_147.L_CORE X_NUC_164.L_CORE 0.001776
K_13377 X_NUC_147.L_CORE X_NUC_165.L_CORE 0.002254
K_13378 X_NUC_148.L_CORE X_NUC_149.L_CORE 0.001664
K_13379 X_NUC_148.L_CORE X_NUC_150.L_CORE 0.002290
K_13380 X_NUC_148.L_CORE X_NUC_151.L_CORE 0.003447
K_13381 X_NUC_148.L_CORE X_NUC_152.L_CORE 0.001559
K_13382 X_NUC_148.L_CORE X_NUC_153.L_CORE 0.004931
K_13383 X_NUC_148.L_CORE X_NUC_154.L_CORE 0.001949
K_13384 X_NUC_148.L_CORE X_NUC_155.L_CORE 0.001820
K_13385 X_NUC_148.L_CORE X_NUC_156.L_CORE 0.005215
K_13386 X_NUC_148.L_CORE X_NUC_157.L_CORE 0.001618
K_13387 X_NUC_148.L_CORE X_NUC_158.L_CORE 0.002661
K_13388 X_NUC_148.L_CORE X_NUC_159.L_CORE 0.002452
K_13389 X_NUC_148.L_CORE X_NUC_160.L_CORE 0.001689
K_13390 X_NUC_148.L_CORE X_NUC_161.L_CORE 0.003580
K_13391 X_NUC_148.L_CORE X_NUC_162.L_CORE 0.001852
K_13392 X_NUC_148.L_CORE X_NUC_163.L_CORE 0.002072
K_13393 X_NUC_148.L_CORE X_NUC_164.L_CORE 0.002553
K_13394 X_NUC_148.L_CORE X_NUC_165.L_CORE 0.001921
K_13395 X_NUC_149.L_CORE X_NUC_150.L_CORE 0.001664
K_13396 X_NUC_149.L_CORE X_NUC_151.L_CORE 0.002294
K_13397 X_NUC_149.L_CORE X_NUC_152.L_CORE 0.003459
K_13398 X_NUC_149.L_CORE X_NUC_153.L_CORE 0.001568
K_13399 X_NUC_149.L_CORE X_NUC_154.L_CORE 0.004952
K_13400 X_NUC_149.L_CORE X_NUC_155.L_CORE 0.001967
K_13401 X_NUC_149.L_CORE X_NUC_156.L_CORE 0.001841
K_13402 X_NUC_149.L_CORE X_NUC_157.L_CORE 0.005189
K_13403 X_NUC_149.L_CORE X_NUC_158.L_CORE 0.001645
K_13404 X_NUC_149.L_CORE X_NUC_159.L_CORE 0.002692
K_13405 X_NUC_149.L_CORE X_NUC_160.L_CORE 0.002487
K_13406 X_NUC_149.L_CORE X_NUC_161.L_CORE 0.001736
K_13407 X_NUC_149.L_CORE X_NUC_162.L_CORE 0.003472
K_13408 X_NUC_149.L_CORE X_NUC_163.L_CORE 0.001919
K_13409 X_NUC_149.L_CORE X_NUC_164.L_CORE 0.002136
K_13410 X_NUC_149.L_CORE X_NUC_165.L_CORE 0.002431
K_13411 X_NUC_150.L_CORE X_NUC_151.L_CORE 0.001670
K_13412 X_NUC_150.L_CORE X_NUC_152.L_CORE 0.002307
K_13413 X_NUC_150.L_CORE X_NUC_153.L_CORE 0.003483
K_13414 X_NUC_150.L_CORE X_NUC_154.L_CORE 0.001583
K_13415 X_NUC_150.L_CORE X_NUC_155.L_CORE 0.004984
K_13416 X_NUC_150.L_CORE X_NUC_156.L_CORE 0.001994
K_13417 X_NUC_150.L_CORE X_NUC_157.L_CORE 0.001871
K_13418 X_NUC_150.L_CORE X_NUC_158.L_CORE 0.005151
K_13419 X_NUC_150.L_CORE X_NUC_159.L_CORE 0.001683
K_13420 X_NUC_150.L_CORE X_NUC_160.L_CORE 0.002731
K_13421 X_NUC_150.L_CORE X_NUC_161.L_CORE 0.002530
K_13422 X_NUC_150.L_CORE X_NUC_162.L_CORE 0.001799
K_13423 X_NUC_150.L_CORE X_NUC_163.L_CORE 0.003333
K_13424 X_NUC_150.L_CORE X_NUC_164.L_CORE 0.002015
K_13425 X_NUC_150.L_CORE X_NUC_165.L_CORE 0.002223
K_13426 X_NUC_151.L_CORE X_NUC_152.L_CORE 0.001682
K_13427 X_NUC_151.L_CORE X_NUC_153.L_CORE 0.002328
K_13428 X_NUC_151.L_CORE X_NUC_154.L_CORE 0.003520
K_13429 X_NUC_151.L_CORE X_NUC_155.L_CORE 0.001605
K_13430 X_NUC_151.L_CORE X_NUC_156.L_CORE 0.005027
K_13431 X_NUC_151.L_CORE X_NUC_157.L_CORE 0.002030
K_13432 X_NUC_151.L_CORE X_NUC_158.L_CORE 0.001910
K_13433 X_NUC_151.L_CORE X_NUC_159.L_CORE 0.005098
K_13434 X_NUC_151.L_CORE X_NUC_160.L_CORE 0.001731
K_13435 X_NUC_151.L_CORE X_NUC_161.L_CORE 0.002777
K_13436 X_NUC_151.L_CORE X_NUC_162.L_CORE 0.002581
K_13437 X_NUC_151.L_CORE X_NUC_163.L_CORE 0.001885
K_13438 X_NUC_151.L_CORE X_NUC_164.L_CORE 0.003145
K_13439 X_NUC_151.L_CORE X_NUC_165.L_CORE 0.002168
K_13440 X_NUC_152.L_CORE X_NUC_153.L_CORE 0.001702
K_13441 X_NUC_152.L_CORE X_NUC_154.L_CORE 0.002360
K_13442 X_NUC_152.L_CORE X_NUC_155.L_CORE 0.003572
K_13443 X_NUC_152.L_CORE X_NUC_156.L_CORE 0.001634
K_13444 X_NUC_152.L_CORE X_NUC_157.L_CORE 0.005080
K_13445 X_NUC_152.L_CORE X_NUC_158.L_CORE 0.002076
K_13446 X_NUC_152.L_CORE X_NUC_159.L_CORE 0.001960
K_13447 X_NUC_152.L_CORE X_NUC_160.L_CORE 0.005025
K_13448 X_NUC_152.L_CORE X_NUC_161.L_CORE 0.001795
K_13449 X_NUC_152.L_CORE X_NUC_162.L_CORE 0.002830
K_13450 X_NUC_152.L_CORE X_NUC_163.L_CORE 0.002639
K_13451 X_NUC_152.L_CORE X_NUC_164.L_CORE 0.002010
K_13452 X_NUC_152.L_CORE X_NUC_165.L_CORE 0.002856
K_13453 X_NUC_153.L_CORE X_NUC_154.L_CORE 0.001729
K_13454 X_NUC_153.L_CORE X_NUC_155.L_CORE 0.002402
K_13455 X_NUC_153.L_CORE X_NUC_156.L_CORE 0.003640
K_13456 X_NUC_153.L_CORE X_NUC_157.L_CORE 0.001672
K_13457 X_NUC_153.L_CORE X_NUC_158.L_CORE 0.005143
K_13458 X_NUC_153.L_CORE X_NUC_159.L_CORE 0.002136
K_13459 X_NUC_153.L_CORE X_NUC_160.L_CORE 0.002025
K_13460 X_NUC_153.L_CORE X_NUC_161.L_CORE 0.004924
K_13461 X_NUC_153.L_CORE X_NUC_162.L_CORE 0.001879
K_13462 X_NUC_153.L_CORE X_NUC_163.L_CORE 0.002887
K_13463 X_NUC_153.L_CORE X_NUC_164.L_CORE 0.002701
K_13464 X_NUC_153.L_CORE X_NUC_165.L_CORE 0.002226
K_13465 X_NUC_154.L_CORE X_NUC_155.L_CORE 0.001764
K_13466 X_NUC_154.L_CORE X_NUC_156.L_CORE 0.002457
K_13467 X_NUC_154.L_CORE X_NUC_157.L_CORE 0.003727
K_13468 X_NUC_154.L_CORE X_NUC_158.L_CORE 0.001722
K_13469 X_NUC_154.L_CORE X_NUC_159.L_CORE 0.005214
K_13470 X_NUC_154.L_CORE X_NUC_160.L_CORE 0.002212
K_13471 X_NUC_154.L_CORE X_NUC_161.L_CORE 0.002108
K_13472 X_NUC_154.L_CORE X_NUC_162.L_CORE 0.004784
K_13473 X_NUC_154.L_CORE X_NUC_163.L_CORE 0.001994
K_13474 X_NUC_154.L_CORE X_NUC_164.L_CORE 0.002939
K_13475 X_NUC_154.L_CORE X_NUC_165.L_CORE 0.002748
K_13476 X_NUC_155.L_CORE X_NUC_156.L_CORE 0.001809
K_13477 X_NUC_155.L_CORE X_NUC_157.L_CORE 0.002527
K_13478 X_NUC_155.L_CORE X_NUC_158.L_CORE 0.003836
K_13479 X_NUC_155.L_CORE X_NUC_159.L_CORE 0.001784
K_13480 X_NUC_155.L_CORE X_NUC_160.L_CORE 0.005290
K_13481 X_NUC_155.L_CORE X_NUC_161.L_CORE 0.002309
K_13482 X_NUC_155.L_CORE X_NUC_162.L_CORE 0.002217
K_13483 X_NUC_155.L_CORE X_NUC_163.L_CORE 0.004587
K_13484 X_NUC_155.L_CORE X_NUC_164.L_CORE 0.002162
K_13485 X_NUC_155.L_CORE X_NUC_165.L_CORE 0.002953
K_13486 X_NUC_156.L_CORE X_NUC_157.L_CORE 0.001867
K_13487 X_NUC_156.L_CORE X_NUC_158.L_CORE 0.002616
K_13488 X_NUC_156.L_CORE X_NUC_159.L_CORE 0.003972
K_13489 X_NUC_156.L_CORE X_NUC_160.L_CORE 0.001865
K_13490 X_NUC_156.L_CORE X_NUC_161.L_CORE 0.005363
K_13491 X_NUC_156.L_CORE X_NUC_162.L_CORE 0.002435
K_13492 X_NUC_156.L_CORE X_NUC_163.L_CORE 0.002363
K_13493 X_NUC_156.L_CORE X_NUC_164.L_CORE 0.004299
K_13494 X_NUC_156.L_CORE X_NUC_165.L_CORE 0.002461
K_13495 X_NUC_157.L_CORE X_NUC_158.L_CORE 0.001941
K_13496 X_NUC_157.L_CORE X_NUC_159.L_CORE 0.002729
K_13497 X_NUC_157.L_CORE X_NUC_160.L_CORE 0.004142
K_13498 X_NUC_157.L_CORE X_NUC_161.L_CORE 0.001970
K_13499 X_NUC_157.L_CORE X_NUC_162.L_CORE 0.005420
K_13500 X_NUC_157.L_CORE X_NUC_163.L_CORE 0.002604
K_13501 X_NUC_157.L_CORE X_NUC_164.L_CORE 0.002571
K_13502 X_NUC_157.L_CORE X_NUC_165.L_CORE 0.003821
K_13503 X_NUC_158.L_CORE X_NUC_159.L_CORE 0.002034
K_13504 X_NUC_158.L_CORE X_NUC_160.L_CORE 0.002874
K_13505 X_NUC_158.L_CORE X_NUC_161.L_CORE 0.004356
K_13506 X_NUC_158.L_CORE X_NUC_162.L_CORE 0.002111
K_13507 X_NUC_158.L_CORE X_NUC_163.L_CORE 0.005431
K_13508 X_NUC_158.L_CORE X_NUC_164.L_CORE 0.002842
K_13509 X_NUC_158.L_CORE X_NUC_165.L_CORE 0.002915
K_13510 X_NUC_159.L_CORE X_NUC_160.L_CORE 0.002157
K_13511 X_NUC_159.L_CORE X_NUC_161.L_CORE 0.003065
K_13512 X_NUC_159.L_CORE X_NUC_162.L_CORE 0.004627
K_13513 X_NUC_159.L_CORE X_NUC_163.L_CORE 0.002310
K_13514 X_NUC_159.L_CORE X_NUC_164.L_CORE 0.005325
K_13515 X_NUC_159.L_CORE X_NUC_165.L_CORE 0.003222
K_13516 X_NUC_160.L_CORE X_NUC_161.L_CORE 0.002321
K_13517 X_NUC_160.L_CORE X_NUC_162.L_CORE 0.003325
K_13518 X_NUC_160.L_CORE X_NUC_163.L_CORE 0.004972
K_13519 X_NUC_160.L_CORE X_NUC_164.L_CORE 0.002621
K_13520 X_NUC_160.L_CORE X_NUC_165.L_CORE 0.004903
K_13521 X_NUC_161.L_CORE X_NUC_162.L_CORE 0.002551
K_13522 X_NUC_161.L_CORE X_NUC_163.L_CORE 0.003699
K_13523 X_NUC_161.L_CORE X_NUC_164.L_CORE 0.005399
K_13524 X_NUC_161.L_CORE X_NUC_165.L_CORE 0.003232
K_13525 X_NUC_162.L_CORE X_NUC_163.L_CORE 0.002899
K_13526 X_NUC_162.L_CORE X_NUC_164.L_CORE 0.004288
K_13527 X_NUC_162.L_CORE X_NUC_165.L_CORE 0.005768
K_13528 X_NUC_163.L_CORE X_NUC_164.L_CORE 0.003505
K_13529 X_NUC_163.L_CORE X_NUC_165.L_CORE 0.005381
K_13530 X_NUC_164.L_CORE X_NUC_165.L_CORE 0.004983

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
