* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Germanium-73 (Z=32, A=73)
* Auto-generated topological mutual impedance array
* Nodes: 73

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON
X_NUC_65 NODE_65 0 NUCLEON
X_NUC_66 NODE_66 0 NUCLEON
X_NUC_67 NODE_67 0 NUCLEON
X_NUC_68 NODE_68 0 NUCLEON
X_NUC_69 NODE_69 0 NUCLEON
X_NUC_70 NODE_70 0 NUCLEON
X_NUC_71 NODE_71 0 NUCLEON
X_NUC_72 NODE_72 0 NUCLEON
X_NUC_73 NODE_73 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.007918
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.007644
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.007703
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.007790
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.008541
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.008669
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.008376
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.008680
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.009039
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.008856
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.008953
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.008682
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.005204
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.005130
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005087
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.005179
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.007536
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.007741
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.007496
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.007508
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.005161
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.005058
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.005071
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.005049
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.004699
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.004701
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.004615
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.004698
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.005762
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.005783
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.005722
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.005639
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.004037
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.003985
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.003962
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.003989
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.004593
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.004635
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.004536
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.004573
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.004298
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.004261
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.004242
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.004213
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.003700
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.003683
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.003638
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.003673
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.004171
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.004189
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.004126
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.004119
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.003598
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.003571
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.003543
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.003548
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.003583
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.003581
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.003532
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.003548
K_64 X_NUC_1.L_CORE X_NUC_65.L_CORE 0.029663
K_65 X_NUC_1.L_CORE X_NUC_66.L_CORE 0.005768
K_66 X_NUC_1.L_CORE X_NUC_67.L_CORE 0.005925
K_67 X_NUC_1.L_CORE X_NUC_68.L_CORE 0.005703
K_68 X_NUC_1.L_CORE X_NUC_69.L_CORE 0.003806
K_69 X_NUC_1.L_CORE X_NUC_70.L_CORE 0.004617
K_70 X_NUC_1.L_CORE X_NUC_71.L_CORE 0.003599
K_71 X_NUC_1.L_CORE X_NUC_72.L_CORE 0.003355
K_72 X_NUC_1.L_CORE X_NUC_73.L_CORE 0.003411
K_73 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_74 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_75 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.008211
K_76 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.007918
K_77 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.007978
K_78 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.008075
K_79 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.008403
K_80 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.008541
K_81 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.008253
K_82 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.008544
K_83 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.009216
K_84 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.009039
K_85 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.009133
K_86 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.008846
K_87 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.005278
K_88 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.005204
K_89 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.005158
K_90 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.005253
K_91 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.007339
K_92 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.007536
K_93 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.007306
K_94 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.007316
K_95 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.005266
K_96 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.005161
K_97 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.005173
K_98 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.005150
K_99 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.004693
K_100 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.004699
K_101 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.004611
K_102 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.004694
K_103 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.005737
K_104 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.005762
K_105 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.005700
K_106 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.005617
K_107 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.004090
K_108 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.004037
K_109 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.004013
K_110 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.004041
K_111 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.004549
K_112 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.004593
K_113 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.004495
K_114 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.004531
K_115 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.004334
K_116 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.004298
K_117 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.004277
K_118 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.004248
K_119 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.003715
K_120 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.003700
K_121 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.003653
K_122 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.003689
K_123 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.004152
K_124 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.004171
K_125 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.004109
K_126 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.004102
K_127 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.003624
K_128 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.003598
K_129 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.003569
K_130 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.003573
K_131 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.003583
K_132 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.003583
K_133 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.003533
K_134 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.003549
K_135 X_NUC_2.L_CORE X_NUC_65.L_CORE 0.027326
K_136 X_NUC_2.L_CORE X_NUC_66.L_CORE 0.005926
K_137 X_NUC_2.L_CORE X_NUC_67.L_CORE 0.005843
K_138 X_NUC_2.L_CORE X_NUC_68.L_CORE 0.005755
K_139 X_NUC_2.L_CORE X_NUC_69.L_CORE 0.003842
K_140 X_NUC_2.L_CORE X_NUC_70.L_CORE 0.004556
K_141 X_NUC_2.L_CORE X_NUC_71.L_CORE 0.003638
K_142 X_NUC_2.L_CORE X_NUC_72.L_CORE 0.003354
K_143 X_NUC_2.L_CORE X_NUC_73.L_CORE 0.003411
K_144 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_145 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.008140
K_146 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.007848
K_147 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.007918
K_148 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.008007
K_149 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.008700
K_150 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.008844
K_151 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.008541
K_152 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.008856
K_153 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.009111
K_154 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.008931
K_155 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.009039
K_156 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.008753
K_157 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.005325
K_158 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.005248
K_159 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.005204
K_160 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.005300
K_161 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.007567
K_162 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.007780
K_163 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.007536
K_164 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.007543
K_165 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.005252
K_166 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.005146
K_167 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.005161
K_168 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.005136
K_169 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.004785
K_170 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.004789
K_171 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.004699
K_172 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.004785
K_173 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.005799
K_174 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.005822
K_175 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.005762
K_176 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.005675
K_177 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.004115
K_178 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.004061
K_179 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.004037
K_180 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.004065
K_181 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.004649
K_182 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.004694
K_183 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.004593
K_184 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.004630
K_185 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.004354
K_186 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.004317
K_187 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.004298
K_188 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.004267
K_189 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.003764
K_190 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.003748
K_191 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.003700
K_192 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.003736
K_193 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.004216
K_194 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.004235
K_195 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.004171
K_196 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.004163
K_197 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.003654
K_198 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.003627
K_199 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.003598
K_200 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.003602
K_201 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.003634
K_202 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.003633
K_203 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.003583
K_204 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.003599
K_205 X_NUC_3.L_CORE X_NUC_65.L_CORE 0.026022
K_206 X_NUC_3.L_CORE X_NUC_66.L_CORE 0.005878
K_207 X_NUC_3.L_CORE X_NUC_67.L_CORE 0.005992
K_208 X_NUC_3.L_CORE X_NUC_68.L_CORE 0.005730
K_209 X_NUC_3.L_CORE X_NUC_69.L_CORE 0.003874
K_210 X_NUC_3.L_CORE X_NUC_70.L_CORE 0.004644
K_211 X_NUC_3.L_CORE X_NUC_71.L_CORE 0.003648
K_212 X_NUC_3.L_CORE X_NUC_72.L_CORE 0.003402
K_213 X_NUC_3.L_CORE X_NUC_73.L_CORE 0.003447
K_214 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.008041
K_215 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.007759
K_216 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.007821
K_217 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.007918
K_218 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.008393
K_219 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.008523
K_220 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.008243
K_221 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.008541
K_222 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.009425
K_223 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.009227
K_224 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.009337
K_225 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.009039
K_226 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.005226
K_227 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.005153
K_228 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.005109
K_229 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.005204
K_230 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.007556
K_231 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.007767
K_232 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.007520
K_233 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.007536
K_234 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.005277
K_235 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.005169
K_236 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.005183
K_237 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.005161
K_238 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.004697
K_239 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.004701
K_240 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.004614
K_241 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.004699
K_242 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.005889
K_243 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.005914
K_244 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.005849
K_245 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.005762
K_246 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.004086
K_247 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.004032
K_248 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.004009
K_249 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.004037
K_250 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.004610
K_251 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.004654
K_252 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.004554
K_253 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.004593
K_254 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.004386
K_255 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.004348
K_256 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.004327
K_257 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.004298
K_258 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.003726
K_259 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.003710
K_260 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.003663
K_261 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.003700
K_262 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.004223
K_263 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.004242
K_264 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.004177
K_265 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.004171
K_266 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.003649
K_267 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.003622
K_268 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.003593
K_269 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.003598
K_270 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.003617
K_271 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.003616
K_272 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.003566
K_273 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.003583
K_274 X_NUC_4.L_CORE X_NUC_65.L_CORE 0.028016
K_275 X_NUC_4.L_CORE X_NUC_66.L_CORE 0.005839
K_276 X_NUC_4.L_CORE X_NUC_67.L_CORE 0.005857
K_277 X_NUC_4.L_CORE X_NUC_68.L_CORE 0.005854
K_278 X_NUC_4.L_CORE X_NUC_69.L_CORE 0.003825
K_279 X_NUC_4.L_CORE X_NUC_70.L_CORE 0.004644
K_280 X_NUC_4.L_CORE X_NUC_71.L_CORE 0.003658
K_281 X_NUC_4.L_CORE X_NUC_72.L_CORE 0.003373
K_282 X_NUC_4.L_CORE X_NUC_73.L_CORE 0.003455
K_283 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_284 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_285 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_286 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.005681
K_287 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.005828
K_288 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.005712
K_289 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.005769
K_290 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.006968
K_291 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.007077
K_292 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.007079
K_293 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.006881
K_294 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.008642
K_295 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.008665
K_296 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.008385
K_297 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.008690
K_298 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.004339
K_299 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.004426
K_300 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.004368
K_301 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.004355
K_302 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.008168
K_303 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.008063
K_304 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008045
K_305 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.007866
K_306 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.004701
K_307 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.004764
K_308 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.004661
K_309 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.004727
K_310 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.004294
K_311 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.004349
K_312 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.004312
K_313 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.004261
K_314 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006291
K_315 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.006233
K_316 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.006116
K_317 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.006172
K_318 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.003711
K_319 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.003763
K_320 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.003703
K_321 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.003714
K_322 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.004632
K_323 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.004642
K_324 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.004605
K_325 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.004550
K_326 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.004304
K_327 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.004323
K_328 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.004240
K_329 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.004281
K_330 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.003554
K_331 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.003591
K_332 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.003546
K_333 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.003533
K_334 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.004279
K_335 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.004278
K_336 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.004221
K_337 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.004214
K_338 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.003598
K_339 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.003623
K_340 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.003567
K_341 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.003575
K_342 X_NUC_5.L_CORE X_NUC_65.L_CORE 0.006478
K_343 X_NUC_5.L_CORE X_NUC_66.L_CORE 0.020599
K_344 X_NUC_5.L_CORE X_NUC_67.L_CORE 0.004420
K_345 X_NUC_5.L_CORE X_NUC_68.L_CORE 0.005043
K_346 X_NUC_5.L_CORE X_NUC_69.L_CORE 0.005454
K_347 X_NUC_5.L_CORE X_NUC_70.L_CORE 0.003388
K_348 X_NUC_5.L_CORE X_NUC_71.L_CORE 0.004575
K_349 X_NUC_5.L_CORE X_NUC_72.L_CORE 0.003456
K_350 X_NUC_5.L_CORE X_NUC_73.L_CORE 0.003272
K_351 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_352 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_353 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.005540
K_354 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.005681
K_355 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.005571
K_356 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.005624
K_357 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.006856
K_358 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.006968
K_359 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.006966
K_360 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.006777
K_361 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.008605
K_362 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.008642
K_363 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.008358
K_364 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.008660
K_365 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.004256
K_366 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.004339
K_367 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.004284
K_368 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.004271
K_369 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.008264
K_370 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.008168
K_371 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008143
K_372 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.007957
K_373 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.004638
K_374 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.004701
K_375 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.004600
K_376 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.004664
K_377 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.004239
K_378 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.004294
K_379 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.004258
K_380 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.004209
K_381 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006344
K_382 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006291
K_383 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.006168
K_384 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.006226
K_385 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.003659
K_386 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.003711
K_387 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.003652
K_388 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.003663
K_389 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.004620
K_390 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.004632
K_391 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.004593
K_392 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.004539
K_393 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.004283
K_394 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.004304
K_395 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.004221
K_396 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.004261
K_397 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.003517
K_398 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.003554
K_399 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.003510
K_400 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.003497
K_401 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.004277
K_402 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.004279
K_403 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.004220
K_404 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.004214
K_405 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.003572
K_406 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.003598
K_407 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.003542
K_408 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.003550
K_409 X_NUC_6.L_CORE X_NUC_65.L_CORE 0.006302
K_410 X_NUC_6.L_CORE X_NUC_66.L_CORE 0.022858
K_411 X_NUC_6.L_CORE X_NUC_67.L_CORE 0.004338
K_412 X_NUC_6.L_CORE X_NUC_68.L_CORE 0.005005
K_413 X_NUC_6.L_CORE X_NUC_69.L_CORE 0.005467
K_414 X_NUC_6.L_CORE X_NUC_70.L_CORE 0.003342
K_415 X_NUC_6.L_CORE X_NUC_71.L_CORE 0.004599
K_416 X_NUC_6.L_CORE X_NUC_72.L_CORE 0.003432
K_417 X_NUC_6.L_CORE X_NUC_73.L_CORE 0.003253
K_418 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_419 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.005646
K_420 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.005793
K_421 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.005681
K_422 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.005735
K_423 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.006854
K_424 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.006962
K_425 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.006968
K_426 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.006775
K_427 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.008908
K_428 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.008941
K_429 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.008642
K_430 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.008969
K_431 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.004310
K_432 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.004395
K_433 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.004339
K_434 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.004325
K_435 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.008283
K_436 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.008180
K_437 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.008168
K_438 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.007975
K_439 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.004740
K_440 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.004806
K_441 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.004701
K_442 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.004768
K_443 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.004274
K_444 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.004329
K_445 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.004294
K_446 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.004243
K_447 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006475
K_448 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006415
K_449 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006291
K_450 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006349
K_451 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.003718
K_452 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.003771
K_453 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.003711
K_454 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.003721
K_455 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.004658
K_456 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.004670
K_457 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.004632
K_458 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.004576
K_459 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.004369
K_460 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.004390
K_461 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.004304
K_462 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.004346
K_463 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.003562
K_464 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.003599
K_465 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.003554
K_466 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.003541
K_467 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.004337
K_468 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.004338
K_469 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.004279
K_470 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.004271
K_471 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.003629
K_472 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.003655
K_473 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.003598
K_474 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.003605
K_475 X_NUC_7.L_CORE X_NUC_65.L_CORE 0.006318
K_476 X_NUC_7.L_CORE X_NUC_66.L_CORE 0.021707
K_477 X_NUC_7.L_CORE X_NUC_67.L_CORE 0.004409
K_478 X_NUC_7.L_CORE X_NUC_68.L_CORE 0.005005
K_479 X_NUC_7.L_CORE X_NUC_69.L_CORE 0.005583
K_480 X_NUC_7.L_CORE X_NUC_70.L_CORE 0.003382
K_481 X_NUC_7.L_CORE X_NUC_71.L_CORE 0.004632
K_482 X_NUC_7.L_CORE X_NUC_72.L_CORE 0.003489
K_483 X_NUC_7.L_CORE X_NUC_73.L_CORE 0.003289
K_484 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.005592
K_485 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.005734
K_486 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.005624
K_487 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.005681
K_488 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.007050
K_489 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.007167
K_490 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.007170
K_491 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.006968
K_492 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.008580
K_493 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.008609
K_494 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.008335
K_495 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.008642
K_496 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.004322
K_497 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.004409
K_498 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.004351
K_499 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.004339
K_500 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.008493
K_501 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.008382
K_502 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.008362
K_503 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.008168
K_504 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.004673
K_505 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.004737
K_506 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.004635
K_507 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.004701
K_508 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.004325
K_509 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.004382
K_510 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.004345
K_511 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.004294
K_512 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006410
K_513 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006352
K_514 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.006228
K_515 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006291
K_516 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.003707
K_517 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.003760
K_518 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.003700
K_519 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.003711
K_520 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.004716
K_521 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.004728
K_522 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.004688
K_523 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.004632
K_524 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.004325
K_525 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.004346
K_526 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.004261
K_527 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.004304
K_528 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.003575
K_529 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.003613
K_530 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.003567
K_531 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.003554
K_532 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.004345
K_533 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.004345
K_534 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.004285
K_535 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.004279
K_536 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.003621
K_537 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.003647
K_538 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.003589
K_539 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.003598
K_540 X_NUC_8.L_CORE X_NUC_65.L_CORE 0.006392
K_541 X_NUC_8.L_CORE X_NUC_66.L_CORE 0.021609
K_542 X_NUC_8.L_CORE X_NUC_67.L_CORE 0.004370
K_543 X_NUC_8.L_CORE X_NUC_68.L_CORE 0.005112
K_544 X_NUC_8.L_CORE X_NUC_69.L_CORE 0.005470
K_545 X_NUC_8.L_CORE X_NUC_70.L_CORE 0.003389
K_546 X_NUC_8.L_CORE X_NUC_71.L_CORE 0.004671
K_547 X_NUC_8.L_CORE X_NUC_72.L_CORE 0.003465
K_548 X_NUC_8.L_CORE X_NUC_73.L_CORE 0.003302
K_549 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_550 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_551 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_552 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.004799
K_553 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.004748
K_554 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.004814
K_555 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.004718
K_556 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.006154
K_557 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.005986
K_558 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.006019
K_559 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.006060
K_560 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.008157
K_561 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.008293
K_562 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.008248
K_563 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.008000
K_564 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.003931
K_565 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.003873
K_566 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.003906
K_567 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.003868
K_568 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.008389
K_569 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.008281
K_570 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008071
K_571 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.008253
K_572 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.004444
K_573 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.004435
K_574 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.004449
K_575 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.004368
K_576 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.004084
K_577 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.004017
K_578 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.004024
K_579 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.004020
K_580 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006549
K_581 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006612
K_582 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006458
K_583 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006431
K_584 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.003573
K_585 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.003543
K_586 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.003553
K_587 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.003514
K_588 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.004634
K_589 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.004581
K_590 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.004538
K_591 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.004559
K_592 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.004300
K_593 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.004303
K_594 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.004272
K_595 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.004226
K_596 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.003554
K_597 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.003519
K_598 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.003513
K_599 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.003496
K_600 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.004171
K_601 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.004153
K_602 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.004110
K_603 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.004101
K_604 X_NUC_9.L_CORE X_NUC_65.L_CORE 0.007289
K_605 X_NUC_9.L_CORE X_NUC_66.L_CORE 0.004525
K_606 X_NUC_9.L_CORE X_NUC_67.L_CORE 0.018201
K_607 X_NUC_9.L_CORE X_NUC_68.L_CORE 0.003781
K_608 X_NUC_9.L_CORE X_NUC_69.L_CORE 0.004523
K_609 X_NUC_9.L_CORE X_NUC_70.L_CORE 0.005197
K_610 X_NUC_9.L_CORE X_NUC_71.L_CORE 0.003167
K_611 X_NUC_9.L_CORE X_NUC_72.L_CORE 0.004392
K_612 X_NUC_9.L_CORE X_NUC_73.L_CORE 0.003396
K_613 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_614 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_615 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.004849
K_616 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.004799
K_617 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.004866
K_618 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.004767
K_619 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.006331
K_620 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.006154
K_621 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.006187
K_622 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.006232
K_623 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.008016
K_624 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.008157
K_625 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.008109
K_626 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.007872
K_627 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.003991
K_628 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.003931
K_629 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.003966
K_630 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.003925
K_631 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.008488
K_632 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.008389
K_633 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.008165
K_634 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.008353
K_635 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.004451
K_636 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.004444
K_637 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.004457
K_638 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.004375
K_639 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.004154
K_640 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.004084
K_641 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.004091
K_642 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.004087
K_643 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006482
K_644 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006549
K_645 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006396
K_646 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.006370
K_647 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.003604
K_648 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.003573
K_649 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.003583
K_650 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.003544
K_651 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.004687
K_652 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.004634
K_653 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.004588
K_654 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.004610
K_655 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.004297
K_656 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.004300
K_657 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.004269
K_658 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.004223
K_659 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.003589
K_660 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.003554
K_661 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.003547
K_662 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.003530
K_663 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.004187
K_664 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.004171
K_665 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.004127
K_666 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.004118
K_667 X_NUC_10.L_CORE X_NUC_65.L_CORE 0.007333
K_668 X_NUC_10.L_CORE X_NUC_66.L_CORE 0.004621
K_669 X_NUC_10.L_CORE X_NUC_67.L_CORE 0.017151
K_670 X_NUC_10.L_CORE X_NUC_68.L_CORE 0.003807
K_671 X_NUC_10.L_CORE X_NUC_69.L_CORE 0.004605
K_672 X_NUC_10.L_CORE X_NUC_70.L_CORE 0.005140
K_673 X_NUC_10.L_CORE X_NUC_71.L_CORE 0.003201
K_674 X_NUC_10.L_CORE X_NUC_72.L_CORE 0.004408
K_675 X_NUC_10.L_CORE X_NUC_73.L_CORE 0.003404
K_676 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_677 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.004781
K_678 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.004731
K_679 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.004799
K_680 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.004702
K_681 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.006292
K_682 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.006115
K_683 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.006154
K_684 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.006195
K_685 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.008057
K_686 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.008194
K_687 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.008157
K_688 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.007911
K_689 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.003955
K_690 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.003896
K_691 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.003931
K_692 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.003891
K_693 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.008733
K_694 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.008618
K_695 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.008389
K_696 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.008587
K_697 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.004438
K_698 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.004430
K_699 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.004444
K_700 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.004363
K_701 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.004146
K_702 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.004076
K_703 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.004084
K_704 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.004079
K_705 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006638
K_706 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006707
K_707 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006549
K_708 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006519
K_709 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.003593
K_710 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.003563
K_711 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.003573
K_712 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.003534
K_713 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.004735
K_714 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.004679
K_715 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.004634
K_716 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.004656
K_717 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.004328
K_718 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.004331
K_719 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.004300
K_720 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.004253
K_721 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.003596
K_722 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.003560
K_723 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.003554
K_724 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.003536
K_725 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.004233
K_726 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.004215
K_727 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.004171
K_728 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.004161
K_729 X_NUC_11.L_CORE X_NUC_65.L_CORE 0.007128
K_730 X_NUC_11.L_CORE X_NUC_66.L_CORE 0.004553
K_731 X_NUC_11.L_CORE X_NUC_67.L_CORE 0.018554
K_732 X_NUC_11.L_CORE X_NUC_68.L_CORE 0.003774
K_733 X_NUC_11.L_CORE X_NUC_69.L_CORE 0.004614
K_734 X_NUC_11.L_CORE X_NUC_70.L_CORE 0.005198
K_735 X_NUC_11.L_CORE X_NUC_71.L_CORE 0.003192
K_736 X_NUC_11.L_CORE X_NUC_72.L_CORE 0.004476
K_737 X_NUC_11.L_CORE X_NUC_73.L_CORE 0.003421
K_738 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.004880
K_739 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.004828
K_740 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.004898
K_741 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.004799
K_742 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.006246
K_743 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.006073
K_744 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.006108
K_745 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.006154
K_746 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.008311
K_747 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.008462
K_748 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.008414
K_749 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.008157
K_750 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.003996
K_751 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.003936
K_752 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.003971
K_753 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.003931
K_754 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.008519
K_755 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.008412
K_756 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.008192
K_757 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.008389
K_758 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.004523
K_759 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.004514
K_760 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.004529
K_761 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.004444
K_762 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.004151
K_763 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.004080
K_764 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.004088
K_765 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.004084
K_766 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006668
K_767 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006737
K_768 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006574
K_769 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006549
K_770 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.003635
K_771 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.003603
K_772 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.003613
K_773 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.003573
K_774 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.004711
K_775 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.004656
K_776 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.004611
K_777 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.004634
K_778 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.004377
K_779 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.004380
K_780 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.004347
K_781 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.004300
K_782 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.003614
K_783 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.003578
K_784 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.003571
K_785 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.003554
K_786 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.004243
K_787 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.004225
K_788 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.004180
K_789 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.004171
K_790 X_NUC_12.L_CORE X_NUC_65.L_CORE 0.007353
K_791 X_NUC_12.L_CORE X_NUC_66.L_CORE 0.004581
K_792 X_NUC_12.L_CORE X_NUC_67.L_CORE 0.017611
K_793 X_NUC_12.L_CORE X_NUC_68.L_CORE 0.003837
K_794 X_NUC_12.L_CORE X_NUC_69.L_CORE 0.004578
K_795 X_NUC_12.L_CORE X_NUC_70.L_CORE 0.005270
K_796 X_NUC_12.L_CORE X_NUC_71.L_CORE 0.003215
K_797 X_NUC_12.L_CORE X_NUC_72.L_CORE 0.004451
K_798 X_NUC_12.L_CORE X_NUC_73.L_CORE 0.003448
K_799 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_800 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_801 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_802 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.004321
K_803 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.004298
K_804 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.004262
K_805 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.004348
K_806 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.005673
K_807 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.005806
K_808 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.005675
K_809 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.005754
K_810 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.007793
K_811 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.007556
K_812 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.007539
K_813 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.007638
K_814 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.003699
K_815 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.003713
K_816 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.003663
K_817 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.003724
K_818 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.008471
K_819 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.008694
K_820 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.008408
K_821 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.008373
K_822 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.004298
K_823 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.004254
K_824 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.004216
K_825 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.004279
K_826 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.003977
K_827 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.004020
K_828 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.003946
K_829 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.003996
K_830 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006663
K_831 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006598
K_832 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006489
K_833 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006493
K_834 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.003533
K_835 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.003529
K_836 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.003483
K_837 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.003531
K_838 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.004634
K_839 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.004683
K_840 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.004583
K_841 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.004612
K_842 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.004304
K_843 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.004278
K_844 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.004219
K_845 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.004257
K_846 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.003700
K_847 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.003711
K_848 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.003650
K_849 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.003687
K_850 X_NUC_13.L_CORE X_NUC_65.L_CORE 0.008513
K_851 X_NUC_13.L_CORE X_NUC_66.L_CORE 0.005786
K_852 X_NUC_13.L_CORE X_NUC_67.L_CORE 0.003923
K_853 X_NUC_13.L_CORE X_NUC_68.L_CORE 0.014814
K_854 X_NUC_13.L_CORE X_NUC_69.L_CORE 0.003493
K_855 X_NUC_13.L_CORE X_NUC_70.L_CORE 0.004340
K_856 X_NUC_13.L_CORE X_NUC_71.L_CORE 0.004883
K_857 X_NUC_13.L_CORE X_NUC_72.L_CORE 0.003158
K_858 X_NUC_13.L_CORE X_NUC_73.L_CORE 0.004069
K_859 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_860 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_861 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.004343
K_862 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.004321
K_863 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.004284
K_864 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.004371
K_865 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.005545
K_866 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.005673
K_867 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.005549
K_868 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.005623
K_869 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.008041
K_870 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.007793
K_871 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.007769
K_872 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.007877
K_873 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.003684
K_874 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.003699
K_875 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.003649
K_876 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.003710
K_877 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.008251
K_878 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.008471
K_879 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008199
K_880 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.008167
K_881 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.004342
K_882 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.004298
K_883 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.004258
K_884 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.004323
K_885 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.003933
K_886 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.003977
K_887 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.003904
K_888 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.003952
K_889 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006723
K_890 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006663
K_891 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006547
K_892 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006552
K_893 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.003536
K_894 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.003533
K_895 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.003486
K_896 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.003534
K_897 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.004585
K_898 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.004634
K_899 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.004536
K_900 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.004564
K_901 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.004329
K_902 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.004304
K_903 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.004244
K_904 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.004282
K_905 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.003688
K_906 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.003700
K_907 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.003639
K_908 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.003676
K_909 X_NUC_14.L_CORE X_NUC_65.L_CORE 0.008308
K_910 X_NUC_14.L_CORE X_NUC_66.L_CORE 0.005895
K_911 X_NUC_14.L_CORE X_NUC_67.L_CORE 0.003884
K_912 X_NUC_14.L_CORE X_NUC_68.L_CORE 0.014919
K_913 X_NUC_14.L_CORE X_NUC_69.L_CORE 0.003511
K_914 X_NUC_14.L_CORE X_NUC_70.L_CORE 0.004270
K_915 X_NUC_14.L_CORE X_NUC_71.L_CORE 0.004951
K_916 X_NUC_14.L_CORE X_NUC_72.L_CORE 0.003150
K_917 X_NUC_14.L_CORE X_NUC_73.L_CORE 0.004053
K_918 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_919 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.004381
K_920 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.004358
K_921 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.004321
K_922 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.004410
K_923 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.005667
K_924 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.005801
K_925 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.005673
K_926 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.005750
K_927 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.008062
K_928 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.007807
K_929 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.007793
K_930 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.007897
K_931 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.003735
K_932 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.003750
K_933 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.003699
K_934 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.003762
K_935 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.008520
K_936 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.008755
K_937 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.008471
K_938 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.008428
K_939 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.004383
K_940 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.004338
K_941 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.004298
K_942 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.004364
K_943 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.004006
K_944 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.004051
K_945 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.003977
K_946 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.004026
K_947 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006845
K_948 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006778
K_949 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006663
K_950 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.006664
K_951 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.003584
K_952 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.003580
K_953 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.003533
K_954 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.003583
K_955 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.004685
K_956 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.004736
K_957 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.004634
K_958 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.004663
K_959 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.004392
K_960 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.004365
K_961 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.004304
K_962 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.004343
K_963 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.003751
K_964 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.003763
K_965 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.003700
K_966 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.003738
K_967 X_NUC_15.L_CORE X_NUC_65.L_CORE 0.008347
K_968 X_NUC_15.L_CORE X_NUC_66.L_CORE 0.005875
K_969 X_NUC_15.L_CORE X_NUC_67.L_CORE 0.003936
K_970 X_NUC_15.L_CORE X_NUC_68.L_CORE 0.014936
K_971 X_NUC_15.L_CORE X_NUC_69.L_CORE 0.003541
K_972 X_NUC_15.L_CORE X_NUC_70.L_CORE 0.004353
K_973 X_NUC_15.L_CORE X_NUC_71.L_CORE 0.004993
K_974 X_NUC_15.L_CORE X_NUC_72.L_CORE 0.003194
K_975 X_NUC_15.L_CORE X_NUC_73.L_CORE 0.004123
K_976 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.004294
K_977 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.004272
K_978 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.004236
K_979 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.004321
K_980 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.005591
K_981 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.005720
K_982 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.005595
K_983 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.005673
K_984 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.007946
K_985 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.007701
K_986 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.007682
K_987 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.007793
K_988 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.003673
K_989 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.003687
K_990 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.003638
K_991 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.003699
K_992 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.008557
K_993 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.008795
K_994 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.008499
K_995 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.008471
K_996 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.004315
K_997 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.004272
K_998 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.004233
K_999 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.004298
K_1000 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.003956
K_1001 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.004000
K_1002 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.003927
K_1003 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.003977
K_1004 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006840
K_1005 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006773
K_1006 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006655
K_1007 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006663
K_1008 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.003534
K_1009 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.003530
K_1010 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.003484
K_1011 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.003533
K_1012 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.004655
K_1013 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.004705
K_1014 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.004604
K_1015 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.004634
K_1016 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.004350
K_1017 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.004324
K_1018 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.004264
K_1019 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.004304
K_1020 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.003712
K_1021 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.003723
K_1022 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.003662
K_1023 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.003700
K_1024 X_NUC_16.L_CORE X_NUC_65.L_CORE 0.008181
K_1025 X_NUC_16.L_CORE X_NUC_66.L_CORE 0.005758
K_1026 X_NUC_16.L_CORE X_NUC_67.L_CORE 0.003873
K_1027 X_NUC_16.L_CORE X_NUC_68.L_CORE 0.015820
K_1028 X_NUC_16.L_CORE X_NUC_69.L_CORE 0.003487
K_1029 X_NUC_16.L_CORE X_NUC_70.L_CORE 0.004321
K_1030 X_NUC_16.L_CORE X_NUC_71.L_CORE 0.004970
K_1031 X_NUC_16.L_CORE X_NUC_72.L_CORE 0.003157
K_1032 X_NUC_16.L_CORE X_NUC_73.L_CORE 0.004108
K_1033 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_1034 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_1035 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_1036 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.004036
K_1037 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.004102
K_1038 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.004086
K_1039 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.004042
K_1040 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.005378
K_1041 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.005341
K_1042 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.005405
K_1043 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.005276
K_1044 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.007550
K_1045 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.007799
K_1046 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.007555
K_1047 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.007620
K_1048 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.003567
K_1049 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.003596
K_1050 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.003596
K_1051 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.003545
K_1052 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.008497
K_1053 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.008330
K_1054 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.008303
K_1055 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.008165
K_1056 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.004231
K_1057 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.004305
K_1058 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.004250
K_1059 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.004228
K_1060 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.003943
K_1061 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.003946
K_1062 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.003951
K_1063 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.003887
K_1064 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006663
K_1065 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006722
K_1066 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.006543
K_1067 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.006555
K_1068 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.003573
K_1069 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.003609
K_1070 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.003583
K_1071 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.003548
K_1072 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.004632
K_1073 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.004627
K_1074 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.004597
K_1075 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.004542
K_1076 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.004298
K_1077 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.004337
K_1078 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.004276
K_1079 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.004252
K_1080 X_NUC_17.L_CORE X_NUC_65.L_CORE 0.004439
K_1081 X_NUC_17.L_CORE X_NUC_66.L_CORE 0.007899
K_1082 X_NUC_17.L_CORE X_NUC_67.L_CORE 0.005224
K_1083 X_NUC_17.L_CORE X_NUC_68.L_CORE 0.003579
K_1084 X_NUC_17.L_CORE X_NUC_69.L_CORE 0.012587
K_1085 X_NUC_17.L_CORE X_NUC_70.L_CORE 0.003387
K_1086 X_NUC_17.L_CORE X_NUC_71.L_CORE 0.004159
K_1087 X_NUC_17.L_CORE X_NUC_72.L_CORE 0.004708
K_1088 X_NUC_17.L_CORE X_NUC_73.L_CORE 0.003320
K_1089 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_1090 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_1091 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.003971
K_1092 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.004036
K_1093 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.004020
K_1094 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.003978
K_1095 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.005412
K_1096 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.005378
K_1097 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.005442
K_1098 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.005311
K_1099 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.007314
K_1100 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.007550
K_1101 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.007324
K_1102 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.007383
K_1103 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.003538
K_1104 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.003567
K_1105 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.003567
K_1106 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.003516
K_1107 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.008661
K_1108 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.008497
K_1109 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.008463
K_1110 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.008316
K_1111 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.004158
K_1112 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.004231
K_1113 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.004177
K_1114 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.004157
K_1115 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.003938
K_1116 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.003943
K_1117 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.003946
K_1118 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.003883
K_1119 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.006599
K_1120 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006663
K_1121 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.006485
K_1122 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.006497
K_1123 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.003538
K_1124 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.003573
K_1125 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.003548
K_1126 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.003514
K_1127 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.004635
K_1128 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.004632
K_1129 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.004601
K_1130 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.004546
K_1131 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.004258
K_1132 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.004298
K_1133 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.004238
K_1134 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.004214
K_1135 X_NUC_18.L_CORE X_NUC_65.L_CORE 0.004385
K_1136 X_NUC_18.L_CORE X_NUC_66.L_CORE 0.008034
K_1137 X_NUC_18.L_CORE X_NUC_67.L_CORE 0.005096
K_1138 X_NUC_18.L_CORE X_NUC_68.L_CORE 0.003567
K_1139 X_NUC_18.L_CORE X_NUC_69.L_CORE 0.012843
K_1140 X_NUC_18.L_CORE X_NUC_70.L_CORE 0.003344
K_1141 X_NUC_18.L_CORE X_NUC_71.L_CORE 0.004181
K_1142 X_NUC_18.L_CORE X_NUC_72.L_CORE 0.004652
K_1143 X_NUC_18.L_CORE X_NUC_73.L_CORE 0.003301
K_1144 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_1145 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.003986
K_1146 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.004050
K_1147 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.004036
K_1148 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.003993
K_1149 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.005348
K_1150 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.005313
K_1151 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.005378
K_1152 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.005249
K_1153 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.007534
K_1154 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.007787
K_1155 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.007550
K_1156 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.007609
K_1157 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.003538
K_1158 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.003567
K_1159 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.003567
K_1160 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.003516
K_1161 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.008690
K_1162 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.008518
K_1163 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.008497
K_1164 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.008342
K_1165 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.004210
K_1166 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.004285
K_1167 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.004231
K_1168 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.004209
K_1169 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.003934
K_1170 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.003938
K_1171 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.003943
K_1172 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.003879
K_1173 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006782
K_1174 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006848
K_1175 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006663
K_1176 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.006672
K_1177 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.003562
K_1178 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.003598
K_1179 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.003573
K_1180 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.003538
K_1181 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.004665
K_1182 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.004661
K_1183 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.004632
K_1184 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.004575
K_1185 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.004318
K_1186 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.004359
K_1187 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.004298
K_1188 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.004272
K_1189 X_NUC_19.L_CORE X_NUC_65.L_CORE 0.004353
K_1190 X_NUC_19.L_CORE X_NUC_66.L_CORE 0.007761
K_1191 X_NUC_19.L_CORE X_NUC_67.L_CORE 0.005150
K_1192 X_NUC_19.L_CORE X_NUC_68.L_CORE 0.003547
K_1193 X_NUC_19.L_CORE X_NUC_69.L_CORE 0.013383
K_1194 X_NUC_19.L_CORE X_NUC_70.L_CORE 0.003365
K_1195 X_NUC_19.L_CORE X_NUC_71.L_CORE 0.004172
K_1196 X_NUC_19.L_CORE X_NUC_72.L_CORE 0.004748
K_1197 X_NUC_19.L_CORE X_NUC_73.L_CORE 0.003322
K_1198 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.004027
K_1199 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.004094
K_1200 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.004078
K_1201 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.004036
K_1202 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.005482
K_1203 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.005444
K_1204 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.005513
K_1205 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.005378
K_1206 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.007472
K_1207 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.007718
K_1208 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.007482
K_1209 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.007550
K_1210 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.003589
K_1211 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.003619
K_1212 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.003619
K_1213 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.003567
K_1214 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.008858
K_1215 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.008676
K_1216 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.008646
K_1217 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.008497
K_1218 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.004232
K_1219 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.004307
K_1220 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.004252
K_1221 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.004231
K_1222 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.004000
K_1223 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.004004
K_1224 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.004009
K_1225 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.003943
K_1226 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006769
K_1227 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.006835
K_1228 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006647
K_1229 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006663
K_1230 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.003598
K_1231 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.003635
K_1232 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.003609
K_1233 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.003573
K_1234 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.004725
K_1235 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.004721
K_1236 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.004689
K_1237 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.004632
K_1238 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.004343
K_1239 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.004385
K_1240 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.004322
K_1241 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.004298
K_1242 X_NUC_20.L_CORE X_NUC_65.L_CORE 0.004419
K_1243 X_NUC_20.L_CORE X_NUC_66.L_CORE 0.007996
K_1244 X_NUC_20.L_CORE X_NUC_67.L_CORE 0.005154
K_1245 X_NUC_20.L_CORE X_NUC_68.L_CORE 0.003607
K_1246 X_NUC_20.L_CORE X_NUC_69.L_CORE 0.012977
K_1247 X_NUC_20.L_CORE X_NUC_70.L_CORE 0.003392
K_1248 X_NUC_20.L_CORE X_NUC_71.L_CORE 0.004238
K_1249 X_NUC_20.L_CORE X_NUC_72.L_CORE 0.004739
K_1250 X_NUC_20.L_CORE X_NUC_73.L_CORE 0.003354
K_1251 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_1252 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_1253 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_1254 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.003863
K_1255 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.003794
K_1256 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.003830
K_1257 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.003819
K_1258 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.005205
K_1259 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.005144
K_1260 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.005102
K_1261 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.005212
K_1262 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.007411
K_1263 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.007269
K_1264 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.007360
K_1265 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.007175
K_1266 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.003507
K_1267 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.003453
K_1268 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.003461
K_1269 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.003478
K_1270 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.008503
K_1271 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.008482
K_1272 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.008206
K_1273 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.008415
K_1274 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.004231
K_1275 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.004162
K_1276 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.004183
K_1277 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.004154
K_1278 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.003977
K_1279 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.003927
K_1280 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.003904
K_1281 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.003946
K_1282 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.006549
K_1283 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.006486
K_1284 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.006402
K_1285 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.006369
K_1286 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.003711
K_1287 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.003659
K_1288 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.003655
K_1289 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.003659
K_1290 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.004593
K_1291 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.004545
K_1292 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.004496
K_1293 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.004526
K_1294 X_NUC_21.L_CORE X_NUC_65.L_CORE 0.007321
K_1295 X_NUC_21.L_CORE X_NUC_66.L_CORE 0.003621
K_1296 X_NUC_21.L_CORE X_NUC_67.L_CORE 0.007447
K_1297 X_NUC_21.L_CORE X_NUC_68.L_CORE 0.004762
K_1298 X_NUC_21.L_CORE X_NUC_69.L_CORE 0.003389
K_1299 X_NUC_21.L_CORE X_NUC_70.L_CORE 0.011029
K_1300 X_NUC_21.L_CORE X_NUC_71.L_CORE 0.003319
K_1301 X_NUC_21.L_CORE X_NUC_72.L_CORE 0.004112
K_1302 X_NUC_21.L_CORE X_NUC_73.L_CORE 0.004358
K_1303 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_1304 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_1305 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.003935
K_1306 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.003863
K_1307 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.003900
K_1308 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.003889
K_1309 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.005265
K_1310 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.005205
K_1311 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.005161
K_1312 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.005274
K_1313 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.007553
K_1314 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.007411
K_1315 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.007503
K_1316 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.007307
K_1317 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.003562
K_1318 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.003507
K_1319 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.003514
K_1320 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.003532
K_1321 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.008511
K_1322 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.008503
K_1323 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.008219
K_1324 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.008429
K_1325 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.004302
K_1326 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.004231
K_1327 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.004253
K_1328 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.004222
K_1329 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.004026
K_1330 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.003977
K_1331 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.003952
K_1332 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.003996
K_1333 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.006608
K_1334 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.006549
K_1335 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.006460
K_1336 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.006425
K_1337 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.003764
K_1338 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.003711
K_1339 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.003707
K_1340 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.003711
K_1341 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.004640
K_1342 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.004593
K_1343 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.004541
K_1344 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.004573
K_1345 X_NUC_22.L_CORE X_NUC_65.L_CORE 0.007470
K_1346 X_NUC_22.L_CORE X_NUC_66.L_CORE 0.003683
K_1347 X_NUC_22.L_CORE X_NUC_67.L_CORE 0.007474
K_1348 X_NUC_22.L_CORE X_NUC_68.L_CORE 0.004844
K_1349 X_NUC_22.L_CORE X_NUC_69.L_CORE 0.003433
K_1350 X_NUC_22.L_CORE X_NUC_70.L_CORE 0.010824
K_1351 X_NUC_22.L_CORE X_NUC_71.L_CORE 0.003367
K_1352 X_NUC_22.L_CORE X_NUC_72.L_CORE 0.004143
K_1353 X_NUC_22.L_CORE X_NUC_73.L_CORE 0.004398
K_1354 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_1355 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.003896
K_1356 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.003825
K_1357 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.003863
K_1358 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.003851
K_1359 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.005310
K_1360 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.005247
K_1361 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.005205
K_1362 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.005320
K_1363 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.007454
K_1364 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.007314
K_1365 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.007411
K_1366 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.007218
K_1367 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.003554
K_1368 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.003498
K_1369 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.003507
K_1370 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.003524
K_1371 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.008820
K_1372 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.008804
K_1373 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.008503
K_1374 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.008730
K_1375 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.004278
K_1376 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.004207
K_1377 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.004231
K_1378 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.004199
K_1379 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.004051
K_1380 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.004000
K_1381 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.003977
K_1382 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.004020
K_1383 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.006701
K_1384 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.006636
K_1385 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.006549
K_1386 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.006511
K_1387 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.003768
K_1388 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.003714
K_1389 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.003711
K_1390 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.003714
K_1391 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.004694
K_1392 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.004644
K_1393 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.004593
K_1394 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.004624
K_1395 X_NUC_23.L_CORE X_NUC_65.L_CORE 0.007224
K_1396 X_NUC_23.L_CORE X_NUC_66.L_CORE 0.003644
K_1397 X_NUC_23.L_CORE X_NUC_67.L_CORE 0.007545
K_1398 X_NUC_23.L_CORE X_NUC_68.L_CORE 0.004768
K_1399 X_NUC_23.L_CORE X_NUC_69.L_CORE 0.003434
K_1400 X_NUC_23.L_CORE X_NUC_70.L_CORE 0.011290
K_1401 X_NUC_23.L_CORE X_NUC_71.L_CORE 0.003354
K_1402 X_NUC_23.L_CORE X_NUC_72.L_CORE 0.004193
K_1403 X_NUC_23.L_CORE X_NUC_73.L_CORE 0.004427
K_1404 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.003908
K_1405 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.003837
K_1406 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.003874
K_1407 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.003863
K_1408 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.005195
K_1409 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.005135
K_1410 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.005094
K_1411 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.005205
K_1412 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.007662
K_1413 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.007510
K_1414 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.007611
K_1415 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.007411
K_1416 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.003536
K_1417 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.003481
K_1418 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.003489
K_1419 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.003507
K_1420 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.008579
K_1421 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.008565
K_1422 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.008281
K_1423 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.008503
K_1424 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.004310
K_1425 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.004238
K_1426 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.004261
K_1427 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.004231
K_1428 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.004006
K_1429 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.003956
K_1430 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.003933
K_1431 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.003977
K_1432 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.006740
K_1433 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.006674
K_1434 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.006582
K_1435 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.006549
K_1436 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.003764
K_1437 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.003710
K_1438 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.003707
K_1439 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.003711
K_1440 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.004660
K_1441 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.004611
K_1442 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.004560
K_1443 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.004593
K_1444 X_NUC_24.L_CORE X_NUC_65.L_CORE 0.007273
K_1445 X_NUC_24.L_CORE X_NUC_66.L_CORE 0.003636
K_1446 X_NUC_24.L_CORE X_NUC_67.L_CORE 0.007291
K_1447 X_NUC_24.L_CORE X_NUC_68.L_CORE 0.004842
K_1448 X_NUC_24.L_CORE X_NUC_69.L_CORE 0.003401
K_1449 X_NUC_24.L_CORE X_NUC_70.L_CORE 0.011340
K_1450 X_NUC_24.L_CORE X_NUC_71.L_CORE 0.003363
K_1451 X_NUC_24.L_CORE X_NUC_72.L_CORE 0.004140
K_1452 X_NUC_24.L_CORE X_NUC_73.L_CORE 0.004445
K_1453 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_1454 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_1455 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_1456 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.003770
K_1457 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.003812
K_1458 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.003760
K_1459 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.003815
K_1460 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.005124
K_1461 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.005245
K_1462 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.005186
K_1463 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.005146
K_1464 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.007366
K_1465 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.007347
K_1466 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.007170
K_1467 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.007401
K_1468 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.003507
K_1469 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.003559
K_1470 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.003510
K_1471 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.003534
K_1472 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.008497
K_1473 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.008680
K_1474 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.008460
K_1475 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.008335
K_1476 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.004298
K_1477 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.004333
K_1478 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.004251
K_1479 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.004321
K_1480 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.004084
K_1481 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.004154
K_1482 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.004087
K_1483 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.004091
K_1484 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.006291
K_1485 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.006336
K_1486 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.006161
K_1487 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.006225
K_1488 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.004037
K_1489 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.004086
K_1490 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.004008
K_1491 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.004042
K_1492 X_NUC_25.L_CORE X_NUC_65.L_CORE 0.004609
K_1493 X_NUC_25.L_CORE X_NUC_66.L_CORE 0.008602
K_1494 X_NUC_25.L_CORE X_NUC_67.L_CORE 0.003360
K_1495 X_NUC_25.L_CORE X_NUC_68.L_CORE 0.007223
K_1496 X_NUC_25.L_CORE X_NUC_69.L_CORE 0.004635
K_1497 X_NUC_25.L_CORE X_NUC_70.L_CORE 0.003390
K_1498 X_NUC_25.L_CORE X_NUC_71.L_CORE 0.009320
K_1499 X_NUC_25.L_CORE X_NUC_72.L_CORE 0.003456
K_1500 X_NUC_25.L_CORE X_NUC_73.L_CORE 0.004186
K_1501 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_1502 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_1503 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.003727
K_1504 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.003770
K_1505 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.003719
K_1506 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.003771
K_1507 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.005009
K_1508 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.005124
K_1509 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.005068
K_1510 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.005031
K_1511 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.007377
K_1512 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.007366
K_1513 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.007184
K_1514 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.007417
K_1515 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.003456
K_1516 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.003507
K_1517 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.003459
K_1518 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.003482
K_1519 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.008313
K_1520 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.008497
K_1521 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.008285
K_1522 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.008167
K_1523 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.004263
K_1524 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.004298
K_1525 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.004218
K_1526 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.004286
K_1527 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.004017
K_1528 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.004084
K_1529 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.004019
K_1530 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.004024
K_1531 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.006241
K_1532 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.006291
K_1533 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.006117
K_1534 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.006179
K_1535 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.003989
K_1536 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.004037
K_1537 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.003961
K_1538 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.003995
K_1539 X_NUC_26.L_CORE X_NUC_65.L_CORE 0.004528
K_1540 X_NUC_26.L_CORE X_NUC_66.L_CORE 0.008625
K_1541 X_NUC_26.L_CORE X_NUC_67.L_CORE 0.003317
K_1542 X_NUC_26.L_CORE X_NUC_68.L_CORE 0.007048
K_1543 X_NUC_26.L_CORE X_NUC_69.L_CORE 0.004625
K_1544 X_NUC_26.L_CORE X_NUC_70.L_CORE 0.003338
K_1545 X_NUC_26.L_CORE X_NUC_71.L_CORE 0.009371
K_1546 X_NUC_26.L_CORE X_NUC_72.L_CORE 0.003424
K_1547 X_NUC_26.L_CORE X_NUC_73.L_CORE 0.004132
K_1548 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_1549 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.003778
K_1550 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.003821
K_1551 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.003770
K_1552 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.003823
K_1553 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.005062
K_1554 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.005180
K_1555 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.005124
K_1556 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.005085
K_1557 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.007570
K_1558 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.007554
K_1559 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.007366
K_1560 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.007613
K_1561 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.003503
K_1562 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.003556
K_1563 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.003507
K_1564 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.003531
K_1565 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.008521
K_1566 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.008712
K_1567 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.008497
K_1568 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.008364
K_1569 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.004345
K_1570 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.004381
K_1571 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.004298
K_1572 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.004369
K_1573 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.004081
K_1574 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.004151
K_1575 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.004084
K_1576 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.004088
K_1577 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.006423
K_1578 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.006474
K_1579 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.006291
K_1580 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.006356
K_1581 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.004066
K_1582 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.004117
K_1583 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.004037
K_1584 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.004072
K_1585 X_NUC_27.L_CORE X_NUC_65.L_CORE 0.004530
K_1586 X_NUC_27.L_CORE X_NUC_66.L_CORE 0.008537
K_1587 X_NUC_27.L_CORE X_NUC_67.L_CORE 0.003347
K_1588 X_NUC_27.L_CORE X_NUC_68.L_CORE 0.007036
K_1589 X_NUC_27.L_CORE X_NUC_69.L_CORE 0.004691
K_1590 X_NUC_27.L_CORE X_NUC_70.L_CORE 0.003375
K_1591 X_NUC_27.L_CORE X_NUC_71.L_CORE 0.009633
K_1592 X_NUC_27.L_CORE X_NUC_72.L_CORE 0.003479
K_1593 X_NUC_27.L_CORE X_NUC_73.L_CORE 0.004204
K_1594 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.003725
K_1595 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.003767
K_1596 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.003717
K_1597 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.003770
K_1598 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.005100
K_1599 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.005220
K_1600 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.005162
K_1601 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.005124
K_1602 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.007323
K_1603 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.007308
K_1604 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.007134
K_1605 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.007366
K_1606 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.003479
K_1607 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.003531
K_1608 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.003482
K_1609 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.003507
K_1610 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.008654
K_1611 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.008855
K_1612 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.008623
K_1613 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.008497
K_1614 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.004274
K_1615 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.004308
K_1616 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.004228
K_1617 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.004298
K_1618 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.004076
K_1619 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.004146
K_1620 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.004079
K_1621 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.004084
K_1622 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.006353
K_1623 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.006402
K_1624 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.006222
K_1625 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.006291
K_1626 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.004031
K_1627 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.004080
K_1628 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.004002
K_1629 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.004037
K_1630 X_NUC_28.L_CORE X_NUC_65.L_CORE 0.004524
K_1631 X_NUC_28.L_CORE X_NUC_66.L_CORE 0.008319
K_1632 X_NUC_28.L_CORE X_NUC_67.L_CORE 0.003317
K_1633 X_NUC_28.L_CORE X_NUC_68.L_CORE 0.007206
K_1634 X_NUC_28.L_CORE X_NUC_69.L_CORE 0.004589
K_1635 X_NUC_28.L_CORE X_NUC_70.L_CORE 0.003369
K_1636 X_NUC_28.L_CORE X_NUC_71.L_CORE 0.009665
K_1637 X_NUC_28.L_CORE X_NUC_72.L_CORE 0.003441
K_1638 X_NUC_28.L_CORE X_NUC_73.L_CORE 0.004204
K_1639 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_1640 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_1641 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_1642 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.003740
K_1643 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.003744
K_1644 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.003772
K_1645 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.003705
K_1646 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.005124
K_1647 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.005014
K_1648 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.005078
K_1649 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.005027
K_1650 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.007411
K_1651 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.007578
K_1652 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.007505
K_1653 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.007329
K_1654 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.003567
K_1655 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.003544
K_1656 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.003572
K_1657 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.003518
K_1658 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.008471
K_1659 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.008257
K_1660 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.008215
K_1661 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.008157
K_1662 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.004444
K_1663 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.004462
K_1664 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.004461
K_1665 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.004381
K_1666 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.004294
K_1667 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.004246
K_1668 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.004264
K_1669 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.004209
K_1670 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.005762
K_1671 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.005748
K_1672 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.005706
K_1673 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.005622
K_1674 X_NUC_29.L_CORE X_NUC_65.L_CORE 0.004151
K_1675 X_NUC_29.L_CORE X_NUC_66.L_CORE 0.004122
K_1676 X_NUC_29.L_CORE X_NUC_67.L_CORE 0.009442
K_1677 X_NUC_29.L_CORE X_NUC_68.L_CORE 0.003191
K_1678 X_NUC_29.L_CORE X_NUC_69.L_CORE 0.006858
K_1679 X_NUC_29.L_CORE X_NUC_70.L_CORE 0.004619
K_1680 X_NUC_29.L_CORE X_NUC_71.L_CORE 0.003404
K_1681 X_NUC_29.L_CORE X_NUC_72.L_CORE 0.007845
K_1682 X_NUC_29.L_CORE X_NUC_73.L_CORE 0.003752
K_1683 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_1684 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_1685 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.003735
K_1686 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.003740
K_1687 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.003768
K_1688 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.003701
K_1689 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.005239
K_1690 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.005124
K_1691 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.005190
K_1692 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.005136
K_1693 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.007246
K_1694 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.007411
K_1695 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.007338
K_1696 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.007173
K_1697 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.003589
K_1698 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.003567
K_1699 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.003594
K_1700 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.003540
K_1701 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.008687
K_1702 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.008471
K_1703 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.008418
K_1704 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.008356
K_1705 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.004425
K_1706 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.004444
K_1707 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.004442
K_1708 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.004363
K_1709 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.004341
K_1710 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.004294
K_1711 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.004312
K_1712 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.004255
K_1713 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.005772
K_1714 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.005762
K_1715 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.005718
K_1716 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.005632
K_1717 X_NUC_30.L_CORE X_NUC_65.L_CORE 0.004147
K_1718 X_NUC_30.L_CORE X_NUC_66.L_CORE 0.004181
K_1719 X_NUC_30.L_CORE X_NUC_67.L_CORE 0.009148
K_1720 X_NUC_30.L_CORE X_NUC_68.L_CORE 0.003202
K_1721 X_NUC_30.L_CORE X_NUC_69.L_CORE 0.007091
K_1722 X_NUC_30.L_CORE X_NUC_70.L_CORE 0.004562
K_1723 X_NUC_30.L_CORE X_NUC_71.L_CORE 0.003439
K_1724 X_NUC_30.L_CORE X_NUC_72.L_CORE 0.007855
K_1725 X_NUC_30.L_CORE X_NUC_73.L_CORE 0.003754
K_1726 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_1727 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.003707
K_1728 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.003712
K_1729 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.003740
K_1730 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.003674
K_1731 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.005169
K_1732 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.005058
K_1733 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.005124
K_1734 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.005070
K_1735 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.007312
K_1736 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.007477
K_1737 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.007411
K_1738 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.007237
K_1739 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.003561
K_1740 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.003539
K_1741 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.003567
K_1742 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.003513
K_1743 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.008736
K_1744 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.008509
K_1745 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.008471
K_1746 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.008400
K_1747 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.004425
K_1748 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.004444
K_1749 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.004444
K_1750 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.004364
K_1751 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.004322
K_1752 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.004274
K_1753 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.004294
K_1754 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.004237
K_1755 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.005815
K_1756 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.005803
K_1757 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.005762
K_1758 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.005673
K_1759 X_NUC_31.L_CORE X_NUC_65.L_CORE 0.004082
K_1760 X_NUC_31.L_CORE X_NUC_66.L_CORE 0.004103
K_1761 X_NUC_31.L_CORE X_NUC_67.L_CORE 0.009045
K_1762 X_NUC_31.L_CORE X_NUC_68.L_CORE 0.003170
K_1763 X_NUC_31.L_CORE X_NUC_69.L_CORE 0.006987
K_1764 X_NUC_31.L_CORE X_NUC_70.L_CORE 0.004566
K_1765 X_NUC_31.L_CORE X_NUC_71.L_CORE 0.003413
K_1766 X_NUC_31.L_CORE X_NUC_72.L_CORE 0.008048
K_1767 X_NUC_31.L_CORE X_NUC_73.L_CORE 0.003756
K_1768 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.003774
K_1769 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.003779
K_1770 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.003808
K_1771 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.003740
K_1772 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.005225
K_1773 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.005110
K_1774 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.005177
K_1775 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.005124
K_1776 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.007487
K_1777 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.007665
K_1778 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.007589
K_1779 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.007411
K_1780 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.003617
K_1781 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.003594
K_1782 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.003623
K_1783 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.003567
K_1784 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.008807
K_1785 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.008575
K_1786 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.008528
K_1787 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.008471
K_1788 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.004508
K_1789 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.004528
K_1790 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.004527
K_1791 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.004444
K_1792 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.004382
K_1793 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.004332
K_1794 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.004351
K_1795 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.004294
K_1796 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.005909
K_1797 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.005897
K_1798 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.005851
K_1799 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.005762
K_1800 X_NUC_32.L_CORE X_NUC_65.L_CORE 0.004147
K_1801 X_NUC_32.L_CORE X_NUC_66.L_CORE 0.004147
K_1802 X_NUC_32.L_CORE X_NUC_67.L_CORE 0.009177
K_1803 X_NUC_32.L_CORE X_NUC_68.L_CORE 0.003217
K_1804 X_NUC_32.L_CORE X_NUC_69.L_CORE 0.006977
K_1805 X_NUC_32.L_CORE X_NUC_70.L_CORE 0.004648
K_1806 X_NUC_32.L_CORE X_NUC_71.L_CORE 0.003454
K_1807 X_NUC_32.L_CORE X_NUC_72.L_CORE 0.008080
K_1808 X_NUC_32.L_CORE X_NUC_73.L_CORE 0.003810
K_1809 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_1810 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_1811 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_1812 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.003770
K_1813 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.003721
K_1814 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.003719
K_1815 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.003765
K_1816 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.005205
K_1817 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.005250
K_1818 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.005150
K_1819 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.005270
K_1820 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.007550
K_1821 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.007309
K_1822 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.007335
K_1823 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.007365
K_1824 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.003699
K_1825 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.003676
K_1826 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.003646
K_1827 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.003705
K_1828 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.008389
K_1829 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.008461
K_1830 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.008148
K_1831 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.008346
K_1832 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.004701
K_1833 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.004630
K_1834 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.004601
K_1835 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.004656
K_1836 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.004699
K_1837 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.004683
K_1838 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.004606
K_1839 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.004688
K_1840 X_NUC_33.L_CORE X_NUC_65.L_CORE 0.005621
K_1841 X_NUC_33.L_CORE X_NUC_66.L_CORE 0.003766
K_1842 X_NUC_33.L_CORE X_NUC_67.L_CORE 0.003977
K_1843 X_NUC_33.L_CORE X_NUC_68.L_CORE 0.009621
K_1844 X_NUC_33.L_CORE X_NUC_69.L_CORE 0.003152
K_1845 X_NUC_33.L_CORE X_NUC_70.L_CORE 0.007035
K_1846 X_NUC_33.L_CORE X_NUC_71.L_CORE 0.004626
K_1847 X_NUC_33.L_CORE X_NUC_72.L_CORE 0.003613
K_1848 X_NUC_33.L_CORE X_NUC_73.L_CORE 0.006216
K_1849 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_1850 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_1851 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.003819
K_1852 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.003770
K_1853 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.003767
K_1854 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.003815
K_1855 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.005158
K_1856 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.005205
K_1857 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.005106
K_1858 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.005223
K_1859 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.007806
K_1860 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.007550
K_1861 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.007574
K_1862 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.007607
K_1863 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.003720
K_1864 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.003699
K_1865 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.003668
K_1866 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.003727
K_1867 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.008306
K_1868 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.008389
K_1869 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.008077
K_1870 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.008271
K_1871 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.004773
K_1872 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.004701
K_1873 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.004669
K_1874 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.004727
K_1875 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.004712
K_1876 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.004699
K_1877 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.004620
K_1878 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.004703
K_1879 X_NUC_34.L_CORE X_NUC_65.L_CORE 0.005624
K_1880 X_NUC_34.L_CORE X_NUC_66.L_CORE 0.003815
K_1881 X_NUC_34.L_CORE X_NUC_67.L_CORE 0.003959
K_1882 X_NUC_34.L_CORE X_NUC_68.L_CORE 0.009996
K_1883 X_NUC_34.L_CORE X_NUC_69.L_CORE 0.003177
K_1884 X_NUC_34.L_CORE X_NUC_70.L_CORE 0.006866
K_1885 X_NUC_34.L_CORE X_NUC_71.L_CORE 0.004722
K_1886 X_NUC_34.L_CORE X_NUC_72.L_CORE 0.003618
K_1887 X_NUC_34.L_CORE X_NUC_73.L_CORE 0.006247
K_1888 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_1889 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.003822
K_1890 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.003771
K_1891 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.003770
K_1892 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.003817
K_1893 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.005258
K_1894 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.005306
K_1895 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.005205
K_1896 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.005327
K_1897 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.007773
K_1898 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.007516
K_1899 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.007550
K_1900 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.007577
K_1901 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.003752
K_1902 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.003730
K_1903 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.003699
K_1904 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.003759
K_1905 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.008639
K_1906 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.008725
K_1907 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.008389
K_1908 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.008599
K_1909 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.004806
K_1910 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.004731
K_1911 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.004701
K_1912 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.004759
K_1913 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.004794
K_1914 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.004778
K_1915 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.004699
K_1916 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.004784
K_1917 X_NUC_35.L_CORE X_NUC_65.L_CORE 0.005556
K_1918 X_NUC_35.L_CORE X_NUC_66.L_CORE 0.003785
K_1919 X_NUC_35.L_CORE X_NUC_67.L_CORE 0.003984
K_1920 X_NUC_35.L_CORE X_NUC_68.L_CORE 0.009572
K_1921 X_NUC_35.L_CORE X_NUC_69.L_CORE 0.003185
K_1922 X_NUC_35.L_CORE X_NUC_70.L_CORE 0.007060
K_1923 X_NUC_35.L_CORE X_NUC_71.L_CORE 0.004710
K_1924 X_NUC_35.L_CORE X_NUC_72.L_CORE 0.003662
K_1925 X_NUC_35.L_CORE X_NUC_73.L_CORE 0.006391
K_1926 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.003773
K_1927 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.003725
K_1928 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.003723
K_1929 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.003770
K_1930 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.005139
K_1931 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.005184
K_1932 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.005088
K_1933 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.005205
K_1934 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.007739
K_1935 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.007484
K_1936 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.007513
K_1937 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.007550
K_1938 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.003692
K_1939 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.003670
K_1940 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.003640
K_1941 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.003699
K_1942 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.008419
K_1943 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.008499
K_1944 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.008181
K_1945 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.008389
K_1946 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.004745
K_1947 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.004674
K_1948 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.004643
K_1949 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.004701
K_1950 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.004707
K_1951 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.004692
K_1952 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.004615
K_1953 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.004699
K_1954 X_NUC_36.L_CORE X_NUC_65.L_CORE 0.005497
K_1955 X_NUC_36.L_CORE X_NUC_66.L_CORE 0.003750
K_1956 X_NUC_36.L_CORE X_NUC_67.L_CORE 0.003916
K_1957 X_NUC_36.L_CORE X_NUC_68.L_CORE 0.009738
K_1958 X_NUC_36.L_CORE X_NUC_69.L_CORE 0.003143
K_1959 X_NUC_36.L_CORE X_NUC_70.L_CORE 0.006908
K_1960 X_NUC_36.L_CORE X_NUC_71.L_CORE 0.004684
K_1961 X_NUC_36.L_CORE X_NUC_72.L_CORE 0.003604
K_1962 X_NUC_36.L_CORE X_NUC_73.L_CORE 0.006320
K_1963 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_1964 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_1965 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_1966 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.003863
K_1967 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.003936
K_1968 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.003896
K_1969 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.003894
K_1970 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.005378
K_1971 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.005430
K_1972 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.005448
K_1973 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.005321
K_1974 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.007793
K_1975 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.008024
K_1976 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.007746
K_1977 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.007885
K_1978 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.003931
K_1979 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.003996
K_1980 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.003964
K_1981 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.003931
K_1982 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.008168
K_1983 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.008289
K_1984 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.008148
K_1985 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.007975
K_1986 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.005161
K_1987 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.005269
K_1988 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.005167
K_1989 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.005157
K_1990 X_NUC_37.L_CORE X_NUC_65.L_CORE 0.003571
K_1991 X_NUC_37.L_CORE X_NUC_66.L_CORE 0.006700
K_1992 X_NUC_37.L_CORE X_NUC_67.L_CORE 0.003684
K_1993 X_NUC_37.L_CORE X_NUC_68.L_CORE 0.003935
K_1994 X_NUC_37.L_CORE X_NUC_69.L_CORE 0.010397
K_1995 X_NUC_37.L_CORE X_NUC_70.L_CORE 0.003254
K_1996 X_NUC_37.L_CORE X_NUC_71.L_CORE 0.007042
K_1997 X_NUC_37.L_CORE X_NUC_72.L_CORE 0.004944
K_1998 X_NUC_37.L_CORE X_NUC_73.L_CORE 0.004126
K_1999 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_2000 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_2001 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.003793
K_2002 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.003863
K_2003 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.003825
K_2004 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.003823
K_2005 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.005324
K_2006 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.005378
K_2007 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.005394
K_2008 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.005271
K_2009 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.007571
K_2010 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.007793
K_2011 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.007533
K_2012 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.007660
K_2013 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.003868
K_2014 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.003931
K_2015 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.003900
K_2016 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.003869
K_2017 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.008039
K_2018 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.008168
K_2019 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.008026
K_2020 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.007861
K_2021 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.005056
K_2022 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.005161
K_2023 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.005064
K_2024 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.005055
K_2025 X_NUC_38.L_CORE X_NUC_65.L_CORE 0.003531
K_2026 X_NUC_38.L_CORE X_NUC_66.L_CORE 0.006699
K_2027 X_NUC_38.L_CORE X_NUC_67.L_CORE 0.003625
K_2028 X_NUC_38.L_CORE X_NUC_68.L_CORE 0.003904
K_2029 X_NUC_38.L_CORE X_NUC_69.L_CORE 0.010237
K_2030 X_NUC_38.L_CORE X_NUC_70.L_CORE 0.003206
K_2031 X_NUC_38.L_CORE X_NUC_71.L_CORE 0.007050
K_2032 X_NUC_38.L_CORE X_NUC_72.L_CORE 0.004849
K_2033 X_NUC_38.L_CORE X_NUC_73.L_CORE 0.004072
K_2034 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_2035 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.003830
K_2036 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.003901
K_2037 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.003863
K_2038 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.003860
K_2039 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.005307
K_2040 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.005359
K_2041 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.005378
K_2042 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.005255
K_2043 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.007830
K_2044 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.008070
K_2045 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.007793
K_2046 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.007929
K_2047 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.003898
K_2048 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.003961
K_2049 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.003931
K_2050 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.003899
K_2051 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.008175
K_2052 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.008304
K_2053 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.008168
K_2054 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.007988
K_2055 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.005152
K_2056 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.005261
K_2057 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.005161
K_2058 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.005150
K_2059 X_NUC_39.L_CORE X_NUC_65.L_CORE 0.003512
K_2060 X_NUC_39.L_CORE X_NUC_66.L_CORE 0.006525
K_2061 X_NUC_39.L_CORE X_NUC_67.L_CORE 0.003642
K_2062 X_NUC_39.L_CORE X_NUC_68.L_CORE 0.003874
K_2063 X_NUC_39.L_CORE X_NUC_69.L_CORE 0.010452
K_2064 X_NUC_39.L_CORE X_NUC_70.L_CORE 0.003224
K_2065 X_NUC_39.L_CORE X_NUC_71.L_CORE 0.006996
K_2066 X_NUC_39.L_CORE X_NUC_72.L_CORE 0.004952
K_2067 X_NUC_39.L_CORE X_NUC_73.L_CORE 0.004108
K_2068 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.003832
K_2069 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.003903
K_2070 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.003865
K_2071 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.003863
K_2072 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.005433
K_2073 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.005488
K_2074 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.005507
K_2075 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.005378
K_2076 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.007694
K_2077 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.007922
K_2078 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.007654
K_2079 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.007793
K_2080 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.003930
K_2081 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.003995
K_2082 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.003963
K_2083 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.003931
K_2084 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.008361
K_2085 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.008499
K_2086 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.008346
K_2087 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.008168
K_2088 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.005161
K_2089 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.005271
K_2090 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.005169
K_2091 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.005161
K_2092 X_NUC_40.L_CORE X_NUC_65.L_CORE 0.003535
K_2093 X_NUC_40.L_CORE X_NUC_66.L_CORE 0.006591
K_2094 X_NUC_40.L_CORE X_NUC_67.L_CORE 0.003632
K_2095 X_NUC_40.L_CORE X_NUC_68.L_CORE 0.003938
K_2096 X_NUC_40.L_CORE X_NUC_69.L_CORE 0.009997
K_2097 X_NUC_40.L_CORE X_NUC_70.L_CORE 0.003239
K_2098 X_NUC_40.L_CORE X_NUC_71.L_CORE 0.007223
K_2099 X_NUC_40.L_CORE X_NUC_72.L_CORE 0.004912
K_2100 X_NUC_40.L_CORE X_NUC_73.L_CORE 0.004151
K_2101 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_2102 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_2103 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_2104 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.004036
K_2105 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.003977
K_2106 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.004027
K_2107 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.003977
K_2108 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.005673
K_2109 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.005537
K_2110 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.005553
K_2111 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.005610
K_2112 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.008157
K_2113 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.008048
K_2114 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.008133
K_2115 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.007880
K_2116 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.004339
K_2117 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.004258
K_2118 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.004290
K_2119 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.004267
K_2120 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.007536
K_2121 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.007339
K_2122 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.007318
K_2123 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.007305
K_2124 X_NUC_41.L_CORE X_NUC_65.L_CORE 0.004257
K_2125 X_NUC_41.L_CORE X_NUC_66.L_CORE 0.003251
K_2126 X_NUC_41.L_CORE X_NUC_67.L_CORE 0.007556
K_2127 X_NUC_41.L_CORE X_NUC_68.L_CORE 0.003626
K_2128 X_NUC_41.L_CORE X_NUC_69.L_CORE 0.003950
K_2129 X_NUC_41.L_CORE X_NUC_70.L_CORE 0.011054
K_2130 X_NUC_41.L_CORE X_NUC_71.L_CORE 0.003388
K_2131 X_NUC_41.L_CORE X_NUC_72.L_CORE 0.007139
K_2132 X_NUC_41.L_CORE X_NUC_73.L_CORE 0.005277
K_2133 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_2134 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_2135 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.004095
K_2136 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.004036
K_2137 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.004087
K_2138 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.004035
K_2139 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.005815
K_2140 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.005673
K_2141 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.005688
K_2142 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.005750
K_2143 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.008258
K_2144 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.008157
K_2145 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.008239
K_2146 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.007977
K_2147 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.004423
K_2148 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.004339
K_2149 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.004372
K_2150 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.004348
K_2151 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.007740
K_2152 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.007536
K_2153 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.007509
K_2154 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.007495
K_2155 X_NUC_42.L_CORE X_NUC_65.L_CORE 0.004284
K_2156 X_NUC_42.L_CORE X_NUC_66.L_CORE 0.003295
K_2157 X_NUC_42.L_CORE X_NUC_67.L_CORE 0.007574
K_2158 X_NUC_42.L_CORE X_NUC_68.L_CORE 0.003661
K_2159 X_NUC_42.L_CORE X_NUC_69.L_CORE 0.004019
K_2160 X_NUC_42.L_CORE X_NUC_70.L_CORE 0.010818
K_2161 X_NUC_42.L_CORE X_NUC_71.L_CORE 0.003439
K_2162 X_NUC_42.L_CORE X_NUC_72.L_CORE 0.007300
K_2163 X_NUC_42.L_CORE X_NUC_73.L_CORE 0.005345
K_2164 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_2165 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.004043
K_2166 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.003985
K_2167 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.004036
K_2168 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.003985
K_2169 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.005797
K_2170 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.005654
K_2171 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.005673
K_2172 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.005732
K_2173 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.008169
K_2174 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.008065
K_2175 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.008157
K_2176 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.007896
K_2177 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.004389
K_2178 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.004305
K_2179 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.004339
K_2180 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.004315
K_2181 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.007765
K_2182 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.007554
K_2183 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.007536
K_2184 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.007517
K_2185 X_NUC_43.L_CORE X_NUC_65.L_CORE 0.004201
K_2186 X_NUC_43.L_CORE X_NUC_66.L_CORE 0.003251
K_2187 X_NUC_43.L_CORE X_NUC_67.L_CORE 0.007444
K_2188 X_NUC_43.L_CORE X_NUC_68.L_CORE 0.003605
K_2189 X_NUC_43.L_CORE X_NUC_69.L_CORE 0.003989
K_2190 X_NUC_43.L_CORE X_NUC_70.L_CORE 0.010656
K_2191 X_NUC_43.L_CORE X_NUC_71.L_CORE 0.003406
K_2192 X_NUC_43.L_CORE X_NUC_72.L_CORE 0.007384
K_2193 X_NUC_43.L_CORE X_NUC_73.L_CORE 0.005324
K_2194 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.004095
K_2195 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.004035
K_2196 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.004087
K_2197 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.004036
K_2198 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.005734
K_2199 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.005595
K_2200 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.005612
K_2201 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.005673
K_2202 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.008452
K_2203 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.008337
K_2204 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.008432
K_2205 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.008157
K_2206 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.004413
K_2207 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.004329
K_2208 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.004362
K_2209 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.004339
K_2210 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.007781
K_2211 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.007569
K_2212 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.007546
K_2213 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.007536
K_2214 X_NUC_44.L_CORE X_NUC_65.L_CORE 0.004238
K_2215 X_NUC_44.L_CORE X_NUC_66.L_CORE 0.003257
K_2216 X_NUC_44.L_CORE X_NUC_67.L_CORE 0.007340
K_2217 X_NUC_44.L_CORE X_NUC_68.L_CORE 0.003655
K_2218 X_NUC_44.L_CORE X_NUC_69.L_CORE 0.003960
K_2219 X_NUC_44.L_CORE X_NUC_70.L_CORE 0.011176
K_2220 X_NUC_44.L_CORE X_NUC_71.L_CORE 0.003430
K_2221 X_NUC_44.L_CORE X_NUC_72.L_CORE 0.007239
K_2222 X_NUC_44.L_CORE X_NUC_73.L_CORE 0.005412
K_2223 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_2224 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_2225 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_2226 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.004321
K_2227 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.004332
K_2228 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.004278
K_2229 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.004366
K_2230 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.006154
K_2231 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.006323
K_2232 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.006173
K_2233 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.006240
K_2234 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.008642
K_2235 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.008565
K_2236 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.008343
K_2237 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.008637
K_2238 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.005204
K_2239 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.005264
K_2240 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.005147
K_2241 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.005251
K_2242 X_NUC_45.L_CORE X_NUC_65.L_CORE 0.003990
K_2243 X_NUC_45.L_CORE X_NUC_66.L_CORE 0.004430
K_2244 X_NUC_45.L_CORE X_NUC_67.L_CORE 0.003221
K_2245 X_NUC_45.L_CORE X_NUC_68.L_CORE 0.008428
K_2246 X_NUC_45.L_CORE X_NUC_69.L_CORE 0.003740
K_2247 X_NUC_45.L_CORE X_NUC_70.L_CORE 0.004219
K_2248 X_NUC_45.L_CORE X_NUC_71.L_CORE 0.011442
K_2249 X_NUC_45.L_CORE X_NUC_72.L_CORE 0.003809
K_2250 X_NUC_45.L_CORE X_NUC_73.L_CORE 0.007294
K_2251 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_2252 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_2253 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.004309
K_2254 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.004321
K_2255 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.004267
K_2256 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.004355
K_2257 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.005992
K_2258 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.006154
K_2259 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.006012
K_2260 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.006074
K_2261 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.008706
K_2262 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.008642
K_2263 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.008407
K_2264 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.008708
K_2265 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.005142
K_2266 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.005204
K_2267 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.005089
K_2268 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.005189
K_2269 X_NUC_46.L_CORE X_NUC_65.L_CORE 0.003955
K_2270 X_NUC_46.L_CORE X_NUC_66.L_CORE 0.004460
K_2271 X_NUC_46.L_CORE X_NUC_67.L_CORE 0.003193
K_2272 X_NUC_46.L_CORE X_NUC_68.L_CORE 0.008322
K_2273 X_NUC_46.L_CORE X_NUC_69.L_CORE 0.003750
K_2274 X_NUC_46.L_CORE X_NUC_70.L_CORE 0.004140
K_2275 X_NUC_46.L_CORE X_NUC_71.L_CORE 0.012026
K_2276 X_NUC_46.L_CORE X_NUC_72.L_CORE 0.003783
K_2277 X_NUC_46.L_CORE X_NUC_73.L_CORE 0.007126
K_2278 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_2279 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.004365
K_2280 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.004377
K_2281 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.004321
K_2282 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.004412
K_2283 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.006130
K_2284 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.006300
K_2285 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.006154
K_2286 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.006217
K_2287 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.008960
K_2288 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.008882
K_2289 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.008642
K_2290 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.008962
K_2291 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.005259
K_2292 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.005323
K_2293 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.005204
K_2294 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.005310
K_2295 X_NUC_47.L_CORE X_NUC_65.L_CORE 0.003936
K_2296 X_NUC_47.L_CORE X_NUC_66.L_CORE 0.004417
K_2297 X_NUC_47.L_CORE X_NUC_67.L_CORE 0.003208
K_2298 X_NUC_47.L_CORE X_NUC_68.L_CORE 0.008109
K_2299 X_NUC_47.L_CORE X_NUC_69.L_CORE 0.003766
K_2300 X_NUC_47.L_CORE X_NUC_70.L_CORE 0.004186
K_2301 X_NUC_47.L_CORE X_NUC_71.L_CORE 0.011951
K_2302 X_NUC_47.L_CORE X_NUC_72.L_CORE 0.003838
K_2303 X_NUC_47.L_CORE X_NUC_73.L_CORE 0.007369
K_2304 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.004276
K_2305 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.004287
K_2306 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.004234
K_2307 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.004321
K_2308 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.006066
K_2309 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.006231
K_2310 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.006087
K_2311 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.006154
K_2312 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.008633
K_2313 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.008564
K_2314 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.008341
K_2315 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.008642
K_2316 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.005155
K_2317 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.005215
K_2318 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.005101
K_2319 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.005204
K_2320 X_NUC_48.L_CORE X_NUC_65.L_CORE 0.003919
K_2321 X_NUC_48.L_CORE X_NUC_66.L_CORE 0.004368
K_2322 X_NUC_48.L_CORE X_NUC_67.L_CORE 0.003175
K_2323 X_NUC_48.L_CORE X_NUC_68.L_CORE 0.008251
K_2324 X_NUC_48.L_CORE X_NUC_69.L_CORE 0.003702
K_2325 X_NUC_48.L_CORE X_NUC_70.L_CORE 0.004159
K_2326 X_NUC_48.L_CORE X_NUC_71.L_CORE 0.011662
K_2327 X_NUC_48.L_CORE X_NUC_72.L_CORE 0.003775
K_2328 X_NUC_48.L_CORE X_NUC_73.L_CORE 0.007289
K_2329 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_2330 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_2331 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_2332 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.004799
K_2333 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.004861
K_2334 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.004869
K_2335 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.004777
K_2336 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.006968
K_2337 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.006881
K_2338 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.006986
K_2339 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.006783
K_2340 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.009039
K_2341 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.009255
K_2342 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.009139
K_2343 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.008875
K_2344 X_NUC_49.L_CORE X_NUC_65.L_CORE 0.003316
K_2345 X_NUC_49.L_CORE X_NUC_66.L_CORE 0.004077
K_2346 X_NUC_49.L_CORE X_NUC_67.L_CORE 0.004643
K_2347 X_NUC_49.L_CORE X_NUC_68.L_CORE 0.003265
K_2348 X_NUC_49.L_CORE X_NUC_69.L_CORE 0.009072
K_2349 X_NUC_49.L_CORE X_NUC_70.L_CORE 0.004014
K_2350 X_NUC_49.L_CORE X_NUC_71.L_CORE 0.004543
K_2351 X_NUC_49.L_CORE X_NUC_72.L_CORE 0.012941
K_2352 X_NUC_49.L_CORE X_NUC_73.L_CORE 0.004743
K_2353 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_2354 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_2355 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.004736
K_2356 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.004799
K_2357 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.004805
K_2358 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.004716
K_2359 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.007050
K_2360 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.006968
K_2361 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.007072
K_2362 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.006863
K_2363 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.008822
K_2364 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.009039
K_2365 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.008923
K_2366 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.008677
K_2367 X_NUC_50.L_CORE X_NUC_65.L_CORE 0.003301
K_2368 X_NUC_50.L_CORE X_NUC_66.L_CORE 0.004110
K_2369 X_NUC_50.L_CORE X_NUC_67.L_CORE 0.004572
K_2370 X_NUC_50.L_CORE X_NUC_68.L_CORE 0.003263
K_2371 X_NUC_50.L_CORE X_NUC_69.L_CORE 0.009331
K_2372 X_NUC_50.L_CORE X_NUC_70.L_CORE 0.003954
K_2373 X_NUC_50.L_CORE X_NUC_71.L_CORE 0.004591
K_2374 X_NUC_50.L_CORE X_NUC_72.L_CORE 0.012271
K_2375 X_NUC_50.L_CORE X_NUC_73.L_CORE 0.004711
K_2376 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_2377 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.004729
K_2378 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.004790
K_2379 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.004799
K_2380 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.004709
K_2381 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.006943
K_2382 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.006861
K_2383 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.006968
K_2384 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.006764
K_2385 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.008926
K_2386 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.009143
K_2387 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.009039
K_2388 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.008776
K_2389 X_NUC_51.L_CORE X_NUC_65.L_CORE 0.003266
K_2390 X_NUC_51.L_CORE X_NUC_66.L_CORE 0.004031
K_2391 X_NUC_51.L_CORE X_NUC_67.L_CORE 0.004552
K_2392 X_NUC_51.L_CORE X_NUC_68.L_CORE 0.003227
K_2393 X_NUC_51.L_CORE X_NUC_69.L_CORE 0.009042
K_2394 X_NUC_51.L_CORE X_NUC_70.L_CORE 0.003952
K_2395 X_NUC_51.L_CORE X_NUC_71.L_CORE 0.004522
K_2396 X_NUC_51.L_CORE X_NUC_72.L_CORE 0.012886
K_2397 X_NUC_51.L_CORE X_NUC_73.L_CORE 0.004706
K_2398 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.004818
K_2399 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.004883
K_2400 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.004891
K_2401 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.004799
K_2402 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.007160
K_2403 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.007070
K_2404 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.007183
K_2405 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.006968
K_2406 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.009195
K_2407 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.009431
K_2408 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.009309
K_2409 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.009039
K_2410 X_NUC_52.L_CORE X_NUC_65.L_CORE 0.003295
K_2411 X_NUC_52.L_CORE X_NUC_66.L_CORE 0.004066
K_2412 X_NUC_52.L_CORE X_NUC_67.L_CORE 0.004559
K_2413 X_NUC_52.L_CORE X_NUC_68.L_CORE 0.003274
K_2414 X_NUC_52.L_CORE X_NUC_69.L_CORE 0.008944
K_2415 X_NUC_52.L_CORE X_NUC_70.L_CORE 0.003998
K_2416 X_NUC_52.L_CORE X_NUC_71.L_CORE 0.004610
K_2417 X_NUC_52.L_CORE X_NUC_72.L_CORE 0.012794
K_2418 X_NUC_52.L_CORE X_NUC_73.L_CORE 0.004803
K_2419 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_2420 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_2421 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_2422 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.005681
K_2423 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.005534
K_2424 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.005577
K_2425 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.005612
K_2426 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.008541
K_2427 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.008367
K_2428 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.008245
K_2429 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.008515
K_2430 X_NUC_53.L_CORE X_NUC_65.L_CORE 0.003940
K_2431 X_NUC_53.L_CORE X_NUC_66.L_CORE 0.003204
K_2432 X_NUC_53.L_CORE X_NUC_67.L_CORE 0.004240
K_2433 X_NUC_53.L_CORE X_NUC_68.L_CORE 0.004792
K_2434 X_NUC_53.L_CORE X_NUC_69.L_CORE 0.003432
K_2435 X_NUC_53.L_CORE X_NUC_70.L_CORE 0.010283
K_2436 X_NUC_53.L_CORE X_NUC_71.L_CORE 0.004404
K_2437 X_NUC_53.L_CORE X_NUC_72.L_CORE 0.005324
K_2438 X_NUC_53.L_CORE X_NUC_73.L_CORE 0.012132
K_2439 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_2440 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_2441 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.005834
K_2442 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.005681
K_2443 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.005724
K_2444 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.005762
K_2445 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.008710
K_2446 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.008541
K_2447 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.008403
K_2448 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.008690
K_2449 X_NUC_54.L_CORE X_NUC_65.L_CORE 0.003949
K_2450 X_NUC_54.L_CORE X_NUC_66.L_CORE 0.003239
K_2451 X_NUC_54.L_CORE X_NUC_67.L_CORE 0.004228
K_2452 X_NUC_54.L_CORE X_NUC_68.L_CORE 0.004851
K_2453 X_NUC_54.L_CORE X_NUC_69.L_CORE 0.003469
K_2454 X_NUC_54.L_CORE X_NUC_70.L_CORE 0.009899
K_2455 X_NUC_54.L_CORE X_NUC_71.L_CORE 0.004498
K_2456 X_NUC_54.L_CORE X_NUC_72.L_CORE 0.005360
K_2457 X_NUC_54.L_CORE X_NUC_73.L_CORE 0.012625
K_2458 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_2459 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.005786
K_2460 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.005634
K_2461 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.005681
K_2462 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.005716
K_2463 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.008855
K_2464 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.008670
K_2465 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.008541
K_2466 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.008834
K_2467 X_NUC_55.L_CORE X_NUC_65.L_CORE 0.003893
K_2468 X_NUC_55.L_CORE X_NUC_66.L_CORE 0.003202
K_2469 X_NUC_55.L_CORE X_NUC_67.L_CORE 0.004217
K_2470 X_NUC_55.L_CORE X_NUC_68.L_CORE 0.004740
K_2471 X_NUC_55.L_CORE X_NUC_69.L_CORE 0.003456
K_2472 X_NUC_55.L_CORE X_NUC_70.L_CORE 0.009928
K_2473 X_NUC_55.L_CORE X_NUC_71.L_CORE 0.004440
K_2474 X_NUC_55.L_CORE X_NUC_72.L_CORE 0.005418
K_2475 X_NUC_55.L_CORE X_NUC_73.L_CORE 0.012669
K_2476 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.005747
K_2477 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.005598
K_2478 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.005642
K_2479 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.005681
K_2480 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.008552
K_2481 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.008385
K_2482 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.008261
K_2483 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.008541
K_2484 X_NUC_56.L_CORE X_NUC_65.L_CORE 0.003893
K_2485 X_NUC_56.L_CORE X_NUC_66.L_CORE 0.003193
K_2486 X_NUC_56.L_CORE X_NUC_67.L_CORE 0.004162
K_2487 X_NUC_56.L_CORE X_NUC_68.L_CORE 0.004799
K_2488 X_NUC_56.L_CORE X_NUC_69.L_CORE 0.003417
K_2489 X_NUC_56.L_CORE X_NUC_70.L_CORE 0.009838
K_2490 X_NUC_56.L_CORE X_NUC_71.L_CORE 0.004449
K_2491 X_NUC_56.L_CORE X_NUC_72.L_CORE 0.005286
K_2492 X_NUC_56.L_CORE X_NUC_73.L_CORE 0.012830
K_2493 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.207973
K_2494 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.207973
K_2495 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.207973
K_2496 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.007918
K_2497 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.008195
K_2498 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.007952
K_2499 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.008086
K_2500 X_NUC_57.L_CORE X_NUC_65.L_CORE 0.003280
K_2501 X_NUC_57.L_CORE X_NUC_66.L_CORE 0.004221
K_2502 X_NUC_57.L_CORE X_NUC_67.L_CORE 0.003337
K_2503 X_NUC_57.L_CORE X_NUC_68.L_CORE 0.004448
K_2504 X_NUC_57.L_CORE X_NUC_69.L_CORE 0.005116
K_2505 X_NUC_57.L_CORE X_NUC_70.L_CORE 0.003875
K_2506 X_NUC_57.L_CORE X_NUC_71.L_CORE 0.010867
K_2507 X_NUC_57.L_CORE X_NUC_72.L_CORE 0.005486
K_2508 X_NUC_57.L_CORE X_NUC_73.L_CORE 0.007487
K_2509 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.207973
K_2510 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.207973
K_2511 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.007656
K_2512 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.007918
K_2513 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.007693
K_2514 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.007814
K_2515 X_NUC_58.L_CORE X_NUC_65.L_CORE 0.003257
K_2516 X_NUC_58.L_CORE X_NUC_66.L_CORE 0.004238
K_2517 X_NUC_58.L_CORE X_NUC_67.L_CORE 0.003302
K_2518 X_NUC_58.L_CORE X_NUC_68.L_CORE 0.004423
K_2519 X_NUC_58.L_CORE X_NUC_69.L_CORE 0.005127
K_2520 X_NUC_58.L_CORE X_NUC_70.L_CORE 0.003807
K_2521 X_NUC_58.L_CORE X_NUC_71.L_CORE 0.011207
K_2522 X_NUC_58.L_CORE X_NUC_72.L_CORE 0.005392
K_2523 X_NUC_58.L_CORE X_NUC_73.L_CORE 0.007264
K_2524 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.207973
K_2525 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.007872
K_2526 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.008151
K_2527 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.007918
K_2528 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.008044
K_2529 X_NUC_59.L_CORE X_NUC_65.L_CORE 0.003233
K_2530 X_NUC_59.L_CORE X_NUC_66.L_CORE 0.004174
K_2531 X_NUC_59.L_CORE X_NUC_67.L_CORE 0.003306
K_2532 X_NUC_59.L_CORE X_NUC_68.L_CORE 0.004359
K_2533 X_NUC_59.L_CORE X_NUC_69.L_CORE 0.005119
K_2534 X_NUC_59.L_CORE X_NUC_70.L_CORE 0.003823
K_2535 X_NUC_59.L_CORE X_NUC_71.L_CORE 0.010668
K_2536 X_NUC_59.L_CORE X_NUC_72.L_CORE 0.005493
K_2537 X_NUC_59.L_CORE X_NUC_73.L_CORE 0.007369
K_2538 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.007749
K_2539 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.008014
K_2540 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.007787
K_2541 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.007918
K_2542 X_NUC_60.L_CORE X_NUC_65.L_CORE 0.003240
K_2543 X_NUC_60.L_CORE X_NUC_66.L_CORE 0.004167
K_2544 X_NUC_60.L_CORE X_NUC_67.L_CORE 0.003286
K_2545 X_NUC_60.L_CORE X_NUC_68.L_CORE 0.004421
K_2546 X_NUC_60.L_CORE X_NUC_69.L_CORE 0.005021
K_2547 X_NUC_60.L_CORE X_NUC_70.L_CORE 0.003829
K_2548 X_NUC_60.L_CORE X_NUC_71.L_CORE 0.011059
K_2549 X_NUC_60.L_CORE X_NUC_72.L_CORE 0.005386
K_2550 X_NUC_60.L_CORE X_NUC_73.L_CORE 0.007483
K_2551 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.207973
K_2552 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.207973
K_2553 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.207973
K_2554 X_NUC_61.L_CORE X_NUC_65.L_CORE 0.003291
K_2555 X_NUC_61.L_CORE X_NUC_66.L_CORE 0.003345
K_2556 X_NUC_61.L_CORE X_NUC_67.L_CORE 0.004253
K_2557 X_NUC_61.L_CORE X_NUC_68.L_CORE 0.003638
K_2558 X_NUC_61.L_CORE X_NUC_69.L_CORE 0.004672
K_2559 X_NUC_61.L_CORE X_NUC_70.L_CORE 0.005564
K_2560 X_NUC_61.L_CORE X_NUC_71.L_CORE 0.004712
K_2561 X_NUC_61.L_CORE X_NUC_72.L_CORE 0.011628
K_2562 X_NUC_61.L_CORE X_NUC_73.L_CORE 0.008777
K_2563 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.207973
K_2564 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.207973
K_2565 X_NUC_62.L_CORE X_NUC_65.L_CORE 0.003286
K_2566 X_NUC_62.L_CORE X_NUC_66.L_CORE 0.003374
K_2567 X_NUC_62.L_CORE X_NUC_67.L_CORE 0.004220
K_2568 X_NUC_62.L_CORE X_NUC_68.L_CORE 0.003650
K_2569 X_NUC_62.L_CORE X_NUC_69.L_CORE 0.004737
K_2570 X_NUC_62.L_CORE X_NUC_70.L_CORE 0.005456
K_2571 X_NUC_62.L_CORE X_NUC_71.L_CORE 0.004798
K_2572 X_NUC_62.L_CORE X_NUC_72.L_CORE 0.011563
K_2573 X_NUC_62.L_CORE X_NUC_73.L_CORE 0.008766
K_2574 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.207973
K_2575 X_NUC_63.L_CORE X_NUC_65.L_CORE 0.003246
K_2576 X_NUC_63.L_CORE X_NUC_66.L_CORE 0.003324
K_2577 X_NUC_63.L_CORE X_NUC_67.L_CORE 0.004193
K_2578 X_NUC_63.L_CORE X_NUC_68.L_CORE 0.003593
K_2579 X_NUC_63.L_CORE X_NUC_69.L_CORE 0.004682
K_2580 X_NUC_63.L_CORE X_NUC_70.L_CORE 0.005426
K_2581 X_NUC_63.L_CORE X_NUC_71.L_CORE 0.004704
K_2582 X_NUC_63.L_CORE X_NUC_72.L_CORE 0.011819
K_2583 X_NUC_63.L_CORE X_NUC_73.L_CORE 0.008640
K_2584 X_NUC_64.L_CORE X_NUC_65.L_CORE 0.003262
K_2585 X_NUC_64.L_CORE X_NUC_66.L_CORE 0.003330
K_2586 X_NUC_64.L_CORE X_NUC_67.L_CORE 0.004172
K_2587 X_NUC_64.L_CORE X_NUC_68.L_CORE 0.003640
K_2588 X_NUC_64.L_CORE X_NUC_69.L_CORE 0.004632
K_2589 X_NUC_64.L_CORE X_NUC_70.L_CORE 0.005486
K_2590 X_NUC_64.L_CORE X_NUC_71.L_CORE 0.004764
K_2591 X_NUC_64.L_CORE X_NUC_72.L_CORE 0.011203
K_2592 X_NUC_64.L_CORE X_NUC_73.L_CORE 0.009009
K_2593 X_NUC_65.L_CORE X_NUC_66.L_CORE 0.005005
K_2594 X_NUC_65.L_CORE X_NUC_67.L_CORE 0.005387
K_2595 X_NUC_65.L_CORE X_NUC_68.L_CORE 0.005579
K_2596 X_NUC_65.L_CORE X_NUC_69.L_CORE 0.003374
K_2597 X_NUC_65.L_CORE X_NUC_70.L_CORE 0.004486
K_2598 X_NUC_65.L_CORE X_NUC_71.L_CORE 0.003316
K_2599 X_NUC_65.L_CORE X_NUC_72.L_CORE 0.003072
K_2600 X_NUC_65.L_CORE X_NUC_73.L_CORE 0.003220
K_2601 X_NUC_66.L_CORE X_NUC_67.L_CORE 0.003716
K_2602 X_NUC_66.L_CORE X_NUC_68.L_CORE 0.004577
K_2603 X_NUC_66.L_CORE X_NUC_69.L_CORE 0.005497
K_2604 X_NUC_66.L_CORE X_NUC_70.L_CORE 0.002977
K_2605 X_NUC_66.L_CORE X_NUC_71.L_CORE 0.004747
K_2606 X_NUC_66.L_CORE X_NUC_72.L_CORE 0.003224
K_2607 X_NUC_66.L_CORE X_NUC_73.L_CORE 0.003072
K_2608 X_NUC_67.L_CORE X_NUC_68.L_CORE 0.003269
K_2609 X_NUC_67.L_CORE X_NUC_69.L_CORE 0.004233
K_2610 X_NUC_67.L_CORE X_NUC_70.L_CORE 0.005395
K_2611 X_NUC_67.L_CORE X_NUC_71.L_CORE 0.002882
K_2612 X_NUC_67.L_CORE X_NUC_72.L_CORE 0.004747
K_2613 X_NUC_67.L_CORE X_NUC_73.L_CORE 0.003316
K_2614 X_NUC_68.L_CORE X_NUC_69.L_CORE 0.003100
K_2615 X_NUC_68.L_CORE X_NUC_70.L_CORE 0.004134
K_2616 X_NUC_68.L_CORE X_NUC_71.L_CORE 0.005395
K_2617 X_NUC_68.L_CORE X_NUC_72.L_CORE 0.002977
K_2618 X_NUC_68.L_CORE X_NUC_73.L_CORE 0.004486
K_2619 X_NUC_69.L_CORE X_NUC_70.L_CORE 0.003100
K_2620 X_NUC_69.L_CORE X_NUC_71.L_CORE 0.004233
K_2621 X_NUC_69.L_CORE X_NUC_72.L_CORE 0.005497
K_2622 X_NUC_69.L_CORE X_NUC_73.L_CORE 0.003374
K_2623 X_NUC_70.L_CORE X_NUC_71.L_CORE 0.003269
K_2624 X_NUC_70.L_CORE X_NUC_72.L_CORE 0.004577
K_2625 X_NUC_70.L_CORE X_NUC_73.L_CORE 0.005579
K_2626 X_NUC_71.L_CORE X_NUC_72.L_CORE 0.003716
K_2627 X_NUC_71.L_CORE X_NUC_73.L_CORE 0.005387
K_2628 X_NUC_72.L_CORE X_NUC_73.L_CORE 0.005005

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
