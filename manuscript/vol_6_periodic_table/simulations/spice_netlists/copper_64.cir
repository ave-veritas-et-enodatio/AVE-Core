* Applied Vacuum Engineering (AVE) - SPICE Netlist
* Element: Copper-64 (Z=29, A=64)
* Auto-generated topological mutual impedance array
* Nodes: 64

* -----------------------------------------------------------------
* NUCLEON (Baseline 6^3_2 Topological Defect)
* -----------------------------------------------------------------
.SUBCKT NUCLEON IN OUT
L_CORE IN OUT 1uH
C_CORE IN OUT 1pF
.ENDS NUCLEON

* -----------------------------------------------------------------
* MACROSCOPIC TOPOLOGY (Nucleon Array)
* -----------------------------------------------------------------
V_STIM NODE_1 0 AC 1 PULSE(0 100k 10n 1n 1n 50n 100n)

X_NUC_1 NODE_1 0 NUCLEON
X_NUC_2 NODE_2 0 NUCLEON
X_NUC_3 NODE_3 0 NUCLEON
X_NUC_4 NODE_4 0 NUCLEON
X_NUC_5 NODE_5 0 NUCLEON
X_NUC_6 NODE_6 0 NUCLEON
X_NUC_7 NODE_7 0 NUCLEON
X_NUC_8 NODE_8 0 NUCLEON
X_NUC_9 NODE_9 0 NUCLEON
X_NUC_10 NODE_10 0 NUCLEON
X_NUC_11 NODE_11 0 NUCLEON
X_NUC_12 NODE_12 0 NUCLEON
X_NUC_13 NODE_13 0 NUCLEON
X_NUC_14 NODE_14 0 NUCLEON
X_NUC_15 NODE_15 0 NUCLEON
X_NUC_16 NODE_16 0 NUCLEON
X_NUC_17 NODE_17 0 NUCLEON
X_NUC_18 NODE_18 0 NUCLEON
X_NUC_19 NODE_19 0 NUCLEON
X_NUC_20 NODE_20 0 NUCLEON
X_NUC_21 NODE_21 0 NUCLEON
X_NUC_22 NODE_22 0 NUCLEON
X_NUC_23 NODE_23 0 NUCLEON
X_NUC_24 NODE_24 0 NUCLEON
X_NUC_25 NODE_25 0 NUCLEON
X_NUC_26 NODE_26 0 NUCLEON
X_NUC_27 NODE_27 0 NUCLEON
X_NUC_28 NODE_28 0 NUCLEON
X_NUC_29 NODE_29 0 NUCLEON
X_NUC_30 NODE_30 0 NUCLEON
X_NUC_31 NODE_31 0 NUCLEON
X_NUC_32 NODE_32 0 NUCLEON
X_NUC_33 NODE_33 0 NUCLEON
X_NUC_34 NODE_34 0 NUCLEON
X_NUC_35 NODE_35 0 NUCLEON
X_NUC_36 NODE_36 0 NUCLEON
X_NUC_37 NODE_37 0 NUCLEON
X_NUC_38 NODE_38 0 NUCLEON
X_NUC_39 NODE_39 0 NUCLEON
X_NUC_40 NODE_40 0 NUCLEON
X_NUC_41 NODE_41 0 NUCLEON
X_NUC_42 NODE_42 0 NUCLEON
X_NUC_43 NODE_43 0 NUCLEON
X_NUC_44 NODE_44 0 NUCLEON
X_NUC_45 NODE_45 0 NUCLEON
X_NUC_46 NODE_46 0 NUCLEON
X_NUC_47 NODE_47 0 NUCLEON
X_NUC_48 NODE_48 0 NUCLEON
X_NUC_49 NODE_49 0 NUCLEON
X_NUC_50 NODE_50 0 NUCLEON
X_NUC_51 NODE_51 0 NUCLEON
X_NUC_52 NODE_52 0 NUCLEON
X_NUC_53 NODE_53 0 NUCLEON
X_NUC_54 NODE_54 0 NUCLEON
X_NUC_55 NODE_55 0 NUCLEON
X_NUC_56 NODE_56 0 NUCLEON
X_NUC_57 NODE_57 0 NUCLEON
X_NUC_58 NODE_58 0 NUCLEON
X_NUC_59 NODE_59 0 NUCLEON
X_NUC_60 NODE_60 0 NUCLEON
X_NUC_61 NODE_61 0 NUCLEON
X_NUC_62 NODE_62 0 NUCLEON
X_NUC_63 NODE_63 0 NUCLEON
X_NUC_64 NODE_64 0 NUCLEON

* -----------------------------------------------------------------
* SPATIAL MUTUAL INDUCTANCE (K-FACTORS)
* -----------------------------------------------------------------
K_1 X_NUC_1.L_CORE X_NUC_2.L_CORE 0.207973
K_2 X_NUC_1.L_CORE X_NUC_3.L_CORE 0.207973
K_3 X_NUC_1.L_CORE X_NUC_4.L_CORE 0.207973
K_4 X_NUC_1.L_CORE X_NUC_5.L_CORE 0.008275
K_5 X_NUC_1.L_CORE X_NUC_6.L_CORE 0.007977
K_6 X_NUC_1.L_CORE X_NUC_7.L_CORE 0.008039
K_7 X_NUC_1.L_CORE X_NUC_8.L_CORE 0.008133
K_8 X_NUC_1.L_CORE X_NUC_9.L_CORE 0.008923
K_9 X_NUC_1.L_CORE X_NUC_10.L_CORE 0.009061
K_10 X_NUC_1.L_CORE X_NUC_11.L_CORE 0.008737
K_11 X_NUC_1.L_CORE X_NUC_12.L_CORE 0.009067
K_12 X_NUC_1.L_CORE X_NUC_13.L_CORE 0.009409
K_13 X_NUC_1.L_CORE X_NUC_14.L_CORE 0.009212
K_14 X_NUC_1.L_CORE X_NUC_15.L_CORE 0.009302
K_15 X_NUC_1.L_CORE X_NUC_16.L_CORE 0.009018
K_16 X_NUC_1.L_CORE X_NUC_17.L_CORE 0.005461
K_17 X_NUC_1.L_CORE X_NUC_18.L_CORE 0.005380
K_18 X_NUC_1.L_CORE X_NUC_19.L_CORE 0.005331
K_19 X_NUC_1.L_CORE X_NUC_20.L_CORE 0.005430
K_20 X_NUC_1.L_CORE X_NUC_21.L_CORE 0.007798
K_21 X_NUC_1.L_CORE X_NUC_22.L_CORE 0.008004
K_22 X_NUC_1.L_CORE X_NUC_23.L_CORE 0.007739
K_23 X_NUC_1.L_CORE X_NUC_24.L_CORE 0.007754
K_24 X_NUC_1.L_CORE X_NUC_25.L_CORE 0.005407
K_25 X_NUC_1.L_CORE X_NUC_26.L_CORE 0.005299
K_26 X_NUC_1.L_CORE X_NUC_27.L_CORE 0.005306
K_27 X_NUC_1.L_CORE X_NUC_28.L_CORE 0.005284
K_28 X_NUC_1.L_CORE X_NUC_29.L_CORE 0.004934
K_29 X_NUC_1.L_CORE X_NUC_30.L_CORE 0.004935
K_30 X_NUC_1.L_CORE X_NUC_31.L_CORE 0.004839
K_31 X_NUC_1.L_CORE X_NUC_32.L_CORE 0.004926
K_32 X_NUC_1.L_CORE X_NUC_33.L_CORE 0.005923
K_33 X_NUC_1.L_CORE X_NUC_34.L_CORE 0.005939
K_34 X_NUC_1.L_CORE X_NUC_35.L_CORE 0.005867
K_35 X_NUC_1.L_CORE X_NUC_36.L_CORE 0.005790
K_36 X_NUC_1.L_CORE X_NUC_37.L_CORE 0.004269
K_37 X_NUC_1.L_CORE X_NUC_38.L_CORE 0.004215
K_38 X_NUC_1.L_CORE X_NUC_39.L_CORE 0.004185
K_39 X_NUC_1.L_CORE X_NUC_40.L_CORE 0.004213
K_40 X_NUC_1.L_CORE X_NUC_41.L_CORE 0.004762
K_41 X_NUC_1.L_CORE X_NUC_42.L_CORE 0.004798
K_42 X_NUC_1.L_CORE X_NUC_43.L_CORE 0.004694
K_43 X_NUC_1.L_CORE X_NUC_44.L_CORE 0.004730
K_44 X_NUC_1.L_CORE X_NUC_45.L_CORE 0.004463
K_45 X_NUC_1.L_CORE X_NUC_46.L_CORE 0.004428
K_46 X_NUC_1.L_CORE X_NUC_47.L_CORE 0.004397
K_47 X_NUC_1.L_CORE X_NUC_48.L_CORE 0.004375
K_48 X_NUC_1.L_CORE X_NUC_49.L_CORE 0.003952
K_49 X_NUC_1.L_CORE X_NUC_50.L_CORE 0.003935
K_50 X_NUC_1.L_CORE X_NUC_51.L_CORE 0.003882
K_51 X_NUC_1.L_CORE X_NUC_52.L_CORE 0.003914
K_52 X_NUC_1.L_CORE X_NUC_53.L_CORE 0.004175
K_53 X_NUC_1.L_CORE X_NUC_54.L_CORE 0.004176
K_54 X_NUC_1.L_CORE X_NUC_55.L_CORE 0.004116
K_55 X_NUC_1.L_CORE X_NUC_56.L_CORE 0.004118
K_56 X_NUC_1.L_CORE X_NUC_57.L_CORE 0.030167
K_57 X_NUC_1.L_CORE X_NUC_58.L_CORE 0.005998
K_58 X_NUC_1.L_CORE X_NUC_59.L_CORE 0.006164
K_59 X_NUC_1.L_CORE X_NUC_60.L_CORE 0.005906
K_60 X_NUC_1.L_CORE X_NUC_61.L_CORE 0.003991
K_61 X_NUC_1.L_CORE X_NUC_62.L_CORE 0.004740
K_62 X_NUC_1.L_CORE X_NUC_63.L_CORE 0.003769
K_63 X_NUC_1.L_CORE X_NUC_64.L_CORE 0.003541
K_64 X_NUC_2.L_CORE X_NUC_3.L_CORE 0.207973
K_65 X_NUC_2.L_CORE X_NUC_4.L_CORE 0.207973
K_66 X_NUC_2.L_CORE X_NUC_5.L_CORE 0.008596
K_67 X_NUC_2.L_CORE X_NUC_6.L_CORE 0.008275
K_68 X_NUC_2.L_CORE X_NUC_7.L_CORE 0.008338
K_69 X_NUC_2.L_CORE X_NUC_8.L_CORE 0.008444
K_70 X_NUC_2.L_CORE X_NUC_9.L_CORE 0.008776
K_71 X_NUC_2.L_CORE X_NUC_10.L_CORE 0.008923
K_72 X_NUC_2.L_CORE X_NUC_11.L_CORE 0.008606
K_73 X_NUC_2.L_CORE X_NUC_12.L_CORE 0.008920
K_74 X_NUC_2.L_CORE X_NUC_13.L_CORE 0.009599
K_75 X_NUC_2.L_CORE X_NUC_14.L_CORE 0.009409
K_76 X_NUC_2.L_CORE X_NUC_15.L_CORE 0.009495
K_77 X_NUC_2.L_CORE X_NUC_16.L_CORE 0.009194
K_78 X_NUC_2.L_CORE X_NUC_17.L_CORE 0.005541
K_79 X_NUC_2.L_CORE X_NUC_18.L_CORE 0.005461
K_80 X_NUC_2.L_CORE X_NUC_19.L_CORE 0.005407
K_81 X_NUC_2.L_CORE X_NUC_20.L_CORE 0.005511
K_82 X_NUC_2.L_CORE X_NUC_21.L_CORE 0.007598
K_83 X_NUC_2.L_CORE X_NUC_22.L_CORE 0.007798
K_84 X_NUC_2.L_CORE X_NUC_23.L_CORE 0.007548
K_85 X_NUC_2.L_CORE X_NUC_24.L_CORE 0.007562
K_86 X_NUC_2.L_CORE X_NUC_25.L_CORE 0.005519
K_87 X_NUC_2.L_CORE X_NUC_26.L_CORE 0.005407
K_88 X_NUC_2.L_CORE X_NUC_27.L_CORE 0.005413
K_89 X_NUC_2.L_CORE X_NUC_28.L_CORE 0.005390
K_90 X_NUC_2.L_CORE X_NUC_29.L_CORE 0.004930
K_91 X_NUC_2.L_CORE X_NUC_30.L_CORE 0.004934
K_92 X_NUC_2.L_CORE X_NUC_31.L_CORE 0.004836
K_93 X_NUC_2.L_CORE X_NUC_32.L_CORE 0.004924
K_94 X_NUC_2.L_CORE X_NUC_33.L_CORE 0.005901
K_95 X_NUC_2.L_CORE X_NUC_34.L_CORE 0.005923
K_96 X_NUC_2.L_CORE X_NUC_35.L_CORE 0.005848
K_97 X_NUC_2.L_CORE X_NUC_36.L_CORE 0.005772
K_98 X_NUC_2.L_CORE X_NUC_37.L_CORE 0.004324
K_99 X_NUC_2.L_CORE X_NUC_38.L_CORE 0.004269
K_100 X_NUC_2.L_CORE X_NUC_39.L_CORE 0.004237
K_101 X_NUC_2.L_CORE X_NUC_40.L_CORE 0.004267
K_102 X_NUC_2.L_CORE X_NUC_41.L_CORE 0.004724
K_103 X_NUC_2.L_CORE X_NUC_42.L_CORE 0.004762
K_104 X_NUC_2.L_CORE X_NUC_43.L_CORE 0.004659
K_105 X_NUC_2.L_CORE X_NUC_44.L_CORE 0.004694
K_106 X_NUC_2.L_CORE X_NUC_45.L_CORE 0.004496
K_107 X_NUC_2.L_CORE X_NUC_46.L_CORE 0.004463
K_108 X_NUC_2.L_CORE X_NUC_47.L_CORE 0.004429
K_109 X_NUC_2.L_CORE X_NUC_48.L_CORE 0.004407
K_110 X_NUC_2.L_CORE X_NUC_49.L_CORE 0.003967
K_111 X_NUC_2.L_CORE X_NUC_50.L_CORE 0.003952
K_112 X_NUC_2.L_CORE X_NUC_51.L_CORE 0.003897
K_113 X_NUC_2.L_CORE X_NUC_52.L_CORE 0.003929
K_114 X_NUC_2.L_CORE X_NUC_53.L_CORE 0.004172
K_115 X_NUC_2.L_CORE X_NUC_54.L_CORE 0.004175
K_116 X_NUC_2.L_CORE X_NUC_55.L_CORE 0.004114
K_117 X_NUC_2.L_CORE X_NUC_56.L_CORE 0.004116
K_118 X_NUC_2.L_CORE X_NUC_57.L_CORE 0.027751
K_119 X_NUC_2.L_CORE X_NUC_58.L_CORE 0.006169
K_120 X_NUC_2.L_CORE X_NUC_59.L_CORE 0.006077
K_121 X_NUC_2.L_CORE X_NUC_60.L_CORE 0.005961
K_122 X_NUC_2.L_CORE X_NUC_61.L_CORE 0.004029
K_123 X_NUC_2.L_CORE X_NUC_62.L_CORE 0.004685
K_124 X_NUC_2.L_CORE X_NUC_63.L_CORE 0.003806
K_125 X_NUC_2.L_CORE X_NUC_64.L_CORE 0.003543
K_126 X_NUC_3.L_CORE X_NUC_4.L_CORE 0.207973
K_127 X_NUC_3.L_CORE X_NUC_5.L_CORE 0.008520
K_128 X_NUC_3.L_CORE X_NUC_6.L_CORE 0.008202
K_129 X_NUC_3.L_CORE X_NUC_7.L_CORE 0.008275
K_130 X_NUC_3.L_CORE X_NUC_8.L_CORE 0.008372
K_131 X_NUC_3.L_CORE X_NUC_9.L_CORE 0.009104
K_132 X_NUC_3.L_CORE X_NUC_10.L_CORE 0.009259
K_133 X_NUC_3.L_CORE X_NUC_11.L_CORE 0.008923
K_134 X_NUC_3.L_CORE X_NUC_12.L_CORE 0.009266
K_135 X_NUC_3.L_CORE X_NUC_13.L_CORE 0.009500
K_136 X_NUC_3.L_CORE X_NUC_14.L_CORE 0.009306
K_137 X_NUC_3.L_CORE X_NUC_15.L_CORE 0.009409
K_138 X_NUC_3.L_CORE X_NUC_16.L_CORE 0.009107
K_139 X_NUC_3.L_CORE X_NUC_17.L_CORE 0.005597
K_140 X_NUC_3.L_CORE X_NUC_18.L_CORE 0.005512
K_141 X_NUC_3.L_CORE X_NUC_19.L_CORE 0.005461
K_142 X_NUC_3.L_CORE X_NUC_20.L_CORE 0.005566
K_143 X_NUC_3.L_CORE X_NUC_21.L_CORE 0.007848
K_144 X_NUC_3.L_CORE X_NUC_22.L_CORE 0.008063
K_145 X_NUC_3.L_CORE X_NUC_23.L_CORE 0.007798
K_146 X_NUC_3.L_CORE X_NUC_24.L_CORE 0.007808
K_147 X_NUC_3.L_CORE X_NUC_25.L_CORE 0.005512
K_148 X_NUC_3.L_CORE X_NUC_26.L_CORE 0.005398
K_149 X_NUC_3.L_CORE X_NUC_27.L_CORE 0.005407
K_150 X_NUC_3.L_CORE X_NUC_28.L_CORE 0.005383
K_151 X_NUC_3.L_CORE X_NUC_29.L_CORE 0.005032
K_152 X_NUC_3.L_CORE X_NUC_30.L_CORE 0.005035
K_153 X_NUC_3.L_CORE X_NUC_31.L_CORE 0.004934
K_154 X_NUC_3.L_CORE X_NUC_32.L_CORE 0.005025
K_155 X_NUC_3.L_CORE X_NUC_33.L_CORE 0.005975
K_156 X_NUC_3.L_CORE X_NUC_34.L_CORE 0.005995
K_157 X_NUC_3.L_CORE X_NUC_35.L_CORE 0.005923
K_158 X_NUC_3.L_CORE X_NUC_36.L_CORE 0.005842
K_159 X_NUC_3.L_CORE X_NUC_37.L_CORE 0.004357
K_160 X_NUC_3.L_CORE X_NUC_38.L_CORE 0.004300
K_161 X_NUC_3.L_CORE X_NUC_39.L_CORE 0.004269
K_162 X_NUC_3.L_CORE X_NUC_40.L_CORE 0.004299
K_163 X_NUC_3.L_CORE X_NUC_41.L_CORE 0.004830
K_164 X_NUC_3.L_CORE X_NUC_42.L_CORE 0.004869
K_165 X_NUC_3.L_CORE X_NUC_43.L_CORE 0.004762
K_166 X_NUC_3.L_CORE X_NUC_44.L_CORE 0.004798
K_167 X_NUC_3.L_CORE X_NUC_45.L_CORE 0.004530
K_168 X_NUC_3.L_CORE X_NUC_46.L_CORE 0.004495
K_169 X_NUC_3.L_CORE X_NUC_47.L_CORE 0.004463
K_170 X_NUC_3.L_CORE X_NUC_48.L_CORE 0.004439
K_171 X_NUC_3.L_CORE X_NUC_49.L_CORE 0.004024
K_172 X_NUC_3.L_CORE X_NUC_50.L_CORE 0.004007
K_173 X_NUC_3.L_CORE X_NUC_51.L_CORE 0.003952
K_174 X_NUC_3.L_CORE X_NUC_52.L_CORE 0.003984
K_175 X_NUC_3.L_CORE X_NUC_53.L_CORE 0.004235
K_176 X_NUC_3.L_CORE X_NUC_54.L_CORE 0.004237
K_177 X_NUC_3.L_CORE X_NUC_55.L_CORE 0.004175
K_178 X_NUC_3.L_CORE X_NUC_56.L_CORE 0.004177
K_179 X_NUC_3.L_CORE X_NUC_57.L_CORE 0.026411
K_180 X_NUC_3.L_CORE X_NUC_58.L_CORE 0.006118
K_181 X_NUC_3.L_CORE X_NUC_59.L_CORE 0.006241
K_182 X_NUC_3.L_CORE X_NUC_60.L_CORE 0.005943
K_183 X_NUC_3.L_CORE X_NUC_61.L_CORE 0.004067
K_184 X_NUC_3.L_CORE X_NUC_62.L_CORE 0.004778
K_185 X_NUC_3.L_CORE X_NUC_63.L_CORE 0.003824
K_186 X_NUC_3.L_CORE X_NUC_64.L_CORE 0.003594
K_187 X_NUC_4.L_CORE X_NUC_5.L_CORE 0.008411
K_188 X_NUC_4.L_CORE X_NUC_6.L_CORE 0.008104
K_189 X_NUC_4.L_CORE X_NUC_7.L_CORE 0.008169
K_190 X_NUC_4.L_CORE X_NUC_8.L_CORE 0.008275
K_191 X_NUC_4.L_CORE X_NUC_9.L_CORE 0.008770
K_192 X_NUC_4.L_CORE X_NUC_10.L_CORE 0.008909
K_193 X_NUC_4.L_CORE X_NUC_11.L_CORE 0.008601
K_194 X_NUC_4.L_CORE X_NUC_12.L_CORE 0.008923
K_195 X_NUC_4.L_CORE X_NUC_13.L_CORE 0.009834
K_196 X_NUC_4.L_CORE X_NUC_14.L_CORE 0.009619
K_197 X_NUC_4.L_CORE X_NUC_15.L_CORE 0.009722
K_198 X_NUC_4.L_CORE X_NUC_16.L_CORE 0.009409
K_199 X_NUC_4.L_CORE X_NUC_17.L_CORE 0.005488
K_200 X_NUC_4.L_CORE X_NUC_18.L_CORE 0.005408
K_201 X_NUC_4.L_CORE X_NUC_19.L_CORE 0.005358
K_202 X_NUC_4.L_CORE X_NUC_20.L_CORE 0.005461
K_203 X_NUC_4.L_CORE X_NUC_21.L_CORE 0.007833
K_204 X_NUC_4.L_CORE X_NUC_22.L_CORE 0.008047
K_205 X_NUC_4.L_CORE X_NUC_23.L_CORE 0.007778
K_206 X_NUC_4.L_CORE X_NUC_24.L_CORE 0.007798
K_207 X_NUC_4.L_CORE X_NUC_25.L_CORE 0.005536
K_208 X_NUC_4.L_CORE X_NUC_26.L_CORE 0.005421
K_209 X_NUC_4.L_CORE X_NUC_27.L_CORE 0.005429
K_210 X_NUC_4.L_CORE X_NUC_28.L_CORE 0.005407
K_211 X_NUC_4.L_CORE X_NUC_29.L_CORE 0.004939
K_212 X_NUC_4.L_CORE X_NUC_30.L_CORE 0.004941
K_213 X_NUC_4.L_CORE X_NUC_31.L_CORE 0.004845
K_214 X_NUC_4.L_CORE X_NUC_32.L_CORE 0.004934
K_215 X_NUC_4.L_CORE X_NUC_33.L_CORE 0.006059
K_216 X_NUC_4.L_CORE X_NUC_34.L_CORE 0.006080
K_217 X_NUC_4.L_CORE X_NUC_35.L_CORE 0.006002
K_218 X_NUC_4.L_CORE X_NUC_36.L_CORE 0.005923
K_219 X_NUC_4.L_CORE X_NUC_37.L_CORE 0.004325
K_220 X_NUC_4.L_CORE X_NUC_38.L_CORE 0.004270
K_221 X_NUC_4.L_CORE X_NUC_39.L_CORE 0.004239
K_222 X_NUC_4.L_CORE X_NUC_40.L_CORE 0.004269
K_223 X_NUC_4.L_CORE X_NUC_41.L_CORE 0.004791
K_224 X_NUC_4.L_CORE X_NUC_42.L_CORE 0.004829
K_225 X_NUC_4.L_CORE X_NUC_43.L_CORE 0.004724
K_226 X_NUC_4.L_CORE X_NUC_44.L_CORE 0.004762
K_227 X_NUC_4.L_CORE X_NUC_45.L_CORE 0.004554
K_228 X_NUC_4.L_CORE X_NUC_46.L_CORE 0.004519
K_229 X_NUC_4.L_CORE X_NUC_47.L_CORE 0.004485
K_230 X_NUC_4.L_CORE X_NUC_48.L_CORE 0.004463
K_231 X_NUC_4.L_CORE X_NUC_49.L_CORE 0.003990
K_232 X_NUC_4.L_CORE X_NUC_50.L_CORE 0.003973
K_233 X_NUC_4.L_CORE X_NUC_51.L_CORE 0.003919
K_234 X_NUC_4.L_CORE X_NUC_52.L_CORE 0.003952
K_235 X_NUC_4.L_CORE X_NUC_53.L_CORE 0.004232
K_236 X_NUC_4.L_CORE X_NUC_54.L_CORE 0.004234
K_237 X_NUC_4.L_CORE X_NUC_55.L_CORE 0.004171
K_238 X_NUC_4.L_CORE X_NUC_56.L_CORE 0.004175
K_239 X_NUC_4.L_CORE X_NUC_57.L_CORE 0.028468
K_240 X_NUC_4.L_CORE X_NUC_58.L_CORE 0.006076
K_241 X_NUC_4.L_CORE X_NUC_59.L_CORE 0.006096
K_242 X_NUC_4.L_CORE X_NUC_60.L_CORE 0.006071
K_243 X_NUC_4.L_CORE X_NUC_61.L_CORE 0.004015
K_244 X_NUC_4.L_CORE X_NUC_62.L_CORE 0.004777
K_245 X_NUC_4.L_CORE X_NUC_63.L_CORE 0.003832
K_246 X_NUC_4.L_CORE X_NUC_64.L_CORE 0.003570
K_247 X_NUC_5.L_CORE X_NUC_6.L_CORE 0.207973
K_248 X_NUC_5.L_CORE X_NUC_7.L_CORE 0.207973
K_249 X_NUC_5.L_CORE X_NUC_8.L_CORE 0.207973
K_250 X_NUC_5.L_CORE X_NUC_9.L_CORE 0.005972
K_251 X_NUC_5.L_CORE X_NUC_10.L_CORE 0.006135
K_252 X_NUC_5.L_CORE X_NUC_11.L_CORE 0.006005
K_253 X_NUC_5.L_CORE X_NUC_12.L_CORE 0.006069
K_254 X_NUC_5.L_CORE X_NUC_13.L_CORE 0.007331
K_255 X_NUC_5.L_CORE X_NUC_14.L_CORE 0.007452
K_256 X_NUC_5.L_CORE X_NUC_15.L_CORE 0.007449
K_257 X_NUC_5.L_CORE X_NUC_16.L_CORE 0.007232
K_258 X_NUC_5.L_CORE X_NUC_17.L_CORE 0.009048
K_259 X_NUC_5.L_CORE X_NUC_18.L_CORE 0.009077
K_260 X_NUC_5.L_CORE X_NUC_19.L_CORE 0.008764
K_261 X_NUC_5.L_CORE X_NUC_20.L_CORE 0.009089
K_262 X_NUC_5.L_CORE X_NUC_21.L_CORE 0.004594
K_263 X_NUC_5.L_CORE X_NUC_22.L_CORE 0.004690
K_264 X_NUC_5.L_CORE X_NUC_23.L_CORE 0.004624
K_265 X_NUC_5.L_CORE X_NUC_24.L_CORE 0.004609
K_266 X_NUC_5.L_CORE X_NUC_25.L_CORE 0.008434
K_267 X_NUC_5.L_CORE X_NUC_26.L_CORE 0.008338
K_268 X_NUC_5.L_CORE X_NUC_27.L_CORE 0.008295
K_269 X_NUC_5.L_CORE X_NUC_28.L_CORE 0.008115
K_270 X_NUC_5.L_CORE X_NUC_29.L_CORE 0.004976
K_271 X_NUC_5.L_CORE X_NUC_30.L_CORE 0.005046
K_272 X_NUC_5.L_CORE X_NUC_31.L_CORE 0.004928
K_273 X_NUC_5.L_CORE X_NUC_32.L_CORE 0.004998
K_274 X_NUC_5.L_CORE X_NUC_33.L_CORE 0.004562
K_275 X_NUC_5.L_CORE X_NUC_34.L_CORE 0.004623
K_276 X_NUC_5.L_CORE X_NUC_35.L_CORE 0.004577
K_277 X_NUC_5.L_CORE X_NUC_36.L_CORE 0.004523
K_278 X_NUC_5.L_CORE X_NUC_37.L_CORE 0.006388
K_279 X_NUC_5.L_CORE X_NUC_38.L_CORE 0.006346
K_280 X_NUC_5.L_CORE X_NUC_39.L_CORE 0.006215
K_281 X_NUC_5.L_CORE X_NUC_40.L_CORE 0.006265
K_282 X_NUC_5.L_CORE X_NUC_41.L_CORE 0.003994
K_283 X_NUC_5.L_CORE X_NUC_42.L_CORE 0.004051
K_284 X_NUC_5.L_CORE X_NUC_43.L_CORE 0.003980
K_285 X_NUC_5.L_CORE X_NUC_44.L_CORE 0.003991
K_286 X_NUC_5.L_CORE X_NUC_45.L_CORE 0.004805
K_287 X_NUC_5.L_CORE X_NUC_46.L_CORE 0.004822
K_288 X_NUC_5.L_CORE X_NUC_47.L_CORE 0.004768
K_289 X_NUC_5.L_CORE X_NUC_48.L_CORE 0.004721
K_290 X_NUC_5.L_CORE X_NUC_49.L_CORE 0.004476
K_291 X_NUC_5.L_CORE X_NUC_50.L_CORE 0.004501
K_292 X_NUC_5.L_CORE X_NUC_51.L_CORE 0.004412
K_293 X_NUC_5.L_CORE X_NUC_52.L_CORE 0.004442
K_294 X_NUC_5.L_CORE X_NUC_53.L_CORE 0.003952
K_295 X_NUC_5.L_CORE X_NUC_54.L_CORE 0.003987
K_296 X_NUC_5.L_CORE X_NUC_55.L_CORE 0.003927
K_297 X_NUC_5.L_CORE X_NUC_56.L_CORE 0.003919
K_298 X_NUC_5.L_CORE X_NUC_57.L_CORE 0.006729
K_299 X_NUC_5.L_CORE X_NUC_58.L_CORE 0.021149
K_300 X_NUC_5.L_CORE X_NUC_59.L_CORE 0.004636
K_301 X_NUC_5.L_CORE X_NUC_60.L_CORE 0.005286
K_302 X_NUC_5.L_CORE X_NUC_61.L_CORE 0.005662
K_303 X_NUC_5.L_CORE X_NUC_62.L_CORE 0.003608
K_304 X_NUC_5.L_CORE X_NUC_63.L_CORE 0.004648
K_305 X_NUC_5.L_CORE X_NUC_64.L_CORE 0.003681
K_306 X_NUC_6.L_CORE X_NUC_7.L_CORE 0.207973
K_307 X_NUC_6.L_CORE X_NUC_8.L_CORE 0.207973
K_308 X_NUC_6.L_CORE X_NUC_9.L_CORE 0.005817
K_309 X_NUC_6.L_CORE X_NUC_10.L_CORE 0.005972
K_310 X_NUC_6.L_CORE X_NUC_11.L_CORE 0.005850
K_311 X_NUC_6.L_CORE X_NUC_12.L_CORE 0.005908
K_312 X_NUC_6.L_CORE X_NUC_13.L_CORE 0.007206
K_313 X_NUC_6.L_CORE X_NUC_14.L_CORE 0.007331
K_314 X_NUC_6.L_CORE X_NUC_15.L_CORE 0.007323
K_315 X_NUC_6.L_CORE X_NUC_16.L_CORE 0.007117
K_316 X_NUC_6.L_CORE X_NUC_17.L_CORE 0.009002
K_317 X_NUC_6.L_CORE X_NUC_18.L_CORE 0.009048
K_318 X_NUC_6.L_CORE X_NUC_19.L_CORE 0.008729
K_319 X_NUC_6.L_CORE X_NUC_20.L_CORE 0.009051
K_320 X_NUC_6.L_CORE X_NUC_21.L_CORE 0.004502
K_321 X_NUC_6.L_CORE X_NUC_22.L_CORE 0.004594
K_322 X_NUC_6.L_CORE X_NUC_23.L_CORE 0.004530
K_323 X_NUC_6.L_CORE X_NUC_24.L_CORE 0.004516
K_324 X_NUC_6.L_CORE X_NUC_25.L_CORE 0.008520
K_325 X_NUC_6.L_CORE X_NUC_26.L_CORE 0.008434
K_326 X_NUC_6.L_CORE X_NUC_27.L_CORE 0.008384
K_327 X_NUC_6.L_CORE X_NUC_28.L_CORE 0.008198
K_328 X_NUC_6.L_CORE X_NUC_29.L_CORE 0.004906
K_329 X_NUC_6.L_CORE X_NUC_30.L_CORE 0.004976
K_330 X_NUC_6.L_CORE X_NUC_31.L_CORE 0.004862
K_331 X_NUC_6.L_CORE X_NUC_32.L_CORE 0.004929
K_332 X_NUC_6.L_CORE X_NUC_33.L_CORE 0.004502
K_333 X_NUC_6.L_CORE X_NUC_34.L_CORE 0.004562
K_334 X_NUC_6.L_CORE X_NUC_35.L_CORE 0.004517
K_335 X_NUC_6.L_CORE X_NUC_36.L_CORE 0.004465
K_336 X_NUC_6.L_CORE X_NUC_37.L_CORE 0.006425
K_337 X_NUC_6.L_CORE X_NUC_38.L_CORE 0.006388
K_338 X_NUC_6.L_CORE X_NUC_39.L_CORE 0.006252
K_339 X_NUC_6.L_CORE X_NUC_40.L_CORE 0.006303
K_340 X_NUC_6.L_CORE X_NUC_41.L_CORE 0.003938
K_341 X_NUC_6.L_CORE X_NUC_42.L_CORE 0.003994
K_342 X_NUC_6.L_CORE X_NUC_43.L_CORE 0.003925
K_343 X_NUC_6.L_CORE X_NUC_44.L_CORE 0.003935
K_344 X_NUC_6.L_CORE X_NUC_45.L_CORE 0.004786
K_345 X_NUC_6.L_CORE X_NUC_46.L_CORE 0.004805
K_346 X_NUC_6.L_CORE X_NUC_47.L_CORE 0.004750
K_347 X_NUC_6.L_CORE X_NUC_48.L_CORE 0.004704
K_348 X_NUC_6.L_CORE X_NUC_49.L_CORE 0.004450
K_349 X_NUC_6.L_CORE X_NUC_50.L_CORE 0.004476
K_350 X_NUC_6.L_CORE X_NUC_51.L_CORE 0.004388
K_351 X_NUC_6.L_CORE X_NUC_52.L_CORE 0.004418
K_352 X_NUC_6.L_CORE X_NUC_53.L_CORE 0.003916
K_353 X_NUC_6.L_CORE X_NUC_54.L_CORE 0.003952
K_354 X_NUC_6.L_CORE X_NUC_55.L_CORE 0.003893
K_355 X_NUC_6.L_CORE X_NUC_56.L_CORE 0.003884
K_356 X_NUC_6.L_CORE X_NUC_57.L_CORE 0.006540
K_357 X_NUC_6.L_CORE X_NUC_58.L_CORE 0.023534
K_358 X_NUC_6.L_CORE X_NUC_59.L_CORE 0.004546
K_359 X_NUC_6.L_CORE X_NUC_60.L_CORE 0.005244
K_360 X_NUC_6.L_CORE X_NUC_61.L_CORE 0.005671
K_361 X_NUC_6.L_CORE X_NUC_62.L_CORE 0.003558
K_362 X_NUC_6.L_CORE X_NUC_63.L_CORE 0.004661
K_363 X_NUC_6.L_CORE X_NUC_64.L_CORE 0.003656
K_364 X_NUC_7.L_CORE X_NUC_8.L_CORE 0.207973
K_365 X_NUC_7.L_CORE X_NUC_9.L_CORE 0.005934
K_366 X_NUC_7.L_CORE X_NUC_10.L_CORE 0.006097
K_367 X_NUC_7.L_CORE X_NUC_11.L_CORE 0.005972
K_368 X_NUC_7.L_CORE X_NUC_12.L_CORE 0.006032
K_369 X_NUC_7.L_CORE X_NUC_13.L_CORE 0.007209
K_370 X_NUC_7.L_CORE X_NUC_14.L_CORE 0.007329
K_371 X_NUC_7.L_CORE X_NUC_15.L_CORE 0.007331
K_372 X_NUC_7.L_CORE X_NUC_16.L_CORE 0.007120
K_373 X_NUC_7.L_CORE X_NUC_17.L_CORE 0.009343
K_374 X_NUC_7.L_CORE X_NUC_18.L_CORE 0.009385
K_375 X_NUC_7.L_CORE X_NUC_19.L_CORE 0.009048
K_376 X_NUC_7.L_CORE X_NUC_20.L_CORE 0.009397
K_377 X_NUC_7.L_CORE X_NUC_21.L_CORE 0.004563
K_378 X_NUC_7.L_CORE X_NUC_22.L_CORE 0.004659
K_379 X_NUC_7.L_CORE X_NUC_23.L_CORE 0.004594
K_380 X_NUC_7.L_CORE X_NUC_24.L_CORE 0.004579
K_381 X_NUC_7.L_CORE X_NUC_25.L_CORE 0.008566
K_382 X_NUC_7.L_CORE X_NUC_26.L_CORE 0.008472
K_383 X_NUC_7.L_CORE X_NUC_27.L_CORE 0.008434
K_384 X_NUC_7.L_CORE X_NUC_28.L_CORE 0.008239
K_385 X_NUC_7.L_CORE X_NUC_29.L_CORE 0.005021
K_386 X_NUC_7.L_CORE X_NUC_30.L_CORE 0.005095
K_387 X_NUC_7.L_CORE X_NUC_31.L_CORE 0.004976
K_388 X_NUC_7.L_CORE X_NUC_32.L_CORE 0.005046
K_389 X_NUC_7.L_CORE X_NUC_33.L_CORE 0.004545
K_390 X_NUC_7.L_CORE X_NUC_34.L_CORE 0.004607
K_391 X_NUC_7.L_CORE X_NUC_35.L_CORE 0.004562
K_392 X_NUC_7.L_CORE X_NUC_36.L_CORE 0.004508
K_393 X_NUC_7.L_CORE X_NUC_37.L_CORE 0.006570
K_394 X_NUC_7.L_CORE X_NUC_38.L_CORE 0.006527
K_395 X_NUC_7.L_CORE X_NUC_39.L_CORE 0.006388
K_396 X_NUC_7.L_CORE X_NUC_40.L_CORE 0.006439
K_397 X_NUC_7.L_CORE X_NUC_41.L_CORE 0.004006
K_398 X_NUC_7.L_CORE X_NUC_42.L_CORE 0.004064
K_399 X_NUC_7.L_CORE X_NUC_43.L_CORE 0.003994
K_400 X_NUC_7.L_CORE X_NUC_44.L_CORE 0.004003
K_401 X_NUC_7.L_CORE X_NUC_45.L_CORE 0.004840
K_402 X_NUC_7.L_CORE X_NUC_46.L_CORE 0.004859
K_403 X_NUC_7.L_CORE X_NUC_47.L_CORE 0.004805
K_404 X_NUC_7.L_CORE X_NUC_48.L_CORE 0.004756
K_405 X_NUC_7.L_CORE X_NUC_49.L_CORE 0.004541
K_406 X_NUC_7.L_CORE X_NUC_50.L_CORE 0.004568
K_407 X_NUC_7.L_CORE X_NUC_51.L_CORE 0.004476
K_408 X_NUC_7.L_CORE X_NUC_52.L_CORE 0.004507
K_409 X_NUC_7.L_CORE X_NUC_53.L_CORE 0.003975
K_410 X_NUC_7.L_CORE X_NUC_54.L_CORE 0.004012
K_411 X_NUC_7.L_CORE X_NUC_55.L_CORE 0.003952
K_412 X_NUC_7.L_CORE X_NUC_56.L_CORE 0.003942
K_413 X_NUC_7.L_CORE X_NUC_57.L_CORE 0.006555
K_414 X_NUC_7.L_CORE X_NUC_58.L_CORE 0.022358
K_415 X_NUC_7.L_CORE X_NUC_59.L_CORE 0.004626
K_416 X_NUC_7.L_CORE X_NUC_60.L_CORE 0.005249
K_417 X_NUC_7.L_CORE X_NUC_61.L_CORE 0.005801
K_418 X_NUC_7.L_CORE X_NUC_62.L_CORE 0.003604
K_419 X_NUC_7.L_CORE X_NUC_63.L_CORE 0.004708
K_420 X_NUC_7.L_CORE X_NUC_64.L_CORE 0.003718
K_421 X_NUC_8.L_CORE X_NUC_9.L_CORE 0.005875
K_422 X_NUC_8.L_CORE X_NUC_10.L_CORE 0.006033
K_423 X_NUC_8.L_CORE X_NUC_11.L_CORE 0.005909
K_424 X_NUC_8.L_CORE X_NUC_12.L_CORE 0.005972
K_425 X_NUC_8.L_CORE X_NUC_13.L_CORE 0.007424
K_426 X_NUC_8.L_CORE X_NUC_14.L_CORE 0.007555
K_427 X_NUC_8.L_CORE X_NUC_15.L_CORE 0.007552
K_428 X_NUC_8.L_CORE X_NUC_16.L_CORE 0.007331
K_429 X_NUC_8.L_CORE X_NUC_17.L_CORE 0.008990
K_430 X_NUC_8.L_CORE X_NUC_18.L_CORE 0.009028
K_431 X_NUC_8.L_CORE X_NUC_19.L_CORE 0.008719
K_432 X_NUC_8.L_CORE X_NUC_20.L_CORE 0.009048
K_433 X_NUC_8.L_CORE X_NUC_21.L_CORE 0.004577
K_434 X_NUC_8.L_CORE X_NUC_22.L_CORE 0.004674
K_435 X_NUC_8.L_CORE X_NUC_23.L_CORE 0.004608
K_436 X_NUC_8.L_CORE X_NUC_24.L_CORE 0.004594
K_437 X_NUC_8.L_CORE X_NUC_25.L_CORE 0.008779
K_438 X_NUC_8.L_CORE X_NUC_26.L_CORE 0.008677
K_439 X_NUC_8.L_CORE X_NUC_27.L_CORE 0.008629
K_440 X_NUC_8.L_CORE X_NUC_28.L_CORE 0.008434
K_441 X_NUC_8.L_CORE X_NUC_29.L_CORE 0.004950
K_442 X_NUC_8.L_CORE X_NUC_30.L_CORE 0.005021
K_443 X_NUC_8.L_CORE X_NUC_31.L_CORE 0.004905
K_444 X_NUC_8.L_CORE X_NUC_32.L_CORE 0.004976
K_445 X_NUC_8.L_CORE X_NUC_33.L_CORE 0.004600
K_446 X_NUC_8.L_CORE X_NUC_34.L_CORE 0.004663
K_447 X_NUC_8.L_CORE X_NUC_35.L_CORE 0.004616
K_448 X_NUC_8.L_CORE X_NUC_36.L_CORE 0.004562
K_449 X_NUC_8.L_CORE X_NUC_37.L_CORE 0.006512
K_450 X_NUC_8.L_CORE X_NUC_38.L_CORE 0.006471
K_451 X_NUC_8.L_CORE X_NUC_39.L_CORE 0.006332
K_452 X_NUC_8.L_CORE X_NUC_40.L_CORE 0.006388
K_453 X_NUC_8.L_CORE X_NUC_41.L_CORE 0.003995
K_454 X_NUC_8.L_CORE X_NUC_42.L_CORE 0.004053
K_455 X_NUC_8.L_CORE X_NUC_43.L_CORE 0.003982
K_456 X_NUC_8.L_CORE X_NUC_44.L_CORE 0.003994
K_457 X_NUC_8.L_CORE X_NUC_45.L_CORE 0.004890
K_458 X_NUC_8.L_CORE X_NUC_46.L_CORE 0.004910
K_459 X_NUC_8.L_CORE X_NUC_47.L_CORE 0.004853
K_460 X_NUC_8.L_CORE X_NUC_48.L_CORE 0.004805
K_461 X_NUC_8.L_CORE X_NUC_49.L_CORE 0.004509
K_462 X_NUC_8.L_CORE X_NUC_50.L_CORE 0.004535
K_463 X_NUC_8.L_CORE X_NUC_51.L_CORE 0.004444
K_464 X_NUC_8.L_CORE X_NUC_52.L_CORE 0.004476
K_465 X_NUC_8.L_CORE X_NUC_53.L_CORE 0.003984
K_466 X_NUC_8.L_CORE X_NUC_54.L_CORE 0.004021
K_467 X_NUC_8.L_CORE X_NUC_55.L_CORE 0.003960
K_468 X_NUC_8.L_CORE X_NUC_56.L_CORE 0.003952
K_469 X_NUC_8.L_CORE X_NUC_57.L_CORE 0.006635
K_470 X_NUC_8.L_CORE X_NUC_58.L_CORE 0.022254
K_471 X_NUC_8.L_CORE X_NUC_59.L_CORE 0.004583
K_472 X_NUC_8.L_CORE X_NUC_60.L_CORE 0.005364
K_473 X_NUC_8.L_CORE X_NUC_61.L_CORE 0.005686
K_474 X_NUC_8.L_CORE X_NUC_62.L_CORE 0.003612
K_475 X_NUC_8.L_CORE X_NUC_63.L_CORE 0.004742
K_476 X_NUC_8.L_CORE X_NUC_64.L_CORE 0.003701
K_477 X_NUC_9.L_CORE X_NUC_10.L_CORE 0.207973
K_478 X_NUC_9.L_CORE X_NUC_11.L_CORE 0.207973
K_479 X_NUC_9.L_CORE X_NUC_12.L_CORE 0.207973
K_480 X_NUC_9.L_CORE X_NUC_13.L_CORE 0.005078
K_481 X_NUC_9.L_CORE X_NUC_14.L_CORE 0.005021
K_482 X_NUC_9.L_CORE X_NUC_15.L_CORE 0.005095
K_483 X_NUC_9.L_CORE X_NUC_16.L_CORE 0.004988
K_484 X_NUC_9.L_CORE X_NUC_17.L_CORE 0.006522
K_485 X_NUC_9.L_CORE X_NUC_18.L_CORE 0.006334
K_486 X_NUC_9.L_CORE X_NUC_19.L_CORE 0.006370
K_487 X_NUC_9.L_CORE X_NUC_20.L_CORE 0.006414
K_488 X_NUC_9.L_CORE X_NUC_21.L_CORE 0.008601
K_489 X_NUC_9.L_CORE X_NUC_22.L_CORE 0.008742
K_490 X_NUC_9.L_CORE X_NUC_23.L_CORE 0.008687
K_491 X_NUC_9.L_CORE X_NUC_24.L_CORE 0.008414
K_492 X_NUC_9.L_CORE X_NUC_25.L_CORE 0.004201
K_493 X_NUC_9.L_CORE X_NUC_26.L_CORE 0.004135
K_494 X_NUC_9.L_CORE X_NUC_27.L_CORE 0.004171
K_495 X_NUC_9.L_CORE X_NUC_28.L_CORE 0.004127
K_496 X_NUC_9.L_CORE X_NUC_29.L_CORE 0.008663
K_497 X_NUC_9.L_CORE X_NUC_30.L_CORE 0.008542
K_498 X_NUC_9.L_CORE X_NUC_31.L_CORE 0.008323
K_499 X_NUC_9.L_CORE X_NUC_32.L_CORE 0.008492
K_500 X_NUC_9.L_CORE X_NUC_33.L_CORE 0.004755
K_501 X_NUC_9.L_CORE X_NUC_34.L_CORE 0.004742
K_502 X_NUC_9.L_CORE X_NUC_35.L_CORE 0.004753
K_503 X_NUC_9.L_CORE X_NUC_36.L_CORE 0.004664
K_504 X_NUC_9.L_CORE X_NUC_37.L_CORE 0.004394
K_505 X_NUC_9.L_CORE X_NUC_38.L_CORE 0.004319
K_506 X_NUC_9.L_CORE X_NUC_39.L_CORE 0.004323
K_507 X_NUC_9.L_CORE X_NUC_40.L_CORE 0.004317
K_508 X_NUC_9.L_CORE X_NUC_41.L_CORE 0.006567
K_509 X_NUC_9.L_CORE X_NUC_42.L_CORE 0.006604
K_510 X_NUC_9.L_CORE X_NUC_43.L_CORE 0.006461
K_511 X_NUC_9.L_CORE X_NUC_44.L_CORE 0.006429
K_512 X_NUC_9.L_CORE X_NUC_45.L_CORE 0.003924
K_513 X_NUC_9.L_CORE X_NUC_46.L_CORE 0.003889
K_514 X_NUC_9.L_CORE X_NUC_47.L_CORE 0.003894
K_515 X_NUC_9.L_CORE X_NUC_48.L_CORE 0.003852
K_516 X_NUC_9.L_CORE X_NUC_49.L_CORE 0.004805
K_517 X_NUC_9.L_CORE X_NUC_50.L_CORE 0.004753
K_518 X_NUC_9.L_CORE X_NUC_51.L_CORE 0.004708
K_519 X_NUC_9.L_CORE X_NUC_52.L_CORE 0.004715
K_520 X_NUC_9.L_CORE X_NUC_53.L_CORE 0.004463
K_521 X_NUC_9.L_CORE X_NUC_54.L_CORE 0.004447
K_522 X_NUC_9.L_CORE X_NUC_55.L_CORE 0.004413
K_523 X_NUC_9.L_CORE X_NUC_56.L_CORE 0.004377
K_524 X_NUC_9.L_CORE X_NUC_57.L_CORE 0.007559
K_525 X_NUC_9.L_CORE X_NUC_58.L_CORE 0.004738
K_526 X_NUC_9.L_CORE X_NUC_59.L_CORE 0.018733
K_527 X_NUC_9.L_CORE X_NUC_60.L_CORE 0.004002
K_528 X_NUC_9.L_CORE X_NUC_61.L_CORE 0.004780
K_529 X_NUC_9.L_CORE X_NUC_62.L_CORE 0.005396
K_530 X_NUC_9.L_CORE X_NUC_63.L_CORE 0.003445
K_531 X_NUC_9.L_CORE X_NUC_64.L_CORE 0.004331
K_532 X_NUC_10.L_CORE X_NUC_11.L_CORE 0.207973
K_533 X_NUC_10.L_CORE X_NUC_12.L_CORE 0.207973
K_534 X_NUC_10.L_CORE X_NUC_13.L_CORE 0.005134
K_535 X_NUC_10.L_CORE X_NUC_14.L_CORE 0.005078
K_536 X_NUC_10.L_CORE X_NUC_15.L_CORE 0.005153
K_537 X_NUC_10.L_CORE X_NUC_16.L_CORE 0.005042
K_538 X_NUC_10.L_CORE X_NUC_17.L_CORE 0.006721
K_539 X_NUC_10.L_CORE X_NUC_18.L_CORE 0.006522
K_540 X_NUC_10.L_CORE X_NUC_19.L_CORE 0.006558
K_541 X_NUC_10.L_CORE X_NUC_20.L_CORE 0.006606
K_542 X_NUC_10.L_CORE X_NUC_21.L_CORE 0.008453
K_543 X_NUC_10.L_CORE X_NUC_22.L_CORE 0.008601
K_544 X_NUC_10.L_CORE X_NUC_23.L_CORE 0.008542
K_545 X_NUC_10.L_CORE X_NUC_24.L_CORE 0.008282
K_546 X_NUC_10.L_CORE X_NUC_25.L_CORE 0.004268
K_547 X_NUC_10.L_CORE X_NUC_26.L_CORE 0.004201
K_548 X_NUC_10.L_CORE X_NUC_27.L_CORE 0.004238
K_549 X_NUC_10.L_CORE X_NUC_28.L_CORE 0.004192
K_550 X_NUC_10.L_CORE X_NUC_29.L_CORE 0.008772
K_551 X_NUC_10.L_CORE X_NUC_30.L_CORE 0.008663
K_552 X_NUC_10.L_CORE X_NUC_31.L_CORE 0.008427
K_553 X_NUC_10.L_CORE X_NUC_32.L_CORE 0.008602
K_554 X_NUC_10.L_CORE X_NUC_33.L_CORE 0.004765
K_555 X_NUC_10.L_CORE X_NUC_34.L_CORE 0.004755
K_556 X_NUC_10.L_CORE X_NUC_35.L_CORE 0.004765
K_557 X_NUC_10.L_CORE X_NUC_36.L_CORE 0.004675
K_558 X_NUC_10.L_CORE X_NUC_37.L_CORE 0.004472
K_559 X_NUC_10.L_CORE X_NUC_38.L_CORE 0.004394
K_560 X_NUC_10.L_CORE X_NUC_39.L_CORE 0.004398
K_561 X_NUC_10.L_CORE X_NUC_40.L_CORE 0.004391
K_562 X_NUC_10.L_CORE X_NUC_41.L_CORE 0.006524
K_563 X_NUC_10.L_CORE X_NUC_42.L_CORE 0.006567
K_564 X_NUC_10.L_CORE X_NUC_43.L_CORE 0.006424
K_565 X_NUC_10.L_CORE X_NUC_44.L_CORE 0.006392
K_566 X_NUC_10.L_CORE X_NUC_45.L_CORE 0.003959
K_567 X_NUC_10.L_CORE X_NUC_46.L_CORE 0.003924
K_568 X_NUC_10.L_CORE X_NUC_47.L_CORE 0.003929
K_569 X_NUC_10.L_CORE X_NUC_48.L_CORE 0.003886
K_570 X_NUC_10.L_CORE X_NUC_49.L_CORE 0.004856
K_571 X_NUC_10.L_CORE X_NUC_50.L_CORE 0.004805
K_572 X_NUC_10.L_CORE X_NUC_51.L_CORE 0.004757
K_573 X_NUC_10.L_CORE X_NUC_52.L_CORE 0.004764
K_574 X_NUC_10.L_CORE X_NUC_53.L_CORE 0.004477
K_575 X_NUC_10.L_CORE X_NUC_54.L_CORE 0.004463
K_576 X_NUC_10.L_CORE X_NUC_55.L_CORE 0.004428
K_577 X_NUC_10.L_CORE X_NUC_56.L_CORE 0.004391
K_578 X_NUC_10.L_CORE X_NUC_57.L_CORE 0.007603
K_579 X_NUC_10.L_CORE X_NUC_58.L_CORE 0.004843
K_580 X_NUC_10.L_CORE X_NUC_59.L_CORE 0.017646
K_581 X_NUC_10.L_CORE X_NUC_60.L_CORE 0.004032
K_582 X_NUC_10.L_CORE X_NUC_61.L_CORE 0.004870
K_583 X_NUC_10.L_CORE X_NUC_62.L_CORE 0.005345
K_584 X_NUC_10.L_CORE X_NUC_63.L_CORE 0.003482
K_585 X_NUC_10.L_CORE X_NUC_64.L_CORE 0.004352
K_586 X_NUC_11.L_CORE X_NUC_12.L_CORE 0.207973
K_587 X_NUC_11.L_CORE X_NUC_13.L_CORE 0.005058
K_588 X_NUC_11.L_CORE X_NUC_14.L_CORE 0.005003
K_589 X_NUC_11.L_CORE X_NUC_15.L_CORE 0.005078
K_590 X_NUC_11.L_CORE X_NUC_16.L_CORE 0.004970
K_591 X_NUC_11.L_CORE X_NUC_17.L_CORE 0.006679
K_592 X_NUC_11.L_CORE X_NUC_18.L_CORE 0.006481
K_593 X_NUC_11.L_CORE X_NUC_19.L_CORE 0.006522
K_594 X_NUC_11.L_CORE X_NUC_20.L_CORE 0.006566
K_595 X_NUC_11.L_CORE X_NUC_21.L_CORE 0.008504
K_596 X_NUC_11.L_CORE X_NUC_22.L_CORE 0.008647
K_597 X_NUC_11.L_CORE X_NUC_23.L_CORE 0.008601
K_598 X_NUC_11.L_CORE X_NUC_24.L_CORE 0.008330
K_599 X_NUC_11.L_CORE X_NUC_25.L_CORE 0.004229
K_600 X_NUC_11.L_CORE X_NUC_26.L_CORE 0.004163
K_601 X_NUC_11.L_CORE X_NUC_27.L_CORE 0.004201
K_602 X_NUC_11.L_CORE X_NUC_28.L_CORE 0.004155
K_603 X_NUC_11.L_CORE X_NUC_29.L_CORE 0.009031
K_604 X_NUC_11.L_CORE X_NUC_30.L_CORE 0.008903
K_605 X_NUC_11.L_CORE X_NUC_31.L_CORE 0.008663
K_606 X_NUC_11.L_CORE X_NUC_32.L_CORE 0.008846
K_607 X_NUC_11.L_CORE X_NUC_33.L_CORE 0.004754
K_608 X_NUC_11.L_CORE X_NUC_34.L_CORE 0.004742
K_609 X_NUC_11.L_CORE X_NUC_35.L_CORE 0.004755
K_610 X_NUC_11.L_CORE X_NUC_36.L_CORE 0.004664
K_611 X_NUC_11.L_CORE X_NUC_37.L_CORE 0.004467
K_612 X_NUC_11.L_CORE X_NUC_38.L_CORE 0.004389
K_613 X_NUC_11.L_CORE X_NUC_39.L_CORE 0.004394
K_614 X_NUC_11.L_CORE X_NUC_40.L_CORE 0.004386
K_615 X_NUC_11.L_CORE X_NUC_41.L_CORE 0.006670
K_616 X_NUC_11.L_CORE X_NUC_42.L_CORE 0.006712
K_617 X_NUC_11.L_CORE X_NUC_43.L_CORE 0.006567
K_618 X_NUC_11.L_CORE X_NUC_44.L_CORE 0.006529
K_619 X_NUC_11.L_CORE X_NUC_45.L_CORE 0.003953
K_620 X_NUC_11.L_CORE X_NUC_46.L_CORE 0.003918
K_621 X_NUC_11.L_CORE X_NUC_47.L_CORE 0.003924
K_622 X_NUC_11.L_CORE X_NUC_48.L_CORE 0.003880
K_623 X_NUC_11.L_CORE X_NUC_49.L_CORE 0.004905
K_624 X_NUC_11.L_CORE X_NUC_50.L_CORE 0.004852
K_625 X_NUC_11.L_CORE X_NUC_51.L_CORE 0.004805
K_626 X_NUC_11.L_CORE X_NUC_52.L_CORE 0.004811
K_627 X_NUC_11.L_CORE X_NUC_53.L_CORE 0.004512
K_628 X_NUC_11.L_CORE X_NUC_54.L_CORE 0.004497
K_629 X_NUC_11.L_CORE X_NUC_55.L_CORE 0.004463
K_630 X_NUC_11.L_CORE X_NUC_56.L_CORE 0.004424
K_631 X_NUC_11.L_CORE X_NUC_57.L_CORE 0.007382
K_632 X_NUC_11.L_CORE X_NUC_58.L_CORE 0.004768
K_633 X_NUC_11.L_CORE X_NUC_59.L_CORE 0.019167
K_634 X_NUC_11.L_CORE X_NUC_60.L_CORE 0.003996
K_635 X_NUC_11.L_CORE X_NUC_61.L_CORE 0.004883
K_636 X_NUC_11.L_CORE X_NUC_62.L_CORE 0.005410
K_637 X_NUC_11.L_CORE X_NUC_63.L_CORE 0.003477
K_638 X_NUC_11.L_CORE X_NUC_64.L_CORE 0.004407
K_639 X_NUC_12.L_CORE X_NUC_13.L_CORE 0.005170
K_640 X_NUC_12.L_CORE X_NUC_14.L_CORE 0.005111
K_641 X_NUC_12.L_CORE X_NUC_15.L_CORE 0.005190
K_642 X_NUC_12.L_CORE X_NUC_16.L_CORE 0.005078
K_643 X_NUC_12.L_CORE X_NUC_17.L_CORE 0.006629
K_644 X_NUC_12.L_CORE X_NUC_18.L_CORE 0.006436
K_645 X_NUC_12.L_CORE X_NUC_19.L_CORE 0.006473
K_646 X_NUC_12.L_CORE X_NUC_20.L_CORE 0.006522
K_647 X_NUC_12.L_CORE X_NUC_21.L_CORE 0.008786
K_648 X_NUC_12.L_CORE X_NUC_22.L_CORE 0.008944
K_649 X_NUC_12.L_CORE X_NUC_23.L_CORE 0.008885
K_650 X_NUC_12.L_CORE X_NUC_24.L_CORE 0.008601
K_651 X_NUC_12.L_CORE X_NUC_25.L_CORE 0.004276
K_652 X_NUC_12.L_CORE X_NUC_26.L_CORE 0.004208
K_653 X_NUC_12.L_CORE X_NUC_27.L_CORE 0.004246
K_654 X_NUC_12.L_CORE X_NUC_28.L_CORE 0.004201
K_655 X_NUC_12.L_CORE X_NUC_29.L_CORE 0.008828
K_656 X_NUC_12.L_CORE X_NUC_30.L_CORE 0.008709
K_657 X_NUC_12.L_CORE X_NUC_31.L_CORE 0.008477
K_658 X_NUC_12.L_CORE X_NUC_32.L_CORE 0.008663
K_659 X_NUC_12.L_CORE X_NUC_33.L_CORE 0.004848
K_660 X_NUC_12.L_CORE X_NUC_34.L_CORE 0.004836
K_661 X_NUC_12.L_CORE X_NUC_35.L_CORE 0.004848
K_662 X_NUC_12.L_CORE X_NUC_36.L_CORE 0.004755
K_663 X_NUC_12.L_CORE X_NUC_37.L_CORE 0.004474
K_664 X_NUC_12.L_CORE X_NUC_38.L_CORE 0.004396
K_665 X_NUC_12.L_CORE X_NUC_39.L_CORE 0.004400
K_666 X_NUC_12.L_CORE X_NUC_40.L_CORE 0.004394
K_667 X_NUC_12.L_CORE X_NUC_41.L_CORE 0.006707
K_668 X_NUC_12.L_CORE X_NUC_42.L_CORE 0.006750
K_669 X_NUC_12.L_CORE X_NUC_43.L_CORE 0.006598
K_670 X_NUC_12.L_CORE X_NUC_44.L_CORE 0.006567
K_671 X_NUC_12.L_CORE X_NUC_45.L_CORE 0.003999
K_672 X_NUC_12.L_CORE X_NUC_46.L_CORE 0.003962
K_673 X_NUC_12.L_CORE X_NUC_47.L_CORE 0.003968
K_674 X_NUC_12.L_CORE X_NUC_48.L_CORE 0.003924
K_675 X_NUC_12.L_CORE X_NUC_49.L_CORE 0.004898
K_676 X_NUC_12.L_CORE X_NUC_50.L_CORE 0.004844
K_677 X_NUC_12.L_CORE X_NUC_51.L_CORE 0.004796
K_678 X_NUC_12.L_CORE X_NUC_52.L_CORE 0.004805
K_679 X_NUC_12.L_CORE X_NUC_53.L_CORE 0.004552
K_680 X_NUC_12.L_CORE X_NUC_54.L_CORE 0.004536
K_681 X_NUC_12.L_CORE X_NUC_55.L_CORE 0.004500
K_682 X_NUC_12.L_CORE X_NUC_56.L_CORE 0.004463
K_683 X_NUC_12.L_CORE X_NUC_57.L_CORE 0.007621
K_684 X_NUC_12.L_CORE X_NUC_58.L_CORE 0.004799
K_685 X_NUC_12.L_CORE X_NUC_59.L_CORE 0.018180
K_686 X_NUC_12.L_CORE X_NUC_60.L_CORE 0.004066
K_687 X_NUC_12.L_CORE X_NUC_61.L_CORE 0.004846
K_688 X_NUC_12.L_CORE X_NUC_62.L_CORE 0.005484
K_689 X_NUC_12.L_CORE X_NUC_63.L_CORE 0.003502
K_690 X_NUC_12.L_CORE X_NUC_64.L_CORE 0.004403
K_691 X_NUC_13.L_CORE X_NUC_14.L_CORE 0.207973
K_692 X_NUC_13.L_CORE X_NUC_15.L_CORE 0.207973
K_693 X_NUC_13.L_CORE X_NUC_16.L_CORE 0.207973
K_694 X_NUC_13.L_CORE X_NUC_17.L_CORE 0.004608
K_695 X_NUC_13.L_CORE X_NUC_18.L_CORE 0.004582
K_696 X_NUC_13.L_CORE X_NUC_19.L_CORE 0.004541
K_697 X_NUC_13.L_CORE X_NUC_20.L_CORE 0.004638
K_698 X_NUC_13.L_CORE X_NUC_21.L_CORE 0.006064
K_699 X_NUC_13.L_CORE X_NUC_22.L_CORE 0.006214
K_700 X_NUC_13.L_CORE X_NUC_23.L_CORE 0.006062
K_701 X_NUC_13.L_CORE X_NUC_24.L_CORE 0.006154
K_702 X_NUC_13.L_CORE X_NUC_25.L_CORE 0.008285
K_703 X_NUC_13.L_CORE X_NUC_26.L_CORE 0.008026
K_704 X_NUC_13.L_CORE X_NUC_27.L_CORE 0.007992
K_705 X_NUC_13.L_CORE X_NUC_28.L_CORE 0.008108
K_706 X_NUC_13.L_CORE X_NUC_29.L_CORE 0.003995
K_707 X_NUC_13.L_CORE X_NUC_30.L_CORE 0.004011
K_708 X_NUC_13.L_CORE X_NUC_31.L_CORE 0.003952
K_709 X_NUC_13.L_CORE X_NUC_32.L_CORE 0.004023
K_710 X_NUC_13.L_CORE X_NUC_33.L_CORE 0.008749
K_711 X_NUC_13.L_CORE X_NUC_34.L_CORE 0.008967
K_712 X_NUC_13.L_CORE X_NUC_35.L_CORE 0.008648
K_713 X_NUC_13.L_CORE X_NUC_36.L_CORE 0.008637
K_714 X_NUC_13.L_CORE X_NUC_37.L_CORE 0.004657
K_715 X_NUC_13.L_CORE X_NUC_38.L_CORE 0.004609
K_716 X_NUC_13.L_CORE X_NUC_39.L_CORE 0.004559
K_717 X_NUC_13.L_CORE X_NUC_40.L_CORE 0.004632
K_718 X_NUC_13.L_CORE X_NUC_41.L_CORE 0.004344
K_719 X_NUC_13.L_CORE X_NUC_42.L_CORE 0.004391
K_720 X_NUC_13.L_CORE X_NUC_43.L_CORE 0.004302
K_721 X_NUC_13.L_CORE X_NUC_44.L_CORE 0.004360
K_722 X_NUC_13.L_CORE X_NUC_45.L_CORE 0.006567
K_723 X_NUC_13.L_CORE X_NUC_46.L_CORE 0.006521
K_724 X_NUC_13.L_CORE X_NUC_47.L_CORE 0.006392
K_725 X_NUC_13.L_CORE X_NUC_48.L_CORE 0.006421
K_726 X_NUC_13.L_CORE X_NUC_49.L_CORE 0.003994
K_727 X_NUC_13.L_CORE X_NUC_50.L_CORE 0.003991
K_728 X_NUC_13.L_CORE X_NUC_51.L_CORE 0.003929
K_729 X_NUC_13.L_CORE X_NUC_52.L_CORE 0.003985
K_730 X_NUC_13.L_CORE X_NUC_53.L_CORE 0.004762
K_731 X_NUC_13.L_CORE X_NUC_54.L_CORE 0.004789
K_732 X_NUC_13.L_CORE X_NUC_55.L_CORE 0.004687
K_733 X_NUC_13.L_CORE X_NUC_56.L_CORE 0.004729
K_734 X_NUC_13.L_CORE X_NUC_57.L_CORE 0.008774
K_735 X_NUC_13.L_CORE X_NUC_58.L_CORE 0.006066
K_736 X_NUC_13.L_CORE X_NUC_59.L_CORE 0.004150
K_737 X_NUC_13.L_CORE X_NUC_60.L_CORE 0.015176
K_738 X_NUC_13.L_CORE X_NUC_61.L_CORE 0.003745
K_739 X_NUC_13.L_CORE X_NUC_62.L_CORE 0.004636
K_740 X_NUC_13.L_CORE X_NUC_63.L_CORE 0.005065
K_741 X_NUC_13.L_CORE X_NUC_64.L_CORE 0.003592
K_742 X_NUC_14.L_CORE X_NUC_15.L_CORE 0.207973
K_743 X_NUC_14.L_CORE X_NUC_16.L_CORE 0.207973
K_744 X_NUC_14.L_CORE X_NUC_17.L_CORE 0.004633
K_745 X_NUC_14.L_CORE X_NUC_18.L_CORE 0.004608
K_746 X_NUC_14.L_CORE X_NUC_19.L_CORE 0.004565
K_747 X_NUC_14.L_CORE X_NUC_20.L_CORE 0.004664
K_748 X_NUC_14.L_CORE X_NUC_21.L_CORE 0.005919
K_749 X_NUC_14.L_CORE X_NUC_22.L_CORE 0.006064
K_750 X_NUC_14.L_CORE X_NUC_23.L_CORE 0.005920
K_751 X_NUC_14.L_CORE X_NUC_24.L_CORE 0.006005
K_752 X_NUC_14.L_CORE X_NUC_25.L_CORE 0.008555
K_753 X_NUC_14.L_CORE X_NUC_26.L_CORE 0.008285
K_754 X_NUC_14.L_CORE X_NUC_27.L_CORE 0.008241
K_755 X_NUC_14.L_CORE X_NUC_28.L_CORE 0.008368
K_756 X_NUC_14.L_CORE X_NUC_29.L_CORE 0.003978
K_757 X_NUC_14.L_CORE X_NUC_30.L_CORE 0.003995
K_758 X_NUC_14.L_CORE X_NUC_31.L_CORE 0.003936
K_759 X_NUC_14.L_CORE X_NUC_32.L_CORE 0.004006
K_760 X_NUC_14.L_CORE X_NUC_33.L_CORE 0.008531
K_761 X_NUC_14.L_CORE X_NUC_34.L_CORE 0.008749
K_762 X_NUC_14.L_CORE X_NUC_35.L_CORE 0.008445
K_763 X_NUC_14.L_CORE X_NUC_36.L_CORE 0.008435
K_764 X_NUC_14.L_CORE X_NUC_37.L_CORE 0.004703
K_765 X_NUC_14.L_CORE X_NUC_38.L_CORE 0.004657
K_766 X_NUC_14.L_CORE X_NUC_39.L_CORE 0.004604
K_767 X_NUC_14.L_CORE X_NUC_40.L_CORE 0.004679
K_768 X_NUC_14.L_CORE X_NUC_41.L_CORE 0.004297
K_769 X_NUC_14.L_CORE X_NUC_42.L_CORE 0.004344
K_770 X_NUC_14.L_CORE X_NUC_43.L_CORE 0.004257
K_771 X_NUC_14.L_CORE X_NUC_44.L_CORE 0.004313
K_772 X_NUC_14.L_CORE X_NUC_45.L_CORE 0.006606
K_773 X_NUC_14.L_CORE X_NUC_46.L_CORE 0.006567
K_774 X_NUC_14.L_CORE X_NUC_47.L_CORE 0.006431
K_775 X_NUC_14.L_CORE X_NUC_48.L_CORE 0.006461
K_776 X_NUC_14.L_CORE X_NUC_49.L_CORE 0.003995
K_777 X_NUC_14.L_CORE X_NUC_50.L_CORE 0.003994
K_778 X_NUC_14.L_CORE X_NUC_51.L_CORE 0.003931
K_779 X_NUC_14.L_CORE X_NUC_52.L_CORE 0.003987
K_780 X_NUC_14.L_CORE X_NUC_53.L_CORE 0.004732
K_781 X_NUC_14.L_CORE X_NUC_54.L_CORE 0.004762
K_782 X_NUC_14.L_CORE X_NUC_55.L_CORE 0.004660
K_783 X_NUC_14.L_CORE X_NUC_56.L_CORE 0.004702
K_784 X_NUC_14.L_CORE X_NUC_57.L_CORE 0.008557
K_785 X_NUC_14.L_CORE X_NUC_58.L_CORE 0.006187
K_786 X_NUC_14.L_CORE X_NUC_59.L_CORE 0.004107
K_787 X_NUC_14.L_CORE X_NUC_60.L_CORE 0.015279
K_788 X_NUC_14.L_CORE X_NUC_61.L_CORE 0.003764
K_789 X_NUC_14.L_CORE X_NUC_62.L_CORE 0.004562
K_790 X_NUC_14.L_CORE X_NUC_63.L_CORE 0.005124
K_791 X_NUC_14.L_CORE X_NUC_64.L_CORE 0.003584
K_792 X_NUC_15.L_CORE X_NUC_16.L_CORE 0.207973
K_793 X_NUC_15.L_CORE X_NUC_17.L_CORE 0.004677
K_794 X_NUC_15.L_CORE X_NUC_18.L_CORE 0.004650
K_795 X_NUC_15.L_CORE X_NUC_19.L_CORE 0.004608
K_796 X_NUC_15.L_CORE X_NUC_20.L_CORE 0.004709
K_797 X_NUC_15.L_CORE X_NUC_21.L_CORE 0.006060
K_798 X_NUC_15.L_CORE X_NUC_22.L_CORE 0.006213
K_799 X_NUC_15.L_CORE X_NUC_23.L_CORE 0.006064
K_800 X_NUC_15.L_CORE X_NUC_24.L_CORE 0.006153
K_801 X_NUC_15.L_CORE X_NUC_25.L_CORE 0.008598
K_802 X_NUC_15.L_CORE X_NUC_26.L_CORE 0.008316
K_803 X_NUC_15.L_CORE X_NUC_27.L_CORE 0.008285
K_804 X_NUC_15.L_CORE X_NUC_28.L_CORE 0.008408
K_805 X_NUC_15.L_CORE X_NUC_29.L_CORE 0.004039
K_806 X_NUC_15.L_CORE X_NUC_30.L_CORE 0.004056
K_807 X_NUC_15.L_CORE X_NUC_31.L_CORE 0.003995
K_808 X_NUC_15.L_CORE X_NUC_32.L_CORE 0.004068
K_809 X_NUC_15.L_CORE X_NUC_33.L_CORE 0.008837
K_810 X_NUC_15.L_CORE X_NUC_34.L_CORE 0.009071
K_811 X_NUC_15.L_CORE X_NUC_35.L_CORE 0.008749
K_812 X_NUC_15.L_CORE X_NUC_36.L_CORE 0.008730
K_813 X_NUC_15.L_CORE X_NUC_37.L_CORE 0.004758
K_814 X_NUC_15.L_CORE X_NUC_38.L_CORE 0.004709
K_815 X_NUC_15.L_CORE X_NUC_39.L_CORE 0.004657
K_816 X_NUC_15.L_CORE X_NUC_40.L_CORE 0.004734
K_817 X_NUC_15.L_CORE X_NUC_41.L_CORE 0.004385
K_818 X_NUC_15.L_CORE X_NUC_42.L_CORE 0.004435
K_819 X_NUC_15.L_CORE X_NUC_43.L_CORE 0.004344
K_820 X_NUC_15.L_CORE X_NUC_44.L_CORE 0.004403
K_821 X_NUC_15.L_CORE X_NUC_45.L_CORE 0.006749
K_822 X_NUC_15.L_CORE X_NUC_46.L_CORE 0.006704
K_823 X_NUC_15.L_CORE X_NUC_47.L_CORE 0.006567
K_824 X_NUC_15.L_CORE X_NUC_48.L_CORE 0.006595
K_825 X_NUC_15.L_CORE X_NUC_49.L_CORE 0.004060
K_826 X_NUC_15.L_CORE X_NUC_50.L_CORE 0.004058
K_827 X_NUC_15.L_CORE X_NUC_51.L_CORE 0.003994
K_828 X_NUC_15.L_CORE X_NUC_52.L_CORE 0.004052
K_829 X_NUC_15.L_CORE X_NUC_53.L_CORE 0.004838
K_830 X_NUC_15.L_CORE X_NUC_54.L_CORE 0.004868
K_831 X_NUC_15.L_CORE X_NUC_55.L_CORE 0.004762
K_832 X_NUC_15.L_CORE X_NUC_56.L_CORE 0.004805
K_833 X_NUC_15.L_CORE X_NUC_57.L_CORE 0.008586
K_834 X_NUC_15.L_CORE X_NUC_58.L_CORE 0.006163
K_835 X_NUC_15.L_CORE X_NUC_59.L_CORE 0.004165
K_836 X_NUC_15.L_CORE X_NUC_60.L_CORE 0.015371
K_837 X_NUC_15.L_CORE X_NUC_61.L_CORE 0.003801
K_838 X_NUC_15.L_CORE X_NUC_62.L_CORE 0.004659
K_839 X_NUC_15.L_CORE X_NUC_63.L_CORE 0.005186
K_840 X_NUC_15.L_CORE X_NUC_64.L_CORE 0.003642
K_841 X_NUC_16.L_CORE X_NUC_17.L_CORE 0.004577
K_842 X_NUC_16.L_CORE X_NUC_18.L_CORE 0.004552
K_843 X_NUC_16.L_CORE X_NUC_19.L_CORE 0.004512
K_844 X_NUC_16.L_CORE X_NUC_20.L_CORE 0.004608
K_845 X_NUC_16.L_CORE X_NUC_21.L_CORE 0.005973
K_846 X_NUC_16.L_CORE X_NUC_22.L_CORE 0.006119
K_847 X_NUC_16.L_CORE X_NUC_23.L_CORE 0.005974
K_848 X_NUC_16.L_CORE X_NUC_24.L_CORE 0.006064
K_849 X_NUC_16.L_CORE X_NUC_25.L_CORE 0.008459
K_850 X_NUC_16.L_CORE X_NUC_26.L_CORE 0.008191
K_851 X_NUC_16.L_CORE X_NUC_27.L_CORE 0.008154
K_852 X_NUC_16.L_CORE X_NUC_28.L_CORE 0.008285
K_853 X_NUC_16.L_CORE X_NUC_29.L_CORE 0.003967
K_854 X_NUC_16.L_CORE X_NUC_30.L_CORE 0.003983
K_855 X_NUC_16.L_CORE X_NUC_31.L_CORE 0.003925
K_856 X_NUC_16.L_CORE X_NUC_32.L_CORE 0.003995
K_857 X_NUC_16.L_CORE X_NUC_33.L_CORE 0.008849
K_858 X_NUC_16.L_CORE X_NUC_34.L_CORE 0.009083
K_859 X_NUC_16.L_CORE X_NUC_35.L_CORE 0.008752
K_860 X_NUC_16.L_CORE X_NUC_36.L_CORE 0.008749
K_861 X_NUC_16.L_CORE X_NUC_37.L_CORE 0.004679
K_862 X_NUC_16.L_CORE X_NUC_38.L_CORE 0.004632
K_863 X_NUC_16.L_CORE X_NUC_39.L_CORE 0.004581
K_864 X_NUC_16.L_CORE X_NUC_40.L_CORE 0.004657
K_865 X_NUC_16.L_CORE X_NUC_41.L_CORE 0.004326
K_866 X_NUC_16.L_CORE X_NUC_42.L_CORE 0.004374
K_867 X_NUC_16.L_CORE X_NUC_43.L_CORE 0.004286
K_868 X_NUC_16.L_CORE X_NUC_44.L_CORE 0.004344
K_869 X_NUC_16.L_CORE X_NUC_45.L_CORE 0.006715
K_870 X_NUC_16.L_CORE X_NUC_46.L_CORE 0.006671
K_871 X_NUC_16.L_CORE X_NUC_47.L_CORE 0.006532
K_872 X_NUC_16.L_CORE X_NUC_48.L_CORE 0.006567
K_873 X_NUC_16.L_CORE X_NUC_49.L_CORE 0.004001
K_874 X_NUC_16.L_CORE X_NUC_50.L_CORE 0.003999
K_875 X_NUC_16.L_CORE X_NUC_51.L_CORE 0.003937
K_876 X_NUC_16.L_CORE X_NUC_52.L_CORE 0.003994
K_877 X_NUC_16.L_CORE X_NUC_53.L_CORE 0.004792
K_878 X_NUC_16.L_CORE X_NUC_54.L_CORE 0.004821
K_879 X_NUC_16.L_CORE X_NUC_55.L_CORE 0.004717
K_880 X_NUC_16.L_CORE X_NUC_56.L_CORE 0.004762
K_881 X_NUC_16.L_CORE X_NUC_57.L_CORE 0.008421
K_882 X_NUC_16.L_CORE X_NUC_58.L_CORE 0.006036
K_883 X_NUC_16.L_CORE X_NUC_59.L_CORE 0.004095
K_884 X_NUC_16.L_CORE X_NUC_60.L_CORE 0.016248
K_885 X_NUC_16.L_CORE X_NUC_61.L_CORE 0.003739
K_886 X_NUC_16.L_CORE X_NUC_62.L_CORE 0.004622
K_887 X_NUC_16.L_CORE X_NUC_63.L_CORE 0.005153
K_888 X_NUC_16.L_CORE X_NUC_64.L_CORE 0.003600
K_889 X_NUC_17.L_CORE X_NUC_18.L_CORE 0.207973
K_890 X_NUC_17.L_CORE X_NUC_19.L_CORE 0.207973
K_891 X_NUC_17.L_CORE X_NUC_20.L_CORE 0.207973
K_892 X_NUC_17.L_CORE X_NUC_21.L_CORE 0.004343
K_893 X_NUC_17.L_CORE X_NUC_22.L_CORE 0.004420
K_894 X_NUC_17.L_CORE X_NUC_23.L_CORE 0.004401
K_895 X_NUC_17.L_CORE X_NUC_24.L_CORE 0.004350
K_896 X_NUC_17.L_CORE X_NUC_25.L_CORE 0.005807
K_897 X_NUC_17.L_CORE X_NUC_26.L_CORE 0.005765
K_898 X_NUC_17.L_CORE X_NUC_27.L_CORE 0.005837
K_899 X_NUC_17.L_CORE X_NUC_28.L_CORE 0.005687
K_900 X_NUC_17.L_CORE X_NUC_29.L_CORE 0.008103
K_901 X_NUC_17.L_CORE X_NUC_30.L_CORE 0.008386
K_902 X_NUC_17.L_CORE X_NUC_31.L_CORE 0.008104
K_903 X_NUC_17.L_CORE X_NUC_32.L_CORE 0.008166
K_904 X_NUC_17.L_CORE X_NUC_33.L_CORE 0.003905
K_905 X_NUC_17.L_CORE X_NUC_34.L_CORE 0.003939
K_906 X_NUC_17.L_CORE X_NUC_35.L_CORE 0.003937
K_907 X_NUC_17.L_CORE X_NUC_36.L_CORE 0.003876
K_908 X_NUC_17.L_CORE X_NUC_37.L_CORE 0.008771
K_909 X_NUC_17.L_CORE X_NUC_38.L_CORE 0.008630
K_910 X_NUC_17.L_CORE X_NUC_39.L_CORE 0.008575
K_911 X_NUC_17.L_CORE X_NUC_40.L_CORE 0.008421
K_912 X_NUC_17.L_CORE X_NUC_41.L_CORE 0.004657
K_913 X_NUC_17.L_CORE X_NUC_42.L_CORE 0.004742
K_914 X_NUC_17.L_CORE X_NUC_43.L_CORE 0.004675
K_915 X_NUC_17.L_CORE X_NUC_44.L_CORE 0.004645
K_916 X_NUC_17.L_CORE X_NUC_45.L_CORE 0.004394
K_917 X_NUC_17.L_CORE X_NUC_46.L_CORE 0.004403
K_918 X_NUC_17.L_CORE X_NUC_47.L_CORE 0.004399
K_919 X_NUC_17.L_CORE X_NUC_48.L_CORE 0.004325
K_920 X_NUC_17.L_CORE X_NUC_49.L_CORE 0.006388
K_921 X_NUC_17.L_CORE X_NUC_50.L_CORE 0.006447
K_922 X_NUC_17.L_CORE X_NUC_51.L_CORE 0.006300
K_923 X_NUC_17.L_CORE X_NUC_52.L_CORE 0.006275
K_924 X_NUC_17.L_CORE X_NUC_53.L_CORE 0.004269
K_925 X_NUC_17.L_CORE X_NUC_54.L_CORE 0.004310
K_926 X_NUC_17.L_CORE X_NUC_55.L_CORE 0.004268
K_927 X_NUC_17.L_CORE X_NUC_56.L_CORE 0.004222
K_928 X_NUC_17.L_CORE X_NUC_57.L_CORE 0.004633
K_929 X_NUC_17.L_CORE X_NUC_58.L_CORE 0.008242
K_930 X_NUC_17.L_CORE X_NUC_59.L_CORE 0.005547
K_931 X_NUC_17.L_CORE X_NUC_60.L_CORE 0.003831
K_932 X_NUC_17.L_CORE X_NUC_61.L_CORE 0.012783
K_933 X_NUC_17.L_CORE X_NUC_62.L_CORE 0.003698
K_934 X_NUC_17.L_CORE X_NUC_63.L_CORE 0.004505
K_935 X_NUC_17.L_CORE X_NUC_64.L_CORE 0.004780
K_936 X_NUC_18.L_CORE X_NUC_19.L_CORE 0.207973
K_937 X_NUC_18.L_CORE X_NUC_20.L_CORE 0.207973
K_938 X_NUC_18.L_CORE X_NUC_21.L_CORE 0.004269
K_939 X_NUC_18.L_CORE X_NUC_22.L_CORE 0.004343
K_940 X_NUC_18.L_CORE X_NUC_23.L_CORE 0.004324
K_941 X_NUC_18.L_CORE X_NUC_24.L_CORE 0.004276
K_942 X_NUC_18.L_CORE X_NUC_25.L_CORE 0.005845
K_943 X_NUC_18.L_CORE X_NUC_26.L_CORE 0.005807
K_944 X_NUC_18.L_CORE X_NUC_27.L_CORE 0.005878
K_945 X_NUC_18.L_CORE X_NUC_28.L_CORE 0.005725
K_946 X_NUC_18.L_CORE X_NUC_29.L_CORE 0.007835
K_947 X_NUC_18.L_CORE X_NUC_30.L_CORE 0.008103
K_948 X_NUC_18.L_CORE X_NUC_31.L_CORE 0.007841
K_949 X_NUC_18.L_CORE X_NUC_32.L_CORE 0.007897
K_950 X_NUC_18.L_CORE X_NUC_33.L_CORE 0.003870
K_951 X_NUC_18.L_CORE X_NUC_34.L_CORE 0.003905
K_952 X_NUC_18.L_CORE X_NUC_35.L_CORE 0.003902
K_953 X_NUC_18.L_CORE X_NUC_36.L_CORE 0.003843
K_954 X_NUC_18.L_CORE X_NUC_37.L_CORE 0.008903
K_955 X_NUC_18.L_CORE X_NUC_38.L_CORE 0.008771
K_956 X_NUC_18.L_CORE X_NUC_39.L_CORE 0.008706
K_957 X_NUC_18.L_CORE X_NUC_40.L_CORE 0.008544
K_958 X_NUC_18.L_CORE X_NUC_41.L_CORE 0.004573
K_959 X_NUC_18.L_CORE X_NUC_42.L_CORE 0.004657
K_960 X_NUC_18.L_CORE X_NUC_43.L_CORE 0.004592
K_961 X_NUC_18.L_CORE X_NUC_44.L_CORE 0.004564
K_962 X_NUC_18.L_CORE X_NUC_45.L_CORE 0.004384
K_963 X_NUC_18.L_CORE X_NUC_46.L_CORE 0.004394
K_964 X_NUC_18.L_CORE X_NUC_47.L_CORE 0.004389
K_965 X_NUC_18.L_CORE X_NUC_48.L_CORE 0.004316
K_966 X_NUC_18.L_CORE X_NUC_49.L_CORE 0.006325
K_967 X_NUC_18.L_CORE X_NUC_50.L_CORE 0.006388
K_968 X_NUC_18.L_CORE X_NUC_51.L_CORE 0.006243
K_969 X_NUC_18.L_CORE X_NUC_52.L_CORE 0.006218
K_970 X_NUC_18.L_CORE X_NUC_53.L_CORE 0.004228
K_971 X_NUC_18.L_CORE X_NUC_54.L_CORE 0.004269
K_972 X_NUC_18.L_CORE X_NUC_55.L_CORE 0.004228
K_973 X_NUC_18.L_CORE X_NUC_56.L_CORE 0.004183
K_974 X_NUC_18.L_CORE X_NUC_57.L_CORE 0.004575
K_975 X_NUC_18.L_CORE X_NUC_58.L_CORE 0.008396
K_976 X_NUC_18.L_CORE X_NUC_59.L_CORE 0.005403
K_977 X_NUC_18.L_CORE X_NUC_60.L_CORE 0.003818
K_978 X_NUC_18.L_CORE X_NUC_61.L_CORE 0.013007
K_979 X_NUC_18.L_CORE X_NUC_62.L_CORE 0.003647
K_980 X_NUC_18.L_CORE X_NUC_63.L_CORE 0.004522
K_981 X_NUC_18.L_CORE X_NUC_64.L_CORE 0.004732
K_982 X_NUC_19.L_CORE X_NUC_20.L_CORE 0.207973
K_983 X_NUC_19.L_CORE X_NUC_21.L_CORE 0.004286
K_984 X_NUC_19.L_CORE X_NUC_22.L_CORE 0.004361
K_985 X_NUC_19.L_CORE X_NUC_23.L_CORE 0.004343
K_986 X_NUC_19.L_CORE X_NUC_24.L_CORE 0.004294
K_987 X_NUC_19.L_CORE X_NUC_25.L_CORE 0.005773
K_988 X_NUC_19.L_CORE X_NUC_26.L_CORE 0.005734
K_989 X_NUC_19.L_CORE X_NUC_27.L_CORE 0.005807
K_990 X_NUC_19.L_CORE X_NUC_28.L_CORE 0.005657
K_991 X_NUC_19.L_CORE X_NUC_29.L_CORE 0.008089
K_992 X_NUC_19.L_CORE X_NUC_30.L_CORE 0.008378
K_993 X_NUC_19.L_CORE X_NUC_31.L_CORE 0.008103
K_994 X_NUC_19.L_CORE X_NUC_32.L_CORE 0.008158
K_995 X_NUC_19.L_CORE X_NUC_33.L_CORE 0.003871
K_996 X_NUC_19.L_CORE X_NUC_34.L_CORE 0.003906
K_997 X_NUC_19.L_CORE X_NUC_35.L_CORE 0.003905
K_998 X_NUC_19.L_CORE X_NUC_36.L_CORE 0.003845
K_999 X_NUC_19.L_CORE X_NUC_37.L_CORE 0.008964
K_1000 X_NUC_19.L_CORE X_NUC_38.L_CORE 0.008821
K_1001 X_NUC_19.L_CORE X_NUC_39.L_CORE 0.008771
K_1002 X_NUC_19.L_CORE X_NUC_40.L_CORE 0.008598
K_1003 X_NUC_19.L_CORE X_NUC_41.L_CORE 0.004637
K_1004 X_NUC_19.L_CORE X_NUC_42.L_CORE 0.004722
K_1005 X_NUC_19.L_CORE X_NUC_43.L_CORE 0.004657
K_1006 X_NUC_19.L_CORE X_NUC_44.L_CORE 0.004626
K_1007 X_NUC_19.L_CORE X_NUC_45.L_CORE 0.004388
K_1008 X_NUC_19.L_CORE X_NUC_46.L_CORE 0.004397
K_1009 X_NUC_19.L_CORE X_NUC_47.L_CORE 0.004394
K_1010 X_NUC_19.L_CORE X_NUC_48.L_CORE 0.004319
K_1011 X_NUC_19.L_CORE X_NUC_49.L_CORE 0.006473
K_1012 X_NUC_19.L_CORE X_NUC_50.L_CORE 0.006538
K_1013 X_NUC_19.L_CORE X_NUC_51.L_CORE 0.006388
K_1014 X_NUC_19.L_CORE X_NUC_52.L_CORE 0.006358
K_1015 X_NUC_19.L_CORE X_NUC_53.L_CORE 0.004268
K_1016 X_NUC_19.L_CORE X_NUC_54.L_CORE 0.004310
K_1017 X_NUC_19.L_CORE X_NUC_55.L_CORE 0.004269
K_1018 X_NUC_19.L_CORE X_NUC_56.L_CORE 0.004223
K_1019 X_NUC_19.L_CORE X_NUC_57.L_CORE 0.004538
K_1020 X_NUC_19.L_CORE X_NUC_58.L_CORE 0.008093
K_1021 X_NUC_19.L_CORE X_NUC_59.L_CORE 0.005464
K_1022 X_NUC_19.L_CORE X_NUC_60.L_CORE 0.003795
K_1023 X_NUC_19.L_CORE X_NUC_61.L_CORE 0.013586
K_1024 X_NUC_19.L_CORE X_NUC_62.L_CORE 0.003675
K_1025 X_NUC_19.L_CORE X_NUC_63.L_CORE 0.004523
K_1026 X_NUC_19.L_CORE X_NUC_64.L_CORE 0.004819
K_1027 X_NUC_20.L_CORE X_NUC_21.L_CORE 0.004335
K_1028 X_NUC_20.L_CORE X_NUC_22.L_CORE 0.004412
K_1029 X_NUC_20.L_CORE X_NUC_23.L_CORE 0.004393
K_1030 X_NUC_20.L_CORE X_NUC_24.L_CORE 0.004343
K_1031 X_NUC_20.L_CORE X_NUC_25.L_CORE 0.005929
K_1032 X_NUC_20.L_CORE X_NUC_26.L_CORE 0.005887
K_1033 X_NUC_20.L_CORE X_NUC_27.L_CORE 0.005964
K_1034 X_NUC_20.L_CORE X_NUC_28.L_CORE 0.005807
K_1035 X_NUC_20.L_CORE X_NUC_29.L_CORE 0.008029
K_1036 X_NUC_20.L_CORE X_NUC_30.L_CORE 0.008311
K_1037 X_NUC_20.L_CORE X_NUC_31.L_CORE 0.008036
K_1038 X_NUC_20.L_CORE X_NUC_32.L_CORE 0.008103
K_1039 X_NUC_20.L_CORE X_NUC_33.L_CORE 0.003932
K_1040 X_NUC_20.L_CORE X_NUC_34.L_CORE 0.003968
K_1041 X_NUC_20.L_CORE X_NUC_35.L_CORE 0.003966
K_1042 X_NUC_20.L_CORE X_NUC_36.L_CORE 0.003905
K_1043 X_NUC_20.L_CORE X_NUC_37.L_CORE 0.009151
K_1044 X_NUC_20.L_CORE X_NUC_38.L_CORE 0.009000
K_1045 X_NUC_20.L_CORE X_NUC_39.L_CORE 0.008938
K_1046 X_NUC_20.L_CORE X_NUC_40.L_CORE 0.008771
K_1047 X_NUC_20.L_CORE X_NUC_41.L_CORE 0.004666
K_1048 X_NUC_20.L_CORE X_NUC_42.L_CORE 0.004753
K_1049 X_NUC_20.L_CORE X_NUC_43.L_CORE 0.004685
K_1050 X_NUC_20.L_CORE X_NUC_44.L_CORE 0.004657
K_1051 X_NUC_20.L_CORE X_NUC_45.L_CORE 0.004465
K_1052 X_NUC_20.L_CORE X_NUC_46.L_CORE 0.004475
K_1053 X_NUC_20.L_CORE X_NUC_47.L_CORE 0.004471
K_1054 X_NUC_20.L_CORE X_NUC_48.L_CORE 0.004394
K_1055 X_NUC_20.L_CORE X_NUC_49.L_CORE 0.006502
K_1056 X_NUC_20.L_CORE X_NUC_50.L_CORE 0.006567
K_1057 X_NUC_20.L_CORE X_NUC_51.L_CORE 0.006412
K_1058 X_NUC_20.L_CORE X_NUC_52.L_CORE 0.006388
K_1059 X_NUC_20.L_CORE X_NUC_53.L_CORE 0.004316
K_1060 X_NUC_20.L_CORE X_NUC_54.L_CORE 0.004359
K_1061 X_NUC_20.L_CORE X_NUC_55.L_CORE 0.004316
K_1062 X_NUC_20.L_CORE X_NUC_56.L_CORE 0.004269
K_1063 X_NUC_20.L_CORE X_NUC_57.L_CORE 0.004609
K_1064 X_NUC_20.L_CORE X_NUC_58.L_CORE 0.008342
K_1065 X_NUC_20.L_CORE X_NUC_59.L_CORE 0.005467
K_1066 X_NUC_20.L_CORE X_NUC_60.L_CORE 0.003864
K_1067 X_NUC_20.L_CORE X_NUC_61.L_CORE 0.013227
K_1068 X_NUC_20.L_CORE X_NUC_62.L_CORE 0.003706
K_1069 X_NUC_20.L_CORE X_NUC_63.L_CORE 0.004597
K_1070 X_NUC_20.L_CORE X_NUC_64.L_CORE 0.004832
K_1071 X_NUC_21.L_CORE X_NUC_22.L_CORE 0.207973
K_1072 X_NUC_21.L_CORE X_NUC_23.L_CORE 0.207973
K_1073 X_NUC_21.L_CORE X_NUC_24.L_CORE 0.207973
K_1074 X_NUC_21.L_CORE X_NUC_25.L_CORE 0.004205
K_1075 X_NUC_21.L_CORE X_NUC_26.L_CORE 0.004123
K_1076 X_NUC_21.L_CORE X_NUC_27.L_CORE 0.004165
K_1077 X_NUC_21.L_CORE X_NUC_28.L_CORE 0.004152
K_1078 X_NUC_21.L_CORE X_NUC_29.L_CORE 0.005690
K_1079 X_NUC_21.L_CORE X_NUC_30.L_CORE 0.005615
K_1080 X_NUC_21.L_CORE X_NUC_31.L_CORE 0.005565
K_1081 X_NUC_21.L_CORE X_NUC_32.L_CORE 0.005694
K_1082 X_NUC_21.L_CORE X_NUC_33.L_CORE 0.008044
K_1083 X_NUC_21.L_CORE X_NUC_34.L_CORE 0.007869
K_1084 X_NUC_21.L_CORE X_NUC_35.L_CORE 0.007962
K_1085 X_NUC_21.L_CORE X_NUC_36.L_CORE 0.007760
K_1086 X_NUC_21.L_CORE X_NUC_37.L_CORE 0.003905
K_1087 X_NUC_21.L_CORE X_NUC_38.L_CORE 0.003839
K_1088 X_NUC_21.L_CORE X_NUC_39.L_CORE 0.003846
K_1089 X_NUC_21.L_CORE X_NUC_40.L_CORE 0.003867
K_1090 X_NUC_21.L_CORE X_NUC_41.L_CORE 0.008749
K_1091 X_NUC_21.L_CORE X_NUC_42.L_CORE 0.008684
K_1092 X_NUC_21.L_CORE X_NUC_43.L_CORE 0.008417
K_1093 X_NUC_21.L_CORE X_NUC_44.L_CORE 0.008611
K_1094 X_NUC_21.L_CORE X_NUC_45.L_CORE 0.004755
K_1095 X_NUC_21.L_CORE X_NUC_46.L_CORE 0.004669
K_1096 X_NUC_21.L_CORE X_NUC_47.L_CORE 0.004686
K_1097 X_NUC_21.L_CORE X_NUC_48.L_CORE 0.004657
K_1098 X_NUC_21.L_CORE X_NUC_49.L_CORE 0.004562
K_1099 X_NUC_21.L_CORE X_NUC_50.L_CORE 0.004497
K_1100 X_NUC_21.L_CORE X_NUC_51.L_CORE 0.004466
K_1101 X_NUC_21.L_CORE X_NUC_52.L_CORE 0.004511
K_1102 X_NUC_21.L_CORE X_NUC_53.L_CORE 0.005923
K_1103 X_NUC_21.L_CORE X_NUC_54.L_CORE 0.005839
K_1104 X_NUC_21.L_CORE X_NUC_55.L_CORE 0.005779
K_1105 X_NUC_21.L_CORE X_NUC_56.L_CORE 0.005781
K_1106 X_NUC_21.L_CORE X_NUC_57.L_CORE 0.007477
K_1107 X_NUC_21.L_CORE X_NUC_58.L_CORE 0.003825
K_1108 X_NUC_21.L_CORE X_NUC_59.L_CORE 0.007897
K_1109 X_NUC_21.L_CORE X_NUC_60.L_CORE 0.005118
K_1110 X_NUC_21.L_CORE X_NUC_61.L_CORE 0.003684
K_1111 X_NUC_21.L_CORE X_NUC_62.L_CORE 0.010960
K_1112 X_NUC_21.L_CORE X_NUC_63.L_CORE 0.003722
K_1113 X_NUC_21.L_CORE X_NUC_64.L_CORE 0.004513
K_1114 X_NUC_22.L_CORE X_NUC_23.L_CORE 0.207973
K_1115 X_NUC_22.L_CORE X_NUC_24.L_CORE 0.207973
K_1116 X_NUC_22.L_CORE X_NUC_25.L_CORE 0.004290
K_1117 X_NUC_22.L_CORE X_NUC_26.L_CORE 0.004205
K_1118 X_NUC_22.L_CORE X_NUC_27.L_CORE 0.004248
K_1119 X_NUC_22.L_CORE X_NUC_28.L_CORE 0.004235
K_1120 X_NUC_22.L_CORE X_NUC_29.L_CORE 0.005764
K_1121 X_NUC_22.L_CORE X_NUC_30.L_CORE 0.005690
K_1122 X_NUC_22.L_CORE X_NUC_31.L_CORE 0.005636
K_1123 X_NUC_22.L_CORE X_NUC_32.L_CORE 0.005770
K_1124 X_NUC_22.L_CORE X_NUC_33.L_CORE 0.008218
K_1125 X_NUC_22.L_CORE X_NUC_34.L_CORE 0.008044
K_1126 X_NUC_22.L_CORE X_NUC_35.L_CORE 0.008137
K_1127 X_NUC_22.L_CORE X_NUC_36.L_CORE 0.007921
K_1128 X_NUC_22.L_CORE X_NUC_37.L_CORE 0.003973
K_1129 X_NUC_22.L_CORE X_NUC_38.L_CORE 0.003905
K_1130 X_NUC_22.L_CORE X_NUC_39.L_CORE 0.003912
K_1131 X_NUC_22.L_CORE X_NUC_40.L_CORE 0.003933
K_1132 X_NUC_22.L_CORE X_NUC_41.L_CORE 0.008799
K_1133 X_NUC_22.L_CORE X_NUC_42.L_CORE 0.008749
K_1134 X_NUC_22.L_CORE X_NUC_43.L_CORE 0.008469
K_1135 X_NUC_22.L_CORE X_NUC_44.L_CORE 0.008667
K_1136 X_NUC_22.L_CORE X_NUC_45.L_CORE 0.004843
K_1137 X_NUC_22.L_CORE X_NUC_46.L_CORE 0.004755
K_1138 X_NUC_22.L_CORE X_NUC_47.L_CORE 0.004772
K_1139 X_NUC_22.L_CORE X_NUC_48.L_CORE 0.004741
K_1140 X_NUC_22.L_CORE X_NUC_49.L_CORE 0.004628
K_1141 X_NUC_22.L_CORE X_NUC_50.L_CORE 0.004562
K_1142 X_NUC_22.L_CORE X_NUC_51.L_CORE 0.004529
K_1143 X_NUC_22.L_CORE X_NUC_52.L_CORE 0.004576
K_1144 X_NUC_22.L_CORE X_NUC_53.L_CORE 0.006004
K_1145 X_NUC_22.L_CORE X_NUC_54.L_CORE 0.005923
K_1146 X_NUC_22.L_CORE X_NUC_55.L_CORE 0.005858
K_1147 X_NUC_22.L_CORE X_NUC_56.L_CORE 0.005859
K_1148 X_NUC_22.L_CORE X_NUC_57.L_CORE 0.007618
K_1149 X_NUC_22.L_CORE X_NUC_58.L_CORE 0.003894
K_1150 X_NUC_22.L_CORE X_NUC_59.L_CORE 0.007920
K_1151 X_NUC_22.L_CORE X_NUC_60.L_CORE 0.005213
K_1152 X_NUC_22.L_CORE X_NUC_61.L_CORE 0.003736
K_1153 X_NUC_22.L_CORE X_NUC_62.L_CORE 0.010826
K_1154 X_NUC_22.L_CORE X_NUC_63.L_CORE 0.003780
K_1155 X_NUC_22.L_CORE X_NUC_64.L_CORE 0.004558
K_1156 X_NUC_23.L_CORE X_NUC_24.L_CORE 0.207973
K_1157 X_NUC_23.L_CORE X_NUC_25.L_CORE 0.004244
K_1158 X_NUC_23.L_CORE X_NUC_26.L_CORE 0.004161
K_1159 X_NUC_23.L_CORE X_NUC_27.L_CORE 0.004205
K_1160 X_NUC_23.L_CORE X_NUC_28.L_CORE 0.004191
K_1161 X_NUC_23.L_CORE X_NUC_29.L_CORE 0.005819
K_1162 X_NUC_23.L_CORE X_NUC_30.L_CORE 0.005741
K_1163 X_NUC_23.L_CORE X_NUC_31.L_CORE 0.005690
K_1164 X_NUC_23.L_CORE X_NUC_32.L_CORE 0.005825
K_1165 X_NUC_23.L_CORE X_NUC_33.L_CORE 0.008115
K_1166 X_NUC_23.L_CORE X_NUC_34.L_CORE 0.007941
K_1167 X_NUC_23.L_CORE X_NUC_35.L_CORE 0.008044
K_1168 X_NUC_23.L_CORE X_NUC_36.L_CORE 0.007829
K_1169 X_NUC_23.L_CORE X_NUC_37.L_CORE 0.003964
K_1170 X_NUC_23.L_CORE X_NUC_38.L_CORE 0.003896
K_1171 X_NUC_23.L_CORE X_NUC_39.L_CORE 0.003905
K_1172 X_NUC_23.L_CORE X_NUC_40.L_CORE 0.003925
K_1173 X_NUC_23.L_CORE X_NUC_41.L_CORE 0.009105
K_1174 X_NUC_23.L_CORE X_NUC_42.L_CORE 0.009041
K_1175 X_NUC_23.L_CORE X_NUC_43.L_CORE 0.008749
K_1176 X_NUC_23.L_CORE X_NUC_44.L_CORE 0.008959
K_1177 X_NUC_23.L_CORE X_NUC_45.L_CORE 0.004823
K_1178 X_NUC_23.L_CORE X_NUC_46.L_CORE 0.004735
K_1179 X_NUC_23.L_CORE X_NUC_47.L_CORE 0.004755
K_1180 X_NUC_23.L_CORE X_NUC_48.L_CORE 0.004723
K_1181 X_NUC_23.L_CORE X_NUC_49.L_CORE 0.004662
K_1182 X_NUC_23.L_CORE X_NUC_50.L_CORE 0.004594
K_1183 X_NUC_23.L_CORE X_NUC_51.L_CORE 0.004562
K_1184 X_NUC_23.L_CORE X_NUC_52.L_CORE 0.004609
K_1185 X_NUC_23.L_CORE X_NUC_53.L_CORE 0.006072
K_1186 X_NUC_23.L_CORE X_NUC_54.L_CORE 0.005985
K_1187 X_NUC_23.L_CORE X_NUC_55.L_CORE 0.005923
K_1188 X_NUC_23.L_CORE X_NUC_56.L_CORE 0.005922
K_1189 X_NUC_23.L_CORE X_NUC_57.L_CORE 0.007362
K_1190 X_NUC_23.L_CORE X_NUC_58.L_CORE 0.003850
K_1191 X_NUC_23.L_CORE X_NUC_59.L_CORE 0.008002
K_1192 X_NUC_23.L_CORE X_NUC_60.L_CORE 0.005126
K_1193 X_NUC_23.L_CORE X_NUC_61.L_CORE 0.003737
K_1194 X_NUC_23.L_CORE X_NUC_62.L_CORE 0.011282
K_1195 X_NUC_23.L_CORE X_NUC_63.L_CORE 0.003769
K_1196 X_NUC_23.L_CORE X_NUC_64.L_CORE 0.004613
K_1197 X_NUC_24.L_CORE X_NUC_25.L_CORE 0.004258
K_1198 X_NUC_24.L_CORE X_NUC_26.L_CORE 0.004174
K_1199 X_NUC_24.L_CORE X_NUC_27.L_CORE 0.004217
K_1200 X_NUC_24.L_CORE X_NUC_28.L_CORE 0.004205
K_1201 X_NUC_24.L_CORE X_NUC_29.L_CORE 0.005682
K_1202 X_NUC_24.L_CORE X_NUC_30.L_CORE 0.005609
K_1203 X_NUC_24.L_CORE X_NUC_31.L_CORE 0.005560
K_1204 X_NUC_24.L_CORE X_NUC_32.L_CORE 0.005690
K_1205 X_NUC_24.L_CORE X_NUC_33.L_CORE 0.008348
K_1206 X_NUC_24.L_CORE X_NUC_34.L_CORE 0.008159
K_1207 X_NUC_24.L_CORE X_NUC_35.L_CORE 0.008263
K_1208 X_NUC_24.L_CORE X_NUC_36.L_CORE 0.008044
K_1209 X_NUC_24.L_CORE X_NUC_37.L_CORE 0.003942
K_1210 X_NUC_24.L_CORE X_NUC_38.L_CORE 0.003875
K_1211 X_NUC_24.L_CORE X_NUC_39.L_CORE 0.003883
K_1212 X_NUC_24.L_CORE X_NUC_40.L_CORE 0.003905
K_1213 X_NUC_24.L_CORE X_NUC_41.L_CORE 0.008877
K_1214 X_NUC_24.L_CORE X_NUC_42.L_CORE 0.008817
K_1215 X_NUC_24.L_CORE X_NUC_43.L_CORE 0.008538
K_1216 X_NUC_24.L_CORE X_NUC_44.L_CORE 0.008749
K_1217 X_NUC_24.L_CORE X_NUC_45.L_CORE 0.004856
K_1218 X_NUC_24.L_CORE X_NUC_46.L_CORE 0.004766
K_1219 X_NUC_24.L_CORE X_NUC_47.L_CORE 0.004785
K_1220 X_NUC_24.L_CORE X_NUC_48.L_CORE 0.004755
K_1221 X_NUC_24.L_CORE X_NUC_49.L_CORE 0.004612
K_1222 X_NUC_24.L_CORE X_NUC_50.L_CORE 0.004546
K_1223 X_NUC_24.L_CORE X_NUC_51.L_CORE 0.004514
K_1224 X_NUC_24.L_CORE X_NUC_52.L_CORE 0.004562
K_1225 X_NUC_24.L_CORE X_NUC_53.L_CORE 0.006070
K_1226 X_NUC_24.L_CORE X_NUC_54.L_CORE 0.005983
K_1227 X_NUC_24.L_CORE X_NUC_55.L_CORE 0.005919
K_1228 X_NUC_24.L_CORE X_NUC_56.L_CORE 0.005923
K_1229 X_NUC_24.L_CORE X_NUC_57.L_CORE 0.007415
K_1230 X_NUC_24.L_CORE X_NUC_58.L_CORE 0.003841
K_1231 X_NUC_24.L_CORE X_NUC_59.L_CORE 0.007716
K_1232 X_NUC_24.L_CORE X_NUC_60.L_CORE 0.005212
K_1233 X_NUC_24.L_CORE X_NUC_61.L_CORE 0.003699
K_1234 X_NUC_24.L_CORE X_NUC_62.L_CORE 0.011315
K_1235 X_NUC_24.L_CORE X_NUC_63.L_CORE 0.003778
K_1236 X_NUC_24.L_CORE X_NUC_64.L_CORE 0.004566
K_1237 X_NUC_25.L_CORE X_NUC_26.L_CORE 0.207973
K_1238 X_NUC_25.L_CORE X_NUC_27.L_CORE 0.207973
K_1239 X_NUC_25.L_CORE X_NUC_28.L_CORE 0.207973
K_1240 X_NUC_25.L_CORE X_NUC_29.L_CORE 0.004162
K_1241 X_NUC_25.L_CORE X_NUC_30.L_CORE 0.004214
K_1242 X_NUC_25.L_CORE X_NUC_31.L_CORE 0.004150
K_1243 X_NUC_25.L_CORE X_NUC_32.L_CORE 0.004216
K_1244 X_NUC_25.L_CORE X_NUC_33.L_CORE 0.005690
K_1245 X_NUC_25.L_CORE X_NUC_34.L_CORE 0.005839
K_1246 X_NUC_25.L_CORE X_NUC_35.L_CORE 0.005761
K_1247 X_NUC_25.L_CORE X_NUC_36.L_CORE 0.005715
K_1248 X_NUC_25.L_CORE X_NUC_37.L_CORE 0.008103
K_1249 X_NUC_25.L_CORE X_NUC_38.L_CORE 0.008097
K_1250 X_NUC_25.L_CORE X_NUC_39.L_CORE 0.007866
K_1251 X_NUC_25.L_CORE X_NUC_40.L_CORE 0.008138
K_1252 X_NUC_25.L_CORE X_NUC_41.L_CORE 0.003995
K_1253 X_NUC_25.L_CORE X_NUC_42.L_CORE 0.004063
K_1254 X_NUC_25.L_CORE X_NUC_43.L_CORE 0.003996
K_1255 X_NUC_25.L_CORE X_NUC_44.L_CORE 0.004028
K_1256 X_NUC_25.L_CORE X_NUC_45.L_CORE 0.008663
K_1257 X_NUC_25.L_CORE X_NUC_46.L_CORE 0.008867
K_1258 X_NUC_25.L_CORE X_NUC_47.L_CORE 0.008592
K_1259 X_NUC_25.L_CORE X_NUC_48.L_CORE 0.008521
K_1260 X_NUC_25.L_CORE X_NUC_49.L_CORE 0.004976
K_1261 X_NUC_25.L_CORE X_NUC_50.L_CORE 0.005029
K_1262 X_NUC_25.L_CORE X_NUC_51.L_CORE 0.004914
K_1263 X_NUC_25.L_CORE X_NUC_52.L_CORE 0.004997
K_1264 X_NUC_25.L_CORE X_NUC_53.L_CORE 0.004934
K_1265 X_NUC_25.L_CORE X_NUC_54.L_CORE 0.005022
K_1266 X_NUC_25.L_CORE X_NUC_55.L_CORE 0.004913
K_1267 X_NUC_25.L_CORE X_NUC_56.L_CORE 0.004935
K_1268 X_NUC_25.L_CORE X_NUC_57.L_CORE 0.004801
K_1269 X_NUC_25.L_CORE X_NUC_58.L_CORE 0.008783
K_1270 X_NUC_25.L_CORE X_NUC_59.L_CORE 0.003601
K_1271 X_NUC_25.L_CORE X_NUC_60.L_CORE 0.007795
K_1272 X_NUC_25.L_CORE X_NUC_61.L_CORE 0.005073
K_1273 X_NUC_25.L_CORE X_NUC_62.L_CORE 0.003775
K_1274 X_NUC_25.L_CORE X_NUC_63.L_CORE 0.009042
K_1275 X_NUC_25.L_CORE X_NUC_64.L_CORE 0.004113
K_1276 X_NUC_26.L_CORE X_NUC_27.L_CORE 0.207973
K_1277 X_NUC_26.L_CORE X_NUC_28.L_CORE 0.207973
K_1278 X_NUC_26.L_CORE X_NUC_29.L_CORE 0.004110
K_1279 X_NUC_26.L_CORE X_NUC_30.L_CORE 0.004162
K_1280 X_NUC_26.L_CORE X_NUC_31.L_CORE 0.004099
K_1281 X_NUC_26.L_CORE X_NUC_32.L_CORE 0.004163
K_1282 X_NUC_26.L_CORE X_NUC_33.L_CORE 0.005548
K_1283 X_NUC_26.L_CORE X_NUC_34.L_CORE 0.005690
K_1284 X_NUC_26.L_CORE X_NUC_35.L_CORE 0.005615
K_1285 X_NUC_26.L_CORE X_NUC_36.L_CORE 0.005573
K_1286 X_NUC_26.L_CORE X_NUC_37.L_CORE 0.008096
K_1287 X_NUC_26.L_CORE X_NUC_38.L_CORE 0.008103
K_1288 X_NUC_26.L_CORE X_NUC_39.L_CORE 0.007866
K_1289 X_NUC_26.L_CORE X_NUC_40.L_CORE 0.008138
K_1290 X_NUC_26.L_CORE X_NUC_41.L_CORE 0.003930
K_1291 X_NUC_26.L_CORE X_NUC_42.L_CORE 0.003995
K_1292 X_NUC_26.L_CORE X_NUC_43.L_CORE 0.003931
K_1293 X_NUC_26.L_CORE X_NUC_44.L_CORE 0.003962
K_1294 X_NUC_26.L_CORE X_NUC_45.L_CORE 0.008457
K_1295 X_NUC_26.L_CORE X_NUC_46.L_CORE 0.008663
K_1296 X_NUC_26.L_CORE X_NUC_47.L_CORE 0.008398
K_1297 X_NUC_26.L_CORE X_NUC_48.L_CORE 0.008333
K_1298 X_NUC_26.L_CORE X_NUC_49.L_CORE 0.004921
K_1299 X_NUC_26.L_CORE X_NUC_50.L_CORE 0.004976
K_1300 X_NUC_26.L_CORE X_NUC_51.L_CORE 0.004863
K_1301 X_NUC_26.L_CORE X_NUC_52.L_CORE 0.004943
K_1302 X_NUC_26.L_CORE X_NUC_53.L_CORE 0.004847
K_1303 X_NUC_26.L_CORE X_NUC_54.L_CORE 0.004934
K_1304 X_NUC_26.L_CORE X_NUC_55.L_CORE 0.004828
K_1305 X_NUC_26.L_CORE X_NUC_56.L_CORE 0.004849
K_1306 X_NUC_26.L_CORE X_NUC_57.L_CORE 0.004715
K_1307 X_NUC_26.L_CORE X_NUC_58.L_CORE 0.008826
K_1308 X_NUC_26.L_CORE X_NUC_59.L_CORE 0.003552
K_1309 X_NUC_26.L_CORE X_NUC_60.L_CORE 0.007597
K_1310 X_NUC_26.L_CORE X_NUC_61.L_CORE 0.005060
K_1311 X_NUC_26.L_CORE X_NUC_62.L_CORE 0.003711
K_1312 X_NUC_26.L_CORE X_NUC_63.L_CORE 0.009030
K_1313 X_NUC_26.L_CORE X_NUC_64.L_CORE 0.004069
K_1314 X_NUC_27.L_CORE X_NUC_28.L_CORE 0.207973
K_1315 X_NUC_27.L_CORE X_NUC_29.L_CORE 0.004172
K_1316 X_NUC_27.L_CORE X_NUC_30.L_CORE 0.004225
K_1317 X_NUC_27.L_CORE X_NUC_31.L_CORE 0.004162
K_1318 X_NUC_27.L_CORE X_NUC_32.L_CORE 0.004227
K_1319 X_NUC_27.L_CORE X_NUC_33.L_CORE 0.005617
K_1320 X_NUC_27.L_CORE X_NUC_34.L_CORE 0.005763
K_1321 X_NUC_27.L_CORE X_NUC_35.L_CORE 0.005690
K_1322 X_NUC_27.L_CORE X_NUC_36.L_CORE 0.005644
K_1323 X_NUC_27.L_CORE X_NUC_37.L_CORE 0.008348
K_1324 X_NUC_27.L_CORE X_NUC_38.L_CORE 0.008349
K_1325 X_NUC_27.L_CORE X_NUC_39.L_CORE 0.008103
K_1326 X_NUC_27.L_CORE X_NUC_40.L_CORE 0.008394
K_1327 X_NUC_27.L_CORE X_NUC_41.L_CORE 0.003993
K_1328 X_NUC_27.L_CORE X_NUC_42.L_CORE 0.004061
K_1329 X_NUC_27.L_CORE X_NUC_43.L_CORE 0.003995
K_1330 X_NUC_27.L_CORE X_NUC_44.L_CORE 0.004026
K_1331 X_NUC_27.L_CORE X_NUC_45.L_CORE 0.008720
K_1332 X_NUC_27.L_CORE X_NUC_46.L_CORE 0.008937
K_1333 X_NUC_27.L_CORE X_NUC_47.L_CORE 0.008663
K_1334 X_NUC_27.L_CORE X_NUC_48.L_CORE 0.008583
K_1335 X_NUC_27.L_CORE X_NUC_49.L_CORE 0.005036
K_1336 X_NUC_27.L_CORE X_NUC_50.L_CORE 0.005093
K_1337 X_NUC_27.L_CORE X_NUC_51.L_CORE 0.004976
K_1338 X_NUC_27.L_CORE X_NUC_52.L_CORE 0.005060
K_1339 X_NUC_27.L_CORE X_NUC_53.L_CORE 0.004953
K_1340 X_NUC_27.L_CORE X_NUC_54.L_CORE 0.005044
K_1341 X_NUC_27.L_CORE X_NUC_55.L_CORE 0.004934
K_1342 X_NUC_27.L_CORE X_NUC_56.L_CORE 0.004955
K_1343 X_NUC_27.L_CORE X_NUC_57.L_CORE 0.004713
K_1344 X_NUC_27.L_CORE X_NUC_58.L_CORE 0.008710
K_1345 X_NUC_27.L_CORE X_NUC_59.L_CORE 0.003586
K_1346 X_NUC_27.L_CORE X_NUC_60.L_CORE 0.007579
K_1347 X_NUC_27.L_CORE X_NUC_61.L_CORE 0.005142
K_1348 X_NUC_27.L_CORE X_NUC_62.L_CORE 0.003759
K_1349 X_NUC_27.L_CORE X_NUC_63.L_CORE 0.009326
K_1350 X_NUC_27.L_CORE X_NUC_64.L_CORE 0.004150
K_1351 X_NUC_28.L_CORE X_NUC_29.L_CORE 0.004108
K_1352 X_NUC_28.L_CORE X_NUC_30.L_CORE 0.004159
K_1353 X_NUC_28.L_CORE X_NUC_31.L_CORE 0.004098
K_1354 X_NUC_28.L_CORE X_NUC_32.L_CORE 0.004162
K_1355 X_NUC_28.L_CORE X_NUC_33.L_CORE 0.005660
K_1356 X_NUC_28.L_CORE X_NUC_34.L_CORE 0.005809
K_1357 X_NUC_28.L_CORE X_NUC_35.L_CORE 0.005732
K_1358 X_NUC_28.L_CORE X_NUC_36.L_CORE 0.005690
K_1359 X_NUC_28.L_CORE X_NUC_37.L_CORE 0.008055
K_1360 X_NUC_28.L_CORE X_NUC_38.L_CORE 0.008056
K_1361 X_NUC_28.L_CORE X_NUC_39.L_CORE 0.007829
K_1362 X_NUC_28.L_CORE X_NUC_40.L_CORE 0.008103
K_1363 X_NUC_28.L_CORE X_NUC_41.L_CORE 0.003962
K_1364 X_NUC_28.L_CORE X_NUC_42.L_CORE 0.004029
K_1365 X_NUC_28.L_CORE X_NUC_43.L_CORE 0.003964
K_1366 X_NUC_28.L_CORE X_NUC_44.L_CORE 0.003995
K_1367 X_NUC_28.L_CORE X_NUC_45.L_CORE 0.008795
K_1368 X_NUC_28.L_CORE X_NUC_46.L_CORE 0.009018
K_1369 X_NUC_28.L_CORE X_NUC_47.L_CORE 0.008729
K_1370 X_NUC_28.L_CORE X_NUC_48.L_CORE 0.008663
K_1371 X_NUC_28.L_CORE X_NUC_49.L_CORE 0.004952
K_1372 X_NUC_28.L_CORE X_NUC_50.L_CORE 0.005006
K_1373 X_NUC_28.L_CORE X_NUC_51.L_CORE 0.004893
K_1374 X_NUC_28.L_CORE X_NUC_52.L_CORE 0.004976
K_1375 X_NUC_28.L_CORE X_NUC_53.L_CORE 0.004930
K_1376 X_NUC_28.L_CORE X_NUC_54.L_CORE 0.005020
K_1377 X_NUC_28.L_CORE X_NUC_55.L_CORE 0.004910
K_1378 X_NUC_28.L_CORE X_NUC_56.L_CORE 0.004934
K_1379 X_NUC_28.L_CORE X_NUC_57.L_CORE 0.004708
K_1380 X_NUC_28.L_CORE X_NUC_58.L_CORE 0.008497
K_1381 X_NUC_28.L_CORE X_NUC_59.L_CORE 0.003551
K_1382 X_NUC_28.L_CORE X_NUC_60.L_CORE 0.007780
K_1383 X_NUC_28.L_CORE X_NUC_61.L_CORE 0.005020
K_1384 X_NUC_28.L_CORE X_NUC_62.L_CORE 0.003751
K_1385 X_NUC_28.L_CORE X_NUC_63.L_CORE 0.009318
K_1386 X_NUC_28.L_CORE X_NUC_64.L_CORE 0.004103
K_1387 X_NUC_29.L_CORE X_NUC_30.L_CORE 0.207973
K_1388 X_NUC_29.L_CORE X_NUC_31.L_CORE 0.207973
K_1389 X_NUC_29.L_CORE X_NUC_32.L_CORE 0.207973
K_1390 X_NUC_29.L_CORE X_NUC_33.L_CORE 0.004205
K_1391 X_NUC_29.L_CORE X_NUC_34.L_CORE 0.004209
K_1392 X_NUC_29.L_CORE X_NUC_35.L_CORE 0.004245
K_1393 X_NUC_29.L_CORE X_NUC_36.L_CORE 0.004160
K_1394 X_NUC_29.L_CORE X_NUC_37.L_CORE 0.005807
K_1395 X_NUC_29.L_CORE X_NUC_38.L_CORE 0.005668
K_1396 X_NUC_29.L_CORE X_NUC_39.L_CORE 0.005746
K_1397 X_NUC_29.L_CORE X_NUC_40.L_CORE 0.005678
K_1398 X_NUC_29.L_CORE X_NUC_41.L_CORE 0.008285
K_1399 X_NUC_29.L_CORE X_NUC_42.L_CORE 0.008465
K_1400 X_NUC_29.L_CORE X_NUC_43.L_CORE 0.008379
K_1401 X_NUC_29.L_CORE X_NUC_44.L_CORE 0.008150
K_1402 X_NUC_29.L_CORE X_NUC_45.L_CORE 0.004201
K_1403 X_NUC_29.L_CORE X_NUC_46.L_CORE 0.004170
K_1404 X_NUC_29.L_CORE X_NUC_47.L_CORE 0.004204
K_1405 X_NUC_29.L_CORE X_NUC_48.L_CORE 0.004131
K_1406 X_NUC_29.L_CORE X_NUC_49.L_CORE 0.008434
K_1407 X_NUC_29.L_CORE X_NUC_50.L_CORE 0.008262
K_1408 X_NUC_29.L_CORE X_NUC_51.L_CORE 0.008228
K_1409 X_NUC_29.L_CORE X_NUC_52.L_CORE 0.008108
K_1410 X_NUC_29.L_CORE X_NUC_53.L_CORE 0.005407
K_1411 X_NUC_29.L_CORE X_NUC_54.L_CORE 0.005407
K_1412 X_NUC_29.L_CORE X_NUC_55.L_CORE 0.005403
K_1413 X_NUC_29.L_CORE X_NUC_56.L_CORE 0.005294
K_1414 X_NUC_29.L_CORE X_NUC_57.L_CORE 0.004337
K_1415 X_NUC_29.L_CORE X_NUC_58.L_CORE 0.004360
K_1416 X_NUC_29.L_CORE X_NUC_59.L_CORE 0.009765
K_1417 X_NUC_29.L_CORE X_NUC_60.L_CORE 0.003479
K_1418 X_NUC_29.L_CORE X_NUC_61.L_CORE 0.007540
K_1419 X_NUC_29.L_CORE X_NUC_62.L_CORE 0.005179
K_1420 X_NUC_29.L_CORE X_NUC_63.L_CORE 0.003928
K_1421 X_NUC_29.L_CORE X_NUC_64.L_CORE 0.007046
K_1422 X_NUC_30.L_CORE X_NUC_31.L_CORE 0.207973
K_1423 X_NUC_30.L_CORE X_NUC_32.L_CORE 0.207973
K_1424 X_NUC_30.L_CORE X_NUC_33.L_CORE 0.004199
K_1425 X_NUC_30.L_CORE X_NUC_34.L_CORE 0.004205
K_1426 X_NUC_30.L_CORE X_NUC_35.L_CORE 0.004239
K_1427 X_NUC_30.L_CORE X_NUC_36.L_CORE 0.004155
K_1428 X_NUC_30.L_CORE X_NUC_37.L_CORE 0.005951
K_1429 X_NUC_30.L_CORE X_NUC_38.L_CORE 0.005807
K_1430 X_NUC_30.L_CORE X_NUC_39.L_CORE 0.005888
K_1431 X_NUC_30.L_CORE X_NUC_40.L_CORE 0.005815
K_1432 X_NUC_30.L_CORE X_NUC_41.L_CORE 0.008103
K_1433 X_NUC_30.L_CORE X_NUC_42.L_CORE 0.008285
K_1434 X_NUC_30.L_CORE X_NUC_43.L_CORE 0.008198
K_1435 X_NUC_30.L_CORE X_NUC_44.L_CORE 0.007983
K_1436 X_NUC_30.L_CORE X_NUC_45.L_CORE 0.004230
K_1437 X_NUC_30.L_CORE X_NUC_46.L_CORE 0.004201
K_1438 X_NUC_30.L_CORE X_NUC_47.L_CORE 0.004234
K_1439 X_NUC_30.L_CORE X_NUC_48.L_CORE 0.004160
K_1440 X_NUC_30.L_CORE X_NUC_49.L_CORE 0.008603
K_1441 X_NUC_30.L_CORE X_NUC_50.L_CORE 0.008434
K_1442 X_NUC_30.L_CORE X_NUC_51.L_CORE 0.008391
K_1443 X_NUC_30.L_CORE X_NUC_52.L_CORE 0.008265
K_1444 X_NUC_30.L_CORE X_NUC_53.L_CORE 0.005404
K_1445 X_NUC_30.L_CORE X_NUC_54.L_CORE 0.005407
K_1446 X_NUC_30.L_CORE X_NUC_55.L_CORE 0.005402
K_1447 X_NUC_30.L_CORE X_NUC_56.L_CORE 0.005293
K_1448 X_NUC_30.L_CORE X_NUC_57.L_CORE 0.004330
K_1449 X_NUC_30.L_CORE X_NUC_58.L_CORE 0.004427
K_1450 X_NUC_30.L_CORE X_NUC_59.L_CORE 0.009448
K_1451 X_NUC_30.L_CORE X_NUC_60.L_CORE 0.003491
K_1452 X_NUC_30.L_CORE X_NUC_61.L_CORE 0.007822
K_1453 X_NUC_30.L_CORE X_NUC_62.L_CORE 0.005110
K_1454 X_NUC_30.L_CORE X_NUC_63.L_CORE 0.003971
K_1455 X_NUC_30.L_CORE X_NUC_64.L_CORE 0.007072
K_1456 X_NUC_31.L_CORE X_NUC_32.L_CORE 0.207973
K_1457 X_NUC_31.L_CORE X_NUC_33.L_CORE 0.004164
K_1458 X_NUC_31.L_CORE X_NUC_34.L_CORE 0.004169
K_1459 X_NUC_31.L_CORE X_NUC_35.L_CORE 0.004205
K_1460 X_NUC_31.L_CORE X_NUC_36.L_CORE 0.004122
K_1461 X_NUC_31.L_CORE X_NUC_37.L_CORE 0.005864
K_1462 X_NUC_31.L_CORE X_NUC_38.L_CORE 0.005724
K_1463 X_NUC_31.L_CORE X_NUC_39.L_CORE 0.005807
K_1464 X_NUC_31.L_CORE X_NUC_40.L_CORE 0.005734
K_1465 X_NUC_31.L_CORE X_NUC_41.L_CORE 0.008181
K_1466 X_NUC_31.L_CORE X_NUC_42.L_CORE 0.008361
K_1467 X_NUC_31.L_CORE X_NUC_43.L_CORE 0.008285
K_1468 X_NUC_31.L_CORE X_NUC_44.L_CORE 0.008057
K_1469 X_NUC_31.L_CORE X_NUC_45.L_CORE 0.004196
K_1470 X_NUC_31.L_CORE X_NUC_46.L_CORE 0.004166
K_1471 X_NUC_31.L_CORE X_NUC_47.L_CORE 0.004201
K_1472 X_NUC_31.L_CORE X_NUC_48.L_CORE 0.004127
K_1473 X_NUC_31.L_CORE X_NUC_49.L_CORE 0.008643
K_1474 X_NUC_31.L_CORE X_NUC_50.L_CORE 0.008464
K_1475 X_NUC_31.L_CORE X_NUC_51.L_CORE 0.008434
K_1476 X_NUC_31.L_CORE X_NUC_52.L_CORE 0.008300
K_1477 X_NUC_31.L_CORE X_NUC_53.L_CORE 0.005408
K_1478 X_NUC_31.L_CORE X_NUC_54.L_CORE 0.005409
K_1479 X_NUC_31.L_CORE X_NUC_55.L_CORE 0.005407
K_1480 X_NUC_31.L_CORE X_NUC_56.L_CORE 0.005296
K_1481 X_NUC_31.L_CORE X_NUC_57.L_CORE 0.004260
K_1482 X_NUC_31.L_CORE X_NUC_58.L_CORE 0.004339
K_1483 X_NUC_31.L_CORE X_NUC_59.L_CORE 0.009347
K_1484 X_NUC_31.L_CORE X_NUC_60.L_CORE 0.003452
K_1485 X_NUC_31.L_CORE X_NUC_61.L_CORE 0.007702
K_1486 X_NUC_31.L_CORE X_NUC_62.L_CORE 0.005117
K_1487 X_NUC_31.L_CORE X_NUC_63.L_CORE 0.003941
K_1488 X_NUC_31.L_CORE X_NUC_64.L_CORE 0.007176
K_1489 X_NUC_32.L_CORE X_NUC_33.L_CORE 0.004249
K_1490 X_NUC_32.L_CORE X_NUC_34.L_CORE 0.004254
K_1491 X_NUC_32.L_CORE X_NUC_35.L_CORE 0.004291
K_1492 X_NUC_32.L_CORE X_NUC_36.L_CORE 0.004205
K_1493 X_NUC_32.L_CORE X_NUC_37.L_CORE 0.005940
K_1494 X_NUC_32.L_CORE X_NUC_38.L_CORE 0.005794
K_1495 X_NUC_32.L_CORE X_NUC_39.L_CORE 0.005878
K_1496 X_NUC_32.L_CORE X_NUC_40.L_CORE 0.005807
K_1497 X_NUC_32.L_CORE X_NUC_41.L_CORE 0.008413
K_1498 X_NUC_32.L_CORE X_NUC_42.L_CORE 0.008609
K_1499 X_NUC_32.L_CORE X_NUC_43.L_CORE 0.008519
K_1500 X_NUC_32.L_CORE X_NUC_44.L_CORE 0.008285
K_1501 X_NUC_32.L_CORE X_NUC_45.L_CORE 0.004273
K_1502 X_NUC_32.L_CORE X_NUC_46.L_CORE 0.004241
K_1503 X_NUC_32.L_CORE X_NUC_47.L_CORE 0.004277
K_1504 X_NUC_32.L_CORE X_NUC_48.L_CORE 0.004201
K_1505 X_NUC_32.L_CORE X_NUC_49.L_CORE 0.008787
K_1506 X_NUC_32.L_CORE X_NUC_50.L_CORE 0.008600
K_1507 X_NUC_32.L_CORE X_NUC_51.L_CORE 0.008562
K_1508 X_NUC_32.L_CORE X_NUC_52.L_CORE 0.008434
K_1509 X_NUC_32.L_CORE X_NUC_53.L_CORE 0.005525
K_1510 X_NUC_32.L_CORE X_NUC_54.L_CORE 0.005526
K_1511 X_NUC_32.L_CORE X_NUC_55.L_CORE 0.005522
K_1512 X_NUC_32.L_CORE X_NUC_56.L_CORE 0.005407
K_1513 X_NUC_32.L_CORE X_NUC_57.L_CORE 0.004327
K_1514 X_NUC_32.L_CORE X_NUC_58.L_CORE 0.004386
K_1515 X_NUC_32.L_CORE X_NUC_59.L_CORE 0.009457
K_1516 X_NUC_32.L_CORE X_NUC_60.L_CORE 0.003509
K_1517 X_NUC_32.L_CORE X_NUC_61.L_CORE 0.007686
K_1518 X_NUC_32.L_CORE X_NUC_62.L_CORE 0.005220
K_1519 X_NUC_32.L_CORE X_NUC_63.L_CORE 0.003997
K_1520 X_NUC_32.L_CORE X_NUC_64.L_CORE 0.007264
K_1521 X_NUC_33.L_CORE X_NUC_34.L_CORE 0.207973
K_1522 X_NUC_33.L_CORE X_NUC_35.L_CORE 0.207973
K_1523 X_NUC_33.L_CORE X_NUC_36.L_CORE 0.207973
K_1524 X_NUC_33.L_CORE X_NUC_37.L_CORE 0.004343
K_1525 X_NUC_33.L_CORE X_NUC_38.L_CORE 0.004279
K_1526 X_NUC_33.L_CORE X_NUC_39.L_CORE 0.004275
K_1527 X_NUC_33.L_CORE X_NUC_40.L_CORE 0.004336
K_1528 X_NUC_33.L_CORE X_NUC_41.L_CORE 0.006064
K_1529 X_NUC_33.L_CORE X_NUC_42.L_CORE 0.006118
K_1530 X_NUC_33.L_CORE X_NUC_43.L_CORE 0.005981
K_1531 X_NUC_33.L_CORE X_NUC_44.L_CORE 0.006144
K_1532 X_NUC_33.L_CORE X_NUC_45.L_CORE 0.008601
K_1533 X_NUC_33.L_CORE X_NUC_46.L_CORE 0.008307
K_1534 X_NUC_33.L_CORE X_NUC_47.L_CORE 0.008299
K_1535 X_NUC_33.L_CORE X_NUC_48.L_CORE 0.008373
K_1536 X_NUC_33.L_CORE X_NUC_49.L_CORE 0.004594
K_1537 X_NUC_33.L_CORE X_NUC_50.L_CORE 0.004559
K_1538 X_NUC_33.L_CORE X_NUC_51.L_CORE 0.004510
K_1539 X_NUC_33.L_CORE X_NUC_52.L_CORE 0.004596
K_1540 X_NUC_33.L_CORE X_NUC_53.L_CORE 0.007798
K_1541 X_NUC_33.L_CORE X_NUC_54.L_CORE 0.007764
K_1542 X_NUC_33.L_CORE X_NUC_55.L_CORE 0.007542
K_1543 X_NUC_33.L_CORE X_NUC_56.L_CORE 0.007732
K_1544 X_NUC_33.L_CORE X_NUC_57.L_CORE 0.005687
K_1545 X_NUC_33.L_CORE X_NUC_58.L_CORE 0.004003
K_1546 X_NUC_33.L_CORE X_NUC_59.L_CORE 0.004287
K_1547 X_NUC_33.L_CORE X_NUC_60.L_CORE 0.010137
K_1548 X_NUC_33.L_CORE X_NUC_61.L_CORE 0.003517
K_1549 X_NUC_33.L_CORE X_NUC_62.L_CORE 0.007964
K_1550 X_NUC_33.L_CORE X_NUC_63.L_CORE 0.005359
K_1551 X_NUC_33.L_CORE X_NUC_64.L_CORE 0.004509
K_1552 X_NUC_34.L_CORE X_NUC_35.L_CORE 0.207973
K_1553 X_NUC_34.L_CORE X_NUC_36.L_CORE 0.207973
K_1554 X_NUC_34.L_CORE X_NUC_37.L_CORE 0.004409
K_1555 X_NUC_34.L_CORE X_NUC_38.L_CORE 0.004343
K_1556 X_NUC_34.L_CORE X_NUC_39.L_CORE 0.004338
K_1557 X_NUC_34.L_CORE X_NUC_40.L_CORE 0.004402
K_1558 X_NUC_34.L_CORE X_NUC_41.L_CORE 0.006007
K_1559 X_NUC_34.L_CORE X_NUC_42.L_CORE 0.006064
K_1560 X_NUC_34.L_CORE X_NUC_43.L_CORE 0.005929
K_1561 X_NUC_34.L_CORE X_NUC_44.L_CORE 0.006087
K_1562 X_NUC_34.L_CORE X_NUC_45.L_CORE 0.008912
K_1563 X_NUC_34.L_CORE X_NUC_46.L_CORE 0.008601
K_1564 X_NUC_34.L_CORE X_NUC_47.L_CORE 0.008585
K_1565 X_NUC_34.L_CORE X_NUC_48.L_CORE 0.008667
K_1566 X_NUC_34.L_CORE X_NUC_49.L_CORE 0.004628
K_1567 X_NUC_34.L_CORE X_NUC_50.L_CORE 0.004594
K_1568 X_NUC_34.L_CORE X_NUC_51.L_CORE 0.004542
K_1569 X_NUC_34.L_CORE X_NUC_52.L_CORE 0.004631
K_1570 X_NUC_34.L_CORE X_NUC_53.L_CORE 0.007822
K_1571 X_NUC_34.L_CORE X_NUC_54.L_CORE 0.007798
K_1572 X_NUC_34.L_CORE X_NUC_55.L_CORE 0.007569
K_1573 X_NUC_34.L_CORE X_NUC_56.L_CORE 0.007760
K_1574 X_NUC_34.L_CORE X_NUC_57.L_CORE 0.005686
K_1575 X_NUC_34.L_CORE X_NUC_58.L_CORE 0.004059
K_1576 X_NUC_34.L_CORE X_NUC_59.L_CORE 0.004264
K_1577 X_NUC_34.L_CORE X_NUC_60.L_CORE 0.010528
K_1578 X_NUC_34.L_CORE X_NUC_61.L_CORE 0.003548
K_1579 X_NUC_34.L_CORE X_NUC_62.L_CORE 0.007751
K_1580 X_NUC_34.L_CORE X_NUC_63.L_CORE 0.005483
K_1581 X_NUC_34.L_CORE X_NUC_64.L_CORE 0.004522
K_1582 X_NUC_35.L_CORE X_NUC_36.L_CORE 0.207973
K_1583 X_NUC_35.L_CORE X_NUC_37.L_CORE 0.004413
K_1584 X_NUC_35.L_CORE X_NUC_38.L_CORE 0.004347
K_1585 X_NUC_35.L_CORE X_NUC_39.L_CORE 0.004343
K_1586 X_NUC_35.L_CORE X_NUC_40.L_CORE 0.004407
K_1587 X_NUC_35.L_CORE X_NUC_41.L_CORE 0.006145
K_1588 X_NUC_35.L_CORE X_NUC_42.L_CORE 0.006203
K_1589 X_NUC_35.L_CORE X_NUC_43.L_CORE 0.006064
K_1590 X_NUC_35.L_CORE X_NUC_44.L_CORE 0.006231
K_1591 X_NUC_35.L_CORE X_NUC_45.L_CORE 0.008922
K_1592 X_NUC_35.L_CORE X_NUC_46.L_CORE 0.008603
K_1593 X_NUC_35.L_CORE X_NUC_47.L_CORE 0.008601
K_1594 X_NUC_35.L_CORE X_NUC_48.L_CORE 0.008676
K_1595 X_NUC_35.L_CORE X_NUC_49.L_CORE 0.004682
K_1596 X_NUC_35.L_CORE X_NUC_50.L_CORE 0.004646
K_1597 X_NUC_35.L_CORE X_NUC_51.L_CORE 0.004594
K_1598 X_NUC_35.L_CORE X_NUC_52.L_CORE 0.004685
K_1599 X_NUC_35.L_CORE X_NUC_53.L_CORE 0.008070
K_1600 X_NUC_35.L_CORE X_NUC_54.L_CORE 0.008038
K_1601 X_NUC_35.L_CORE X_NUC_55.L_CORE 0.007798
K_1602 X_NUC_35.L_CORE X_NUC_56.L_CORE 0.008002
K_1603 X_NUC_35.L_CORE X_NUC_57.L_CORE 0.005610
K_1604 X_NUC_35.L_CORE X_NUC_58.L_CORE 0.004021
K_1605 X_NUC_35.L_CORE X_NUC_59.L_CORE 0.004292
K_1606 X_NUC_35.L_CORE X_NUC_60.L_CORE 0.010048
K_1607 X_NUC_35.L_CORE X_NUC_61.L_CORE 0.003558
K_1608 X_NUC_35.L_CORE X_NUC_62.L_CORE 0.008008
K_1609 X_NUC_35.L_CORE X_NUC_63.L_CORE 0.005480
K_1610 X_NUC_35.L_CORE X_NUC_64.L_CORE 0.004594
K_1611 X_NUC_36.L_CORE X_NUC_37.L_CORE 0.004348
K_1612 X_NUC_36.L_CORE X_NUC_38.L_CORE 0.004285
K_1613 X_NUC_36.L_CORE X_NUC_39.L_CORE 0.004281
K_1614 X_NUC_36.L_CORE X_NUC_40.L_CORE 0.004343
K_1615 X_NUC_36.L_CORE X_NUC_41.L_CORE 0.005982
K_1616 X_NUC_36.L_CORE X_NUC_42.L_CORE 0.006036
K_1617 X_NUC_36.L_CORE X_NUC_43.L_CORE 0.005905
K_1618 X_NUC_36.L_CORE X_NUC_44.L_CORE 0.006064
K_1619 X_NUC_36.L_CORE X_NUC_45.L_CORE 0.008833
K_1620 X_NUC_36.L_CORE X_NUC_46.L_CORE 0.008523
K_1621 X_NUC_36.L_CORE X_NUC_47.L_CORE 0.008514
K_1622 X_NUC_36.L_CORE X_NUC_48.L_CORE 0.008601
K_1623 X_NUC_36.L_CORE X_NUC_49.L_CORE 0.004590
K_1624 X_NUC_36.L_CORE X_NUC_50.L_CORE 0.004556
K_1625 X_NUC_36.L_CORE X_NUC_51.L_CORE 0.004507
K_1626 X_NUC_36.L_CORE X_NUC_52.L_CORE 0.004594
K_1627 X_NUC_36.L_CORE X_NUC_53.L_CORE 0.007856
K_1628 X_NUC_36.L_CORE X_NUC_54.L_CORE 0.007826
K_1629 X_NUC_36.L_CORE X_NUC_55.L_CORE 0.007599
K_1630 X_NUC_36.L_CORE X_NUC_56.L_CORE 0.007798
K_1631 X_NUC_36.L_CORE X_NUC_57.L_CORE 0.005560
K_1632 X_NUC_36.L_CORE X_NUC_58.L_CORE 0.003984
K_1633 X_NUC_36.L_CORE X_NUC_59.L_CORE 0.004214
K_1634 X_NUC_36.L_CORE X_NUC_60.L_CORE 0.010263
K_1635 X_NUC_36.L_CORE X_NUC_61.L_CORE 0.003506
K_1636 X_NUC_36.L_CORE X_NUC_62.L_CORE 0.007813
K_1637 X_NUC_36.L_CORE X_NUC_63.L_CORE 0.005439
K_1638 X_NUC_36.L_CORE X_NUC_64.L_CORE 0.004509
K_1639 X_NUC_37.L_CORE X_NUC_38.L_CORE 0.207973
K_1640 X_NUC_37.L_CORE X_NUC_39.L_CORE 0.207973
K_1641 X_NUC_37.L_CORE X_NUC_40.L_CORE 0.207973
K_1642 X_NUC_37.L_CORE X_NUC_41.L_CORE 0.004608
K_1643 X_NUC_37.L_CORE X_NUC_42.L_CORE 0.004712
K_1644 X_NUC_37.L_CORE X_NUC_43.L_CORE 0.004655
K_1645 X_NUC_37.L_CORE X_NUC_44.L_CORE 0.004651
K_1646 X_NUC_37.L_CORE X_NUC_45.L_CORE 0.006522
K_1647 X_NUC_37.L_CORE X_NUC_46.L_CORE 0.006608
K_1648 X_NUC_37.L_CORE X_NUC_47.L_CORE 0.006619
K_1649 X_NUC_37.L_CORE X_NUC_48.L_CORE 0.006440
K_1650 X_NUC_37.L_CORE X_NUC_49.L_CORE 0.009048
K_1651 X_NUC_37.L_CORE X_NUC_50.L_CORE 0.009379
K_1652 X_NUC_37.L_CORE X_NUC_51.L_CORE 0.009007
K_1653 X_NUC_37.L_CORE X_NUC_52.L_CORE 0.009117
K_1654 X_NUC_37.L_CORE X_NUC_53.L_CORE 0.005461
K_1655 X_NUC_37.L_CORE X_NUC_54.L_CORE 0.005581
K_1656 X_NUC_37.L_CORE X_NUC_55.L_CORE 0.005506
K_1657 X_NUC_37.L_CORE X_NUC_56.L_CORE 0.005449
K_1658 X_NUC_37.L_CORE X_NUC_57.L_CORE 0.003763
K_1659 X_NUC_37.L_CORE X_NUC_58.L_CORE 0.006647
K_1660 X_NUC_37.L_CORE X_NUC_59.L_CORE 0.004000
K_1661 X_NUC_37.L_CORE X_NUC_60.L_CORE 0.004339
K_1662 X_NUC_37.L_CORE X_NUC_61.L_CORE 0.011261
K_1663 X_NUC_37.L_CORE X_NUC_62.L_CORE 0.003769
K_1664 X_NUC_37.L_CORE X_NUC_63.L_CORE 0.008219
K_1665 X_NUC_37.L_CORE X_NUC_64.L_CORE 0.006058
K_1666 X_NUC_38.L_CORE X_NUC_39.L_CORE 0.207973
K_1667 X_NUC_38.L_CORE X_NUC_40.L_CORE 0.207973
K_1668 X_NUC_38.L_CORE X_NUC_41.L_CORE 0.004509
K_1669 X_NUC_38.L_CORE X_NUC_42.L_CORE 0.004608
K_1670 X_NUC_38.L_CORE X_NUC_43.L_CORE 0.004553
K_1671 X_NUC_38.L_CORE X_NUC_44.L_CORE 0.004549
K_1672 X_NUC_38.L_CORE X_NUC_45.L_CORE 0.006434
K_1673 X_NUC_38.L_CORE X_NUC_46.L_CORE 0.006522
K_1674 X_NUC_38.L_CORE X_NUC_47.L_CORE 0.006530
K_1675 X_NUC_38.L_CORE X_NUC_48.L_CORE 0.006358
K_1676 X_NUC_38.L_CORE X_NUC_49.L_CORE 0.008734
K_1677 X_NUC_38.L_CORE X_NUC_50.L_CORE 0.009048
K_1678 X_NUC_38.L_CORE X_NUC_51.L_CORE 0.008704
K_1679 X_NUC_38.L_CORE X_NUC_52.L_CORE 0.008804
K_1680 X_NUC_38.L_CORE X_NUC_53.L_CORE 0.005344
K_1681 X_NUC_38.L_CORE X_NUC_54.L_CORE 0.005461
K_1682 X_NUC_38.L_CORE X_NUC_55.L_CORE 0.005389
K_1683 X_NUC_38.L_CORE X_NUC_56.L_CORE 0.005335
K_1684 X_NUC_38.L_CORE X_NUC_57.L_CORE 0.003721
K_1685 X_NUC_38.L_CORE X_NUC_58.L_CORE 0.006665
K_1686 X_NUC_38.L_CORE X_NUC_59.L_CORE 0.003932
K_1687 X_NUC_38.L_CORE X_NUC_60.L_CORE 0.004304
K_1688 X_NUC_38.L_CORE X_NUC_61.L_CORE 0.011123
K_1689 X_NUC_38.L_CORE X_NUC_62.L_CORE 0.003705
K_1690 X_NUC_38.L_CORE X_NUC_63.L_CORE 0.008210
K_1691 X_NUC_38.L_CORE X_NUC_64.L_CORE 0.005920
K_1692 X_NUC_39.L_CORE X_NUC_40.L_CORE 0.207973
K_1693 X_NUC_39.L_CORE X_NUC_41.L_CORE 0.004561
K_1694 X_NUC_39.L_CORE X_NUC_42.L_CORE 0.004663
K_1695 X_NUC_39.L_CORE X_NUC_43.L_CORE 0.004608
K_1696 X_NUC_39.L_CORE X_NUC_44.L_CORE 0.004603
K_1697 X_NUC_39.L_CORE X_NUC_45.L_CORE 0.006423
K_1698 X_NUC_39.L_CORE X_NUC_46.L_CORE 0.006508
K_1699 X_NUC_39.L_CORE X_NUC_47.L_CORE 0.006522
K_1700 X_NUC_39.L_CORE X_NUC_48.L_CORE 0.006348
K_1701 X_NUC_39.L_CORE X_NUC_49.L_CORE 0.009072
K_1702 X_NUC_39.L_CORE X_NUC_50.L_CORE 0.009416
K_1703 X_NUC_39.L_CORE X_NUC_51.L_CORE 0.009048
K_1704 X_NUC_39.L_CORE X_NUC_52.L_CORE 0.009151
K_1705 X_NUC_39.L_CORE X_NUC_53.L_CORE 0.005413
K_1706 X_NUC_39.L_CORE X_NUC_54.L_CORE 0.005532
K_1707 X_NUC_39.L_CORE X_NUC_55.L_CORE 0.005461
K_1708 X_NUC_39.L_CORE X_NUC_56.L_CORE 0.005404
K_1709 X_NUC_39.L_CORE X_NUC_57.L_CORE 0.003697
K_1710 X_NUC_39.L_CORE X_NUC_58.L_CORE 0.006488
K_1711 X_NUC_39.L_CORE X_NUC_59.L_CORE 0.003951
K_1712 X_NUC_39.L_CORE X_NUC_60.L_CORE 0.004265
K_1713 X_NUC_39.L_CORE X_NUC_61.L_CORE 0.011352
K_1714 X_NUC_39.L_CORE X_NUC_62.L_CORE 0.003729
K_1715 X_NUC_39.L_CORE X_NUC_63.L_CORE 0.008172
K_1716 X_NUC_39.L_CORE X_NUC_64.L_CORE 0.006072
K_1717 X_NUC_40.L_CORE X_NUC_41.L_CORE 0.004565
K_1718 X_NUC_40.L_CORE X_NUC_42.L_CORE 0.004667
K_1719 X_NUC_40.L_CORE X_NUC_43.L_CORE 0.004611
K_1720 X_NUC_40.L_CORE X_NUC_44.L_CORE 0.004608
K_1721 X_NUC_40.L_CORE X_NUC_45.L_CORE 0.006601
K_1722 X_NUC_40.L_CORE X_NUC_46.L_CORE 0.006693
K_1723 X_NUC_40.L_CORE X_NUC_47.L_CORE 0.006705
K_1724 X_NUC_40.L_CORE X_NUC_48.L_CORE 0.006522
K_1725 X_NUC_40.L_CORE X_NUC_49.L_CORE 0.008963
K_1726 X_NUC_40.L_CORE X_NUC_50.L_CORE 0.009294
K_1727 X_NUC_40.L_CORE X_NUC_51.L_CORE 0.008932
K_1728 X_NUC_40.L_CORE X_NUC_52.L_CORE 0.009048
K_1729 X_NUC_40.L_CORE X_NUC_53.L_CORE 0.005469
K_1730 X_NUC_40.L_CORE X_NUC_54.L_CORE 0.005592
K_1731 X_NUC_40.L_CORE X_NUC_55.L_CORE 0.005516
K_1732 X_NUC_40.L_CORE X_NUC_56.L_CORE 0.005461
K_1733 X_NUC_40.L_CORE X_NUC_57.L_CORE 0.003721
K_1734 X_NUC_40.L_CORE X_NUC_58.L_CORE 0.006542
K_1735 X_NUC_40.L_CORE X_NUC_59.L_CORE 0.003936
K_1736 X_NUC_40.L_CORE X_NUC_60.L_CORE 0.004343
K_1737 X_NUC_40.L_CORE X_NUC_61.L_CORE 0.010807
K_1738 X_NUC_40.L_CORE X_NUC_62.L_CORE 0.003749
K_1739 X_NUC_40.L_CORE X_NUC_63.L_CORE 0.008472
K_1740 X_NUC_40.L_CORE X_NUC_64.L_CORE 0.006043
K_1741 X_NUC_41.L_CORE X_NUC_42.L_CORE 0.207973
K_1742 X_NUC_41.L_CORE X_NUC_43.L_CORE 0.207973
K_1743 X_NUC_41.L_CORE X_NUC_44.L_CORE 0.207973
K_1744 X_NUC_41.L_CORE X_NUC_45.L_CORE 0.005078
K_1745 X_NUC_41.L_CORE X_NUC_46.L_CORE 0.004984
K_1746 X_NUC_41.L_CORE X_NUC_47.L_CORE 0.005061
K_1747 X_NUC_41.L_CORE X_NUC_48.L_CORE 0.004984
K_1748 X_NUC_41.L_CORE X_NUC_49.L_CORE 0.007331
K_1749 X_NUC_41.L_CORE X_NUC_50.L_CORE 0.007100
K_1750 X_NUC_41.L_CORE X_NUC_51.L_CORE 0.007130
K_1751 X_NUC_41.L_CORE X_NUC_52.L_CORE 0.007199
K_1752 X_NUC_41.L_CORE X_NUC_53.L_CORE 0.009409
K_1753 X_NUC_41.L_CORE X_NUC_54.L_CORE 0.009151
K_1754 X_NUC_41.L_CORE X_NUC_55.L_CORE 0.009245
K_1755 X_NUC_41.L_CORE X_NUC_56.L_CORE 0.009012
K_1756 X_NUC_41.L_CORE X_NUC_57.L_CORE 0.004374
K_1757 X_NUC_41.L_CORE X_NUC_58.L_CORE 0.003511
K_1758 X_NUC_41.L_CORE X_NUC_59.L_CORE 0.007394
K_1759 X_NUC_41.L_CORE X_NUC_60.L_CORE 0.004042
K_1760 X_NUC_41.L_CORE X_NUC_61.L_CORE 0.004498
K_1761 X_NUC_41.L_CORE X_NUC_62.L_CORE 0.012606
K_1762 X_NUC_41.L_CORE X_NUC_63.L_CORE 0.004163
K_1763 X_NUC_41.L_CORE X_NUC_64.L_CORE 0.008384
K_1764 X_NUC_42.L_CORE X_NUC_43.L_CORE 0.207973
K_1765 X_NUC_42.L_CORE X_NUC_44.L_CORE 0.207973
K_1766 X_NUC_42.L_CORE X_NUC_45.L_CORE 0.005174
K_1767 X_NUC_42.L_CORE X_NUC_46.L_CORE 0.005078
K_1768 X_NUC_42.L_CORE X_NUC_47.L_CORE 0.005157
K_1769 X_NUC_42.L_CORE X_NUC_48.L_CORE 0.005076
K_1770 X_NUC_42.L_CORE X_NUC_49.L_CORE 0.007576
K_1771 X_NUC_42.L_CORE X_NUC_50.L_CORE 0.007331
K_1772 X_NUC_42.L_CORE X_NUC_51.L_CORE 0.007359
K_1773 X_NUC_42.L_CORE X_NUC_52.L_CORE 0.007435
K_1774 X_NUC_42.L_CORE X_NUC_53.L_CORE 0.009668
K_1775 X_NUC_42.L_CORE X_NUC_54.L_CORE 0.009409
K_1776 X_NUC_42.L_CORE X_NUC_55.L_CORE 0.009501
K_1777 X_NUC_42.L_CORE X_NUC_56.L_CORE 0.009249
K_1778 X_NUC_42.L_CORE X_NUC_57.L_CORE 0.004395
K_1779 X_NUC_42.L_CORE X_NUC_58.L_CORE 0.003560
K_1780 X_NUC_42.L_CORE X_NUC_59.L_CORE 0.007377
K_1781 X_NUC_42.L_CORE X_NUC_60.L_CORE 0.004083
K_1782 X_NUC_42.L_CORE X_NUC_61.L_CORE 0.004586
K_1783 X_NUC_42.L_CORE X_NUC_62.L_CORE 0.012243
K_1784 X_NUC_42.L_CORE X_NUC_63.L_CORE 0.004239
K_1785 X_NUC_42.L_CORE X_NUC_64.L_CORE 0.008626
K_1786 X_NUC_43.L_CORE X_NUC_44.L_CORE 0.207973
K_1787 X_NUC_43.L_CORE X_NUC_45.L_CORE 0.005093
K_1788 X_NUC_43.L_CORE X_NUC_46.L_CORE 0.005000
K_1789 X_NUC_43.L_CORE X_NUC_47.L_CORE 0.005078
K_1790 X_NUC_43.L_CORE X_NUC_48.L_CORE 0.004999
K_1791 X_NUC_43.L_CORE X_NUC_49.L_CORE 0.007540
K_1792 X_NUC_43.L_CORE X_NUC_50.L_CORE 0.007294
K_1793 X_NUC_43.L_CORE X_NUC_51.L_CORE 0.007331
K_1794 X_NUC_43.L_CORE X_NUC_52.L_CORE 0.007401
K_1795 X_NUC_43.L_CORE X_NUC_53.L_CORE 0.009561
K_1796 X_NUC_43.L_CORE X_NUC_54.L_CORE 0.009300
K_1797 X_NUC_43.L_CORE X_NUC_55.L_CORE 0.009409
K_1798 X_NUC_43.L_CORE X_NUC_56.L_CORE 0.009154
K_1799 X_NUC_43.L_CORE X_NUC_57.L_CORE 0.004309
K_1800 X_NUC_43.L_CORE X_NUC_58.L_CORE 0.003508
K_1801 X_NUC_43.L_CORE X_NUC_59.L_CORE 0.007273
K_1802 X_NUC_43.L_CORE X_NUC_60.L_CORE 0.004013
K_1803 X_NUC_43.L_CORE X_NUC_61.L_CORE 0.004548
K_1804 X_NUC_43.L_CORE X_NUC_62.L_CORE 0.012082
K_1805 X_NUC_43.L_CORE X_NUC_63.L_CORE 0.004192
K_1806 X_NUC_43.L_CORE X_NUC_64.L_CORE 0.008720
K_1807 X_NUC_44.L_CORE X_NUC_45.L_CORE 0.005174
K_1808 X_NUC_44.L_CORE X_NUC_46.L_CORE 0.005077
K_1809 X_NUC_44.L_CORE X_NUC_47.L_CORE 0.005157
K_1810 X_NUC_44.L_CORE X_NUC_48.L_CORE 0.005078
K_1811 X_NUC_44.L_CORE X_NUC_49.L_CORE 0.007461
K_1812 X_NUC_44.L_CORE X_NUC_50.L_CORE 0.007222
K_1813 X_NUC_44.L_CORE X_NUC_51.L_CORE 0.007254
K_1814 X_NUC_44.L_CORE X_NUC_52.L_CORE 0.007331
K_1815 X_NUC_44.L_CORE X_NUC_53.L_CORE 0.009841
K_1816 X_NUC_44.L_CORE X_NUC_54.L_CORE 0.009557
K_1817 X_NUC_44.L_CORE X_NUC_55.L_CORE 0.009665
K_1818 X_NUC_44.L_CORE X_NUC_56.L_CORE 0.009409
K_1819 X_NUC_44.L_CORE X_NUC_57.L_CORE 0.004345
K_1820 X_NUC_44.L_CORE X_NUC_58.L_CORE 0.003514
K_1821 X_NUC_44.L_CORE X_NUC_59.L_CORE 0.007170
K_1822 X_NUC_44.L_CORE X_NUC_60.L_CORE 0.004075
K_1823 X_NUC_44.L_CORE X_NUC_61.L_CORE 0.004507
K_1824 X_NUC_44.L_CORE X_NUC_62.L_CORE 0.012725
K_1825 X_NUC_44.L_CORE X_NUC_63.L_CORE 0.004227
K_1826 X_NUC_44.L_CORE X_NUC_64.L_CORE 0.008609
K_1827 X_NUC_45.L_CORE X_NUC_46.L_CORE 0.207973
K_1828 X_NUC_45.L_CORE X_NUC_47.L_CORE 0.207973
K_1829 X_NUC_45.L_CORE X_NUC_48.L_CORE 0.207973
K_1830 X_NUC_45.L_CORE X_NUC_49.L_CORE 0.005972
K_1831 X_NUC_45.L_CORE X_NUC_50.L_CORE 0.005996
K_1832 X_NUC_45.L_CORE X_NUC_51.L_CORE 0.005887
K_1833 X_NUC_45.L_CORE X_NUC_52.L_CORE 0.006055
K_1834 X_NUC_45.L_CORE X_NUC_53.L_CORE 0.008923
K_1835 X_NUC_45.L_CORE X_NUC_54.L_CORE 0.009223
K_1836 X_NUC_45.L_CORE X_NUC_55.L_CORE 0.008868
K_1837 X_NUC_45.L_CORE X_NUC_56.L_CORE 0.009082
K_1838 X_NUC_45.L_CORE X_NUC_57.L_CORE 0.004104
K_1839 X_NUC_45.L_CORE X_NUC_58.L_CORE 0.004569
K_1840 X_NUC_45.L_CORE X_NUC_59.L_CORE 0.003588
K_1841 X_NUC_45.L_CORE X_NUC_60.L_CORE 0.008023
K_1842 X_NUC_45.L_CORE X_NUC_61.L_CORE 0.004338
K_1843 X_NUC_45.L_CORE X_NUC_62.L_CORE 0.005082
K_1844 X_NUC_45.L_CORE X_NUC_63.L_CORE 0.013933
K_1845 X_NUC_45.L_CORE X_NUC_64.L_CORE 0.005440
K_1846 X_NUC_46.L_CORE X_NUC_47.L_CORE 0.207973
K_1847 X_NUC_46.L_CORE X_NUC_48.L_CORE 0.207973
K_1848 X_NUC_46.L_CORE X_NUC_49.L_CORE 0.005944
K_1849 X_NUC_46.L_CORE X_NUC_50.L_CORE 0.005972
K_1850 X_NUC_46.L_CORE X_NUC_51.L_CORE 0.005862
K_1851 X_NUC_46.L_CORE X_NUC_52.L_CORE 0.006028
K_1852 X_NUC_46.L_CORE X_NUC_53.L_CORE 0.008635
K_1853 X_NUC_46.L_CORE X_NUC_54.L_CORE 0.008923
K_1854 X_NUC_46.L_CORE X_NUC_55.L_CORE 0.008593
K_1855 X_NUC_46.L_CORE X_NUC_56.L_CORE 0.008787
K_1856 X_NUC_46.L_CORE X_NUC_57.L_CORE 0.004072
K_1857 X_NUC_46.L_CORE X_NUC_58.L_CORE 0.004606
K_1858 X_NUC_46.L_CORE X_NUC_59.L_CORE 0.003553
K_1859 X_NUC_46.L_CORE X_NUC_60.L_CORE 0.007961
K_1860 X_NUC_46.L_CORE X_NUC_61.L_CORE 0.004356
K_1861 X_NUC_46.L_CORE X_NUC_62.L_CORE 0.004966
K_1862 X_NUC_46.L_CORE X_NUC_63.L_CORE 0.014819
K_1863 X_NUC_46.L_CORE X_NUC_64.L_CORE 0.005387
K_1864 X_NUC_47.L_CORE X_NUC_48.L_CORE 0.207973
K_1865 X_NUC_47.L_CORE X_NUC_49.L_CORE 0.006056
K_1866 X_NUC_47.L_CORE X_NUC_50.L_CORE 0.006083
K_1867 X_NUC_47.L_CORE X_NUC_51.L_CORE 0.005972
K_1868 X_NUC_47.L_CORE X_NUC_52.L_CORE 0.006145
K_1869 X_NUC_47.L_CORE X_NUC_53.L_CORE 0.008962
K_1870 X_NUC_47.L_CORE X_NUC_54.L_CORE 0.009276
K_1871 X_NUC_47.L_CORE X_NUC_55.L_CORE 0.008923
K_1872 X_NUC_47.L_CORE X_NUC_56.L_CORE 0.009133
K_1873 X_NUC_47.L_CORE X_NUC_57.L_CORE 0.004042
K_1874 X_NUC_47.L_CORE X_NUC_58.L_CORE 0.004550
K_1875 X_NUC_47.L_CORE X_NUC_59.L_CORE 0.003568
K_1876 X_NUC_47.L_CORE X_NUC_60.L_CORE 0.007741
K_1877 X_NUC_47.L_CORE X_NUC_61.L_CORE 0.004373
K_1878 X_NUC_47.L_CORE X_NUC_62.L_CORE 0.005030
K_1879 X_NUC_47.L_CORE X_NUC_63.L_CORE 0.014718
K_1880 X_NUC_47.L_CORE X_NUC_64.L_CORE 0.005508
K_1881 X_NUC_48.L_CORE X_NUC_49.L_CORE 0.005888
K_1882 X_NUC_48.L_CORE X_NUC_50.L_CORE 0.005912
K_1883 X_NUC_48.L_CORE X_NUC_51.L_CORE 0.005808
K_1884 X_NUC_48.L_CORE X_NUC_52.L_CORE 0.005972
K_1885 X_NUC_48.L_CORE X_NUC_53.L_CORE 0.008756
K_1886 X_NUC_48.L_CORE X_NUC_54.L_CORE 0.009048
K_1887 X_NUC_48.L_CORE X_NUC_55.L_CORE 0.008712
K_1888 X_NUC_48.L_CORE X_NUC_56.L_CORE 0.008923
K_1889 X_NUC_48.L_CORE X_NUC_57.L_CORE 0.004032
K_1890 X_NUC_48.L_CORE X_NUC_58.L_CORE 0.004508
K_1891 X_NUC_48.L_CORE X_NUC_59.L_CORE 0.003529
K_1892 X_NUC_48.L_CORE X_NUC_60.L_CORE 0.007900
K_1893 X_NUC_48.L_CORE X_NUC_61.L_CORE 0.004288
K_1894 X_NUC_48.L_CORE X_NUC_62.L_CORE 0.004997
K_1895 X_NUC_48.L_CORE X_NUC_63.L_CORE 0.014344
K_1896 X_NUC_48.L_CORE X_NUC_64.L_CORE 0.005383
K_1897 X_NUC_49.L_CORE X_NUC_50.L_CORE 0.207973
K_1898 X_NUC_49.L_CORE X_NUC_51.L_CORE 0.207973
K_1899 X_NUC_49.L_CORE X_NUC_52.L_CORE 0.207973
K_1900 X_NUC_49.L_CORE X_NUC_53.L_CORE 0.008275
K_1901 X_NUC_49.L_CORE X_NUC_54.L_CORE 0.008439
K_1902 X_NUC_49.L_CORE X_NUC_55.L_CORE 0.008462
K_1903 X_NUC_49.L_CORE X_NUC_56.L_CORE 0.008178
K_1904 X_NUC_49.L_CORE X_NUC_57.L_CORE 0.003541
K_1905 X_NUC_49.L_CORE X_NUC_58.L_CORE 0.004222
K_1906 X_NUC_49.L_CORE X_NUC_59.L_CORE 0.004824
K_1907 X_NUC_49.L_CORE X_NUC_60.L_CORE 0.003807
K_1908 X_NUC_49.L_CORE X_NUC_61.L_CORE 0.008341
K_1909 X_NUC_49.L_CORE X_NUC_62.L_CORE 0.005009
K_1910 X_NUC_49.L_CORE X_NUC_63.L_CORE 0.006038
K_1911 X_NUC_49.L_CORE X_NUC_64.L_CORE 0.017348
K_1912 X_NUC_50.L_CORE X_NUC_51.L_CORE 0.207973
K_1913 X_NUC_50.L_CORE X_NUC_52.L_CORE 0.207973
K_1914 X_NUC_50.L_CORE X_NUC_53.L_CORE 0.008108
K_1915 X_NUC_50.L_CORE X_NUC_54.L_CORE 0.008275
K_1916 X_NUC_50.L_CORE X_NUC_55.L_CORE 0.008291
K_1917 X_NUC_50.L_CORE X_NUC_56.L_CORE 0.008023
K_1918 X_NUC_50.L_CORE X_NUC_57.L_CORE 0.003525
K_1919 X_NUC_50.L_CORE X_NUC_58.L_CORE 0.004260
K_1920 X_NUC_50.L_CORE X_NUC_59.L_CORE 0.004753
K_1921 X_NUC_50.L_CORE X_NUC_60.L_CORE 0.003808
K_1922 X_NUC_50.L_CORE X_NUC_61.L_CORE 0.008544
K_1923 X_NUC_50.L_CORE X_NUC_62.L_CORE 0.004912
K_1924 X_NUC_50.L_CORE X_NUC_63.L_CORE 0.006133
K_1925 X_NUC_50.L_CORE X_NUC_64.L_CORE 0.016343
K_1926 X_NUC_51.L_CORE X_NUC_52.L_CORE 0.207973
K_1927 X_NUC_51.L_CORE X_NUC_53.L_CORE 0.008088
K_1928 X_NUC_51.L_CORE X_NUC_54.L_CORE 0.008247
K_1929 X_NUC_51.L_CORE X_NUC_55.L_CORE 0.008275
K_1930 X_NUC_51.L_CORE X_NUC_56.L_CORE 0.008003
K_1931 X_NUC_51.L_CORE X_NUC_57.L_CORE 0.003484
K_1932 X_NUC_51.L_CORE X_NUC_58.L_CORE 0.004177
K_1933 X_NUC_51.L_CORE X_NUC_59.L_CORE 0.004734
K_1934 X_NUC_51.L_CORE X_NUC_60.L_CORE 0.003755
K_1935 X_NUC_51.L_CORE X_NUC_61.L_CORE 0.008352
K_1936 X_NUC_51.L_CORE X_NUC_62.L_CORE 0.004911
K_1937 X_NUC_51.L_CORE X_NUC_63.L_CORE 0.006010
K_1938 X_NUC_51.L_CORE X_NUC_64.L_CORE 0.017435
K_1939 X_NUC_52.L_CORE X_NUC_53.L_CORE 0.008363
K_1940 X_NUC_52.L_CORE X_NUC_54.L_CORE 0.008539
K_1941 X_NUC_52.L_CORE X_NUC_55.L_CORE 0.008563
K_1942 X_NUC_52.L_CORE X_NUC_56.L_CORE 0.008275
K_1943 X_NUC_52.L_CORE X_NUC_57.L_CORE 0.003511
K_1944 X_NUC_52.L_CORE X_NUC_58.L_CORE 0.004203
K_1945 X_NUC_52.L_CORE X_NUC_59.L_CORE 0.004725
K_1946 X_NUC_52.L_CORE X_NUC_60.L_CORE 0.003816
K_1947 X_NUC_52.L_CORE X_NUC_61.L_CORE 0.008208
K_1948 X_NUC_52.L_CORE X_NUC_62.L_CORE 0.004975
K_1949 X_NUC_52.L_CORE X_NUC_63.L_CORE 0.006161
K_1950 X_NUC_52.L_CORE X_NUC_64.L_CORE 0.017523
K_1951 X_NUC_53.L_CORE X_NUC_54.L_CORE 0.207973
K_1952 X_NUC_53.L_CORE X_NUC_55.L_CORE 0.207973
K_1953 X_NUC_53.L_CORE X_NUC_56.L_CORE 0.207973
K_1954 X_NUC_53.L_CORE X_NUC_57.L_CORE 0.003856
K_1955 X_NUC_53.L_CORE X_NUC_58.L_CORE 0.003622
K_1956 X_NUC_53.L_CORE X_NUC_59.L_CORE 0.004421
K_1957 X_NUC_53.L_CORE X_NUC_60.L_CORE 0.004987
K_1958 X_NUC_53.L_CORE X_NUC_61.L_CORE 0.004404
K_1959 X_NUC_53.L_CORE X_NUC_62.L_CORE 0.008529
K_1960 X_NUC_53.L_CORE X_NUC_63.L_CORE 0.006412
K_1961 X_NUC_53.L_CORE X_NUC_64.L_CORE 0.009660
K_1962 X_NUC_54.L_CORE X_NUC_55.L_CORE 0.207973
K_1963 X_NUC_54.L_CORE X_NUC_56.L_CORE 0.207973
K_1964 X_NUC_54.L_CORE X_NUC_57.L_CORE 0.003852
K_1965 X_NUC_54.L_CORE X_NUC_58.L_CORE 0.003660
K_1966 X_NUC_54.L_CORE X_NUC_59.L_CORE 0.004391
K_1967 X_NUC_54.L_CORE X_NUC_60.L_CORE 0.005023
K_1968 X_NUC_54.L_CORE X_NUC_61.L_CORE 0.004459
K_1969 X_NUC_54.L_CORE X_NUC_62.L_CORE 0.008235
K_1970 X_NUC_54.L_CORE X_NUC_63.L_CORE 0.006608
K_1971 X_NUC_54.L_CORE X_NUC_64.L_CORE 0.009734
K_1972 X_NUC_55.L_CORE X_NUC_56.L_CORE 0.207973
K_1973 X_NUC_55.L_CORE X_NUC_57.L_CORE 0.003800
K_1974 X_NUC_55.L_CORE X_NUC_58.L_CORE 0.003609
K_1975 X_NUC_55.L_CORE X_NUC_59.L_CORE 0.004379
K_1976 X_NUC_55.L_CORE X_NUC_60.L_CORE 0.004909
K_1977 X_NUC_55.L_CORE X_NUC_61.L_CORE 0.004435
K_1978 X_NUC_55.L_CORE X_NUC_62.L_CORE 0.008253
K_1979 X_NUC_55.L_CORE X_NUC_63.L_CORE 0.006466
K_1980 X_NUC_55.L_CORE X_NUC_64.L_CORE 0.009989
K_1981 X_NUC_56.L_CORE X_NUC_57.L_CORE 0.003808
K_1982 X_NUC_56.L_CORE X_NUC_58.L_CORE 0.003602
K_1983 X_NUC_56.L_CORE X_NUC_59.L_CORE 0.004331
K_1984 X_NUC_56.L_CORE X_NUC_60.L_CORE 0.004985
K_1985 X_NUC_56.L_CORE X_NUC_61.L_CORE 0.004371
K_1986 X_NUC_56.L_CORE X_NUC_62.L_CORE 0.008270
K_1987 X_NUC_56.L_CORE X_NUC_63.L_CORE 0.006513
K_1988 X_NUC_56.L_CORE X_NUC_64.L_CORE 0.009544
K_1989 X_NUC_57.L_CORE X_NUC_58.L_CORE 0.005184
K_1990 X_NUC_57.L_CORE X_NUC_59.L_CORE 0.005575
K_1991 X_NUC_57.L_CORE X_NUC_60.L_CORE 0.005733
K_1992 X_NUC_57.L_CORE X_NUC_61.L_CORE 0.003525
K_1993 X_NUC_57.L_CORE X_NUC_62.L_CORE 0.004551
K_1994 X_NUC_57.L_CORE X_NUC_63.L_CORE 0.003457
K_1995 X_NUC_57.L_CORE X_NUC_64.L_CORE 0.003240
K_1996 X_NUC_58.L_CORE X_NUC_59.L_CORE 0.003890
K_1997 X_NUC_58.L_CORE X_NUC_60.L_CORE 0.004798
K_1998 X_NUC_58.L_CORE X_NUC_61.L_CORE 0.005692
K_1999 X_NUC_58.L_CORE X_NUC_62.L_CORE 0.003178
K_2000 X_NUC_58.L_CORE X_NUC_63.L_CORE 0.004737
K_2001 X_NUC_58.L_CORE X_NUC_64.L_CORE 0.003457
K_2002 X_NUC_59.L_CORE X_NUC_60.L_CORE 0.003472
K_2003 X_NUC_59.L_CORE X_NUC_61.L_CORE 0.004511
K_2004 X_NUC_59.L_CORE X_NUC_62.L_CORE 0.005642
K_2005 X_NUC_59.L_CORE X_NUC_63.L_CORE 0.003178
K_2006 X_NUC_59.L_CORE X_NUC_64.L_CORE 0.004551
K_2007 X_NUC_60.L_CORE X_NUC_61.L_CORE 0.003360
K_2008 X_NUC_60.L_CORE X_NUC_62.L_CORE 0.004511
K_2009 X_NUC_60.L_CORE X_NUC_63.L_CORE 0.005692
K_2010 X_NUC_60.L_CORE X_NUC_64.L_CORE 0.003525
K_2011 X_NUC_61.L_CORE X_NUC_62.L_CORE 0.003472
K_2012 X_NUC_61.L_CORE X_NUC_63.L_CORE 0.004798
K_2013 X_NUC_61.L_CORE X_NUC_64.L_CORE 0.005733
K_2014 X_NUC_62.L_CORE X_NUC_63.L_CORE 0.003890
K_2015 X_NUC_62.L_CORE X_NUC_64.L_CORE 0.005575
K_2016 X_NUC_63.L_CORE X_NUC_64.L_CORE 0.005184

* -----------------------------------------------------------------
* SIMULATION DIRECTIVES
* -----------------------------------------------------------------
* Transient Analysis: 100kV Step Pulse (1ns rise) to test dielectric rupture limits
.TRAN 0.1n 200n
* Broadband AC sweep: 1 MHz to 1 GHz to ping macro-resonance Q-factors
.AC DEC 100 1MEG 1G
.OPTIONS METHOD=GEAR

.END
